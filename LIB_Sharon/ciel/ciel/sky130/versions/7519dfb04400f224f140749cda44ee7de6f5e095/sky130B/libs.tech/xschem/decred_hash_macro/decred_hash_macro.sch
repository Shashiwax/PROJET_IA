C {devices/lab_pin.sym} 31980 -37100 0 0 {name=p31203 lab=_73257_/X }
C {devices/lab_pin.sym} 31980 -37060 0 0 {name=p31204 lab=_86190_/Q }
C {devices/lab_pin.sym} 31980 -37020 0 0 {name=p31205 lab=_73205_/X }
C {devices/lab_pin.sym} 31980 -36980 0 0 {name=p31206 lab=_73258_/X }
C {devices/lab_pin.sym} 32140 -37040 0 1 {name=p31207 lab=_73259_/X }
C {sky130_stdcells/a211o_4.sym} 32060 -37040 0 0 {name=X_73259_ }
C {devices/lab_pin.sym} 32000 -36920 0 0 {name=p31208 lab=_60562_/B }
C {devices/lab_pin.sym} 32000 -36880 0 0 {name=p31209 lab=_64223_/B }
C {devices/lab_pin.sym} 32000 -36840 0 0 {name=p31210 lab=_63347_/C }
C {devices/lab_pin.sym} 32000 -36800 0 0 {name=p31211 lab=_60541_/B }
C {devices/lab_pin.sym} 32120 -36860 0 1 {name=p31212 lab=_63012_/X }
C {sky130_stdcells/and4_4.sym} 32060 -36860 0 0 {name=X_63012_ }
C {devices/lab_pin.sym} 31980 -36750 0 0 {name=p31213 lab=_60408_/A }
C {devices/lab_pin.sym} 31980 -36710 0 0 {name=p31214 lab=_60095_/X }
C {devices/lab_pin.sym} 31980 -36670 0 0 {name=p31215 lab=_60155_/D }
C {devices/lab_pin.sym} 31980 -36630 0 0 {name=p31216 lab=_60185_/X }
C {devices/lab_pin.sym} 31980 -36590 0 0 {name=p31217 lab=_60166_/X }
C {devices/lab_pin.sym} 32140 -36670 0 1 {name=p31218 lab=_60224_/Y }
C {sky130_stdcells/a32oi_4.sym} 32060 -36670 0 0 {name=X_60224_ }
C {devices/lab_pin.sym} 32020 -36510 0 0 {name=p31219 lab=_64401_/B }
C {devices/lab_pin.sym} 32100 -36510 0 1 {name=p31220 lab=_61521_/B }
C {sky130_stdcells/buf_2.sym} 32060 -36510 0 0 {name=X_45158_ }
C {devices/lab_pin.sym} 32020 -36390 0 0 {name=p31221 lab=_44108_/X }
C {devices/lab_pin.sym} 32100 -36390 0 1 {name=p31222 lab=_44109_/X }
C {sky130_stdcells/buf_2.sym} 32060 -36390 0 0 {name=X_44109_ }
C {devices/lab_pin.sym} 32020 -36270 0 0 {name=p31223 lab=_66572_/X }
C {devices/lab_pin.sym} 32100 -36270 0 1 {name=p31224 lab=_68450_/A }
C {sky130_stdcells/buf_2.sym} 32060 -36270 0 0 {name=X_67820_ }
C {devices/lab_pin.sym} 32000 -36160 0 0 {name=p31225 lab=_79806_/A }
C {devices/lab_pin.sym} 32000 -36120 0 0 {name=p31226 lab=_79806_/B }
C {devices/lab_pin.sym} 32120 -36140 0 1 {name=p31227 lab=_79807_/B }
C {sky130_stdcells/xor2_4.sym} 32060 -36140 0 0 {name=X_79806_ }
C {devices/lab_pin.sym} 32000 -36040 0 0 {name=p31228 lab=_60095_/X }
C {devices/lab_pin.sym} 32000 -36000 0 0 {name=p31229 lab=_60402_/A }
C {devices/lab_pin.sym} 32000 -35960 0 0 {name=p31230 lab=_60155_/C }
C {devices/lab_pin.sym} 32000 -35920 0 0 {name=p31231 lab=_60155_/D }
C {devices/lab_pin.sym} 32120 -35980 0 1 {name=p31232 lab=_60193_/A }
C {sky130_stdcells/and4_4.sym} 32060 -35980 0 0 {name=X_60155_ }
C {devices/lab_pin.sym} 32000 -35840 0 0 {name=p31233 lab=_49981_/A }
C {devices/lab_pin.sym} 32000 -35800 0 0 {name=p31234 lab=_53179_/B }
C {devices/lab_pin.sym} 32120 -35820 0 1 {name=p31235 lab=_49966_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -35820 0 0 {name=X_49966_ }
C {devices/lab_pin.sym} 31980 -35710 0 0 {name=p31236 lab=_56223_/C }
C {devices/lab_pin.sym} 31980 -35670 0 0 {name=p31237 lab=_45073_/X }
C {devices/lab_pin.sym} 31980 -35630 0 0 {name=p31238 lab=_45088_/X }
C {devices/lab_pin.sym} 32140 -35670 0 1 {name=p31239 lab=_45089_/Y }
C {sky130_stdcells/o21ai_4.sym} 32060 -35670 0 0 {name=X_45089_ }
C {devices/lab_pin.sym} 32020 -35530 0 0 {name=p31240 lab=_77998_/A }
C {devices/lab_pin.sym} 32100 -35530 0 1 {name=p31241 lab=_78002_/A }
C {sky130_stdcells/inv_2.sym} 32060 -35530 0 0 {name=X_77998_ }
C {devices/lab_pin.sym} 32020 -35410 0 0 {name=p31242 lab=clkbuf_7_6_0_CLK/X }
C {devices/lab_pin.sym} 32100 -35410 0 1 {name=p31243 lab=clkbuf_9_27_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 32060 -35410 0 0 {name=Xclkbuf_8_13_0_CLK }
C {devices/lab_pin.sym} 32020 -35290 0 0 {name=p31244 lab=_48995_/A }
C {devices/lab_pin.sym} 32100 -35290 0 1 {name=p31245 lab=_48917_/X }
C {sky130_stdcells/buf_2.sym} 32060 -35290 0 0 {name=X_48917_ }
C {devices/lab_pin.sym} 32020 -35170 0 0 {name=p31246 lab=_67987_/A }
C {devices/lab_pin.sym} 32100 -35170 0 1 {name=p31247 lab=_67751_/X }
C {sky130_stdcells/buf_2.sym} 32060 -35170 0 0 {name=X_67751_ }
C {devices/lab_pin.sym} 31980 -35070 0 0 {name=p31248 lab=_79728_/Y }
C {devices/lab_pin.sym} 31980 -35030 0 0 {name=p31249 lab=_79724_/X }
C {devices/lab_pin.sym} 31980 -34990 0 0 {name=p31250 lab=_79736_/X }
C {devices/lab_pin.sym} 32140 -35030 0 1 {name=p31251 lab=_79737_/Y }
C {sky130_stdcells/a21boi_4.sym} 32060 -35030 0 0 {name=X_79737_ }
C {devices/lab_pin.sym} 32000 -34900 0 0 {name=p31252 lab=_64877_/X }
C {devices/lab_pin.sym} 32000 -34860 0 0 {name=p31253 lab=_86420_/Q }
C {devices/lab_pin.sym} 32120 -34880 0 1 {name=p31254 lab=_64963_/X }
C {sky130_stdcells/and2_4.sym} 32060 -34880 0 0 {name=X_64963_ }
C {devices/lab_pin.sym} 32020 -34750 0 0 {name=p31255 lab=_59896_/X }
C {devices/lab_pin.sym} 32100 -34750 0 1 {name=p31256 lab=_62548_/B }
C {sky130_stdcells/buf_2.sym} 32060 -34750 0 0 {name=X_60086_ }
C {devices/lab_pin.sym} 32000 -34640 0 0 {name=p31257 lab=_81681_/Q }
C {devices/lab_pin.sym} 32000 -34600 0 0 {name=p31258 lab=_76949_/B }
C {devices/lab_pin.sym} 32120 -34620 0 1 {name=p31259 lab=_76949_/X }
C {sky130_stdcells/xor2_4.sym} 32060 -34620 0 0 {name=X_76949_ }
C {devices/lab_pin.sym} 32020 -34490 0 0 {name=p31260 lab=_49924_/A }
C {devices/lab_pin.sym} 32100 -34490 0 1 {name=p31261 lab=_49897_/X }
C {sky130_stdcells/buf_2.sym} 32060 -34490 0 0 {name=X_49897_ }
C {devices/lab_pin.sym} 31980 -34390 0 0 {name=p31262 lab=_66699_/X }
C {devices/lab_pin.sym} 31980 -34350 0 0 {name=p31263 lab=_66701_/X }
C {devices/lab_pin.sym} 31980 -34310 0 0 {name=p31264 lab=_66606_/X }
C {devices/lab_pin.sym} 32140 -34350 0 1 {name=p31265 lab=_66702_/X }
C {sky130_stdcells/a21o_4.sym} 32060 -34350 0 0 {name=X_66702_ }
C {devices/lab_pin.sym} 32000 -34230 0 0 {name=p31266 lab=_63848_/X }
C {devices/lab_pin.sym} 32000 -34190 0 0 {name=p31267 lab=_63849_/X }
C {devices/lab_pin.sym} 32000 -34150 0 0 {name=p31268 lab=_63914_/C }
C {devices/lab_pin.sym} 32120 -34190 0 1 {name=p31269 lab=_63914_/Y }
C {sky130_stdcells/nor3_4.sym} 32060 -34190 0 0 {name=X_63914_ }
C {devices/lab_pin.sym} 31980 -34070 0 0 {name=p31270 lab=_86471_/Q }
C {devices/lab_pin.sym} 31980 -34030 0 0 {name=p31271 lab=_48836_/X }
C {devices/lab_pin.sym} 31980 -33990 0 0 {name=p31272 lab=_48847_/Y }
C {devices/lab_pin.sym} 32140 -34030 0 1 {name=p31273 lab=_48848_/Y }
C {sky130_stdcells/o21ai_4.sym} 32060 -34030 0 0 {name=X_48848_ }
C {devices/lab_pin.sym} 31980 -33910 0 0 {name=p31274 lab=_67676_/X }
C {devices/lab_pin.sym} 31980 -33870 0 0 {name=p31275 lab=_67680_/X }
C {devices/lab_pin.sym} 31980 -33830 0 0 {name=p31276 lab=_67681_/X }
C {devices/lab_pin.sym} 32140 -33870 0 1 {name=p31277 lab=_67682_/X }
C {sky130_stdcells/a21o_4.sym} 32060 -33870 0 0 {name=X_67682_ }
C {devices/lab_pin.sym} 32000 -33740 0 0 {name=p31278 lab=_79657_/X }
C {devices/lab_pin.sym} 32000 -33700 0 0 {name=p31279 lab=_79668_/B }
C {devices/lab_pin.sym} 32120 -33720 0 1 {name=p31280 lab=_79668_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -33720 0 0 {name=X_79668_ }
C {devices/lab_pin.sym} 31980 -33620 0 0 {name=p31281 lab=_64691_/X }
C {devices/lab_pin.sym} 31980 -33580 0 0 {name=p31282 lab=_86134_/Q }
C {devices/lab_pin.sym} 31980 -33540 0 0 {name=p31283 lab=_64692_/X }
C {devices/lab_pin.sym} 31980 -33500 0 0 {name=p31284 lab=_64893_/X }
C {devices/lab_pin.sym} 32140 -33560 0 1 {name=p31285 lab=_64894_/X }
C {sky130_stdcells/a211o_4.sym} 32060 -33560 0 0 {name=X_64894_ }
C {devices/lab_pin.sym} 31980 -33430 0 0 {name=p31286 lab=_83925_/Q }
C {devices/lab_pin.sym} 31980 -33390 0 0 {name=p31287 lab=_69367_/X }
C {devices/lab_pin.sym} 31980 -33350 0 0 {name=p31288 lab=_69420_/X }
C {devices/lab_pin.sym} 32140 -33390 0 1 {name=p31289 lab=_83925_/D }
C {sky130_stdcells/a21bo_4.sym} 32060 -33390 0 0 {name=X_69421_ }
C {devices/lab_pin.sym} 32020 -33250 0 0 {name=p31290 lab=_66608_/A }
C {devices/lab_pin.sym} 32100 -33250 0 1 {name=p31291 lab=_66633_/X }
C {sky130_stdcells/buf_2.sym} 32060 -33250 0 0 {name=X_66633_ }
C {devices/lab_pin.sym} 32000 -33150 0 0 {name=p31292 lab=_78610_/X }
C {devices/lab_pin.sym} 32000 -33110 0 0 {name=p31293 lab=_78615_/X }
C {devices/lab_pin.sym} 32000 -33070 0 0 {name=p31294 lab=_78618_/Y }
C {devices/lab_pin.sym} 32120 -33110 0 1 {name=p31295 lab=_78640_/C }
C {sky130_stdcells/or3_4.sym} 32060 -33110 0 0 {name=X_78619_ }
C {devices/lab_pin.sym} 32020 -32970 0 0 {name=p31296 lab=_64184_/C }
C {devices/lab_pin.sym} 32100 -32970 0 1 {name=p31297 lab=_63862_/C }
C {sky130_stdcells/buf_2.sym} 32060 -32970 0 0 {name=X_63845_ }
C {devices/lab_pin.sym} 32000 -32870 0 0 {name=p31298 lab=_52166_/A }
C {devices/lab_pin.sym} 32000 -32830 0 0 {name=p31299 lab=_48770_/X }
C {devices/lab_pin.sym} 32000 -32790 0 0 {name=p31300 lab=_48786_/C }
C {devices/lab_pin.sym} 32120 -32830 0 1 {name=p31301 lab=_48779_/X }
C {sky130_stdcells/and3_4.sym} 32060 -32830 0 0 {name=X_48779_ }
C {devices/lab_pin.sym} 31980 -32710 0 0 {name=p31302 lab=_79588_/A }
C {devices/lab_pin.sym} 31980 -32670 0 0 {name=p31303 lab=_79586_/A }
C {devices/lab_pin.sym} 31980 -32630 0 0 {name=p31304 lab=_79585_/Y }
C {devices/lab_pin.sym} 32140 -32670 0 1 {name=p31305 lab=_79599_/Y }
C {sky130_stdcells/a21boi_4.sym} 32060 -32670 0 0 {name=X_79599_ }
C {devices/lab_pin.sym} 32020 -32530 0 0 {name=p31306 lab=clkbuf_8_29_0_CLK/A }
C {devices/lab_pin.sym} 32100 -32530 0 1 {name=p31307 lab=clkbuf_9_57_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 32060 -32530 0 0 {name=Xclkbuf_8_28_0_CLK }
C {devices/lab_pin.sym} 32000 -32420 0 0 {name=p31308 lab=_50799_/A }
C {devices/lab_pin.sym} 32000 -32380 0 0 {name=p31309 lab=_51320_/B }
C {devices/lab_pin.sym} 32120 -32400 0 1 {name=p31310 lab=_50810_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -32400 0 0 {name=X_50810_ }
C {devices/lab_pin.sym} 31970 -32270 0 0 {name=p31311 lab=_81275_/CLK }
C {devices/lab_pin.sym} 31970 -32250 0 0 {name=p31312 lab=_76591_/X }
C {devices/lab_pin.sym} 32150 -32270 0 1 {name=p31313 lab=_81630_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -32260 0 0 {name=X_81630_ }
C {devices/lab_pin.sym} 31980 -32160 0 0 {name=p31314 lab=_69300_/X }
C {devices/lab_pin.sym} 31980 -32120 0 0 {name=p31315 lab=_69340_/X }
C {devices/lab_pin.sym} 31980 -32080 0 0 {name=p31316 lab=_69350_/Y }
C {devices/lab_pin.sym} 31980 -32040 0 0 {name=p31317 lab=_69351_/Y }
C {devices/lab_pin.sym} 32140 -32100 0 1 {name=p31318 lab=_69352_/X }
C {sky130_stdcells/a211o_4.sym} 32060 -32100 0 0 {name=X_69352_ }
C {devices/lab_pin.sym} 32020 -31950 0 0 {name=p31319 lab=_69567_/A }
C {devices/lab_pin.sym} 32100 -31950 0 1 {name=p31320 lab=_66564_/X }
C {sky130_stdcells/buf_2.sym} 32060 -31950 0 0 {name=X_66564_ }
C {devices/lab_pin.sym} 32020 -31830 0 0 {name=p31321 lab=_51790_/A }
C {devices/lab_pin.sym} 32100 -31830 0 1 {name=p31322 lab=_51796_/A }
C {sky130_stdcells/buf_2.sym} 32060 -31830 0 0 {name=X_51790_ }
C {devices/lab_pin.sym} 32020 -31710 0 0 {name=p31323 lab=_64045_/A }
C {devices/lab_pin.sym} 32100 -31710 0 1 {name=p31324 lab=_63776_/X }
C {sky130_stdcells/buf_2.sym} 32060 -31710 0 0 {name=X_63776_ }
C {devices/lab_pin.sym} 32020 -31590 0 0 {name=p31325 lab=_60988_/A }
C {devices/lab_pin.sym} 32100 -31590 0 1 {name=p31326 lab=_60988_/Y }
C {sky130_stdcells/inv_2.sym} 32060 -31590 0 0 {name=X_60988_ }
C {devices/lab_pin.sym} 31980 -31500 0 0 {name=p31327 lab=_68301_/X }
C {devices/lab_pin.sym} 31980 -31460 0 0 {name=p31328 lab=_67842_/Y }
C {devices/lab_pin.sym} 31980 -31420 0 0 {name=p31329 lab=_68287_/X }
C {devices/lab_pin.sym} 31980 -31380 0 0 {name=p31330 lab=_68302_/Y }
C {devices/lab_pin.sym} 32140 -31440 0 1 {name=p31331 lab=_68303_/X }
C {sky130_stdcells/a211o_4.sym} 32060 -31440 0 0 {name=X_68303_ }
C {devices/lab_pin.sym} 32020 -31290 0 0 {name=p31332 lab=_65515_/A }
C {devices/lab_pin.sym} 32100 -31290 0 1 {name=p31333 lab=_65516_/A }
C {sky130_stdcells/buf_2.sym} 32060 -31290 0 0 {name=X_65515_ }
C {devices/lab_pin.sym} 31980 -31190 0 0 {name=p31334 lab=_50739_/Y }
C {devices/lab_pin.sym} 31980 -31150 0 0 {name=p31335 lab=_50735_/X }
C {devices/lab_pin.sym} 31980 -31110 0 0 {name=p31336 lab=_50740_/Y }
C {devices/lab_pin.sym} 32140 -31150 0 1 {name=p31337 lab=_86143_/D }
C {sky130_stdcells/a21boi_4.sym} 32060 -31150 0 0 {name=X_50741_ }
C {devices/lab_pin.sym} 32000 -31030 0 0 {name=p31338 lab=_62727_/A }
C {devices/lab_pin.sym} 32000 -30990 0 0 {name=p31339 lab=_62727_/B }
C {devices/lab_pin.sym} 32000 -30950 0 0 {name=p31340 lab=_61831_/X }
C {devices/lab_pin.sym} 32120 -30990 0 1 {name=p31341 lab=_62727_/Y }
C {sky130_stdcells/nand3_4.sym} 32060 -30990 0 0 {name=X_62727_ }
C {devices/lab_pin.sym} 31970 -30850 0 0 {name=p31342 lab=_81433_/CLK }
C {devices/lab_pin.sym} 31970 -30830 0 0 {name=p31343 lab=_81561_/D }
C {devices/lab_pin.sym} 32150 -30850 0 1 {name=p31344 lab=_81561_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -30840 0 0 {name=X_81561_ }
C {devices/lab_pin.sym} 31980 -30740 0 0 {name=p31345 lab=_69216_/X }
C {devices/lab_pin.sym} 31980 -30700 0 0 {name=p31346 lab=_69281_/Y }
C {devices/lab_pin.sym} 31980 -30660 0 0 {name=p31347 lab=_69231_/X }
C {devices/lab_pin.sym} 31980 -30620 0 0 {name=p31348 lab=_69282_/Y }
C {devices/lab_pin.sym} 32140 -30680 0 1 {name=p31349 lab=_69283_/X }
C {sky130_stdcells/a211o_4.sym} 32060 -30680 0 0 {name=X_69283_ }
C {devices/lab_pin.sym} 32000 -30550 0 0 {name=p31350 lab=_66501_/A }
C {devices/lab_pin.sym} 32000 -30510 0 0 {name=p31351 lab=_66501_/B }
C {devices/lab_pin.sym} 32000 -30470 0 0 {name=p31352 lab=_66495_/C }
C {devices/lab_pin.sym} 32120 -30510 0 1 {name=p31353 lab=_66495_/X }
C {sky130_stdcells/and3_4.sym} 32060 -30510 0 0 {name=X_66495_ }
C {devices/lab_pin.sym} 31970 -30370 0 0 {name=p31354 lab=_83300_/CLK }
C {devices/lab_pin.sym} 31970 -30350 0 0 {name=p31355 lab=_72026_/Y }
C {devices/lab_pin.sym} 32150 -30370 0 1 {name=p31356 lab=_83300_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -30360 0 0 {name=X_83300_ }
C {devices/lab_pin.sym} 31980 -30250 0 0 {name=p31357 lab=_80509_/Y }
C {devices/lab_pin.sym} 31980 -30210 0 0 {name=p31358 lab=_80492_/Y }
C {devices/lab_pin.sym} 31980 -30170 0 0 {name=p31359 lab=_80511_/X }
C {devices/lab_pin.sym} 32140 -30210 0 1 {name=p31360 lab=_80512_/Y }
C {sky130_stdcells/o21ai_4.sym} 32060 -30210 0 0 {name=X_80512_ }
C {devices/lab_pin.sym} 31980 -30090 0 0 {name=p31361 lab=_82653_/D }
C {devices/lab_pin.sym} 31980 -30050 0 0 {name=p31362 lab=_68220_/X }
C {devices/lab_pin.sym} 31980 -30010 0 0 {name=p31363 lab=_68233_/X }
C {devices/lab_pin.sym} 32140 -30050 0 1 {name=p31364 lab=_84005_/D }
C {sky130_stdcells/a21bo_4.sym} 32060 -30050 0 0 {name=X_68234_ }
C {devices/lab_pin.sym} 32000 -29920 0 0 {name=p31365 lab=_53460_/A }
C {devices/lab_pin.sym} 32000 -29880 0 0 {name=p31366 lab=_47853_/Y }
C {devices/lab_pin.sym} 32120 -29900 0 1 {name=p31367 lab=_53460_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -29900 0 0 {name=X_53460_ }
C {devices/lab_pin.sym} 32000 -29790 0 0 {name=p31368 lab=_65446_/A }
C {devices/lab_pin.sym} 32000 -29750 0 0 {name=p31369 lab=_65192_/B }
C {devices/lab_pin.sym} 32000 -29710 0 0 {name=p31370 lab=_65445_/X }
C {devices/lab_pin.sym} 32120 -29750 0 1 {name=p31371 lab=_65446_/Y }
C {sky130_stdcells/nand3_4.sym} 32060 -29750 0 0 {name=X_65446_ }
C {devices/lab_pin.sym} 31970 -29610 0 0 {name=p31372 lab=_84280_/CLK }
C {devices/lab_pin.sym} 31970 -29590 0 0 {name=p31373 lab=_64023_/Y }
C {devices/lab_pin.sym} 32150 -29610 0 1 {name=p31374 lab=_64022_/C }
C {sky130_stdcells/dfxtp_4.sym} 32060 -29600 0 0 {name=X_84280_ }
C {devices/lab_pin.sym} 32000 -29490 0 0 {name=p31375 lab=_52370_/A }
C {devices/lab_pin.sym} 32000 -29450 0 0 {name=p31376 lab=_50651_/X }
C {devices/lab_pin.sym} 32000 -29410 0 0 {name=p31377 lab=_50668_/C }
C {devices/lab_pin.sym} 32120 -29450 0 1 {name=p31378 lab=_50672_/X }
C {sky130_stdcells/and3_4.sym} 32060 -29450 0 0 {name=X_50672_ }
C {devices/lab_pin.sym} 32000 -29340 0 0 {name=p31379 lab=_62658_/A }
C {devices/lab_pin.sym} 32000 -29300 0 0 {name=p31380 lab=_64225_/C }
C {devices/lab_pin.sym} 32000 -29260 0 0 {name=p31381 lab=_60197_/C }
C {devices/lab_pin.sym} 32000 -29220 0 0 {name=p31382 lab=_62657_/X }
C {devices/lab_pin.sym} 32120 -29280 0 1 {name=p31383 lab=_62658_/X }
C {sky130_stdcells/and4_4.sym} 32060 -29280 0 0 {name=X_62658_ }
C {devices/lab_pin.sym} 31970 -29130 0 0 {name=p31384 lab=_81492_/CLK }
C {devices/lab_pin.sym} 31970 -29110 0 0 {name=p31385 lab=_81492_/D }
C {devices/lab_pin.sym} 32150 -29130 0 1 {name=p31386 lab=_76810_/A }
C {sky130_stdcells/dfxtp_4.sym} 32060 -29120 0 0 {name=X_81492_ }
C {devices/lab_pin.sym} 32000 -29000 0 0 {name=p31387 lab=_52407_/A }
C {devices/lab_pin.sym} 32000 -28960 0 0 {name=p31388 lab=_49181_/A }
C {devices/lab_pin.sym} 32120 -28980 0 1 {name=p31389 lab=_52411_/X }
C {sky130_stdcells/and2_4.sym} 32060 -28980 0 0 {name=X_52411_ }
C {devices/lab_pin.sym} 31970 -28850 0 0 {name=p31390 lab=_83231_/CLK }
C {devices/lab_pin.sym} 31970 -28830 0 0 {name=p31391 lab=_83231_/D }
C {devices/lab_pin.sym} 32150 -28850 0 1 {name=p31392 lab=_79405_/B }
C {sky130_stdcells/dfxtp_4.sym} 32060 -28840 0 0 {name=X_83231_ }
C {devices/lab_pin.sym} 32020 -28710 0 0 {name=p31393 lab=_58399_/A }
C {devices/lab_pin.sym} 32100 -28710 0 1 {name=p31394 lab=_61609_/X }
C {sky130_stdcells/buf_2.sym} 32060 -28710 0 0 {name=X_61609_ }
C {devices/lab_pin.sym} 32000 -28600 0 0 {name=p31395 lab=_80452_/A }
C {devices/lab_pin.sym} 32000 -28560 0 0 {name=p31396 lab=_80452_/B }
C {devices/lab_pin.sym} 32120 -28580 0 1 {name=p31397 lab=_80458_/B }
C {sky130_stdcells/xnor2_4.sym} 32060 -28580 0 0 {name=X_80443_ }
C {devices/lab_pin.sym} 31980 -28480 0 0 {name=p31398 lab=_68155_/X }
C {devices/lab_pin.sym} 31980 -28440 0 0 {name=p31399 lab=_67030_/Y }
C {devices/lab_pin.sym} 31980 -28400 0 0 {name=p31400 lab=_68148_/X }
C {devices/lab_pin.sym} 31980 -28360 0 0 {name=p31401 lab=_68164_/Y }
C {devices/lab_pin.sym} 32140 -28420 0 1 {name=p31402 lab=_68165_/X }
C {sky130_stdcells/a211o_4.sym} 32060 -28420 0 0 {name=X_68165_ }
C {devices/lab_pin.sym} 31980 -28290 0 0 {name=p31403 lab=_85642_/Q }
C {devices/lab_pin.sym} 31980 -28250 0 0 {name=p31404 lab=_53378_/X }
C {devices/lab_pin.sym} 31980 -28210 0 0 {name=p31405 lab=_53390_/Y }
C {devices/lab_pin.sym} 32140 -28250 0 1 {name=p31406 lab=_53391_/Y }
C {sky130_stdcells/o21ai_4.sym} 32060 -28250 0 0 {name=X_53391_ }
C {devices/lab_pin.sym} 32000 -28120 0 0 {name=p31407 lab=_58785_/A }
C {devices/lab_pin.sym} 32000 -28080 0 0 {name=p31408 lab=_86019_/Q }
C {devices/lab_pin.sym} 32120 -28100 0 1 {name=p31409 lab=_65377_/X }
C {sky130_stdcells/and2_4.sym} 32060 -28100 0 0 {name=X_65377_ }
C {devices/lab_pin.sym} 32000 -28000 0 0 {name=p31410 lab=_62622_/A }
C {devices/lab_pin.sym} 32000 -27960 0 0 {name=p31411 lab=_62586_/Y }
C {devices/lab_pin.sym} 32000 -27920 0 0 {name=p31412 lab=_62587_/Y }
C {devices/lab_pin.sym} 32000 -27880 0 0 {name=p31413 lab=_62589_/D }
C {devices/lab_pin.sym} 32120 -27940 0 1 {name=p31414 lab=_62589_/Y }
C {sky130_stdcells/nand4_4.sym} 32060 -27940 0 0 {name=X_62589_ }
C {devices/lab_pin.sym} 32020 -27790 0 0 {name=p31415 lab=_55149_/A }
C {devices/lab_pin.sym} 32100 -27790 0 1 {name=p31416 lab=_55135_/A }
C {sky130_stdcells/buf_2.sym} 32060 -27790 0 0 {name=X_55130_ }
C {devices/lab_pin.sym} 31980 -27690 0 0 {name=p31417 lab=_80907_/D }
C {devices/lab_pin.sym} 31980 -27650 0 0 {name=p31418 lab=_67092_/X }
C {devices/lab_pin.sym} 31980 -27610 0 0 {name=p31419 lab=_67115_/X }
C {devices/lab_pin.sym} 32140 -27650 0 1 {name=p31420 lab=_67116_/X }
C {sky130_stdcells/a21bo_4.sym} 32060 -27650 0 0 {name=X_67116_ }
C {devices/lab_pin.sym} 31980 -27530 0 0 {name=p31421 lab=_52339_/Y }
C {devices/lab_pin.sym} 31980 -27490 0 0 {name=p31422 lab=_52340_/X }
C {devices/lab_pin.sym} 31980 -27450 0 0 {name=p31423 lab=_52341_/X }
C {devices/lab_pin.sym} 32140 -27490 0 1 {name=p31424 lab=_52342_/Y }
C {sky130_stdcells/a21oi_4.sym} 32060 -27490 0 0 {name=X_52342_ }
C {devices/lab_pin.sym} 32020 -27350 0 0 {name=p31425 lab=_64328_/A }
C {devices/lab_pin.sym} 32100 -27350 0 1 {name=p31426 lab=_64328_/X }
C {sky130_stdcells/buf_2.sym} 32060 -27350 0 0 {name=X_64328_ }
C {devices/lab_pin.sym} 31970 -27230 0 0 {name=p31427 lab=_86570_/CLK }
C {devices/lab_pin.sym} 31970 -27210 0 0 {name=p31428 lab=_83162_/D }
C {devices/lab_pin.sym} 32150 -27230 0 1 {name=p31429 lab=_83162_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -27220 0 0 {name=X_83162_ }
C {devices/lab_pin.sym} 31980 -27110 0 0 {name=p31430 lab=_80366_/A }
C {devices/lab_pin.sym} 31980 -27070 0 0 {name=p31431 lab=_80366_/B }
C {devices/lab_pin.sym} 31980 -27030 0 0 {name=p31432 lab=_80361_/A }
C {devices/lab_pin.sym} 32140 -27070 0 1 {name=p31433 lab=_80375_/B }
C {sky130_stdcells/o21ai_4.sym} 32060 -27070 0 0 {name=X_80374_ }
C {devices/lab_pin.sym} 32020 -26930 0 0 {name=p31434 lab=_69156_/A }
C {devices/lab_pin.sym} 32100 -26930 0 1 {name=p31435 lab=_68097_/A }
C {sky130_stdcells/buf_2.sym} 32060 -26930 0 0 {name=X_68096_ }
C {devices/lab_pin.sym} 31970 -26810 0 0 {name=p31436 lab=_82485_/CLK }
C {devices/lab_pin.sym} 31970 -26790 0 0 {name=p31437 lab=_82125_/Q }
C {devices/lab_pin.sym} 32150 -26810 0 1 {name=p31438 lab=_77230_/B }
C {sky130_stdcells/dfxtp_4.sym} 32060 -26800 0 0 {name=X_82113_ }
C {devices/lab_pin.sym} 32000 -26700 0 0 {name=p31439 lab=_55043_/X }
C {devices/lab_pin.sym} 32000 -26660 0 0 {name=p31440 lab=_55056_/X }
C {devices/lab_pin.sym} 32000 -26620 0 0 {name=p31441 lab=_55070_/C }
C {devices/lab_pin.sym} 32000 -26580 0 0 {name=p31442 lab=_47710_/A }
C {devices/lab_pin.sym} 32120 -26640 0 1 {name=p31443 lab=_55061_/X }
C {sky130_stdcells/and4_4.sym} 32060 -26640 0 0 {name=X_55061_ }
C {devices/lab_pin.sym} 32000 -26500 0 0 {name=p31444 lab=_66972_/X }
C {devices/lab_pin.sym} 32000 -26460 0 0 {name=p31445 lab=_67047_/B }
C {devices/lab_pin.sym} 32120 -26480 0 1 {name=p31446 lab=_67047_/X }
C {sky130_stdcells/and2_4.sym} 32060 -26480 0 0 {name=X_67047_ }
C {devices/lab_pin.sym} 31980 -26370 0 0 {name=p31447 lab=_85855_/Q }
C {devices/lab_pin.sym} 31980 -26330 0 0 {name=p31448 lab=_52269_/X }
C {devices/lab_pin.sym} 31980 -26290 0 0 {name=p31449 lab=_52272_/Y }
C {devices/lab_pin.sym} 32140 -26330 0 1 {name=p31450 lab=_52273_/Y }
C {sky130_stdcells/o21ai_4.sym} 32060 -26330 0 0 {name=X_52273_ }
C {devices/lab_pin.sym} 32000 -26220 0 0 {name=p31451 lab=_64273_/A }
C {devices/lab_pin.sym} 32000 -26180 0 0 {name=p31452 lab=_64273_/B }
C {devices/lab_pin.sym} 32000 -26140 0 0 {name=p31453 lab=_58232_/A }
C {devices/lab_pin.sym} 32000 -26100 0 0 {name=p31454 lab=_64304_/D }
C {devices/lab_pin.sym} 32120 -26160 0 1 {name=p31455 lab=_64259_/X }
C {sky130_stdcells/and4_4.sym} 32060 -26160 0 0 {name=X_64259_ }
C {devices/lab_pin.sym} 31970 -26010 0 0 {name=p31456 lab=_83846_/CLK }
C {devices/lab_pin.sym} 31970 -25990 0 0 {name=p31457 lab=_74337_/X }
C {devices/lab_pin.sym} 32150 -26010 0 1 {name=p31458 lab=_70323_/C }
C {sky130_stdcells/dfxtp_4.sym} 32060 -26000 0 0 {name=X_83093_ }
C {devices/lab_pin.sym} 31970 -25870 0 0 {name=p31459 lab=_87720_/CLK }
C {devices/lab_pin.sym} 31970 -25850 0 0 {name=p31460 lab=_87970_/D }
C {devices/lab_pin.sym} 32150 -25870 0 1 {name=p31461 lab=_87970_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -25860 0 0 {name=X_87970_ }
C {devices/lab_pin.sym} 31980 -25750 0 0 {name=p31462 lab=_54010_/Y }
C {devices/lab_pin.sym} 31980 -25710 0 0 {name=p31463 lab=_54006_/X }
C {devices/lab_pin.sym} 31980 -25670 0 0 {name=p31464 lab=_54011_/Y }
C {devices/lab_pin.sym} 32140 -25710 0 1 {name=p31465 lab=_54012_/Y }
C {sky130_stdcells/a21boi_4.sym} 32060 -25710 0 0 {name=X_54012_ }
C {devices/lab_pin.sym} 32020 -25570 0 0 {name=p31466 lab=_51170_/A }
C {devices/lab_pin.sym} 32100 -25570 0 1 {name=p31467 lab=_51225_/C }
C {sky130_stdcells/buf_2.sym} 32060 -25570 0 0 {name=X_51224_ }
C {devices/lab_pin.sym} 31970 -25450 0 0 {name=p31468 lab=_86920_/CLK }
C {devices/lab_pin.sym} 31970 -25430 0 0 {name=p31469 lab=_86921_/D }
C {devices/lab_pin.sym} 32150 -25450 0 1 {name=p31470 lab=_86921_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -25440 0 0 {name=X_86921_ }
C {devices/lab_pin.sym} 31970 -25310 0 0 {name=p31471 lab=_82047_/CLK }
C {devices/lab_pin.sym} 31970 -25290 0 0 {name=p31472 lab=_77970_/B }
C {devices/lab_pin.sym} 32150 -25310 0 1 {name=p31473 lab=_82044_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -25300 0 0 {name=X_82044_ }
C {devices/lab_pin.sym} 31980 -25210 0 0 {name=p31474 lab=_58696_/X }
C {devices/lab_pin.sym} 31980 -25170 0 0 {name=p31475 lab=_58818_/Y }
C {devices/lab_pin.sym} 31980 -25130 0 0 {name=p31476 lab=_58819_/Y }
C {devices/lab_pin.sym} 31980 -25090 0 0 {name=p31477 lab=_58728_/X }
C {devices/lab_pin.sym} 31980 -25050 0 0 {name=p31478 lab=_58701_/X }
C {devices/lab_pin.sym} 32140 -25130 0 1 {name=p31479 lab=_58820_/X }
C {sky130_stdcells/o32a_4.sym} 32060 -25130 0 0 {name=X_58820_ }
C {devices/lab_pin.sym} 31980 -24990 0 0 {name=p31480 lab=_51153_/Y }
C {devices/lab_pin.sym} 31980 -24950 0 0 {name=p31481 lab=_51147_/X }
C {devices/lab_pin.sym} 31980 -24910 0 0 {name=p31482 lab=_51154_/X }
C {devices/lab_pin.sym} 32140 -24950 0 1 {name=p31483 lab=_51155_/Y }
C {sky130_stdcells/a21oi_4.sym} 32060 -24950 0 0 {name=X_51155_ }
C {devices/lab_pin.sym} 31970 -24810 0 0 {name=p31484 lab=_86869_/CLK }
C {devices/lab_pin.sym} 31970 -24790 0 0 {name=p31485 lab=_86852_/D }
C {devices/lab_pin.sym} 32150 -24810 0 1 {name=p31486 lab=_63314_/B }
C {sky130_stdcells/dfxtp_4.sym} 32060 -24800 0 0 {name=X_86852_ }
C {devices/lab_pin.sym} 31980 -24690 0 0 {name=p31487 lab=_80808_/D }
C {devices/lab_pin.sym} 31980 -24650 0 0 {name=p31488 lab=_68954_/X }
C {devices/lab_pin.sym} 31980 -24610 0 0 {name=p31489 lab=_68997_/X }
C {devices/lab_pin.sym} 32140 -24650 0 1 {name=p31490 lab=_83952_/D }
C {sky130_stdcells/a21bo_4.sym} 32060 -24650 0 0 {name=X_68998_ }
C {devices/lab_pin.sym} 32000 -24520 0 0 {name=p31491 lab=_50106_/A }
C {devices/lab_pin.sym} 32000 -24480 0 0 {name=p31492 lab=_53834_/B }
C {devices/lab_pin.sym} 32120 -24500 0 1 {name=p31493 lab=_50106_/X }
C {sky130_stdcells/and2_4.sym} 32060 -24500 0 0 {name=X_50106_ }
C {devices/lab_pin.sym} 31970 -24370 0 0 {name=p31494 lab=_86122_/CLK }
C {devices/lab_pin.sym} 31970 -24350 0 0 {name=p31495 lab=_85803_/D }
C {devices/lab_pin.sym} 32150 -24370 0 1 {name=p31496 lab=_85803_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -24360 0 0 {name=X_85803_ }
C {devices/lab_pin.sym} 32000 -24240 0 0 {name=p31497 lab=_58751_/A }
C {devices/lab_pin.sym} 32000 -24200 0 0 {name=p31498 lab=_58764_/B }
C {devices/lab_pin.sym} 32120 -24220 0 1 {name=p31499 lab=_58751_/Y }
C {sky130_stdcells/nor2_4.sym} 32060 -24220 0 0 {name=X_58751_ }
C {devices/lab_pin.sym} 32000 -24100 0 0 {name=p31500 lab=_51097_/A }
C {devices/lab_pin.sym} 32000 -24060 0 0 {name=p31501 lab=_52777_/B }
C {devices/lab_pin.sym} 32120 -24080 0 1 {name=p31502 lab=_51086_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -24080 0 0 {name=X_51086_ }
C {devices/lab_pin.sym} 32000 -23960 0 0 {name=p31503 lab=_55698_/A }
C {devices/lab_pin.sym} 32000 -23920 0 0 {name=p31504 lab=_55963_/B }
C {devices/lab_pin.sym} 32120 -23940 0 1 {name=p31505 lab=_55963_/X }
C {sky130_stdcells/and2_4.sym} 32060 -23940 0 0 {name=X_55963_ }
C {devices/lab_pin.sym} 32020 -23810 0 0 {name=p31506 lab=_68714_/A }
C {devices/lab_pin.sym} 32100 -23810 0 1 {name=p31507 lab=_69747_/A }
C {sky130_stdcells/buf_2.sym} 32060 -23810 0 0 {name=X_67949_ }
C {devices/lab_pin.sym} 31970 -23690 0 0 {name=p31508 lab=_82317_/CLK }
C {devices/lab_pin.sym} 31970 -23670 0 0 {name=p31509 lab=_86783_/D }
C {devices/lab_pin.sym} 32150 -23690 0 1 {name=p31510 lab=_67123_/B }
C {sky130_stdcells/dfxtp_4.sym} 32060 -23680 0 0 {name=X_86783_ }
C {devices/lab_pin.sym} 31970 -23550 0 0 {name=p31511 lab=_84003_/CLK }
C {devices/lab_pin.sym} 31970 -23530 0 0 {name=p31512 lab=_83995_/D }
C {devices/lab_pin.sym} 32150 -23550 0 1 {name=p31513 lab=_82643_/D }
C {sky130_stdcells/dfxtp_4.sym} 32060 -23540 0 0 {name=X_83995_ }
C {devices/lab_pin.sym} 32020 -23410 0 0 {name=p31514 lab=_58635_/A }
C {devices/lab_pin.sym} 32100 -23410 0 1 {name=p31515 lab=_57872_/A }
C {sky130_stdcells/buf_2.sym} 32060 -23410 0 0 {name=X_57702_ }
C {devices/lab_pin.sym} 31980 -23310 0 0 {name=p31516 lab=_50034_/Y }
C {devices/lab_pin.sym} 31980 -23270 0 0 {name=p31517 lab=_50029_/X }
C {devices/lab_pin.sym} 31980 -23230 0 0 {name=p31518 lab=_50036_/X }
C {devices/lab_pin.sym} 32140 -23270 0 1 {name=p31519 lab=_86277_/D }
C {sky130_stdcells/a21oi_4.sym} 32060 -23270 0 0 {name=X_50037_ }
C {devices/lab_pin.sym} 32020 -23130 0 0 {name=p31520 lab=_54888_/A }
C {devices/lab_pin.sym} 32100 -23130 0 1 {name=p31521 lab=_54932_/A }
C {sky130_stdcells/buf_2.sym} 32060 -23130 0 0 {name=X_54914_ }
C {devices/lab_pin.sym} 31970 -23010 0 0 {name=p31522 lab=_85735_/CLK }
C {devices/lab_pin.sym} 31970 -22990 0 0 {name=p31523 lab=_52901_/Y }
C {devices/lab_pin.sym} 32150 -23010 0 1 {name=p31524 lab=_85734_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -23000 0 0 {name=X_85734_ }
C {devices/lab_pin.sym} 32020 -22870 0 0 {name=p31525 lab=_70959_/X }
C {devices/lab_pin.sym} 32100 -22870 0 1 {name=p31526 lab=_70961_/A }
C {sky130_stdcells/buf_2.sym} 32060 -22870 0 0 {name=X_70960_ }
C {devices/lab_pin.sym} 31970 -22750 0 0 {name=p31527 lab=_82961_/CLK }
C {devices/lab_pin.sym} 31970 -22730 0 0 {name=p31528 lab=_82946_/D }
C {devices/lab_pin.sym} 32150 -22750 0 1 {name=p31529 lab=_82946_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -22740 0 0 {name=X_82946_ }
C {devices/lab_pin.sym} 32020 -22610 0 0 {name=p31530 lab=_58813_/A }
C {devices/lab_pin.sym} 32100 -22610 0 1 {name=p31531 lab=_58682_/X }
C {sky130_stdcells/buf_2.sym} 32060 -22610 0 0 {name=X_58682_ }
C {devices/lab_pin.sym} 32000 -22500 0 0 {name=p31532 lab=_55620_/A }
C {devices/lab_pin.sym} 32000 -22460 0 0 {name=p31533 lab=_85239_/Q }
C {devices/lab_pin.sym} 32120 -22480 0 1 {name=p31534 lab=_55894_/X }
C {sky130_stdcells/and2_4.sym} 32060 -22480 0 0 {name=X_55894_ }
C {devices/lab_pin.sym} 31980 -22370 0 0 {name=p31535 lab=_57631_/Y }
C {devices/lab_pin.sym} 31980 -22330 0 0 {name=p31536 lab=_57627_/X }
C {devices/lab_pin.sym} 31980 -22290 0 0 {name=p31537 lab=_57632_/Y }
C {devices/lab_pin.sym} 32140 -22330 0 1 {name=p31538 lab=_84965_/D }
C {sky130_stdcells/a21boi_4.sym} 32060 -22330 0 0 {name=X_57633_ }
C {devices/lab_pin.sym} 32000 -22200 0 0 {name=p31539 lab=_64696_/A }
C {devices/lab_pin.sym} 32000 -22160 0 0 {name=p31540 lab=_69619_/B }
C {devices/lab_pin.sym} 32120 -22180 0 1 {name=p31541 lab=_69619_/Y }
C {sky130_stdcells/nor2_4.sym} 32060 -22180 0 0 {name=X_69619_ }
C {devices/lab_pin.sym} 32020 -22050 0 0 {name=p31542 lab=clkbuf_9_186_0_CLK/X }
C {devices/lab_pin.sym} 32100 -22050 0 1 {name=p31543 lab=_85431_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32060 -22050 0 0 {name=Xclkbuf_10_372_0_CLK }
C {devices/lab_pin.sym} 32000 -21940 0 0 {name=p31544 lab=_54850_/A }
C {devices/lab_pin.sym} 32000 -21900 0 0 {name=p31545 lab=_47623_/A }
C {devices/lab_pin.sym} 32120 -21920 0 1 {name=p31546 lab=_54845_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -21920 0 0 {name=X_54845_ }
C {devices/lab_pin.sym} 31970 -21790 0 0 {name=p31547 lab=_85444_/CLK }
C {devices/lab_pin.sym} 31970 -21770 0 0 {name=p31548 lab=_53267_/Y }
C {devices/lab_pin.sym} 32150 -21790 0 1 {name=p31549 lab=_85665_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -21780 0 0 {name=X_85665_ }
C {devices/lab_pin.sym} 31980 -21670 0 0 {name=p31550 lab=_50976_/B }
C {devices/lab_pin.sym} 31980 -21630 0 0 {name=p31551 lab=_70885_/X }
C {devices/lab_pin.sym} 31980 -21590 0 0 {name=p31552 lab=_70890_/Y }
C {devices/lab_pin.sym} 32140 -21630 0 1 {name=p31553 lab=_70891_/Y }
C {sky130_stdcells/o21ai_4.sym} 32060 -21630 0 0 {name=X_70891_ }
C {devices/lab_pin.sym} 31970 -21490 0 0 {name=p31554 lab=_82859_/CLK }
C {devices/lab_pin.sym} 31970 -21470 0 0 {name=p31555 lab=_78273_/B }
C {devices/lab_pin.sym} 32150 -21490 0 1 {name=p31556 lab=_82877_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -21480 0 0 {name=X_82877_ }
C {devices/lab_pin.sym} 31970 -21350 0 0 {name=p31557 lab=_83987_/CLK }
C {devices/lab_pin.sym} 31970 -21330 0 0 {name=p31558 lab=_87404_/D }
C {devices/lab_pin.sym} 32150 -21350 0 1 {name=p31559 lab=_87404_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -21340 0 0 {name=X_87404_ }
C {devices/lab_pin.sym} 31980 -21240 0 0 {name=p31560 lab=_40400_/X }
C {devices/lab_pin.sym} 31980 -21200 0 0 {name=p31561 lab=_41799_/X }
C {devices/lab_pin.sym} 31980 -21160 0 0 {name=p31562 lab=_88141_/Q }
C {devices/lab_pin.sym} 31980 -21120 0 0 {name=p31563 lab=_41800_/X }
C {devices/lab_pin.sym} 32140 -21180 0 1 {name=p31564 lab=_41810_/X }
C {sky130_stdcells/a2bb2o_4.sym} 32060 -21180 0 0 {name=X_41810_ }
C {devices/lab_pin.sym} 32020 -21030 0 0 {name=p31565 lab=_73078_/A }
C {devices/lab_pin.sym} 32100 -21030 0 1 {name=p31566 lab=_72630_/X }
C {sky130_stdcells/buf_2.sym} 32060 -21030 0 0 {name=X_72630_ }
C {devices/lab_pin.sym} 31970 -20910 0 0 {name=p31567 lab=_83216_/CLK }
C {devices/lab_pin.sym} 31970 -20890 0 0 {name=p31568 lab=_84616_/D }
C {devices/lab_pin.sym} 32150 -20910 0 1 {name=p31569 lab=_79156_/A }
C {sky130_stdcells/dfxtp_4.sym} 32060 -20900 0 0 {name=X_84616_ }
C {devices/lab_pin.sym} 32020 -20770 0 0 {name=p31570 lab=_57563_/X }
C {devices/lab_pin.sym} 32100 -20770 0 1 {name=p31571 lab=_57564_/X }
C {sky130_stdcells/buf_2.sym} 32060 -20770 0 0 {name=X_57564_ }
C {devices/lab_pin.sym} 31970 -20650 0 0 {name=p31572 lab=_82211_/CLK }
C {devices/lab_pin.sym} 31970 -20630 0 0 {name=p31573 lab=_81828_/D }
C {devices/lab_pin.sym} 32150 -20650 0 1 {name=p31574 lab=_77249_/A }
C {sky130_stdcells/dfxtp_4.sym} 32060 -20640 0 0 {name=X_81828_ }
C {devices/lab_pin.sym} 31970 -20510 0 0 {name=p31575 lab=_86796_/CLK }
C {devices/lab_pin.sym} 31970 -20490 0 0 {name=p31576 lab=_40486_/X }
C {devices/lab_pin.sym} 32150 -20510 0 1 {name=p31577 lab=_88384_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -20500 0 0 {name=X_88384_ }
C {devices/lab_pin.sym} 31980 -20390 0 0 {name=p31578 lab=_54773_/Y }
C {devices/lab_pin.sym} 31980 -20350 0 0 {name=p31579 lab=_54774_/X }
C {devices/lab_pin.sym} 31980 -20310 0 0 {name=p31580 lab=_54775_/X }
C {devices/lab_pin.sym} 32140 -20350 0 1 {name=p31581 lab=_85380_/D }
C {sky130_stdcells/a21oi_4.sym} 32060 -20350 0 0 {name=X_54776_ }
C {devices/lab_pin.sym} 31980 -20240 0 0 {name=p31582 lab=_41361_/X }
C {devices/lab_pin.sym} 31980 -20200 0 0 {name=p31583 lab=_42787_/X }
C {devices/lab_pin.sym} 31980 -20160 0 0 {name=p31584 lab=_87717_/Q }
C {devices/lab_pin.sym} 31980 -20120 0 0 {name=p31585 lab=_42788_/X }
C {devices/lab_pin.sym} 32140 -20180 0 1 {name=p31586 lab=_42790_/X }
C {sky130_stdcells/a2bb2o_4.sym} 32060 -20180 0 0 {name=X_42790_ }
C {devices/lab_pin.sym} 31970 -20030 0 0 {name=p31587 lab=_85596_/CLK }
C {devices/lab_pin.sym} 31970 -20010 0 0 {name=p31588 lab=_85596_/D }
C {devices/lab_pin.sym} 32150 -20030 0 1 {name=p31589 lab=_85596_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -20020 0 0 {name=X_85596_ }
C {devices/lab_pin.sym} 32000 -19910 0 0 {name=p31590 lab=_51988_/A }
C {devices/lab_pin.sym} 32000 -19870 0 0 {name=p31591 lab=_51972_/X }
C {devices/lab_pin.sym} 32000 -19830 0 0 {name=p31592 lab=_51958_/C }
C {devices/lab_pin.sym} 32120 -19870 0 1 {name=p31593 lab=_51988_/X }
C {sky130_stdcells/and3_4.sym} 32060 -19870 0 0 {name=X_51988_ }
C {devices/lab_pin.sym} 31980 -19760 0 0 {name=p31594 lab=_59291_/Y }
C {devices/lab_pin.sym} 31980 -19720 0 0 {name=p31595 lab=_59230_/X }
C {devices/lab_pin.sym} 31980 -19680 0 0 {name=p31596 lab=_59298_/X }
C {devices/lab_pin.sym} 31980 -19640 0 0 {name=p31597 lab=_59302_/X }
C {devices/lab_pin.sym} 32140 -19700 0 1 {name=p31598 lab=_59303_/Y }
C {sky130_stdcells/a22oi_4.sym} 32060 -19700 0 0 {name=X_59303_ }
C {devices/lab_pin.sym} 32020 -19550 0 0 {name=p31599 lab=_56528_/A }
C {devices/lab_pin.sym} 32100 -19550 0 1 {name=p31600 lab=_56515_/X }
C {sky130_stdcells/buf_2.sym} 32060 -19550 0 0 {name=X_56515_ }
C {devices/lab_pin.sym} 32020 -19430 0 0 {name=p31601 lab=clkbuf_9_493_0_CLK/A }
C {devices/lab_pin.sym} 32100 -19430 0 1 {name=p31602 lab=clkbuf_9_493_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 32060 -19430 0 0 {name=Xclkbuf_9_493_0_CLK }
C {devices/lab_pin.sym} 31970 -19310 0 0 {name=p31603 lab=_87345_/CLK }
C {devices/lab_pin.sym} 31970 -19290 0 0 {name=p31604 lab=_87335_/D }
C {devices/lab_pin.sym} 32150 -19310 0 1 {name=p31605 lab=_87335_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -19300 0 0 {name=X_87335_ }
C {devices/lab_pin.sym} 31980 -19190 0 0 {name=p31606 lab=_53725_/Y }
C {devices/lab_pin.sym} 31980 -19150 0 0 {name=p31607 lab=_53696_/X }
C {devices/lab_pin.sym} 31980 -19110 0 0 {name=p31608 lab=_53726_/Y }
C {devices/lab_pin.sym} 32140 -19150 0 1 {name=p31609 lab=_53727_/Y }
C {sky130_stdcells/a21boi_4.sym} 32060 -19150 0 0 {name=X_53727_ }
C {devices/lab_pin.sym} 32020 -19010 0 0 {name=p31610 lab=_41741_/A }
C {devices/lab_pin.sym} 32100 -19010 0 1 {name=p31611 lab=_41741_/X }
C {sky130_stdcells/buf_2.sym} 32060 -19010 0 0 {name=X_41741_ }
C {devices/lab_pin.sym} 32000 -18910 0 0 {name=p31612 lab=_72539_/B }
C {devices/lab_pin.sym} 32000 -18870 0 0 {name=p31613 lab=_72510_/C }
C {devices/lab_pin.sym} 32000 -18830 0 0 {name=p31614 lab=_72561_/C }
C {devices/lab_pin.sym} 32120 -18870 0 1 {name=p31615 lab=_72562_/A }
C {sky130_stdcells/and3_4.sym} 32060 -18870 0 0 {name=X_72561_ }
C {devices/lab_pin.sym} 31970 -18730 0 0 {name=p31616 lab=_84529_/CLK }
C {devices/lab_pin.sym} 31970 -18710 0 0 {name=p31617 lab=_84547_/D }
C {devices/lab_pin.sym} 32150 -18730 0 1 {name=p31618 lab=_60970_/C }
C {sky130_stdcells/dfxtp_4.sym} 32060 -18720 0 0 {name=X_84547_ }
C {devices/lab_pin.sym} 32000 -18600 0 0 {name=p31619 lab=_50938_/X }
C {devices/lab_pin.sym} 32000 -18560 0 0 {name=p31620 lab=_51800_/B }
C {devices/lab_pin.sym} 32120 -18580 0 1 {name=p31621 lab=_50939_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -18580 0 0 {name=X_50939_ }
C {devices/lab_pin.sym} 32000 -18460 0 0 {name=p31622 lab=_57499_/A }
C {devices/lab_pin.sym} 32000 -18420 0 0 {name=p31623 lab=_73591_/A }
C {devices/lab_pin.sym} 32120 -18440 0 1 {name=p31624 lab=_57495_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -18440 0 0 {name=X_57495_ }
C {devices/lab_pin.sym} 31970 -18310 0 0 {name=p31625 lab=_81783_/CLK }
C {devices/lab_pin.sym} 31970 -18290 0 0 {name=p31626 lab=_76136_/B }
C {devices/lab_pin.sym} 32150 -18310 0 1 {name=p31627 lab=_81759_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -18300 0 0 {name=X_81759_ }
C {devices/lab_pin.sym} 31980 -18190 0 0 {name=p31628 lab=_70285_/C }
C {devices/lab_pin.sym} 31980 -18150 0 0 {name=p31629 lab=_74288_/X }
C {devices/lab_pin.sym} 31980 -18110 0 0 {name=p31630 lab=_74299_/Y }
C {devices/lab_pin.sym} 32140 -18150 0 1 {name=p31631 lab=_83107_/D }
C {sky130_stdcells/a21bo_4.sym} 32060 -18150 0 0 {name=X_74300_ }
C {devices/lab_pin.sym} 32020 -18010 0 0 {name=p31632 lab=clkbuf_9_193_0_CLK/X }
C {devices/lab_pin.sym} 32100 -18010 0 1 {name=p31633 lab=_84487_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32060 -18010 0 0 {name=Xclkbuf_10_387_0_CLK }
C {devices/lab_pin.sym} 31980 -17910 0 0 {name=p31634 lab=_59219_/X }
C {devices/lab_pin.sym} 31980 -17870 0 0 {name=p31635 lab=_85742_/Q }
C {devices/lab_pin.sym} 31980 -17830 0 0 {name=p31636 lab=_59220_/X }
C {devices/lab_pin.sym} 32140 -17870 0 1 {name=p31637 lab=_59234_/X }
C {sky130_stdcells/o21a_4.sym} 32060 -17870 0 0 {name=X_59234_ }
C {devices/lab_pin.sym} 32000 -17740 0 0 {name=p31638 lab=_71512_/A }
C {devices/lab_pin.sym} 32000 -17700 0 0 {name=p31639 lab=_70710_/A }
C {devices/lab_pin.sym} 32120 -17720 0 1 {name=p31640 lab=_71512_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -17720 0 0 {name=X_71512_ }
C {devices/lab_pin.sym} 31980 -17630 0 0 {name=p31641 lab=_44447_/X }
C {devices/lab_pin.sym} 31980 -17590 0 0 {name=p31642 lab=_44448_/X }
C {devices/lab_pin.sym} 31980 -17550 0 0 {name=p31643 lab=_41138_/X }
C {devices/lab_pin.sym} 31980 -17510 0 0 {name=p31644 lab=_87098_/Q }
C {devices/lab_pin.sym} 31980 -17470 0 0 {name=p31645 lab=_44449_/X }
C {devices/lab_pin.sym} 32140 -17550 0 1 {name=p31646 lab=_44461_/A }
C {sky130_stdcells/o32ai_4.sym} 32060 -17550 0 0 {name=X_44460_ }
C {devices/lab_pin.sym} 32000 -17410 0 0 {name=p31647 lab=_56446_/A }
C {devices/lab_pin.sym} 32000 -17370 0 0 {name=p31648 lab=_56446_/B }
C {devices/lab_pin.sym} 32000 -17330 0 0 {name=p31649 lab=_85190_/Q }
C {devices/lab_pin.sym} 32120 -17370 0 1 {name=p31650 lab=_56446_/Y }
C {sky130_stdcells/nand3_4.sym} 32060 -17370 0 0 {name=X_56446_ }
C {devices/lab_pin.sym} 31980 -17250 0 0 {name=p31651 lab=_75252_/Y }
C {devices/lab_pin.sym} 31980 -17210 0 0 {name=p31652 lab=_75251_/Y }
C {devices/lab_pin.sym} 31980 -17170 0 0 {name=p31653 lab=_75261_/B }
C {devices/lab_pin.sym} 32140 -17210 0 1 {name=p31654 lab=_75280_/X }
C {sky130_stdcells/a21bo_4.sym} 32060 -17210 0 0 {name=X_75280_ }
C {devices/lab_pin.sym} 32020 -17070 0 0 {name=p31655 lab=_41802_/A }
C {devices/lab_pin.sym} 32100 -17070 0 1 {name=p31656 lab=_41672_/X }
C {sky130_stdcells/buf_2.sym} 32060 -17070 0 0 {name=X_41672_ }
C {devices/lab_pin.sym} 31970 -16950 0 0 {name=p31657 lab=_88034_/CLK }
C {devices/lab_pin.sym} 31970 -16930 0 0 {name=p31658 lab=_43789_/X }
C {devices/lab_pin.sym} 32150 -16950 0 1 {name=p31659 lab=_69372_/B }
C {sky130_stdcells/dfxtp_4.sym} 32060 -16940 0 0 {name=X_87266_ }
C {devices/lab_pin.sym} 32000 -16830 0 0 {name=p31660 lab=_48752_/A }
C {devices/lab_pin.sym} 32000 -16790 0 0 {name=p31661 lab=_53658_/B }
C {devices/lab_pin.sym} 32000 -16750 0 0 {name=p31662 lab=_53667_/C }
C {devices/lab_pin.sym} 32120 -16790 0 1 {name=p31663 lab=_53658_/X }
C {sky130_stdcells/and3_4.sym} 32060 -16790 0 0 {name=X_53658_ }
C {devices/lab_pin.sym} 32000 -16660 0 0 {name=p31664 lab=_63598_/A }
C {devices/lab_pin.sym} 32000 -16620 0 0 {name=p31665 lab=_72488_/B }
C {devices/lab_pin.sym} 32120 -16640 0 1 {name=p31666 lab=_72492_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -16640 0 0 {name=X_72492_ }
C {devices/lab_pin.sym} 31970 -16510 0 0 {name=p31667 lab=_84481_/CLK }
C {devices/lab_pin.sym} 31970 -16490 0 0 {name=p31668 lab=_84478_/D }
C {devices/lab_pin.sym} 32150 -16510 0 1 {name=p31669 lab=_84478_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -16500 0 0 {name=X_84478_ }
C {sky130_stdcells/decap_3.sym} 32060 -16340 0 0 {name=XPHY_110 }
C {devices/lab_pin.sym} 31980 -16220 0 0 {name=p31670 lab=_41507_/X }
C {devices/lab_pin.sym} 31980 -16180 0 0 {name=p31671 lab=_43396_/X }
C {devices/lab_pin.sym} 31980 -16140 0 0 {name=p31672 lab=_87434_/Q }
C {devices/lab_pin.sym} 31980 -16100 0 0 {name=p31673 lab=_43397_/X }
C {devices/lab_pin.sym} 32140 -16160 0 1 {name=p31674 lab=_43411_/X }
C {sky130_stdcells/a2bb2o_4.sym} 32060 -16160 0 0 {name=X_43411_ }
C {devices/lab_pin.sym} 32000 -16020 0 0 {name=p31675 lab=_74228_/X }
C {devices/lab_pin.sym} 32000 -15980 0 0 {name=p31676 lab=_74230_/X }
C {devices/lab_pin.sym} 32120 -16000 0 1 {name=p31677 lab=_74241_/A }
C {sky130_stdcells/nand2_4.sym} 32060 -16000 0 0 {name=X_74231_ }
C {devices/lab_pin.sym} 31970 -15870 0 0 {name=p31678 lab=_86218_/CLK }
C {devices/lab_pin.sym} 31970 -15850 0 0 {name=p31679 lab=_50357_/Y }
C {devices/lab_pin.sym} 32150 -15870 0 1 {name=p31680 lab=_86217_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -15860 0 0 {name=X_86217_ }
C {devices/lab_pin.sym} 32020 -15730 0 0 {name=p31681 lab=_48904_/A }
C {devices/lab_pin.sym} 32100 -15730 0 1 {name=p31682 lab=_40623_/X }
C {sky130_stdcells/buf_2.sym} 32060 -15730 0 0 {name=X_40623_ }
C {sky130_stdcells/decap_3.sym} 32060 -15580 0 0 {name=XPHY_121 }
C {devices/lab_pin.sym} 31980 -15450 0 0 {name=p31683 lab=_85787_/Q }
C {devices/lab_pin.sym} 31980 -15410 0 0 {name=p31684 lab=_52601_/X }
C {devices/lab_pin.sym} 31980 -15370 0 0 {name=p31685 lab=_52608_/Y }
C {devices/lab_pin.sym} 32140 -15410 0 1 {name=p31686 lab=_52609_/Y }
C {sky130_stdcells/o21ai_4.sym} 32060 -15410 0 0 {name=X_52609_ }
C {devices/lab_pin.sym} 32020 -15270 0 0 {name=p31687 lab=_58939_/A }
C {devices/lab_pin.sym} 32100 -15270 0 1 {name=p31688 lab=_59165_/X }
C {sky130_stdcells/buf_2.sym} 32060 -15270 0 0 {name=X_59165_ }
C {devices/lab_pin.sym} 31980 -15170 0 0 {name=p31689 lab=_58145_/Y }
C {devices/lab_pin.sym} 31980 -15130 0 0 {name=p31690 lab=_71444_/A }
C {devices/lab_pin.sym} 31980 -15090 0 0 {name=p31691 lab=_71442_/Y }
C {devices/lab_pin.sym} 32140 -15130 0 1 {name=p31692 lab=_71443_/Y }
C {sky130_stdcells/o21ai_4.sym} 32060 -15130 0 0 {name=X_71443_ }
C {devices/lab_pin.sym} 31970 -14990 0 0 {name=p31693 lab=_82386_/CLK }
C {devices/lab_pin.sym} 31970 -14970 0 0 {name=p31694 lab=_71640_/Y }
C {devices/lab_pin.sym} 32150 -14990 0 1 {name=p31695 lab=_59493_/A }
C {sky130_stdcells/dfxtp_4.sym} 32060 -14980 0 0 {name=X_83429_ }
C {devices/lab_pin.sym} 32020 -14850 0 0 {name=p31696 lab=_56370_/Y }
C {devices/lab_pin.sym} 32100 -14850 0 1 {name=p31697 lab=_56377_/X }
C {sky130_stdcells/buf_2.sym} 32060 -14850 0 0 {name=X_56377_ }
C {devices/lab_pin.sym} 31980 -14770 0 0 {name=p31698 lab=_44381_/X }
C {devices/lab_pin.sym} 31980 -14730 0 0 {name=p31699 lab=_44382_/X }
C {devices/lab_pin.sym} 31980 -14690 0 0 {name=p31700 lab=_41473_/X }
C {devices/lab_pin.sym} 31980 -14650 0 0 {name=p31701 lab=_87132_/Q }
C {devices/lab_pin.sym} 31980 -14610 0 0 {name=p31702 lab=_44383_/X }
C {devices/lab_pin.sym} 32140 -14690 0 1 {name=p31703 lab=_44392_/A }
C {sky130_stdcells/o32ai_4.sym} 32060 -14690 0 0 {name=X_44391_ }
C {sky130_stdcells/decap_3.sym} 32060 -14500 0 0 {name=XPHY_132 }
C {devices/lab_pin.sym} 31970 -14350 0 0 {name=p31704 lab=_87446_/CLK }
C {devices/lab_pin.sym} 31970 -14330 0 0 {name=p31705 lab=_87197_/D }
C {devices/lab_pin.sym} 32150 -14350 0 1 {name=p31706 lab=_67856_/B }
C {sky130_stdcells/dfxtp_4.sym} 32060 -14340 0 0 {name=X_87197_ }
C {devices/lab_pin.sym} 31980 -14230 0 0 {name=p31707 lab=_85607_/Q }
C {devices/lab_pin.sym} 31980 -14190 0 0 {name=p31708 lab=_53586_/X }
C {devices/lab_pin.sym} 31980 -14150 0 0 {name=p31709 lab=_53588_/Y }
C {devices/lab_pin.sym} 32140 -14190 0 1 {name=p31710 lab=_53589_/Y }
C {sky130_stdcells/o21ai_4.sym} 32060 -14190 0 0 {name=X_53589_ }
C {sky130_stdcells/decap_3.sym} 32060 -14020 0 0 {name=XPHY_143 }
C {sky130_stdcells/decap_3.sym} 32060 -13840 0 0 {name=XPHY_154 }
C {devices/lab_pin.sym} 32000 -13700 0 0 {name=p31711 lab=_57991_/A }
C {devices/lab_pin.sym} 32000 -13660 0 0 {name=p31712 lab=_58116_/B }
C {devices/lab_pin.sym} 32120 -13680 0 1 {name=p31713 lab=_58116_/Y }
C {sky130_stdcells/nor2_4.sym} 32060 -13680 0 0 {name=X_58116_ }
C {devices/lab_pin.sym} 32000 -13560 0 0 {name=p31714 lab=_46164_/A }
C {devices/lab_pin.sym} 32000 -13520 0 0 {name=p31715 lab=_46087_/A }
C {devices/lab_pin.sym} 32120 -13540 0 1 {name=p31716 lab=_46133_/B }
C {sky130_stdcells/nor2_4.sym} 32060 -13540 0 0 {name=X_46130_ }
C {sky130_stdcells/decap_3.sym} 32060 -13380 0 0 {name=XPHY_165 }
C {devices/lab_pin.sym} 31980 -13270 0 0 {name=p31717 lab=_43316_/X }
C {devices/lab_pin.sym} 31980 -13230 0 0 {name=p31718 lab=_43319_/X }
C {devices/lab_pin.sym} 31980 -13190 0 0 {name=p31719 lab=_41316_/X }
C {devices/lab_pin.sym} 31980 -13150 0 0 {name=p31720 lab=_87469_/Q }
C {devices/lab_pin.sym} 31980 -13110 0 0 {name=p31721 lab=_43330_/X }
C {devices/lab_pin.sym} 32140 -13190 0 1 {name=p31722 lab=_43342_/Y }
C {sky130_stdcells/o32ai_4.sym} 32060 -13190 0 0 {name=X_43342_ }
C {devices/lab_pin.sym} 32000 -13040 0 0 {name=p31723 lab=_74202_/A }
C {devices/lab_pin.sym} 32000 -13000 0 0 {name=p31724 lab=_74161_/Y }
C {devices/lab_pin.sym} 32120 -13020 0 1 {name=p31725 lab=_74162_/Y }
C {sky130_stdcells/nor2_4.sym} 32060 -13020 0 0 {name=X_74162_ }
C {devices/lab_pin.sym} 32000 -12920 0 0 {name=p31726 lab=_55316_/X }
C {devices/lab_pin.sym} 32000 -12880 0 0 {name=p31727 lab=_55325_/X }
C {devices/lab_pin.sym} 32000 -12840 0 0 {name=p31728 lab=_55328_/C }
C {devices/lab_pin.sym} 32000 -12800 0 0 {name=p31729 lab=_55384_/A }
C {devices/lab_pin.sym} 32120 -12860 0 1 {name=p31730 lab=_55328_/X }
C {sky130_stdcells/and4_4.sym} 32060 -12860 0 0 {name=X_55328_ }
C {devices/lab_pin.sym} 31970 -12710 0 0 {name=p31731 lab=_83594_/CLK }
C {devices/lab_pin.sym} 31970 -12690 0 0 {name=p31732 lab=_86148_/D }
C {devices/lab_pin.sym} 32150 -12710 0 1 {name=p31733 lab=_86148_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -12700 0 0 {name=X_86148_ }
C {devices/lab_pin.sym} 32020 -12570 0 0 {name=p31734 lab=_40636_/A }
C {devices/lab_pin.sym} 32100 -12570 0 1 {name=p31735 lab=_40554_/X }
C {sky130_stdcells/buf_2.sym} 32060 -12570 0 0 {name=X_40554_ }
C {sky130_stdcells/decap_3.sym} 32060 -12420 0 0 {name=XPHY_176 }
C {devices/lab_pin.sym} 32020 -12270 0 0 {name=p31736 lab=clkbuf_9_155_0_CLK/X }
C {devices/lab_pin.sym} 32100 -12270 0 1 {name=p31737 lab=_84939_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32060 -12270 0 0 {name=Xclkbuf_10_310_0_CLK }
C {devices/lab_pin.sym} 31980 -12170 0 0 {name=p31738 lab=_59048_/X }
C {devices/lab_pin.sym} 31980 -12130 0 0 {name=p31739 lab=_85657_/Q }
C {devices/lab_pin.sym} 31980 -12090 0 0 {name=p31740 lab=_59070_/X }
C {devices/lab_pin.sym} 32140 -12130 0 1 {name=p31741 lab=_59096_/X }
C {sky130_stdcells/o21a_4.sym} 32060 -12130 0 0 {name=X_59096_ }
C {devices/lab_pin.sym} 32020 -11990 0 0 {name=p31742 lab=_71164_/B }
C {devices/lab_pin.sym} 32100 -11990 0 1 {name=p31743 lab=_71377_/B }
C {sky130_stdcells/buf_2.sym} 32060 -11990 0 0 {name=X_71374_ }
C {sky130_stdcells/decap_3.sym} 32060 -11840 0 0 {name=XPHY_187 }
C {sky130_stdcells/decap_3.sym} 32060 -11660 0 0 {name=XPHY_198 }
C {devices/lab_pin.sym} 31980 -11540 0 0 {name=p31744 lab=_72988_/X }
C {devices/lab_pin.sym} 31980 -11500 0 0 {name=p31745 lab=_86196_/Q }
C {devices/lab_pin.sym} 31980 -11460 0 0 {name=p31746 lab=_72985_/X }
C {devices/lab_pin.sym} 31980 -11420 0 0 {name=p31747 lab=_73112_/X }
C {devices/lab_pin.sym} 32140 -11480 0 1 {name=p31748 lab=_73113_/X }
C {sky130_stdcells/a211o_4.sym} 32060 -11480 0 0 {name=X_73113_ }
C {devices/lab_pin.sym} 32020 -11330 0 0 {name=p31749 lab=clkbuf_9_470_0_CLK/X }
C {devices/lab_pin.sym} 32100 -11330 0 1 {name=p31750 lab=_87577_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32060 -11330 0 0 {name=Xclkbuf_10_940_0_CLK }
C {devices/lab_pin.sym} 32020 -11210 0 0 {name=p31751 lab=_43585_/X }
C {devices/lab_pin.sym} 32100 -11210 0 1 {name=p31752 lab=_46061_/X }
C {sky130_stdcells/buf_2.sym} 32060 -11210 0 0 {name=X_46061_ }
C {devices/lab_pin.sym} 31980 -11120 0 0 {name=p31753 lab=_84930_/Q }
C {devices/lab_pin.sym} 31980 -11080 0 0 {name=p31754 lab=_58025_/X }
C {devices/lab_pin.sym} 31980 -11040 0 0 {name=p31755 lab=_58040_/X }
C {devices/lab_pin.sym} 31980 -11000 0 0 {name=p31756 lab=_58046_/X }
C {devices/lab_pin.sym} 32140 -11060 0 1 {name=p31757 lab=_84930_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 32060 -11060 0 0 {name=X_58047_ }
C {devices/lab_pin.sym} 32020 -10910 0 0 {name=p31758 lab=_83796_/Q }
C {devices/lab_pin.sym} 32100 -10910 0 1 {name=p31759 lab=_70325_/Y }
C {sky130_stdcells/inv_2.sym} 32060 -10910 0 0 {name=X_70325_ }
C {devices/lab_pin.sym} 32020 -10790 0 0 {name=p31760 lab=_43212_/A }
C {devices/lab_pin.sym} 32100 -10790 0 1 {name=p31761 lab=_43273_/X }
C {sky130_stdcells/buf_2.sym} 32060 -10790 0 0 {name=X_43273_ }
C {devices/lab_pin.sym} 31980 -10700 0 0 {name=p31762 lab=_57039_/A }
C {devices/lab_pin.sym} 31980 -10660 0 0 {name=p31763 lab=_44058_/A }
C {devices/lab_pin.sym} 31980 -10620 0 0 {name=p31764 lab=_55134_/X }
C {devices/lab_pin.sym} 31980 -10580 0 0 {name=p31765 lab=_55258_/X }
C {devices/lab_pin.sym} 32140 -10640 0 1 {name=p31766 lab=_55259_/X }
C {sky130_stdcells/a211o_4.sym} 32060 -10640 0 0 {name=X_55259_ }
C {devices/lab_pin.sym} 32000 -10500 0 0 {name=p31767 lab=_74117_/A }
C {devices/lab_pin.sym} 32000 -10460 0 0 {name=p31768 lab=_74093_/B }
C {devices/lab_pin.sym} 32120 -10480 0 1 {name=p31769 lab=_74093_/Y }
C {sky130_stdcells/nor2_4.sym} 32060 -10480 0 0 {name=X_74093_ }
C {devices/lab_pin.sym} 32000 -10360 0 0 {name=p31770 lab=_78957_/A }
C {devices/lab_pin.sym} 32000 -10320 0 0 {name=p31771 lab=_78970_/B }
C {devices/lab_pin.sym} 32120 -10340 0 1 {name=p31772 lab=_78970_/X }
C {sky130_stdcells/and2_4.sym} 32060 -10340 0 0 {name=X_78970_ }
C {devices/lab_pin.sym} 31970 -10210 0 0 {name=p31773 lab=_85761_/CLK }
C {devices/lab_pin.sym} 31970 -10190 0 0 {name=p31774 lab=_51072_/Y }
C {devices/lab_pin.sym} 32150 -10210 0 1 {name=p31775 lab=_86079_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32060 -10200 0 0 {name=X_86079_ }
C {devices/lab_pin.sym} 32020 -10070 0 0 {name=p31776 lab=_40484_/Y }
C {devices/lab_pin.sym} 32100 -10070 0 1 {name=p31777 lab=_40485_/X }
C {sky130_stdcells/buf_2.sym} 32060 -10070 0 0 {name=X_40485_ }
C {devices/lab_pin.sym} 32020 -9950 0 0 {name=p31778 lab=_45237_/A }
C {devices/lab_pin.sym} 32100 -9950 0 1 {name=p31779 lab=_45012_/X }
C {sky130_stdcells/buf_2.sym} 32060 -9950 0 0 {name=X_45012_ }
C {devices/lab_pin.sym} 32020 -9830 0 0 {name=p31780 lab=_42259_/A }
C {devices/lab_pin.sym} 32100 -9830 0 1 {name=p31781 lab=_42224_/X }
C {sky130_stdcells/buf_2.sym} 32060 -9830 0 0 {name=X_42224_ }
C {devices/lab_pin.sym} 31980 -9730 0 0 {name=p31782 lab=_73041_/X }
C {devices/lab_pin.sym} 31980 -9690 0 0 {name=p31783 lab=_73043_/X }
C {devices/lab_pin.sym} 31980 -9650 0 0 {name=p31784 lab=_72877_/X }
C {devices/lab_pin.sym} 32140 -9690 0 1 {name=p31785 lab=_73044_/X }
C {sky130_stdcells/a21o_4.sym} 32060 -9690 0 0 {name=X_73044_ }
C {devices/lab_pin.sym} 32000 -9560 0 0 {name=p31786 lab=_77908_/A }
C {devices/lab_pin.sym} 32000 -9520 0 0 {name=p31787 lab=_77907_/Y }
C {devices/lab_pin.sym} 32120 -9540 0 1 {name=p31788 lab=_77921_/Y }
C {sky130_stdcells/nor2_4.sym} 32060 -9540 0 0 {name=X_77921_ }
C {devices/lab_pin.sym} 32020 -9410 0 0 {name=p31789 lab=clkbuf_9_430_0_CLK/A }
C {devices/lab_pin.sym} 32100 -9410 0 1 {name=p31790 lab=clkbuf_9_431_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 32060 -9410 0 0 {name=Xclkbuf_9_431_0_CLK }
C {devices/lab_pin.sym} 32000 -9320 0 0 {name=p31791 lab=_70260_/A }
C {devices/lab_pin.sym} 32000 -9280 0 0 {name=p31792 lab=_70260_/B }
C {devices/lab_pin.sym} 32000 -9240 0 0 {name=p31793 lab=_83181_/Q }
C {devices/lab_pin.sym} 32000 -9200 0 0 {name=p31794 lab=_70260_/D }
C {devices/lab_pin.sym} 32120 -9260 0 1 {name=p31795 lab=_70256_/X }
C {sky130_stdcells/and4_4.sym} 32060 -9260 0 0 {name=X_70256_ }
C {devices/lab_pin.sym} 32000 -9120 0 0 {name=p31796 lab=_49809_/A }
C {devices/lab_pin.sym} 32000 -9080 0 0 {name=p31797 lab=_53033_/B }
C {devices/lab_pin.sym} 32120 -9100 0 1 {name=p31798 lab=_49820_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -9100 0 0 {name=X_49820_ }
C {devices/lab_pin.sym} 32020 -8970 0 0 {name=p31799 lab=clkbuf_9_162_0_CLK/X }
C {devices/lab_pin.sym} 32100 -8970 0 1 {name=p31800 lab=_85635_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32060 -8970 0 0 {name=Xclkbuf_10_325_0_CLK }
C {devices/lab_pin.sym} 31980 -8890 0 0 {name=p31801 lab=_42154_/X }
C {devices/lab_pin.sym} 31980 -8850 0 0 {name=p31802 lab=_42141_/X }
C {devices/lab_pin.sym} 31980 -8810 0 0 {name=p31803 lab=_41174_/X }
C {devices/lab_pin.sym} 31980 -8770 0 0 {name=p31804 lab=_88007_/Q }
C {devices/lab_pin.sym} 31980 -8730 0 0 {name=p31805 lab=_42142_/X }
C {devices/lab_pin.sym} 32140 -8810 0 1 {name=p31806 lab=_42155_/Y }
C {sky130_stdcells/o32ai_4.sym} 32060 -8810 0 0 {name=X_42155_ }
C {devices/lab_pin.sym} 32000 -8660 0 0 {name=p31807 lab=_82272_/Q }
C {devices/lab_pin.sym} 32000 -8620 0 0 {name=p31808 lab=_81984_/Q }
C {devices/lab_pin.sym} 32120 -8640 0 1 {name=p31809 lab=_77852_/Y }
C {sky130_stdcells/xnor2_4.sym} 32060 -8640 0 0 {name=X_77852_ }
C {devices/lab_pin.sym} 32020 -8510 0 0 {name=p31810 lab=_70233_/A }
C {devices/lab_pin.sym} 32100 -8510 0 1 {name=p31811 lab=_70200_/D }
C {sky130_stdcells/buf_2.sym} 32060 -8510 0 0 {name=X_70187_ }
C {devices/lab_pin.sym} 32000 -8420 0 0 {name=p31812 lab=_60543_/B }
C {devices/lab_pin.sym} 32000 -8380 0 0 {name=p31813 lab=_59998_/B }
C {devices/lab_pin.sym} 32000 -8340 0 0 {name=p31814 lab=_59951_/C }
C {devices/lab_pin.sym} 32000 -8300 0 0 {name=p31815 lab=_59977_/Y }
C {devices/lab_pin.sym} 32120 -8360 0 1 {name=p31816 lab=_59998_/Y }
C {sky130_stdcells/nand4_4.sym} 32060 -8360 0 0 {name=X_59998_ }
C {devices/lab_pin.sym} 32020 -8210 0 0 {name=p31817 lab=clkbuf_9_477_0_CLK/X }
C {devices/lab_pin.sym} 32100 -8210 0 1 {name=p31818 lab=_87821_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32060 -8210 0 0 {name=Xclkbuf_10_955_0_CLK }
C {devices/lab_pin.sym} 32000 -8100 0 0 {name=p31819 lab=_82274_/Q }
C {devices/lab_pin.sym} 32000 -8060 0 0 {name=p31820 lab=_41102_/B }
C {devices/lab_pin.sym} 32120 -8080 0 1 {name=p31821 lab=_41106_/X }
C {sky130_stdcells/or2_4.sym} 32060 -8080 0 0 {name=X_41106_ }
C {devices/lab_pin.sym} 32020 -7950 0 0 {name=p31822 lab=_81491_/Q }
C {devices/lab_pin.sym} 32100 -7950 0 1 {name=p31823 lab=_76805_/A }
C {sky130_stdcells/inv_2.sym} 32060 -7950 0 0 {name=X_76803_ }
C {devices/lab_pin.sym} 32000 -7860 0 0 {name=p31824 lab=_49751_/A }
C {devices/lab_pin.sym} 32000 -7820 0 0 {name=p31825 lab=_49750_/X }
C {devices/lab_pin.sym} 32000 -7780 0 0 {name=p31826 lab=_49761_/C }
C {devices/lab_pin.sym} 32000 -7740 0 0 {name=p31827 lab=_52967_/D }
C {devices/lab_pin.sym} 32120 -7800 0 1 {name=p31828 lab=_49751_/X }
C {sky130_stdcells/and4_4.sym} 32060 -7800 0 0 {name=X_49751_ }
C {devices/lab_pin.sym} 32020 -7650 0 0 {name=p31829 lab=_82397_/Q }
C {devices/lab_pin.sym} 32100 -7650 0 1 {name=p31830 lab=_46964_/A }
C {sky130_stdcells/inv_2.sym} 32060 -7650 0 0 {name=X_46963_ }
C {devices/lab_pin.sym} 31980 -7560 0 0 {name=p31831 lab=_40982_/X }
C {devices/lab_pin.sym} 31980 -7520 0 0 {name=p31832 lab=_42072_/X }
C {devices/lab_pin.sym} 31980 -7480 0 0 {name=p31833 lab=_88042_/Q }
C {devices/lab_pin.sym} 31980 -7440 0 0 {name=p31834 lab=_42073_/X }
C {devices/lab_pin.sym} 32140 -7500 0 1 {name=p31835 lab=_42086_/X }
C {sky130_stdcells/a2bb2o_4.sym} 32060 -7500 0 0 {name=X_42086_ }
C {devices/lab_pin.sym} 31980 -7370 0 0 {name=p31836 lab=_58846_/X }
C {devices/lab_pin.sym} 31980 -7330 0 0 {name=p31837 lab=_85763_/Q }
C {devices/lab_pin.sym} 31980 -7290 0 0 {name=p31838 lab=_58847_/X }
C {devices/lab_pin.sym} 32140 -7330 0 1 {name=p31839 lab=_58949_/X }
C {sky130_stdcells/o21a_4.sym} 32060 -7330 0 0 {name=X_58949_ }
C {devices/lab_pin.sym} 31980 -7210 0 0 {name=p31840 lab=_77777_/Y }
C {devices/lab_pin.sym} 31980 -7170 0 0 {name=p31841 lab=_77778_/X }
C {devices/lab_pin.sym} 31980 -7130 0 0 {name=p31842 lab=_77782_/Y }
C {devices/lab_pin.sym} 32140 -7170 0 1 {name=p31843 lab=_77783_/Y }
C {sky130_stdcells/a21oi_4.sym} 32060 -7170 0 0 {name=X_77783_ }
C {devices/lab_pin.sym} 32000 -7040 0 0 {name=p31844 lab=_80766_/Q }
C {devices/lab_pin.sym} 32000 -7000 0 0 {name=p31845 lab=_74995_/B }
C {devices/lab_pin.sym} 32120 -7020 0 1 {name=p31846 lab=_74995_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -7020 0 0 {name=X_74995_ }
C {devices/lab_pin.sym} 32000 -6910 0 0 {name=p31847 lab=_48702_/A }
C {devices/lab_pin.sym} 32000 -6870 0 0 {name=p31848 lab=_48894_/B }
C {devices/lab_pin.sym} 32000 -6830 0 0 {name=p31849 lab=_48894_/C }
C {devices/lab_pin.sym} 32120 -6870 0 1 {name=p31850 lab=_48702_/X }
C {sky130_stdcells/and3_4.sym} 32060 -6870 0 0 {name=X_48702_ }
C {devices/lab_pin.sym} 32020 -6730 0 0 {name=p31851 lab=clkbuf_9_446_0_CLK/A }
C {devices/lab_pin.sym} 32100 -6730 0 1 {name=p31852 lab=clkbuf_9_446_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 32060 -6730 0 0 {name=Xclkbuf_9_446_0_CLK }
C {devices/lab_pin.sym} 32000 -6620 0 0 {name=p31853 lab=_79522_/A }
C {devices/lab_pin.sym} 32000 -6580 0 0 {name=p31854 lab=_79522_/B }
C {devices/lab_pin.sym} 32120 -6600 0 1 {name=p31855 lab=_82849_/D }
C {sky130_stdcells/nand2_4.sym} 32060 -6600 0 0 {name=X_79522_ }
C {devices/lab_pin.sym} 31980 -6490 0 0 {name=p31856 lab=DATA_AVAILABLE }
C {devices/lab_pin.sym} 31980 -6450 0 0 {name=p31857 lab=_80673_/Q }
C {devices/lab_pin.sym} 31980 -6410 0 0 {name=p31858 lab=_45913_/Y }
C {devices/lab_pin.sym} 32140 -6450 0 1 {name=p31859 lab=_86843_/D }
C {sky130_stdcells/o21a_4.sym} 32060 -6450 0 0 {name=X_45914_ }
C {devices/lab_pin.sym} 32020 -6310 0 0 {name=p31860 lab=_40995_/A }
C {devices/lab_pin.sym} 32100 -6310 0 1 {name=p31861 lab=_41037_/X }
C {sky130_stdcells/buf_2.sym} 32060 -6310 0 0 {name=X_41037_ }
C {devices/lab_pin.sym} 32020 -6190 0 0 {name=p31862 lab=_76734_/A }
C {devices/lab_pin.sym} 32100 -6190 0 1 {name=p31863 lab=_76736_/A }
C {sky130_stdcells/inv_2.sym} 32060 -6190 0 0 {name=X_76734_ }
C {devices/lab_pin.sym} 32000 -6080 0 0 {name=p31864 lab=_49661_/X }
C {devices/lab_pin.sym} 32000 -6040 0 0 {name=p31865 lab=_47174_/X }
C {devices/lab_pin.sym} 32120 -6060 0 1 {name=p31866 lab=_49682_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -6060 0 0 {name=X_49682_ }
C {devices/lab_pin.sym} 32000 -5950 0 0 {name=p31867 lab=_61960_/A }
C {devices/lab_pin.sym} 32000 -5910 0 0 {name=p31868 lab=_61960_/B }
C {devices/lab_pin.sym} 32000 -5870 0 0 {name=p31869 lab=_78066_/B }
C {devices/lab_pin.sym} 32120 -5910 0 1 {name=p31870 lab=_61960_/Y }
C {sky130_stdcells/nor3_4.sym} 32060 -5910 0 0 {name=X_61960_ }
C {devices/lab_pin.sym} 31980 -5790 0 0 {name=p31871 lab=_88355_/Q }
C {devices/lab_pin.sym} 31980 -5750 0 0 {name=p31872 lab=_73801_/X }
C {devices/lab_pin.sym} 31980 -5710 0 0 {name=p31873 lab=_73087_/X }
C {devices/lab_pin.sym} 32140 -5750 0 1 {name=p31874 lab=_73946_/Y }
C {sky130_stdcells/o21ai_4.sym} 32060 -5750 0 0 {name=X_73946_ }
C {devices/lab_pin.sym} 32020 -5610 0 0 {name=p31875 lab=_82948_/Q }
C {devices/lab_pin.sym} 32100 -5610 0 1 {name=p31876 lab=_46894_/Y }
C {sky130_stdcells/inv_2.sym} 32060 -5610 0 0 {name=X_46894_ }
C {devices/lab_pin.sym} 31980 -5510 0 0 {name=p31877 lab=_48563_/X }
C {devices/lab_pin.sym} 31980 -5470 0 0 {name=p31878 lab=_48086_/A }
C {devices/lab_pin.sym} 31980 -5430 0 0 {name=p31879 lab=_48632_/Y }
C {devices/lab_pin.sym} 32140 -5470 0 1 {name=p31880 lab=_48634_/A }
C {sky130_stdcells/o21ai_4.sym} 32060 -5470 0 0 {name=X_48633_ }
C {devices/lab_pin.sym} 32020 -5330 0 0 {name=p31881 lab=_60910_/X }
C {devices/lab_pin.sym} 32100 -5330 0 1 {name=p31882 lab=_60911_/X }
C {sky130_stdcells/buf_2.sym} 32060 -5330 0 0 {name=X_60911_ }
C {devices/lab_pin.sym} 32000 -5220 0 0 {name=p31883 lab=_79446_/X }
C {devices/lab_pin.sym} 32000 -5180 0 0 {name=p31884 lab=_79453_/B }
C {devices/lab_pin.sym} 32120 -5200 0 1 {name=p31885 lab=_79453_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -5200 0 0 {name=X_79453_ }
C {devices/lab_pin.sym} 31980 -5090 0 0 {name=p31886 lab=_45841_/X }
C {devices/lab_pin.sym} 31980 -5050 0 0 {name=p31887 lab=_45844_/X }
C {devices/lab_pin.sym} 31980 -5010 0 0 {name=p31888 lab=_44898_/X }
C {devices/lab_pin.sym} 32140 -5050 0 1 {name=p31889 lab=_45845_/X }
C {sky130_stdcells/a21o_4.sym} 32060 -5050 0 0 {name=X_45845_ }
C {devices/lab_pin.sym} 32000 -4920 0 0 {name=p31890 lab=_76665_/A }
C {devices/lab_pin.sym} 32000 -4880 0 0 {name=p31891 lab=_81443_/D }
C {devices/lab_pin.sym} 32120 -4900 0 1 {name=p31892 lab=_81539_/D }
C {sky130_stdcells/xor2_4.sym} 32060 -4900 0 0 {name=X_76665_ }
C {devices/lab_pin.sym} 32020 -4770 0 0 {name=p31893 lab=_58319_/A }
C {devices/lab_pin.sym} 32100 -4770 0 1 {name=p31894 lab=_61891_/X }
C {sky130_stdcells/buf_2.sym} 32060 -4770 0 0 {name=X_61891_ }
C {devices/lab_pin.sym} 31980 -4670 0 0 {name=p31895 lab=_86994_/Q }
C {devices/lab_pin.sym} 31980 -4630 0 0 {name=p31896 lab=_73776_/X }
C {devices/lab_pin.sym} 31980 -4590 0 0 {name=p31897 lab=_73876_/X }
C {devices/lab_pin.sym} 32140 -4630 0 1 {name=p31898 lab=_73888_/C }
C {sky130_stdcells/o21ai_4.sym} 32060 -4630 0 0 {name=X_73877_ }
C {devices/lab_pin.sym} 32020 -4490 0 0 {name=p31899 lab=_78408_/C }
C {devices/lab_pin.sym} 32100 -4490 0 1 {name=p31900 lab=_78404_/Y }
C {sky130_stdcells/inv_2.sym} 32060 -4490 0 0 {name=X_78404_ }
C {devices/lab_pin.sym} 32000 -4390 0 0 {name=p31901 lab=_63630_/A }
C {devices/lab_pin.sym} 32000 -4350 0 0 {name=p31902 lab=_63630_/B }
C {devices/lab_pin.sym} 32000 -4310 0 0 {name=p31903 lab=_63630_/C }
C {devices/lab_pin.sym} 32120 -4350 0 1 {name=p31904 lab=_63630_/Y }
C {sky130_stdcells/nor3_4.sym} 32060 -4350 0 0 {name=X_63630_ }
C {devices/lab_pin.sym} 32000 -4220 0 0 {name=p31905 lab=_75616_/A }
C {devices/lab_pin.sym} 32000 -4180 0 0 {name=p31906 lab=_75615_/Y }
C {devices/lab_pin.sym} 32120 -4200 0 1 {name=p31907 lab=_75617_/B }
C {sky130_stdcells/xnor2_4.sym} 32060 -4200 0 0 {name=X_75616_ }
C {devices/lab_pin.sym} 32020 -4070 0 0 {name=p31908 lab=_81775_/Q }
C {devices/lab_pin.sym} 32100 -4070 0 1 {name=p31909 lab=_49067_/B }
C {sky130_stdcells/inv_2.sym} 32060 -4070 0 0 {name=X_48564_ }
C {devices/lab_pin.sym} 31980 -3990 0 0 {name=p31910 lab=_59539_/A }
C {devices/lab_pin.sym} 31980 -3950 0 0 {name=p31911 lab=_59557_/X }
C {devices/lab_pin.sym} 31980 -3910 0 0 {name=p31912 lab=_59564_/B }
C {devices/lab_pin.sym} 31980 -3870 0 0 {name=p31913 lab=_59901_/C }
C {devices/lab_pin.sym} 31980 -3840 0 0 {name=p31914 lab=_59877_/X }
C {devices/lab_pin.sym} 32140 -3910 0 1 {name=p31915 lab=_61071_/A }
C {sky130_stdcells/a41oi_4.sym} 32060 -3910 0 0 {name=X_60842_ }
C {devices/lab_pin.sym} 32020 -3750 0 0 {name=p31916 lab=_74012_/A }
C {devices/lab_pin.sym} 32100 -3750 0 1 {name=p31917 lab=_72829_/A }
C {sky130_stdcells/buf_2.sym} 32060 -3750 0 0 {name=X_72828_ }
C {devices/lab_pin.sym} 32000 -3640 0 0 {name=p31918 lab=_84805_/Q }
C {devices/lab_pin.sym} 32000 -3600 0 0 {name=p31919 lab=_84125_/Q }
C {devices/lab_pin.sym} 32120 -3620 0 1 {name=p31920 lab=_79384_/X }
C {sky130_stdcells/xor2_4.sym} 32060 -3620 0 0 {name=X_79384_ }
C {devices/lab_pin.sym} 32000 -3500 0 0 {name=p31921 lab=_45775_/Y }
C {devices/lab_pin.sym} 32000 -3460 0 0 {name=p31922 lab=_44975_/A }
C {devices/lab_pin.sym} 32120 -3480 0 1 {name=p31923 lab=_45776_/X }
C {sky130_stdcells/and2_4.sym} 32060 -3480 0 0 {name=X_45776_ }
C {devices/lab_pin.sym} 32020 -3350 0 0 {name=p31924 lab=_76595_/Y }
C {devices/lab_pin.sym} 32100 -3350 0 1 {name=p31925 lab=_76596_/Y }
C {sky130_stdcells/inv_2.sym} 32060 -3350 0 0 {name=X_76596_ }
C {devices/lab_pin.sym} 31980 -3270 0 0 {name=p31926 lab=_42984_/X }
C {devices/lab_pin.sym} 31980 -3230 0 0 {name=p31927 lab=_42985_/X }
C {devices/lab_pin.sym} 31980 -3190 0 0 {name=p31928 lab=_40480_/X }
C {devices/lab_pin.sym} 31980 -3150 0 0 {name=p31929 lab=_66995_/B }
C {devices/lab_pin.sym} 31980 -3110 0 0 {name=p31930 lab=_42976_/X }
C {devices/lab_pin.sym} 32140 -3190 0 1 {name=p31931 lab=_42988_/Y }
C {sky130_stdcells/o32ai_4.sym} 32060 -3190 0 0 {name=X_42988_ }
C {devices/lab_pin.sym} 32020 -3030 0 0 {name=p31932 lab=_47515_/A }
C {devices/lab_pin.sym} 32100 -3030 0 1 {name=p31933 lab=_47516_/A }
C {sky130_stdcells/inv_2.sym} 32060 -3030 0 0 {name=X_47515_ }
C {devices/lab_pin.sym} 32000 -2920 0 0 {name=p31934 lab=_78335_/A }
C {devices/lab_pin.sym} 32000 -2880 0 0 {name=p31935 lab=_78335_/B }
C {devices/lab_pin.sym} 32120 -2900 0 1 {name=p31936 lab=_78335_/Y }
C {sky130_stdcells/nand2_4.sym} 32060 -2900 0 0 {name=X_78335_ }
C {devices/lab_pin.sym} 32020 -2770 0 0 {name=p31937 lab=_44727_/A }
C {devices/lab_pin.sym} 32100 -2770 0 1 {name=p31938 lab=_44727_/Y }
C {sky130_stdcells/inv_2.sym} 32060 -2770 0 0 {name=X_44727_ }
C {devices/lab_pin.sym} 31980 -2670 0 0 {name=p31939 lab=_75537_/Y }
C {devices/lab_pin.sym} 31980 -2630 0 0 {name=p31940 lab=_75538_/B }
C {devices/lab_pin.sym} 31980 -2590 0 0 {name=p31941 lab=_75539_/X }
C {devices/lab_pin.sym} 32140 -2630 0 1 {name=p31942 lab=_75547_/Y }
C {sky130_stdcells/o21ai_4.sym} 32060 -2630 0 0 {name=X_75547_ }
C {devices/lab_pin.sym} 32000 -2500 0 0 {name=p31943 lab=_63523_/A }
C {devices/lab_pin.sym} 32000 -2460 0 0 {name=p31944 lab=_63561_/B }
C {devices/lab_pin.sym} 32120 -2480 0 1 {name=p31945 lab=_63561_/X }
C {sky130_stdcells/and2_4.sym} 32060 -2480 0 0 {name=X_63561_ }
C {devices/lab_pin.sym} 32020 -2350 0 0 {name=p31946 lab=_41967_/A }
C {devices/lab_pin.sym} 32100 -2350 0 1 {name=p31947 lab=_41939_/X }
C {sky130_stdcells/buf_2.sym} 32060 -2350 0 0 {name=X_41939_ }
C {devices/lab_pin.sym} 32020 -2230 0 0 {name=p31948 lab=_81781_/Q }
C {devices/lab_pin.sym} 32100 -2230 0 1 {name=p31949 lab=_48495_/Y }
C {sky130_stdcells/inv_2.sym} 32060 -2230 0 0 {name=X_48495_ }
C {devices/lab_pin.sym} 32000 -2140 0 0 {name=p31950 lab=_60543_/B }
C {devices/lab_pin.sym} 32000 -2100 0 0 {name=p31951 lab=_60727_/A }
C {devices/lab_pin.sym} 32000 -2060 0 0 {name=p31952 lab=_60772_/Y }
C {devices/lab_pin.sym} 32000 -2020 0 0 {name=p31953 lab=_60725_/B }
C {devices/lab_pin.sym} 32120 -2080 0 1 {name=p31954 lab=_60773_/Y }
C {sky130_stdcells/nand4_4.sym} 32060 -2080 0 0 {name=X_60773_ }
C {devices/lab_pin.sym} 32000 -1940 0 0 {name=p31955 lab=_72758_/X }
C {devices/lab_pin.sym} 32000 -1900 0 0 {name=p31956 lab=_86529_/Q }
C {devices/lab_pin.sym} 32120 -1920 0 1 {name=p31957 lab=_72759_/X }
C {sky130_stdcells/and2_4.sym} 32060 -1920 0 0 {name=X_72759_ }
C {devices/lab_pin.sym} 32020 -1790 0 0 {name=p31958 lab=_57965_/A }
C {devices/lab_pin.sym} 32100 -1790 0 1 {name=p31959 lab=_65300_/X }
C {sky130_stdcells/buf_2.sym} 32060 -1790 0 0 {name=X_65300_ }
C {devices/lab_pin.sym} 31980 -1710 0 0 {name=p31960 lab=_62500_/X }
C {devices/lab_pin.sym} 31980 -1670 0 0 {name=p31961 lab=_62506_/Y }
C {devices/lab_pin.sym} 31980 -1630 0 0 {name=p31962 lab=_62510_/X }
C {devices/lab_pin.sym} 31980 -1590 0 0 {name=p31963 lab=_84845_/Q }
C {devices/lab_pin.sym} 31980 -1550 0 0 {name=p31964 lab=_62511_/X }
C {devices/lab_pin.sym} 32140 -1630 0 1 {name=p31965 lab=_62512_/Y }
C {sky130_stdcells/o32ai_4.sym} 32060 -1630 0 0 {name=X_62512_ }
C {devices/lab_pin.sym} 32020 -1470 0 0 {name=p31966 lab=_81802_/Q }
C {devices/lab_pin.sym} 32100 -1470 0 1 {name=p31967 lab=_54743_/D }
C {sky130_stdcells/inv_2.sym} 32060 -1470 0 0 {name=X_47446_ }
C {devices/lab_pin.sym} 32000 -1370 0 0 {name=p31968 lab=_66231_/X }
C {devices/lab_pin.sym} 32000 -1330 0 0 {name=p31969 lab=_66319_/B }
C {devices/lab_pin.sym} 32000 -1290 0 0 {name=p31970 lab=_84144_/Q }
C {devices/lab_pin.sym} 32120 -1330 0 1 {name=p31971 lab=_66280_/X }
C {sky130_stdcells/and3_4.sym} 32060 -1330 0 0 {name=X_66280_ }
C {devices/lab_pin.sym} 32000 -1200 0 0 {name=p31972 lab=_78265_/A }
C {devices/lab_pin.sym} 32000 -1160 0 0 {name=p31973 lab=_82467_/Q }
C {devices/lab_pin.sym} 32120 -1180 0 1 {name=p31974 lab=_78266_/Y }
C {sky130_stdcells/nor2_4.sym} 32060 -1180 0 0 {name=X_78266_ }
C {devices/lab_pin.sym} 32020 -1050 0 0 {name=p31975 lab=_44679_/A }
C {devices/lab_pin.sym} 32100 -1050 0 1 {name=p31976 lab=_44658_/X }
C {sky130_stdcells/buf_2.sym} 32060 -1050 0 0 {name=X_44658_ }
C {devices/lab_pin.sym} 31980 -970 0 0 {name=p31977 lab=_63434_/X }
C {devices/lab_pin.sym} 31980 -930 0 0 {name=p31978 lab=_63485_/X }
C {devices/lab_pin.sym} 31980 -890 0 0 {name=p31979 lab=_63486_/X }
C {devices/lab_pin.sym} 31980 -850 0 0 {name=p31980 lab=_63490_/X }
C {devices/lab_pin.sym} 31980 -810 0 0 {name=p31981 lab=_63491_/Y }
C {devices/lab_pin.sym} 32140 -890 0 1 {name=p31982 lab=_63492_/Y }
C {sky130_stdcells/o41ai_4.sym} 32060 -890 0 0 {name=X_63492_ }
C {sky130_stdcells/decap_3.sym} 32060 -700 0 0 {name=XPHY_1 }
C {devices/lab_pin.sym} 32900 -42170 0 0 {name=p31983 lab=_75477_/B }
C {devices/lab_pin.sym} 32900 -42130 0 0 {name=p31984 lab=_75477_/C }
C {devices/lab_pin.sym} 32900 -42090 0 0 {name=p31985 lab=_75477_/A }
C {devices/lab_pin.sym} 33060 -42130 0 1 {name=p31986 lab=_75478_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -42130 0 0 {name=X_75478_ }
C {devices/lab_pin.sym} 32940 -41990 0 0 {name=p31987 lab=clkbuf_4_5_1_CLK/X }
C {devices/lab_pin.sym} 33020 -41990 0 1 {name=p31988 lab=clkbuf_6_21_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 32980 -41990 0 0 {name=Xclkbuf_5_10_0_CLK }
C {devices/lab_pin.sym} 32920 -41880 0 0 {name=p31989 lab=_65206_/A }
C {devices/lab_pin.sym} 32920 -41840 0 0 {name=p31990 lab=_86441_/Q }
C {devices/lab_pin.sym} 33040 -41860 0 1 {name=p31991 lab=_65231_/X }
C {sky130_stdcells/and2_4.sym} 32980 -41860 0 0 {name=X_65231_ }
C {devices/lab_pin.sym} 32920 -41740 0 0 {name=p31992 lab=_77217_/A }
C {devices/lab_pin.sym} 32920 -41700 0 0 {name=p31993 lab=_77217_/B }
C {devices/lab_pin.sym} 33040 -41720 0 1 {name=p31994 lab=_77217_/Y }
C {sky130_stdcells/nand2_4.sym} 32980 -41720 0 0 {name=X_77217_ }
C {devices/lab_pin.sym} 32940 -41590 0 0 {name=p31995 lab=_43585_/X }
C {devices/lab_pin.sym} 33020 -41590 0 1 {name=p31996 lab=_43609_/X }
C {sky130_stdcells/buf_2.sym} 32980 -41590 0 0 {name=X_43609_ }
C {devices/lab_pin.sym} 32900 -41490 0 0 {name=p31997 lab=_62441_/Y }
C {devices/lab_pin.sym} 32900 -41450 0 0 {name=p31998 lab=_62396_/X }
C {devices/lab_pin.sym} 32900 -41410 0 0 {name=p31999 lab=_62442_/Y }
C {devices/lab_pin.sym} 33060 -41450 0 1 {name=p32000 lab=_84410_/D }
C {sky130_stdcells/a21oi_4.sym} 32980 -41450 0 0 {name=X_62443_ }
C {devices/lab_pin.sym} 32900 -41330 0 0 {name=p32001 lab=_83068_/Q }
C {devices/lab_pin.sym} 32900 -41290 0 0 {name=p32002 lab=_74412_/X }
C {devices/lab_pin.sym} 32900 -41250 0 0 {name=p32003 lab=_74428_/Y }
C {devices/lab_pin.sym} 33060 -41290 0 1 {name=p32004 lab=_74429_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -41290 0 0 {name=X_74429_ }
C {devices/lab_pin.sym} 32940 -41150 0 0 {name=p32005 lab=_47565_/A }
C {devices/lab_pin.sym} 33020 -41150 0 1 {name=p32006 lab=_47377_/X }
C {sky130_stdcells/buf_2.sym} 32980 -41150 0 0 {name=X_47377_ }
C {devices/lab_pin.sym} 32920 -41040 0 0 {name=p32007 lab=_78197_/A }
C {devices/lab_pin.sym} 32920 -41000 0 0 {name=p32008 lab=_78197_/B }
C {devices/lab_pin.sym} 33040 -41020 0 1 {name=p32009 lab=_78197_/X }
C {sky130_stdcells/xor2_4.sym} 32980 -41020 0 0 {name=X_78197_ }
C {devices/lab_pin.sym} 32940 -40890 0 0 {name=p32010 lab=_44567_/A }
C {devices/lab_pin.sym} 33020 -40890 0 1 {name=p32011 lab=_44589_/X }
C {sky130_stdcells/buf_2.sym} 32980 -40890 0 0 {name=X_44589_ }
C {devices/lab_pin.sym} 32940 -40770 0 0 {name=p32012 lab=_72072_/B }
C {devices/lab_pin.sym} 33020 -40770 0 1 {name=p32013 lab=_50169_/B }
C {sky130_stdcells/buf_2.sym} 32980 -40770 0 0 {name=X_49116_ }
C {devices/lab_pin.sym} 32920 -40660 0 0 {name=p32014 lab=_82939_/Q }
C {devices/lab_pin.sym} 32920 -40620 0 0 {name=p32015 lab=_46328_/B }
C {devices/lab_pin.sym} 33040 -40640 0 1 {name=p32016 lab=_46328_/X }
C {sky130_stdcells/or2_4.sym} 32980 -40640 0 0 {name=X_46328_ }
C {devices/lab_pin.sym} 32900 -40530 0 0 {name=p32017 lab=_65156_/X }
C {devices/lab_pin.sym} 32900 -40490 0 0 {name=p32018 lab=_65160_/X }
C {devices/lab_pin.sym} 32900 -40450 0 0 {name=p32019 lab=_65161_/X }
C {devices/lab_pin.sym} 33060 -40490 0 1 {name=p32020 lab=_65162_/X }
C {sky130_stdcells/a21o_4.sym} 32980 -40490 0 0 {name=X_65162_ }
C {devices/lab_pin.sym} 32920 -40360 0 0 {name=p32021 lab=_77157_/A }
C {devices/lab_pin.sym} 32920 -40320 0 0 {name=p32022 lab=_77157_/B }
C {devices/lab_pin.sym} 33040 -40340 0 1 {name=p32023 lab=_77151_/A }
C {sky130_stdcells/xor2_4.sym} 32980 -40340 0 0 {name=X_77148_ }
C {devices/lab_pin.sym} 32940 -40210 0 0 {name=p32024 lab=_62532_/A }
C {devices/lab_pin.sym} 33020 -40210 0 1 {name=p32025 lab=_62375_/C }
C {sky130_stdcells/buf_2.sym} 32980 -40210 0 0 {name=X_62374_ }
C {devices/lab_pin.sym} 32940 -40090 0 0 {name=p32026 lab=clkbuf_9_454_0_CLK/X }
C {devices/lab_pin.sym} 33020 -40090 0 1 {name=p32027 lab=_88345_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32980 -40090 0 0 {name=Xclkbuf_10_908_0_CLK }
C {devices/lab_pin.sym} 32900 -39990 0 0 {name=p32028 lab=_63280_/B }
C {devices/lab_pin.sym} 32900 -39950 0 0 {name=p32029 lab=_60967_/X }
C {devices/lab_pin.sym} 32900 -39910 0 0 {name=p32030 lab=_64112_/Y }
C {devices/lab_pin.sym} 33060 -39950 0 1 {name=p32031 lab=_64113_/X }
C {sky130_stdcells/a21bo_4.sym} 32980 -39950 0 0 {name=X_64113_ }
C {devices/lab_pin.sym} 32900 -39830 0 0 {name=p32032 lab=_86449_/Q }
C {devices/lab_pin.sym} 32900 -39790 0 0 {name=p32033 lab=_49003_/X }
C {devices/lab_pin.sym} 32900 -39750 0 0 {name=p32034 lab=_49046_/Y }
C {devices/lab_pin.sym} 33060 -39790 0 1 {name=p32035 lab=_49047_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -39790 0 0 {name=X_49047_ }
C {devices/lab_pin.sym} 32900 -39690 0 0 {name=p32036 lab=_61298_/Y }
C {devices/lab_pin.sym} 32900 -39650 0 0 {name=p32037 lab=_61305_/Y }
C {devices/lab_pin.sym} 32900 -39610 0 0 {name=p32038 lab=_61315_/Y }
C {devices/lab_pin.sym} 32900 -39570 0 0 {name=p32039 lab=_61320_/Y }
C {devices/lab_pin.sym} 32900 -39540 0 0 {name=p32040 lab=_61324_/Y }
C {devices/lab_pin.sym} 33060 -39610 0 1 {name=p32041 lab=_61325_/Y }
C {sky130_stdcells/a41oi_4.sym} 32980 -39610 0 0 {name=X_61325_ }
C {devices/lab_pin.sym} 32940 -39450 0 0 {name=p32042 lab=_46259_/A }
C {devices/lab_pin.sym} 33020 -39450 0 1 {name=p32043 lab=_46347_/A }
C {sky130_stdcells/buf_2.sym} 32980 -39450 0 0 {name=X_46259_ }
C {devices/lab_pin.sym} 32900 -39350 0 0 {name=p32044 lab=_65090_/Y }
C {devices/lab_pin.sym} 32900 -39310 0 0 {name=p32045 lab=_65070_/X }
C {devices/lab_pin.sym} 32900 -39270 0 0 {name=p32046 lab=_65092_/X }
C {devices/lab_pin.sym} 33060 -39310 0 1 {name=p32047 lab=_84215_/D }
C {sky130_stdcells/a21o_4.sym} 32980 -39310 0 0 {name=X_65093_ }
C {devices/lab_pin.sym} 32900 -39200 0 0 {name=p32048 lab=_42063_/A }
C {devices/lab_pin.sym} 32900 -39160 0 0 {name=p32049 lab=_69582_/X }
C {devices/lab_pin.sym} 32900 -39120 0 0 {name=p32050 lab=_66564_/X }
C {devices/lab_pin.sym} 32900 -39080 0 0 {name=p32051 lab=_69969_/Y }
C {devices/lab_pin.sym} 33060 -39140 0 1 {name=p32052 lab=_69970_/X }
C {sky130_stdcells/a211o_4.sym} 32980 -39140 0 0 {name=X_69970_ }
C {devices/lab_pin.sym} 32900 -39010 0 0 {name=p32053 lab=_77084_/A }
C {devices/lab_pin.sym} 32900 -38970 0 0 {name=p32054 lab=_77073_/A }
C {devices/lab_pin.sym} 32900 -38930 0 0 {name=p32055 lab=_77078_/Y }
C {devices/lab_pin.sym} 33060 -38970 0 1 {name=p32056 lab=_77079_/Y }
C {sky130_stdcells/a21boi_4.sym} 32980 -38970 0 0 {name=X_77079_ }
C {devices/lab_pin.sym} 32940 -38830 0 0 {name=p32057 lab=clkbuf_4_12_1_CLK/X }
C {devices/lab_pin.sym} 33020 -38830 0 1 {name=p32058 lab=clkbuf_6_51_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 32980 -38830 0 0 {name=Xclkbuf_5_25_0_CLK }
C {devices/lab_pin.sym} 32900 -38740 0 0 {name=p32059 lab=_87485_/Q }
C {devices/lab_pin.sym} 32900 -38700 0 0 {name=p32060 lab=_68870_/X }
C {devices/lab_pin.sym} 32900 -38660 0 0 {name=p32061 lab=_68871_/X }
C {devices/lab_pin.sym} 32900 -38620 0 0 {name=p32062 lab=_68920_/X }
C {devices/lab_pin.sym} 33060 -38680 0 1 {name=p32063 lab=_68921_/X }
C {sky130_stdcells/a211o_4.sym} 32980 -38680 0 0 {name=X_68921_ }
C {devices/lab_pin.sym} 32920 -38560 0 0 {name=p32064 lab=_64434_/B }
C {devices/lab_pin.sym} 32920 -38520 0 0 {name=p32065 lab=_64145_/B }
C {devices/lab_pin.sym} 32920 -38480 0 0 {name=p32066 lab=_64029_/C }
C {devices/lab_pin.sym} 32920 -38440 0 0 {name=p32067 lab=_64029_/D }
C {devices/lab_pin.sym} 33040 -38500 0 1 {name=p32068 lab=_64044_/Y }
C {sky130_stdcells/nand4_4.sym} 32980 -38500 0 0 {name=X_64044_ }
C {devices/lab_pin.sym} 32940 -38350 0 0 {name=p32069 lab=_64203_/B }
C {devices/lab_pin.sym} 33020 -38350 0 1 {name=p32070 lab=_61256_/Y }
C {sky130_stdcells/inv_2.sym} 32980 -38350 0 0 {name=X_61256_ }
C {devices/lab_pin.sym} 32920 -38240 0 0 {name=p32071 lab=_84938_/Q }
C {devices/lab_pin.sym} 32920 -38200 0 0 {name=p32072 lab=_84186_/Q }
C {devices/lab_pin.sym} 33040 -38220 0 1 {name=p32073 lab=_80092_/A }
C {sky130_stdcells/xor2_4.sym} 32980 -38220 0 0 {name=X_80090_ }
C {devices/lab_pin.sym} 32900 -38130 0 0 {name=p32074 lab=_60159_/A }
C {devices/lab_pin.sym} 32900 -38090 0 0 {name=p32075 lab=_60324_/C }
C {devices/lab_pin.sym} 32900 -38050 0 0 {name=p32076 lab=_60218_/A }
C {devices/lab_pin.sym} 32900 -38010 0 0 {name=p32077 lab=_60205_/X }
C {devices/lab_pin.sym} 32900 -37980 0 0 {name=p32078 lab=_61286_/A }
C {devices/lab_pin.sym} 33060 -38050 0 1 {name=p32079 lab=_60207_/Y }
C {sky130_stdcells/a41oi_4.sym} 32980 -38050 0 0 {name=X_60207_ }
C {devices/lab_pin.sym} 32900 -37910 0 0 {name=p32080 lab=_68849_/X }
C {devices/lab_pin.sym} 32900 -37870 0 0 {name=p32081 lab=_68851_/X }
C {devices/lab_pin.sym} 32900 -37830 0 0 {name=p32082 lab=_68806_/X }
C {devices/lab_pin.sym} 33060 -37870 0 1 {name=p32083 lab=_68852_/X }
C {sky130_stdcells/a21o_4.sym} 32980 -37870 0 0 {name=X_68852_ }
C {devices/lab_pin.sym} 32920 -37750 0 0 {name=p32084 lab=_61107_/X }
C {devices/lab_pin.sym} 32920 -37710 0 0 {name=p32085 lab=_61109_/X }
C {devices/lab_pin.sym} 32920 -37670 0 0 {name=p32086 lab=_61172_/A }
C {devices/lab_pin.sym} 33040 -37710 0 1 {name=p32087 lab=_61188_/C }
C {sky130_stdcells/nand3_4.sym} 32980 -37710 0 0 {name=X_61187_ }
C {devices/lab_pin.sym} 32900 -37590 0 0 {name=p32088 lab=_67800_/X }
C {devices/lab_pin.sym} 32900 -37550 0 0 {name=p32089 lab=_67802_/X }
C {devices/lab_pin.sym} 32900 -37510 0 0 {name=p32090 lab=_67709_/X }
C {devices/lab_pin.sym} 33060 -37550 0 1 {name=p32091 lab=_67803_/Y }
C {sky130_stdcells/a21oi_4.sym} 32980 -37550 0 0 {name=X_67803_ }
C {devices/lab_pin.sym} 32900 -37430 0 0 {name=p32092 lab=_59985_/X }
C {devices/lab_pin.sym} 32900 -37390 0 0 {name=p32093 lab=_60091_/A }
C {devices/lab_pin.sym} 32900 -37350 0 0 {name=p32094 lab=_59966_/Y }
C {devices/lab_pin.sym} 33060 -37390 0 1 {name=p32095 lab=_60138_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -37390 0 0 {name=X_60138_ }
C {devices/lab_pin.sym} 32920 -37260 0 0 {name=p32096 lab=_49955_/A }
C {devices/lab_pin.sym} 32920 -37220 0 0 {name=p32097 lab=_53161_/B }
C {devices/lab_pin.sym} 33040 -37240 0 1 {name=p32098 lab=_49949_/Y }
C {sky130_stdcells/nand2_4.sym} 32980 -37240 0 0 {name=X_49949_ }
C {devices/lab_pin.sym} 32900 -37130 0 0 {name=p32099 lab=_68780_/X }
C {devices/lab_pin.sym} 32900 -37090 0 0 {name=p32100 lab=_68782_/X }
C {devices/lab_pin.sym} 32900 -37050 0 0 {name=p32101 lab=_68684_/X }
C {devices/lab_pin.sym} 33060 -37090 0 1 {name=p32102 lab=_68783_/X }
C {sky130_stdcells/a21o_4.sym} 32980 -37090 0 0 {name=X_68783_ }
C {devices/lab_pin.sym} 32900 -36980 0 0 {name=p32103 lab=_65876_/X }
C {devices/lab_pin.sym} 32900 -36940 0 0 {name=p32104 lab=_85627_/Q }
C {devices/lab_pin.sym} 32900 -36900 0 0 {name=p32105 lab=_65976_/X }
C {devices/lab_pin.sym} 32900 -36860 0 0 {name=p32106 lab=_65994_/X }
C {devices/lab_pin.sym} 33060 -36920 0 1 {name=p32107 lab=_65995_/X }
C {sky130_stdcells/a211o_4.sym} 32980 -36920 0 0 {name=X_65995_ }
C {devices/lab_pin.sym} 32890 -36770 0 0 {name=p32108 lab=_82833_/CLK }
C {devices/lab_pin.sym} 32890 -36750 0 0 {name=p32109 lab=_82800_/D }
C {devices/lab_pin.sym} 33070 -36770 0 1 {name=p32110 lab=_82800_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -36760 0 0 {name=X_82800_ }
C {devices/lab_pin.sym} 32900 -36650 0 0 {name=p32111 lab=_67731_/X }
C {devices/lab_pin.sym} 32900 -36610 0 0 {name=p32112 lab=_67733_/X }
C {devices/lab_pin.sym} 32900 -36570 0 0 {name=p32113 lab=_67709_/X }
C {devices/lab_pin.sym} 33060 -36610 0 1 {name=p32114 lab=_67734_/Y }
C {sky130_stdcells/a21oi_4.sym} 32980 -36610 0 0 {name=X_67734_ }
C {devices/lab_pin.sym} 32900 -36490 0 0 {name=p32115 lab=_85723_/Q }
C {devices/lab_pin.sym} 32900 -36450 0 0 {name=p32116 lab=_52957_/X }
C {devices/lab_pin.sym} 32900 -36410 0 0 {name=p32117 lab=_52959_/Y }
C {devices/lab_pin.sym} 33060 -36450 0 1 {name=p32118 lab=_52960_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -36450 0 0 {name=X_52960_ }
C {devices/lab_pin.sym} 32920 -36320 0 0 {name=p32119 lab=_64946_/A }
C {devices/lab_pin.sym} 32920 -36280 0 0 {name=p32120 lab=_85844_/Q }
C {devices/lab_pin.sym} 33040 -36300 0 1 {name=p32121 lab=_64946_/X }
C {sky130_stdcells/and2_4.sym} 32980 -36300 0 0 {name=X_64946_ }
C {devices/lab_pin.sym} 32900 -36210 0 0 {name=p32122 lab=_45943_/A }
C {devices/lab_pin.sym} 32900 -36170 0 0 {name=p32123 lab=_59901_/A }
C {devices/lab_pin.sym} 32900 -36130 0 0 {name=p32124 lab=_59901_/C }
C {devices/lab_pin.sym} 32900 -36090 0 0 {name=p32125 lab=_63001_/A }
C {devices/lab_pin.sym} 32900 -36060 0 0 {name=p32126 lab=_57754_/X }
C {devices/lab_pin.sym} 33060 -36130 0 1 {name=p32127 lab=_60069_/Y }
C {sky130_stdcells/a41oi_4.sym} 32980 -36130 0 0 {name=X_60069_ }
C {devices/lab_pin.sym} 32890 -35970 0 0 {name=p32128 lab=_83783_/CLK }
C {devices/lab_pin.sym} 32890 -35950 0 0 {name=p32129 lab=_83780_/D }
C {devices/lab_pin.sym} 33070 -35970 0 1 {name=p32130 lab=_83780_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -35960 0 0 {name=X_83780_ }
C {devices/lab_pin.sym} 32890 -35830 0 0 {name=p32131 lab=_80821_/CLK }
C {devices/lab_pin.sym} 32890 -35810 0 0 {name=p32132 lab=_80992_/D }
C {devices/lab_pin.sym} 33070 -35830 0 1 {name=p32133 lab=_80948_/D }
C {sky130_stdcells/dfxtp_4.sym} 32980 -35820 0 0 {name=X_80992_ }
C {devices/lab_pin.sym} 32920 -35700 0 0 {name=p32134 lab=_51902_/A }
C {devices/lab_pin.sym} 32920 -35660 0 0 {name=p32135 lab=_46899_/X }
C {devices/lab_pin.sym} 33040 -35680 0 1 {name=p32136 lab=_51911_/Y }
C {sky130_stdcells/nand2_4.sym} 32980 -35680 0 0 {name=X_51911_ }
C {devices/lab_pin.sym} 32890 -35550 0 0 {name=p32137 lab=_84115_/CLK }
C {devices/lab_pin.sym} 32890 -35530 0 0 {name=p32138 lab=_84115_/Q }
C {devices/lab_pin.sym} 33070 -35550 0 1 {name=p32139 lab=_78889_/A }
C {sky130_stdcells/dfxtp_4.sym} 32980 -35540 0 0 {name=X_82731_ }
C {devices/lab_pin.sym} 32920 -35420 0 0 {name=p32140 lab=_67569_/X }
C {devices/lab_pin.sym} 32920 -35380 0 0 {name=p32141 lab=_87717_/Q }
C {devices/lab_pin.sym} 33040 -35400 0 1 {name=p32142 lab=_67665_/X }
C {sky130_stdcells/and2_4.sym} 32980 -35400 0 0 {name=X_67665_ }
C {devices/lab_pin.sym} 32940 -35270 0 0 {name=p32143 lab=_52754_/A }
C {devices/lab_pin.sym} 33020 -35270 0 1 {name=p32144 lab=_52892_/A }
C {sky130_stdcells/buf_2.sym} 32980 -35270 0 0 {name=X_52891_ }
C {devices/lab_pin.sym} 32940 -35150 0 0 {name=p32145 lab=_64602_/A }
C {devices/lab_pin.sym} 33020 -35150 0 1 {name=p32146 lab=_64877_/X }
C {sky130_stdcells/buf_2.sym} 32980 -35150 0 0 {name=X_64877_ }
C {devices/lab_pin.sym} 32940 -35030 0 0 {name=p32147 lab=_69814_/A }
C {devices/lab_pin.sym} 33020 -35030 0 1 {name=p32148 lab=_69733_/A }
C {sky130_stdcells/buf_2.sym} 32980 -35030 0 0 {name=X_69404_ }
C {devices/lab_pin.sym} 32920 -34940 0 0 {name=p32149 lab=_54625_/A }
C {devices/lab_pin.sym} 32920 -34900 0 0 {name=p32150 lab=_54645_/B }
C {devices/lab_pin.sym} 32920 -34860 0 0 {name=p32151 lab=_54618_/X }
C {devices/lab_pin.sym} 32920 -34820 0 0 {name=p32152 lab=_54630_/D }
C {devices/lab_pin.sym} 33040 -34880 0 1 {name=p32153 lab=_54630_/X }
C {sky130_stdcells/and4_4.sym} 32980 -34880 0 0 {name=X_54630_ }
C {devices/lab_pin.sym} 32920 -34740 0 0 {name=p32154 lab=_66689_/A }
C {devices/lab_pin.sym} 32920 -34700 0 0 {name=p32155 lab=_66616_/B }
C {devices/lab_pin.sym} 33040 -34720 0 1 {name=p32156 lab=_66616_/X }
C {sky130_stdcells/and2_4.sym} 32980 -34720 0 0 {name=X_66616_ }
C {devices/lab_pin.sym} 32890 -34590 0 0 {name=p32157 lab=_85773_/CLK }
C {devices/lab_pin.sym} 32890 -34570 0 0 {name=p32158 lab=_85450_/D }
C {devices/lab_pin.sym} 33070 -34590 0 1 {name=p32159 lab=_85450_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -34580 0 0 {name=X_85450_ }
C {devices/lab_pin.sym} 32940 -34450 0 0 {name=p32160 lab=_51842_/A }
C {devices/lab_pin.sym} 33020 -34450 0 1 {name=p32161 lab=_51843_/A }
C {sky130_stdcells/buf_2.sym} 32980 -34450 0 0 {name=X_51842_ }
C {devices/lab_pin.sym} 32920 -34360 0 0 {name=p32162 lab=_61387_/X }
C {devices/lab_pin.sym} 32920 -34320 0 0 {name=p32163 lab=_63877_/B }
C {devices/lab_pin.sym} 32920 -34280 0 0 {name=p32164 lab=_63814_/C }
C {devices/lab_pin.sym} 32920 -34240 0 0 {name=p32165 lab=_63877_/D }
C {devices/lab_pin.sym} 33040 -34300 0 1 {name=p32166 lab=_63828_/Y }
C {sky130_stdcells/nand4_4.sym} 32980 -34300 0 0 {name=X_63828_ }
C {devices/lab_pin.sym} 32890 -34150 0 0 {name=p32167 lab=_82665_/CLK }
C {devices/lab_pin.sym} 32890 -34130 0 0 {name=p32168 lab=_78358_/B }
C {devices/lab_pin.sym} 33070 -34150 0 1 {name=p32169 lab=_78107_/A }
C {sky130_stdcells/dfxtp_4.sym} 32980 -34140 0 0 {name=X_82662_ }
C {devices/lab_pin.sym} 32920 -34020 0 0 {name=p32170 lab=_67572_/A }
C {devices/lab_pin.sym} 32920 -33980 0 0 {name=p32171 lab=_67596_/B }
C {devices/lab_pin.sym} 33040 -34000 0 1 {name=p32172 lab=_67596_/X }
C {sky130_stdcells/and2_4.sym} 32980 -34000 0 0 {name=X_67596_ }
C {devices/lab_pin.sym} 32890 -33870 0 0 {name=p32173 lab=_83242_/CLK }
C {devices/lab_pin.sym} 32890 -33850 0 0 {name=p32174 lab=_84401_/D }
C {devices/lab_pin.sym} 33070 -33870 0 1 {name=p32175 lab=_84401_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -33860 0 0 {name=X_84401_ }
C {devices/lab_pin.sym} 32890 -33730 0 0 {name=p32176 lab=_81620_/CLK }
C {devices/lab_pin.sym} 32890 -33710 0 0 {name=p32177 lab=_76312_/B }
C {devices/lab_pin.sym} 33070 -33730 0 1 {name=p32178 lab=_81613_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -33720 0 0 {name=X_81613_ }
C {devices/lab_pin.sym} 32920 -33600 0 0 {name=p32179 lab=_69128_/X }
C {devices/lab_pin.sym} 32920 -33560 0 0 {name=p32180 lab=_88293_/Q }
C {devices/lab_pin.sym} 33040 -33580 0 1 {name=p32181 lab=_69335_/X }
C {sky130_stdcells/and2_4.sym} 32980 -33580 0 0 {name=X_69335_ }
C {devices/lab_pin.sym} 32920 -33460 0 0 {name=p32182 lab=_54546_/A }
C {devices/lab_pin.sym} 32920 -33420 0 0 {name=p32183 lab=_53386_/B }
C {devices/lab_pin.sym} 33040 -33440 0 1 {name=p32184 lab=_54561_/Y }
C {sky130_stdcells/nand2_4.sym} 32980 -33440 0 0 {name=X_54561_ }
C {devices/lab_pin.sym} 32940 -33310 0 0 {name=p32185 lab=_66547_/A }
C {devices/lab_pin.sym} 33020 -33310 0 1 {name=p32186 lab=_66547_/X }
C {sky130_stdcells/buf_2.sym} 32980 -33310 0 0 {name=X_66547_ }
C {devices/lab_pin.sym} 32890 -33190 0 0 {name=p32187 lab=_85381_/CLK }
C {devices/lab_pin.sym} 32890 -33170 0 0 {name=p32188 lab=_54771_/Y }
C {devices/lab_pin.sym} 33070 -33190 0 1 {name=p32189 lab=_85381_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -33180 0 0 {name=X_85381_ }
C {devices/lab_pin.sym} 32900 -33070 0 0 {name=p32190 lab=_51771_/Y }
C {devices/lab_pin.sym} 32900 -33030 0 0 {name=p32191 lab=_51767_/X }
C {devices/lab_pin.sym} 32900 -32990 0 0 {name=p32192 lab=_51772_/X }
C {devices/lab_pin.sym} 33060 -33030 0 1 {name=p32193 lab=_51773_/Y }
C {sky130_stdcells/a21oi_4.sym} 32980 -33030 0 0 {name=X_51773_ }
C {devices/lab_pin.sym} 32920 -32920 0 0 {name=p32194 lab=_63747_/Y }
C {devices/lab_pin.sym} 32920 -32880 0 0 {name=p32195 lab=_63759_/B }
C {devices/lab_pin.sym} 32920 -32840 0 0 {name=p32196 lab=_63757_/Y }
C {devices/lab_pin.sym} 32920 -32800 0 0 {name=p32197 lab=_63758_/Y }
C {devices/lab_pin.sym} 33040 -32860 0 1 {name=p32198 lab=_63759_/X }
C {sky130_stdcells/and4_4.sym} 32980 -32860 0 0 {name=X_63759_ }
C {devices/lab_pin.sym} 32890 -32710 0 0 {name=p32199 lab=_81216_/CLK }
C {devices/lab_pin.sym} 32890 -32690 0 0 {name=p32200 lab=_82625_/Q }
C {devices/lab_pin.sym} 33070 -32710 0 1 {name=p32201 lab=_82593_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -32700 0 0 {name=X_82593_ }
C {devices/lab_pin.sym} 32900 -32590 0 0 {name=p32202 lab=_56026_/X }
C {devices/lab_pin.sym} 32900 -32550 0 0 {name=p32203 lab=_56290_/X }
C {devices/lab_pin.sym} 32900 -32510 0 0 {name=p32204 lab=_56299_/Y }
C {devices/lab_pin.sym} 33060 -32550 0 1 {name=p32205 lab=_85245_/D }
C {sky130_stdcells/o21ai_4.sym} 32980 -32550 0 0 {name=X_56300_ }
C {devices/lab_pin.sym} 32890 -32410 0 0 {name=p32206 lab=_87137_/CLK }
C {devices/lab_pin.sym} 32890 -32390 0 0 {name=p32207 lab=_87120_/D }
C {devices/lab_pin.sym} 33070 -32410 0 1 {name=p32208 lab=_87120_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -32400 0 0 {name=X_87120_ }
C {devices/lab_pin.sym} 32920 -32290 0 0 {name=p32209 lab=_48234_/A }
C {devices/lab_pin.sym} 32920 -32250 0 0 {name=p32210 lab=_53697_/B }
C {devices/lab_pin.sym} 32920 -32210 0 0 {name=p32211 lab=_53697_/C }
C {devices/lab_pin.sym} 33040 -32250 0 1 {name=p32212 lab=_53512_/Y }
C {sky130_stdcells/nand3_4.sym} 32980 -32250 0 0 {name=X_53512_ }
C {devices/lab_pin.sym} 32890 -32110 0 0 {name=p32213 lab=_82272_/CLK }
C {devices/lab_pin.sym} 32890 -32090 0 0 {name=p32214 lab=_63337_/Y }
C {devices/lab_pin.sym} 33070 -32110 0 1 {name=p32215 lab=_79183_/B }
C {sky130_stdcells/dfxtp_4.sym} 32980 -32100 0 0 {name=X_84332_ }
C {devices/lab_pin.sym} 32940 -31970 0 0 {name=p32216 lab=_50724_/A }
C {devices/lab_pin.sym} 33020 -31970 0 1 {name=p32217 lab=_50751_/B }
C {sky130_stdcells/buf_2.sym} 32980 -31970 0 0 {name=X_50724_ }
C {devices/lab_pin.sym} 32940 -31850 0 0 {name=p32218 lab=_44286_/Y }
C {devices/lab_pin.sym} 33020 -31850 0 1 {name=p32219 lab=_57280_/X }
C {sky130_stdcells/buf_2.sym} 32980 -31850 0 0 {name=X_57280_ }
C {devices/lab_pin.sym} 32890 -31730 0 0 {name=p32220 lab=_81532_/CLK }
C {devices/lab_pin.sym} 32890 -31710 0 0 {name=p32221 lab=_81544_/D }
C {devices/lab_pin.sym} 33070 -31730 0 1 {name=p32222 lab=_76533_/B }
C {sky130_stdcells/dfxtp_4.sym} 32980 -31720 0 0 {name=X_81544_ }
C {devices/lab_pin.sym} 32900 -31620 0 0 {name=p32223 lab=_87030_/Q }
C {devices/lab_pin.sym} 32900 -31580 0 0 {name=p32224 lab=_69182_/X }
C {devices/lab_pin.sym} 32900 -31540 0 0 {name=p32225 lab=_69183_/X }
C {devices/lab_pin.sym} 32900 -31500 0 0 {name=p32226 lab=_69265_/X }
C {devices/lab_pin.sym} 33060 -31560 0 1 {name=p32227 lab=_69266_/X }
C {sky130_stdcells/a211o_4.sym} 32980 -31560 0 0 {name=X_69266_ }
C {devices/lab_pin.sym} 32900 -31430 0 0 {name=p32228 lab=_85432_/Q }
C {devices/lab_pin.sym} 32900 -31390 0 0 {name=p32229 lab=_54485_/X }
C {devices/lab_pin.sym} 32900 -31350 0 0 {name=p32230 lab=_54491_/Y }
C {devices/lab_pin.sym} 33060 -31390 0 1 {name=p32231 lab=_54492_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -31390 0 0 {name=X_54492_ }
C {devices/lab_pin.sym} 32940 -31250 0 0 {name=p32232 lab=_84115_/Q }
C {devices/lab_pin.sym} 33020 -31250 0 1 {name=p32233 lab=_66478_/Y }
C {sky130_stdcells/inv_2.sym} 32980 -31250 0 0 {name=X_66478_ }
C {devices/lab_pin.sym} 32940 -31130 0 0 {name=p32234 lab=_45369_/A }
C {devices/lab_pin.sym} 33020 -31130 0 1 {name=p32235 lab=_56245_/A }
C {sky130_stdcells/buf_2.sym} 32980 -31130 0 0 {name=X_56231_ }
C {devices/lab_pin.sym} 32900 -31030 0 0 {name=p32236 lab=_67347_/X }
C {devices/lab_pin.sym} 32900 -30990 0 0 {name=p32237 lab=_67350_/X }
C {devices/lab_pin.sym} 32900 -30950 0 0 {name=p32238 lab=_68216_/X }
C {devices/lab_pin.sym} 33060 -30990 0 1 {name=p32239 lab=_68217_/Y }
C {sky130_stdcells/a21oi_4.sym} 32980 -30990 0 0 {name=X_68217_ }
C {devices/lab_pin.sym} 32890 -30850 0 0 {name=p32240 lab=_87553_/CLK }
C {devices/lab_pin.sym} 32890 -30830 0 0 {name=p32241 lab=_44572_/Y }
C {devices/lab_pin.sym} 33070 -30850 0 1 {name=p32242 lab=_87051_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -30840 0 0 {name=X_87051_ }
C {devices/lab_pin.sym} 32920 -30720 0 0 {name=p32243 lab=_65408_/A }
C {devices/lab_pin.sym} 32920 -30680 0 0 {name=p32244 lab=_86529_/Q }
C {devices/lab_pin.sym} 33040 -30700 0 1 {name=p32245 lab=_65429_/X }
C {sky130_stdcells/and2_4.sym} 32980 -30700 0 0 {name=X_65429_ }
C {devices/lab_pin.sym} 32920 -30590 0 0 {name=p32246 lab=_53443_/A }
C {devices/lab_pin.sym} 32920 -30550 0 0 {name=p32247 lab=_47830_/Y }
C {devices/lab_pin.sym} 32920 -30510 0 0 {name=p32248 lab=_54067_/A }
C {devices/lab_pin.sym} 33040 -30550 0 1 {name=p32249 lab=_53443_/Y }
C {sky130_stdcells/nand3_4.sym} 32980 -30550 0 0 {name=X_53443_ }
C {devices/lab_pin.sym} 32890 -30410 0 0 {name=p32250 lab=_84263_/CLK }
C {devices/lab_pin.sym} 32890 -30390 0 0 {name=p32251 lab=_84263_/D }
C {devices/lab_pin.sym} 33070 -30410 0 1 {name=p32252 lab=_79863_/B }
C {sky130_stdcells/dfxtp_4.sym} 32980 -30400 0 0 {name=X_84263_ }
C {devices/lab_pin.sym} 32940 -30270 0 0 {name=p32253 lab=_50655_/A }
C {devices/lab_pin.sym} 33020 -30270 0 1 {name=p32254 lab=_50728_/A }
C {sky130_stdcells/buf_2.sym} 32980 -30270 0 0 {name=X_50655_ }
C {devices/lab_pin.sym} 32890 -30150 0 0 {name=p32255 lab=_81475_/CLK }
C {devices/lab_pin.sym} 32890 -30130 0 0 {name=p32256 lab=_81475_/D }
C {devices/lab_pin.sym} 33070 -30150 0 1 {name=p32257 lab=_76659_/A }
C {sky130_stdcells/dfxtp_4.sym} 32980 -30140 0 0 {name=X_81475_ }
C {devices/lab_pin.sym} 32900 -30040 0 0 {name=p32258 lab=_87035_/Q }
C {devices/lab_pin.sym} 32900 -30000 0 0 {name=p32259 lab=_69182_/X }
C {devices/lab_pin.sym} 32900 -29960 0 0 {name=p32260 lab=_69183_/X }
C {devices/lab_pin.sym} 32900 -29920 0 0 {name=p32261 lab=_69196_/X }
C {devices/lab_pin.sym} 33060 -29980 0 1 {name=p32262 lab=_69197_/X }
C {sky130_stdcells/a211o_4.sym} 32980 -29980 0 0 {name=X_69197_ }
C {devices/lab_pin.sym} 32890 -29830 0 0 {name=p32263 lab=_85712_/CLK }
C {devices/lab_pin.sym} 32890 -29810 0 0 {name=p32264 lab=_86002_/D }
C {devices/lab_pin.sym} 33070 -29830 0 1 {name=p32265 lab=_86002_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -29820 0 0 {name=X_86002_ }
C {devices/lab_pin.sym} 32890 -29690 0 0 {name=p32266 lab=_83231_/CLK }
C {devices/lab_pin.sym} 32890 -29670 0 0 {name=p32267 lab=_72620_/Y }
C {devices/lab_pin.sym} 33070 -29690 0 1 {name=p32268 lab=_72617_/A }
C {sky130_stdcells/dfxtp_4.sym} 32980 -29680 0 0 {name=X_83214_ }
C {devices/lab_pin.sym} 32920 -29560 0 0 {name=p32269 lab=_56167_/B }
C {devices/lab_pin.sym} 32920 -29520 0 0 {name=p32270 lab=_56167_/A }
C {devices/lab_pin.sym} 33040 -29540 0 1 {name=p32271 lab=_56162_/X }
C {sky130_stdcells/and2_4.sym} 32980 -29540 0 0 {name=X_56162_ }
C {devices/lab_pin.sym} 32900 -29440 0 0 {name=p32272 lab=_80416_/A }
C {devices/lab_pin.sym} 32900 -29400 0 0 {name=p32273 lab=_80416_/B }
C {devices/lab_pin.sym} 32900 -29360 0 0 {name=p32274 lab=_80411_/Y }
C {devices/lab_pin.sym} 32900 -29320 0 0 {name=p32275 lab=_80414_/Y }
C {devices/lab_pin.sym} 33060 -29380 0 1 {name=p32276 lab=_80426_/X }
C {sky130_stdcells/o22a_4.sym} 32980 -29380 0 0 {name=X_80426_ }
C {devices/lab_pin.sym} 32940 -29230 0 0 {name=p32277 lab=_68089_/A }
C {devices/lab_pin.sym} 33020 -29230 0 1 {name=p32278 lab=_68148_/X }
C {sky130_stdcells/buf_2.sym} 32980 -29230 0 0 {name=X_68148_ }
C {devices/lab_pin.sym} 32900 -29130 0 0 {name=p32279 lab=_85645_/Q }
C {devices/lab_pin.sym} 32900 -29090 0 0 {name=p32280 lab=_53351_/X }
C {devices/lab_pin.sym} 32900 -29050 0 0 {name=p32281 lab=_53373_/Y }
C {devices/lab_pin.sym} 33060 -29090 0 1 {name=p32282 lab=_53374_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -29090 0 0 {name=X_53374_ }
C {devices/lab_pin.sym} 32890 -28950 0 0 {name=p32283 lab=_84194_/CLK }
C {devices/lab_pin.sym} 32890 -28930 0 0 {name=p32284 lab=_65547_/X }
C {devices/lab_pin.sym} 33070 -28950 0 1 {name=p32285 lab=_65546_/C }
C {sky130_stdcells/dfxtp_4.sym} 32980 -28940 0 0 {name=X_84194_ }
C {devices/lab_pin.sym} 32920 -28820 0 0 {name=p32286 lab=_50607_/A }
C {devices/lab_pin.sym} 32920 -28780 0 0 {name=p32287 lab=_52287_/B }
C {devices/lab_pin.sym} 33040 -28800 0 1 {name=p32288 lab=_50586_/Y }
C {sky130_stdcells/nand2_4.sym} 32980 -28800 0 0 {name=X_50586_ }
C {devices/lab_pin.sym} 32900 -28690 0 0 {name=p32289 lab=_55111_/Y }
C {devices/lab_pin.sym} 32900 -28650 0 0 {name=p32290 lab=_55102_/X }
C {devices/lab_pin.sym} 32900 -28610 0 0 {name=p32291 lab=_55112_/X }
C {devices/lab_pin.sym} 33060 -28650 0 1 {name=p32292 lab=_55113_/Y }
C {sky130_stdcells/a21oi_4.sym} 32980 -28650 0 0 {name=X_55113_ }
C {devices/lab_pin.sym} 32940 -28510 0 0 {name=p32293 lab=_52271_/A }
C {devices/lab_pin.sym} 33020 -28510 0 1 {name=p32294 lab=_52334_/A }
C {sky130_stdcells/buf_2.sym} 32980 -28510 0 0 {name=X_52325_ }
C {devices/lab_pin.sym} 32890 -28390 0 0 {name=p32295 lab=_83145_/CLK }
C {devices/lab_pin.sym} 32890 -28370 0 0 {name=p32296 lab=_83145_/D }
C {devices/lab_pin.sym} 33070 -28390 0 1 {name=p32297 lab=_83145_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -28380 0 0 {name=X_83145_ }
C {devices/lab_pin.sym} 32920 -28270 0 0 {name=p32298 lab=_56171_/A }
C {devices/lab_pin.sym} 32920 -28230 0 0 {name=p32299 lab=_56171_/C }
C {devices/lab_pin.sym} 32920 -28190 0 0 {name=p32300 lab=_56093_/C }
C {devices/lab_pin.sym} 33040 -28230 0 1 {name=p32301 lab=_56094_/A }
C {sky130_stdcells/nand3_4.sym} 32980 -28230 0 0 {name=X_56093_ }
C {devices/lab_pin.sym} 32900 -28120 0 0 {name=p32302 lab=_87892_/Q }
C {devices/lab_pin.sym} 32900 -28080 0 0 {name=p32303 lab=_68006_/X }
C {devices/lab_pin.sym} 32900 -28040 0 0 {name=p32304 lab=_67984_/X }
C {devices/lab_pin.sym} 32900 -28000 0 0 {name=p32305 lab=_68078_/X }
C {devices/lab_pin.sym} 33060 -28060 0 1 {name=p32306 lab=_68079_/X }
C {sky130_stdcells/a211o_4.sym} 32980 -28060 0 0 {name=X_68079_ }
C {devices/lab_pin.sym} 32920 -27920 0 0 {name=p32307 lab=_84688_/Q }
C {devices/lab_pin.sym} 32920 -27880 0 0 {name=p32308 lab=_80357_/B }
C {devices/lab_pin.sym} 33040 -27900 0 1 {name=p32309 lab=_80357_/X }
C {sky130_stdcells/xor2_4.sym} 32980 -27900 0 0 {name=X_80357_ }
C {devices/lab_pin.sym} 32940 -27770 0 0 {name=p32310 lab=_70110_/A }
C {devices/lab_pin.sym} 33020 -27770 0 1 {name=p32311 lab=_70112_/C }
C {sky130_stdcells/inv_2.sym} 32980 -27770 0 0 {name=X_70110_ }
C {devices/lab_pin.sym} 32920 -27680 0 0 {name=p32312 lab=_55043_/X }
C {devices/lab_pin.sym} 32920 -27640 0 0 {name=p32313 lab=_55030_/X }
C {devices/lab_pin.sym} 32920 -27600 0 0 {name=p32314 lab=_55026_/C }
C {devices/lab_pin.sym} 32920 -27560 0 0 {name=p32315 lab=_47682_/Y }
C {devices/lab_pin.sym} 33040 -27620 0 1 {name=p32316 lab=_55044_/X }
C {sky130_stdcells/and4_4.sym} 32980 -27620 0 0 {name=X_55044_ }
C {devices/lab_pin.sym} 32940 -27470 0 0 {name=p32317 lab=_62515_/C }
C {devices/lab_pin.sym} 33020 -27470 0 1 {name=p32318 lab=_59922_/C }
C {sky130_stdcells/buf_2.sym} 32980 -27470 0 0 {name=X_59921_ }
C {devices/lab_pin.sym} 32900 -27370 0 0 {name=p32319 lab=_65890_/B }
C {devices/lab_pin.sym} 32900 -27330 0 0 {name=p32320 lab=_52184_/X }
C {devices/lab_pin.sym} 32900 -27290 0 0 {name=p32321 lab=_52255_/Y }
C {devices/lab_pin.sym} 33060 -27330 0 1 {name=p32322 lab=_52256_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -27330 0 0 {name=X_52256_ }
C {devices/lab_pin.sym} 32940 -27190 0 0 {name=p32323 lab=_71090_/A }
C {devices/lab_pin.sym} 33020 -27190 0 1 {name=p32324 lab=_71091_/B }
C {sky130_stdcells/buf_2.sym} 32980 -27190 0 0 {name=X_71090_ }
C {devices/lab_pin.sym} 32890 -27070 0 0 {name=p32325 lab=_83313_/CLK }
C {devices/lab_pin.sym} 32890 -27050 0 0 {name=p32326 lab=_74392_/Y }
C {devices/lab_pin.sym} 33070 -27070 0 1 {name=p32327 lab=_83076_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -27060 0 0 {name=X_83076_ }
C {devices/lab_pin.sym} 32890 -26930 0 0 {name=p32328 lab=_87950_/CLK }
C {devices/lab_pin.sym} 32890 -26910 0 0 {name=p32329 lab=_42261_/X }
C {devices/lab_pin.sym} 33070 -26930 0 1 {name=p32330 lab=_87953_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -26920 0 0 {name=X_87953_ }
C {devices/lab_pin.sym} 32920 -26800 0 0 {name=p32331 lab=_80288_/A }
C {devices/lab_pin.sym} 32920 -26760 0 0 {name=p32332 lab=_80288_/B }
C {devices/lab_pin.sym} 33040 -26780 0 1 {name=p32333 lab=_80304_/A }
C {sky130_stdcells/nor2_4.sym} 32980 -26780 0 0 {name=X_80288_ }
C {devices/lab_pin.sym} 32920 -26680 0 0 {name=p32334 lab=_51191_/X }
C {devices/lab_pin.sym} 32920 -26640 0 0 {name=p32335 lab=_51203_/B }
C {devices/lab_pin.sym} 32920 -26600 0 0 {name=p32336 lab=_51197_/C }
C {devices/lab_pin.sym} 32920 -26560 0 0 {name=p32337 lab=_52900_/D }
C {devices/lab_pin.sym} 33040 -26620 0 1 {name=p32338 lab=_51207_/X }
C {sky130_stdcells/and4_4.sym} 32980 -26620 0 0 {name=X_51207_ }
C {devices/lab_pin.sym} 32900 -26490 0 0 {name=p32339 lab=_68783_/X }
C {devices/lab_pin.sym} 32900 -26450 0 0 {name=p32340 lab=_68786_/X }
C {devices/lab_pin.sym} 32900 -26410 0 0 {name=p32341 lab=_70005_/X }
C {devices/lab_pin.sym} 33060 -26450 0 1 {name=p32342 lab=_70041_/Y }
C {sky130_stdcells/a21oi_4.sym} 32980 -26450 0 0 {name=X_70041_ }
C {devices/lab_pin.sym} 32890 -26310 0 0 {name=p32343 lab=_84407_/CLK }
C {devices/lab_pin.sym} 32890 -26290 0 0 {name=p32344 lab=_45024_/Y }
C {devices/lab_pin.sym} 33070 -26310 0 1 {name=p32345 lab=_64294_/B }
C {sky130_stdcells/dfxtp_4.sym} 32980 -26300 0 0 {name=X_86904_ }
C {devices/lab_pin.sym} 32890 -26170 0 0 {name=p32346 lab=_81975_/CLK }
C {devices/lab_pin.sym} 32890 -26150 0 0 {name=p32347 lab=_77812_/B }
C {devices/lab_pin.sym} 33070 -26170 0 1 {name=p32348 lab=_82027_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -26160 0 0 {name=X_82027_ }
C {devices/lab_pin.sym} 32940 -26030 0 0 {name=p32349 lab=_59852_/A }
C {devices/lab_pin.sym} 33020 -26030 0 1 {name=p32350 lab=_59855_/B }
C {sky130_stdcells/buf_2.sym} 32980 -26030 0 0 {name=X_59852_ }
C {devices/lab_pin.sym} 32900 -25930 0 0 {name=p32351 lab=_85872_/Q }
C {devices/lab_pin.sym} 32900 -25890 0 0 {name=p32352 lab=_52184_/X }
C {devices/lab_pin.sym} 32900 -25850 0 0 {name=p32353 lab=_52186_/Y }
C {devices/lab_pin.sym} 33060 -25890 0 1 {name=p32354 lab=_52187_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -25890 0 0 {name=X_52187_ }
C {devices/lab_pin.sym} 32890 -25750 0 0 {name=p32355 lab=_88144_/CLK }
C {devices/lab_pin.sym} 32890 -25730 0 0 {name=p32356 lab=_87884_/D }
C {devices/lab_pin.sym} 33070 -25750 0 1 {name=p32357 lab=_87884_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -25740 0 0 {name=X_87884_ }
C {devices/lab_pin.sym} 32900 -25640 0 0 {name=p32358 lab=_58792_/Y }
C {devices/lab_pin.sym} 32900 -25600 0 0 {name=p32359 lab=_58739_/X }
C {devices/lab_pin.sym} 32900 -25560 0 0 {name=p32360 lab=_58799_/X }
C {devices/lab_pin.sym} 32900 -25520 0 0 {name=p32361 lab=_58802_/X }
C {devices/lab_pin.sym} 33060 -25580 0 1 {name=p32362 lab=_58803_/Y }
C {sky130_stdcells/a22oi_4.sym} 32980 -25580 0 0 {name=X_58803_ }
C {devices/lab_pin.sym} 32900 -25450 0 0 {name=p32363 lab=_51135_/Y }
C {devices/lab_pin.sym} 32900 -25410 0 0 {name=p32364 lab=_51119_/X }
C {devices/lab_pin.sym} 32900 -25370 0 0 {name=p32365 lab=_51137_/X }
C {devices/lab_pin.sym} 33060 -25410 0 1 {name=p32366 lab=_51138_/Y }
C {sky130_stdcells/a21oi_4.sym} 32980 -25410 0 0 {name=X_51138_ }
C {devices/lab_pin.sym} 32890 -25270 0 0 {name=p32367 lab=_87995_/CLK }
C {devices/lab_pin.sym} 32890 -25250 0 0 {name=p32368 lab=_86835_/D }
C {devices/lab_pin.sym} 33070 -25270 0 1 {name=p32369 lab=_66644_/B }
C {sky130_stdcells/dfxtp_4.sym} 32980 -25260 0 0 {name=X_86835_ }
C {devices/lab_pin.sym} 32900 -25170 0 0 {name=p32370 lab=_59689_/B }
C {devices/lab_pin.sym} 32900 -25130 0 0 {name=p32371 lab=_59631_/B }
C {devices/lab_pin.sym} 32900 -25090 0 0 {name=p32372 lab=_59687_/A }
C {devices/lab_pin.sym} 32900 -25050 0 0 {name=p32373 lab=_59836_/D }
C {devices/lab_pin.sym} 32900 -25020 0 0 {name=p32374 lab=_59782_/X }
C {devices/lab_pin.sym} 33060 -25090 0 1 {name=p32375 lab=_59783_/Y }
C {sky130_stdcells/a41oi_4.sym} 32980 -25090 0 0 {name=X_59783_ }
C {devices/lab_pin.sym} 32940 -24930 0 0 {name=p32376 lab=_56995_/A }
C {devices/lab_pin.sym} 33020 -24930 0 1 {name=p32377 lab=_56995_/X }
C {sky130_stdcells/buf_2.sym} 32980 -24930 0 0 {name=X_56995_ }
C {devices/lab_pin.sym} 32900 -24830 0 0 {name=p32378 lab=_73796_/X }
C {devices/lab_pin.sym} 32900 -24790 0 0 {name=p32379 lab=_73798_/X }
C {devices/lab_pin.sym} 32900 -24750 0 0 {name=p32380 lab=_73799_/X }
C {devices/lab_pin.sym} 33060 -24790 0 1 {name=p32381 lab=_73815_/B }
C {sky130_stdcells/a21o_4.sym} 32980 -24790 0 0 {name=X_73800_ }
C {devices/lab_pin.sym} 32900 -24670 0 0 {name=p32382 lab=_58618_/X }
C {devices/lab_pin.sym} 32900 -24630 0 0 {name=p32383 lab=_86100_/Q }
C {devices/lab_pin.sym} 32900 -24590 0 0 {name=p32384 lab=_58733_/X }
C {devices/lab_pin.sym} 33060 -24630 0 1 {name=p32385 lab=_58734_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -24630 0 0 {name=X_58734_ }
C {devices/lab_pin.sym} 32940 -24490 0 0 {name=p32386 lab=_59538_/D }
C {devices/lab_pin.sym} 33020 -24490 0 1 {name=p32387 lab=_44003_/A }
C {sky130_stdcells/buf_2.sym} 32980 -24490 0 0 {name=X_43960_ }
C {devices/lab_pin.sym} 32920 -24380 0 0 {name=p32388 lab=_51058_/A }
C {devices/lab_pin.sym} 32920 -24340 0 0 {name=p32389 lab=_52760_/B }
C {devices/lab_pin.sym} 33040 -24360 0 1 {name=p32390 lab=_51069_/Y }
C {sky130_stdcells/nand2_4.sym} 32980 -24360 0 0 {name=X_51069_ }
C {devices/lab_pin.sym} 32940 -24230 0 0 {name=p32391 lab=_55946_/A }
C {devices/lab_pin.sym} 33020 -24230 0 1 {name=p32392 lab=_74297_/C }
C {sky130_stdcells/buf_2.sym} 32980 -24230 0 0 {name=X_55946_ }
C {devices/lab_pin.sym} 32940 -24110 0 0 {name=p32393 lab=clkbuf_6_61_0_CLK/X }
C {devices/lab_pin.sym} 33020 -24110 0 1 {name=p32394 lab=clkbuf_8_247_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 32980 -24110 0 0 {name=Xclkbuf_7_123_0_CLK }
C {devices/lab_pin.sym} 32920 -24020 0 0 {name=p32395 lab=_74780_/A }
C {devices/lab_pin.sym} 32920 -23980 0 0 {name=p32396 lab=_74720_/C }
C {devices/lab_pin.sym} 32920 -23940 0 0 {name=p32397 lab=_74744_/X }
C {devices/lab_pin.sym} 32920 -23900 0 0 {name=p32398 lab=_74780_/D }
C {devices/lab_pin.sym} 33040 -23960 0 1 {name=p32399 lab=_74784_/A }
C {sky130_stdcells/nand4_4.sym} 32980 -23960 0 0 {name=X_74780_ }
C {devices/lab_pin.sym} 32890 -23810 0 0 {name=p32400 lab=_84549_/CLK }
C {devices/lab_pin.sym} 32890 -23790 0 0 {name=p32401 lab=_46180_/Y }
C {devices/lab_pin.sym} 33070 -23810 0 1 {name=p32402 lab=_44008_/A }
C {sky130_stdcells/dfxtp_4.sym} 32980 -23800 0 0 {name=X_86766_ }
C {devices/lab_pin.sym} 32900 -23690 0 0 {name=p32403 lab=_83306_/Q }
C {devices/lab_pin.sym} 32900 -23650 0 0 {name=p32404 lab=_71985_/X }
C {devices/lab_pin.sym} 32900 -23610 0 0 {name=p32405 lab=_71991_/Y }
C {devices/lab_pin.sym} 33060 -23650 0 1 {name=p32406 lab=_71992_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -23650 0 0 {name=X_71992_ }
C {devices/lab_pin.sym} 32890 -23510 0 0 {name=p32407 lab=_88376_/CLK }
C {devices/lab_pin.sym} 32890 -23490 0 0 {name=p32408 lab=_68341_/X }
C {devices/lab_pin.sym} 33070 -23510 0 1 {name=p32409 lab=_82626_/D }
C {sky130_stdcells/dfxtp_4.sym} 32980 -23500 0 0 {name=X_83978_ }
C {devices/lab_pin.sym} 32900 -23400 0 0 {name=p32410 lab=_41693_/X }
C {devices/lab_pin.sym} 32900 -23360 0 0 {name=p32411 lab=_42900_/X }
C {devices/lab_pin.sym} 32900 -23320 0 0 {name=p32412 lab=_87656_/Q }
C {devices/lab_pin.sym} 32900 -23280 0 0 {name=p32413 lab=_42901_/X }
C {devices/lab_pin.sym} 33060 -23340 0 1 {name=p32414 lab=_42911_/X }
C {sky130_stdcells/a2bb2o_4.sym} 32980 -23340 0 0 {name=X_42911_ }
C {devices/lab_pin.sym} 32940 -23190 0 0 {name=p32415 lab=_73355_/A }
C {devices/lab_pin.sym} 33020 -23190 0 1 {name=p32416 lab=_73731_/X }
C {sky130_stdcells/buf_2.sym} 32980 -23190 0 0 {name=X_73731_ }
C {devices/lab_pin.sym} 32890 -23070 0 0 {name=p32417 lab=_85718_/CLK }
C {devices/lab_pin.sym} 32890 -23050 0 0 {name=p32418 lab=_52994_/Y }
C {devices/lab_pin.sym} 33070 -23070 0 1 {name=p32419 lab=_85717_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -23060 0 0 {name=X_85717_ }
C {devices/lab_pin.sym} 32900 -22950 0 0 {name=p32420 lab=_58641_/X }
C {devices/lab_pin.sym} 32900 -22910 0 0 {name=p32421 lab=_85945_/Q }
C {devices/lab_pin.sym} 32900 -22870 0 0 {name=p32422 lab=_58664_/X }
C {devices/lab_pin.sym} 33060 -22910 0 1 {name=p32423 lab=_58665_/X }
C {sky130_stdcells/o21a_4.sym} 32980 -22910 0 0 {name=X_58665_ }
C {devices/lab_pin.sym} 32900 -22790 0 0 {name=p32424 lab=_49212_/B }
C {devices/lab_pin.sym} 32900 -22750 0 0 {name=p32425 lab=_70937_/X }
C {devices/lab_pin.sym} 32900 -22710 0 0 {name=p32426 lab=_70942_/Y }
C {devices/lab_pin.sym} 33060 -22750 0 1 {name=p32427 lab=_70943_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -22750 0 0 {name=X_70943_ }
C {devices/lab_pin.sym} 32890 -22610 0 0 {name=p32428 lab=_81190_/CLK }
C {devices/lab_pin.sym} 32890 -22590 0 0 {name=p32429 lab=_78240_/X }
C {devices/lab_pin.sym} 33070 -22610 0 1 {name=p32430 lab=_46436_/A }
C {sky130_stdcells/dfxtp_4.sym} 32980 -22600 0 0 {name=X_82929_ }
C {devices/lab_pin.sym} 32940 -22470 0 0 {name=p32431 lab=_43890_/Y }
C {devices/lab_pin.sym} 33020 -22470 0 1 {name=p32432 lab=_43891_/Y }
C {sky130_stdcells/inv_2.sym} 32980 -22470 0 0 {name=X_43891_ }
C {devices/lab_pin.sym} 32900 -22380 0 0 {name=p32433 lab=_56407_/C }
C {devices/lab_pin.sym} 32900 -22340 0 0 {name=p32434 lab=_55505_/X }
C {devices/lab_pin.sym} 32900 -22300 0 0 {name=p32435 lab=_55513_/X }
C {devices/lab_pin.sym} 32900 -22260 0 0 {name=p32436 lab=_55876_/X }
C {devices/lab_pin.sym} 33060 -22320 0 1 {name=p32437 lab=_55877_/X }
C {sky130_stdcells/a211o_4.sym} 32980 -22320 0 0 {name=X_55877_ }
C {devices/lab_pin.sym} 32890 -22170 0 0 {name=p32438 lab=_86697_/CLK }
C {devices/lab_pin.sym} 32890 -22150 0 0 {name=p32439 lab=_86697_/D }
C {devices/lab_pin.sym} 33070 -22170 0 1 {name=p32440 lab=_86697_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -22160 0 0 {name=X_86697_ }
C {devices/lab_pin.sym} 32940 -22030 0 0 {name=p32441 lab=clkbuf_9_46_0_CLK/X }
C {devices/lab_pin.sym} 33020 -22030 0 1 {name=p32442 lab=clkbuf_opt_9_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 32980 -22030 0 0 {name=Xclkbuf_10_93_0_CLK }
C {devices/lab_pin.sym} 32940 -21910 0 0 {name=p32443 lab=_57563_/X }
C {devices/lab_pin.sym} 33020 -21910 0 1 {name=p32444 lab=_71957_/A }
C {sky130_stdcells/buf_2.sym} 32980 -21910 0 0 {name=X_57616_ }
C {devices/lab_pin.sym} 32900 -21820 0 0 {name=p32445 lab=_45626_/Y }
C {devices/lab_pin.sym} 32900 -21780 0 0 {name=p32446 lab=_45627_/X }
C {devices/lab_pin.sym} 32900 -21740 0 0 {name=p32447 lab=_45548_/X }
C {devices/lab_pin.sym} 32900 -21700 0 0 {name=p32448 lab=_45629_/Y }
C {devices/lab_pin.sym} 33060 -21760 0 1 {name=p32449 lab=_45630_/X }
C {sky130_stdcells/a211o_4.sym} 32980 -21760 0 0 {name=X_45630_ }
C {devices/lab_pin.sym} 32920 -21620 0 0 {name=p32450 lab=_81271_/Q }
C {devices/lab_pin.sym} 32920 -21580 0 0 {name=p32451 lab=_81539_/Q }
C {devices/lab_pin.sym} 33040 -21600 0 1 {name=p32452 lab=_76455_/A }
C {sky130_stdcells/nor2_4.sym} 32980 -21600 0 0 {name=X_76450_ }
C {devices/lab_pin.sym} 32900 -21500 0 0 {name=p32453 lab=_41507_/X }
C {devices/lab_pin.sym} 32900 -21460 0 0 {name=p32454 lab=_42830_/X }
C {devices/lab_pin.sym} 32900 -21420 0 0 {name=p32455 lab=_87690_/Q }
C {devices/lab_pin.sym} 32900 -21380 0 0 {name=p32456 lab=_42832_/X }
C {devices/lab_pin.sym} 33060 -21440 0 1 {name=p32457 lab=_42842_/X }
C {sky130_stdcells/a2bb2o_4.sym} 32980 -21440 0 0 {name=X_42842_ }
C {devices/lab_pin.sym} 32900 -21310 0 0 {name=p32458 lab=_85370_/Q }
C {devices/lab_pin.sym} 32900 -21270 0 0 {name=p32459 lab=_54812_/X }
C {devices/lab_pin.sym} 32900 -21230 0 0 {name=p32460 lab=_54827_/Y }
C {devices/lab_pin.sym} 33060 -21270 0 1 {name=p32461 lab=_54828_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -21270 0 0 {name=X_54828_ }
C {devices/lab_pin.sym} 32920 -21140 0 0 {name=p32462 lab=_73638_/A }
C {devices/lab_pin.sym} 32920 -21100 0 0 {name=p32463 lab=_86589_/Q }
C {devices/lab_pin.sym} 33040 -21120 0 1 {name=p32464 lab=_73662_/X }
C {sky130_stdcells/and2_4.sym} 32980 -21120 0 0 {name=X_73662_ }
C {devices/lab_pin.sym} 32890 -20990 0 0 {name=p32465 lab=_85648_/CLK }
C {devices/lab_pin.sym} 32890 -20970 0 0 {name=p32466 lab=_85648_/D }
C {devices/lab_pin.sym} 33070 -20990 0 1 {name=p32467 lab=_85648_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -20980 0 0 {name=X_85648_ }
C {devices/lab_pin.sym} 32900 -20870 0 0 {name=p32468 lab=_46740_/X }
C {devices/lab_pin.sym} 32900 -20830 0 0 {name=p32469 lab=_70855_/A }
C {devices/lab_pin.sym} 32900 -20790 0 0 {name=p32470 lab=_70873_/Y }
C {devices/lab_pin.sym} 33060 -20830 0 1 {name=p32471 lab=_70874_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -20830 0 0 {name=X_70874_ }
C {devices/lab_pin.sym} 32900 -20710 0 0 {name=p32472 lab=_58140_/X }
C {devices/lab_pin.sym} 32900 -20670 0 0 {name=p32473 lab=_86111_/Q }
C {devices/lab_pin.sym} 32900 -20630 0 0 {name=p32474 lab=_58595_/X }
C {devices/lab_pin.sym} 33060 -20670 0 1 {name=p32475 lab=_58596_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -20670 0 0 {name=X_58596_ }
C {devices/lab_pin.sym} 32920 -20550 0 0 {name=p32476 lab=_75401_/A }
C {devices/lab_pin.sym} 32920 -20510 0 0 {name=p32477 lab=_75399_/Y }
C {devices/lab_pin.sym} 32920 -20470 0 0 {name=p32478 lab=_75397_/Y }
C {devices/lab_pin.sym} 33040 -20510 0 1 {name=p32479 lab=_75401_/Y }
C {sky130_stdcells/nand3_4.sym} 32980 -20510 0 0 {name=X_75401_ }
C {devices/lab_pin.sym} 32900 -20400 0 0 {name=p32480 lab=_79245_/B }
C {devices/lab_pin.sym} 32900 -20360 0 0 {name=p32481 lab=_72590_/X }
C {devices/lab_pin.sym} 32900 -20320 0 0 {name=p32482 lab=_72608_/Y }
C {devices/lab_pin.sym} 32900 -20280 0 0 {name=p32483 lab=_72612_/X }
C {devices/lab_pin.sym} 33060 -20340 0 1 {name=p32484 lab=_72613_/X }
C {sky130_stdcells/o22a_4.sym} 32980 -20340 0 0 {name=X_72613_ }
C {devices/lab_pin.sym} 32940 -20190 0 0 {name=p32485 lab=_45714_/A }
C {devices/lab_pin.sym} 33020 -20190 0 1 {name=p32486 lab=_45561_/X }
C {sky130_stdcells/buf_2.sym} 32980 -20190 0 0 {name=X_45561_ }
C {devices/lab_pin.sym} 32900 -20090 0 0 {name=p32487 lab=_84981_/Q }
C {devices/lab_pin.sym} 32900 -20050 0 0 {name=p32488 lab=_57527_/X }
C {devices/lab_pin.sym} 32900 -20010 0 0 {name=p32489 lab=_57546_/Y }
C {devices/lab_pin.sym} 33060 -20050 0 1 {name=p32490 lab=_57547_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -20050 0 0 {name=X_57547_ }
C {devices/lab_pin.sym} 32920 -19920 0 0 {name=p32491 lab=_76381_/A }
C {devices/lab_pin.sym} 32920 -19880 0 0 {name=p32492 lab=_76381_/B }
C {devices/lab_pin.sym} 33040 -19900 0 1 {name=p32493 lab=_76382_/A }
C {sky130_stdcells/and2_4.sym} 32980 -19900 0 0 {name=X_76381_ }
C {devices/lab_pin.sym} 32940 -19770 0 0 {name=p32494 lab=_42773_/A }
C {devices/lab_pin.sym} 33020 -19770 0 1 {name=p32495 lab=_42773_/Y }
C {sky130_stdcells/inv_2.sym} 32980 -19770 0 0 {name=X_42773_ }
C {devices/lab_pin.sym} 32890 -19650 0 0 {name=p32496 lab=_86982_/CLK }
C {devices/lab_pin.sym} 32890 -19630 0 0 {name=p32497 lab=_40607_/Y }
C {devices/lab_pin.sym} 33070 -19650 0 1 {name=p32498 lab=_88367_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -19640 0 0 {name=X_88367_ }
C {devices/lab_pin.sym} 32920 -19520 0 0 {name=p32499 lab=_54758_/X }
C {devices/lab_pin.sym} 32920 -19480 0 0 {name=p32500 lab=_47469_/A }
C {devices/lab_pin.sym} 33040 -19500 0 1 {name=p32501 lab=_54759_/Y }
C {sky130_stdcells/nand2_4.sym} 32980 -19500 0 0 {name=X_54759_ }
C {devices/lab_pin.sym} 32920 -19380 0 0 {name=p32502 lab=_74117_/A }
C {devices/lab_pin.sym} 32920 -19340 0 0 {name=p32503 lab=_73592_/Y }
C {devices/lab_pin.sym} 33040 -19360 0 1 {name=p32504 lab=_73593_/Y }
C {sky130_stdcells/nor2_4.sym} 32980 -19360 0 0 {name=X_73593_ }
C {devices/lab_pin.sym} 32890 -19230 0 0 {name=p32505 lab=_86500_/CLK }
C {devices/lab_pin.sym} 32890 -19210 0 0 {name=p32506 lab=_53735_/Y }
C {devices/lab_pin.sym} 33070 -19230 0 1 {name=p32507 lab=_85579_/Q }
C {sky130_stdcells/dfxtp_4.sym} 32980 -19220 0 0 {name=X_85579_ }
C {devices/lab_pin.sym} 32900 -19110 0 0 {name=p32508 lab=_57846_/A }
C {devices/lab_pin.sym} 32900 -19070 0 0 {name=p32509 lab=_47286_/X }
C {devices/lab_pin.sym} 32900 -19030 0 0 {name=p32510 lab=_47299_/Y }
C {devices/lab_pin.sym} 33060 -19070 0 1 {name=p32511 lab=_47300_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -19070 0 0 {name=X_47300_ }
C {devices/lab_pin.sym} 32920 -18950 0 0 {name=p32512 lab=_78120_/A }
C {devices/lab_pin.sym} 32920 -18910 0 0 {name=p32513 lab=_78120_/B }
C {devices/lab_pin.sym} 32920 -18870 0 0 {name=p32514 lab=_78120_/C }
C {devices/lab_pin.sym} 33040 -18910 0 1 {name=p32515 lab=_78120_/Y }
C {sky130_stdcells/nand3_4.sym} 32980 -18910 0 0 {name=X_78120_ }
C {devices/lab_pin.sym} 32940 -18770 0 0 {name=p32516 lab=_44512_/A }
C {devices/lab_pin.sym} 33020 -18770 0 1 {name=p32517 lab=_44512_/X }
C {sky130_stdcells/buf_2.sym} 32980 -18770 0 0 {name=X_44512_ }
C {devices/lab_pin.sym} 32920 -18660 0 0 {name=p32518 lab=_80692_/Q }
C {devices/lab_pin.sym} 32920 -18620 0 0 {name=p32519 lab=_80948_/D }
C {devices/lab_pin.sym} 33040 -18640 0 1 {name=p32520 lab=_75333_/A }
C {sky130_stdcells/nand2_4.sym} 32980 -18640 0 0 {name=X_75332_ }
C {devices/lab_pin.sym} 32900 -18540 0 0 {name=p32521 lab=_41721_/X }
C {devices/lab_pin.sym} 32900 -18500 0 0 {name=p32522 lab=_41722_/X }
C {devices/lab_pin.sym} 32900 -18460 0 0 {name=p32523 lab=_88162_/Q }
C {devices/lab_pin.sym} 32900 -18420 0 0 {name=p32524 lab=_41723_/X }
C {devices/lab_pin.sym} 33060 -18480 0 1 {name=p32525 lab=_88162_/D }
C {sky130_stdcells/a2bb2o_4.sym} 32980 -18480 0 0 {name=X_41724_ }
C {devices/lab_pin.sym} 32890 -18330 0 0 {name=p32526 lab=_87577_/CLK }
C {devices/lab_pin.sym} 32890 -18310 0 0 {name=p32527 lab=_87318_/D }
C {devices/lab_pin.sym} 33070 -18330 0 1 {name=p32528 lab=_74226_/A }
C {sky130_stdcells/dfxtp_4.sym} 32980 -18320 0 0 {name=X_87318_ }
C {devices/lab_pin.sym} 32900 -18210 0 0 {name=p32529 lab=_66171_/B }
C {devices/lab_pin.sym} 32900 -18170 0 0 {name=p32530 lab=_48241_/X }
C {devices/lab_pin.sym} 32900 -18130 0 0 {name=p32531 lab=_48279_/Y }
C {devices/lab_pin.sym} 33060 -18170 0 1 {name=p32532 lab=_48280_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -18170 0 0 {name=X_48280_ }
C {devices/lab_pin.sym} 32920 -18050 0 0 {name=p32533 lab=_72573_/A }
C {devices/lab_pin.sym} 32920 -18010 0 0 {name=p32534 lab=_72544_/B }
C {devices/lab_pin.sym} 32920 -17970 0 0 {name=p32535 lab=_79467_/B }
C {devices/lab_pin.sym} 33040 -18010 0 1 {name=p32536 lab=_72544_/Y }
C {sky130_stdcells/nor3_4.sym} 32980 -18010 0 0 {name=X_72544_ }
C {devices/lab_pin.sym} 32900 -17890 0 0 {name=p32537 lab=_45487_/X }
C {devices/lab_pin.sym} 32900 -17850 0 0 {name=p32538 lab=_45491_/X }
C {devices/lab_pin.sym} 32900 -17810 0 0 {name=p32539 lab=_45446_/X }
C {devices/lab_pin.sym} 33060 -17850 0 1 {name=p32540 lab=_45492_/X }
C {sky130_stdcells/a21o_4.sym} 32980 -17850 0 0 {name=X_45492_ }
C {devices/lab_pin.sym} 32940 -17710 0 0 {name=p32541 lab=_57478_/A }
C {devices/lab_pin.sym} 33020 -17710 0 1 {name=p32542 lab=_57478_/Y }
C {sky130_stdcells/inv_2.sym} 32980 -17710 0 0 {name=X_57478_ }
C {devices/lab_pin.sym} 32890 -17590 0 0 {name=p32543 lab=_88301_/CLK }
C {devices/lab_pin.sym} 32890 -17570 0 0 {name=p32544 lab=_88298_/D }
C {devices/lab_pin.sym} 33070 -17590 0 1 {name=p32545 lab=_69265_/B }
C {sky130_stdcells/dfxtp_4.sym} 32980 -17580 0 0 {name=X_88298_ }
C {devices/lab_pin.sym} 32900 -17470 0 0 {name=p32546 lab=_59160_/X }
C {devices/lab_pin.sym} 32900 -17430 0 0 {name=p32547 lab=_85647_/Q }
C {devices/lab_pin.sym} 32900 -17390 0 0 {name=p32548 lab=_59205_/X }
C {devices/lab_pin.sym} 33060 -17430 0 1 {name=p32549 lab=_59217_/X }
C {sky130_stdcells/o21a_4.sym} 32980 -17430 0 0 {name=X_59217_ }
C {devices/lab_pin.sym} 32940 -17290 0 0 {name=p32550 lab=_54097_/B }
C {devices/lab_pin.sym} 33020 -17290 0 1 {name=p32551 lab=_52931_/B }
C {sky130_stdcells/buf_2.sym} 32980 -17290 0 0 {name=X_47231_ }
C {devices/lab_pin.sym} 32920 -17180 0 0 {name=p32552 lab=_84556_/Q }
C {devices/lab_pin.sym} 32920 -17140 0 0 {name=p32553 lab=_78051_/B }
C {devices/lab_pin.sym} 33040 -17160 0 1 {name=p32554 lab=_78051_/X }
C {sky130_stdcells/xor2_4.sym} 32980 -17160 0 0 {name=X_78051_ }
C {devices/lab_pin.sym} 32900 -17070 0 0 {name=p32555 lab=_44425_/X }
C {devices/lab_pin.sym} 32900 -17030 0 0 {name=p32556 lab=_44427_/X }
C {devices/lab_pin.sym} 32900 -16990 0 0 {name=p32557 lab=_41621_/X }
C {devices/lab_pin.sym} 32900 -16950 0 0 {name=p32558 lab=_87105_/Q }
C {devices/lab_pin.sym} 32900 -16910 0 0 {name=p32559 lab=_44428_/X }
C {devices/lab_pin.sym} 33060 -16990 0 1 {name=p32560 lab=_44444_/A }
C {sky130_stdcells/o32ai_4.sym} 32980 -16990 0 0 {name=X_44443_ }
C {devices/lab_pin.sym} 32920 -16850 0 0 {name=p32561 lab=_56431_/A }
C {devices/lab_pin.sym} 32920 -16810 0 0 {name=p32562 lab=_56433_/B }
C {devices/lab_pin.sym} 32920 -16770 0 0 {name=p32563 lab=_85197_/Q }
C {devices/lab_pin.sym} 33040 -16810 0 1 {name=p32564 lab=_56429_/Y }
C {sky130_stdcells/nand3_4.sym} 32980 -16810 0 0 {name=X_56429_ }
C {devices/lab_pin.sym} 32940 -16670 0 0 {name=p32565 lab=clkbuf_8_255_0_CLK/A }
C {devices/lab_pin.sym} 33020 -16670 0 1 {name=p32566 lab=clkbuf_9_509_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 32980 -16670 0 0 {name=Xclkbuf_8_254_0_CLK }
C {devices/lab_pin.sym} 32900 -16570 0 0 {name=p32567 lab=_75226_/Y }
C {devices/lab_pin.sym} 32900 -16530 0 0 {name=p32568 lab=_75228_/X }
C {devices/lab_pin.sym} 32900 -16490 0 0 {name=p32569 lab=_75240_/X }
C {devices/lab_pin.sym} 33060 -16530 0 1 {name=p32570 lab=_75263_/X }
C {sky130_stdcells/a21o_4.sym} 32980 -16530 0 0 {name=X_75263_ }
C {devices/lab_pin.sym} 32890 -16390 0 0 {name=p32571 lab=_87249_/CLK }
C {devices/lab_pin.sym} 32890 -16370 0 0 {name=p32572 lab=_87249_/D }
C {devices/lab_pin.sym} 33070 -16390 0 1 {name=p32573 lab=_68427_/B }
C {sky130_stdcells/dfxtp_4.sym} 32980 -16380 0 0 {name=X_87249_ }
C {devices/lab_pin.sym} 32900 -16270 0 0 {name=p32574 lab=_41628_/X }
C {devices/lab_pin.sym} 32900 -16230 0 0 {name=p32575 lab=_41310_/A }
C {devices/lab_pin.sym} 32900 -16190 0 0 {name=p32576 lab=_41654_/X }
C {devices/lab_pin.sym} 33060 -16230 0 1 {name=p32577 lab=_41655_/X }
C {sky130_stdcells/o21a_4.sym} 32980 -16230 0 0 {name=X_41655_ }
C {devices/lab_pin.sym} 32920 -16100 0 0 {name=p32578 lab=_72414_/X }
C {devices/lab_pin.sym} 32920 -16060 0 0 {name=p32579 lab=_72475_/B }
C {devices/lab_pin.sym} 33040 -16080 0 1 {name=p32580 lab=_72475_/Y }
C {sky130_stdcells/nor2_4.sym} 32980 -16080 0 0 {name=X_72475_ }
C {devices/lab_pin.sym} 32920 -15960 0 0 {name=p32581 lab=_81986_/Q }
C {devices/lab_pin.sym} 32920 -15920 0 0 {name=p32582 lab=_82274_/D }
C {devices/lab_pin.sym} 33040 -15940 0 1 {name=p32583 lab=_77002_/X }
C {sky130_stdcells/xor2_4.sym} 32980 -15940 0 0 {name=X_77002_ }
C {devices/lab_pin.sym} 32920 -15820 0 0 {name=p32584 lab=_73165_/A }
C {devices/lab_pin.sym} 32920 -15780 0 0 {name=p32585 lab=_66310_/B }
C {devices/lab_pin.sym} 33040 -15800 0 1 {name=p32586 lab=_74214_/X }
C {sky130_stdcells/and2_4.sym} 32980 -15800 0 0 {name=X_74214_ }
C {devices/lab_pin.sym} 32900 -15710 0 0 {name=p32587 lab=_40550_/X }
C {devices/lab_pin.sym} 32900 -15670 0 0 {name=p32588 lab=_40556_/X }
C {devices/lab_pin.sym} 32900 -15630 0 0 {name=p32589 lab=_40605_/X }
C {devices/lab_pin.sym} 32900 -15590 0 0 {name=p32590 lab=_88367_/Q }
C {devices/lab_pin.sym} 32900 -15550 0 0 {name=p32591 lab=_40568_/X }
C {devices/lab_pin.sym} 33060 -15630 0 1 {name=p32592 lab=_40607_/A }
C {sky130_stdcells/o32ai_4.sym} 32980 -15630 0 0 {name=X_40606_ }
C {devices/lab_pin.sym} 32940 -15470 0 0 {name=p32593 lab=_54580_/D }
C {devices/lab_pin.sym} 33020 -15470 0 1 {name=p32594 lab=_52887_/D }
C {sky130_stdcells/buf_2.sym} 32980 -15470 0 0 {name=X_47162_ }
C {devices/lab_pin.sym} 32900 -15370 0 0 {name=p32595 lab=_59146_/X }
C {devices/lab_pin.sym} 32900 -15330 0 0 {name=p32596 lab=_85429_/Q }
C {devices/lab_pin.sym} 32900 -15290 0 0 {name=p32597 lab=_59147_/X }
C {devices/lab_pin.sym} 33060 -15330 0 1 {name=p32598 lab=_59148_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -15330 0 0 {name=X_59148_ }
C {devices/lab_pin.sym} 32940 -15190 0 0 {name=p32599 lab=_70370_/A }
C {devices/lab_pin.sym} 33020 -15190 0 1 {name=p32600 lab=_71432_/A }
C {sky130_stdcells/buf_2.sym} 32980 -15190 0 0 {name=X_71426_ }
C {devices/lab_pin.sym} 32900 -15110 0 0 {name=p32601 lab=_44350_/X }
C {devices/lab_pin.sym} 32900 -15070 0 0 {name=p32602 lab=_44351_/X }
C {devices/lab_pin.sym} 32900 -15030 0 0 {name=p32603 lab=_41773_/X }
C {devices/lab_pin.sym} 32900 -14990 0 0 {name=p32604 lab=_87140_/Q }
C {devices/lab_pin.sym} 32900 -14950 0 0 {name=p32605 lab=_44353_/X }
C {devices/lab_pin.sym} 33060 -15030 0 1 {name=p32606 lab=_44374_/Y }
C {sky130_stdcells/o32ai_4.sym} 32980 -15030 0 0 {name=X_44374_ }
C {devices/lab_pin.sym} 32900 -14890 0 0 {name=p32607 lab=_75162_/B }
C {devices/lab_pin.sym} 32900 -14850 0 0 {name=p32608 lab=_75180_/A }
C {devices/lab_pin.sym} 32900 -14810 0 0 {name=p32609 lab=_75179_/A }
C {devices/lab_pin.sym} 33060 -14850 0 1 {name=p32610 lab=_75194_/X }
C {sky130_stdcells/o21a_4.sym} 32980 -14850 0 0 {name=X_75194_ }
C {devices/lab_pin.sym} 32940 -14710 0 0 {name=p32611 lab=_41585_/Y }
C {devices/lab_pin.sym} 33020 -14710 0 1 {name=p32612 lab=_41586_/X }
C {sky130_stdcells/buf_2.sym} 32980 -14710 0 0 {name=X_41586_ }
C {devices/lab_pin.sym} 32940 -14590 0 0 {name=p32613 lab=clkbuf_9_15_0_CLK/X }
C {devices/lab_pin.sym} 33020 -14590 0 1 {name=p32614 lab=_82980_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32980 -14590 0 0 {name=Xclkbuf_10_31_0_CLK }
C {devices/lab_pin.sym} 32940 -14470 0 0 {name=p32615 lab=_46138_/A }
C {devices/lab_pin.sym} 33020 -14470 0 1 {name=p32616 lab=_46120_/A }
C {sky130_stdcells/buf_2.sym} 32980 -14470 0 0 {name=X_46113_ }
C {devices/lab_pin.sym} 32940 -14350 0 0 {name=p32617 lab=_43287_/A }
C {devices/lab_pin.sym} 33020 -14350 0 1 {name=p32618 lab=_43325_/X }
C {sky130_stdcells/buf_2.sym} 32980 -14350 0 0 {name=X_43325_ }
C {devices/lab_pin.sym} 32920 -14240 0 0 {name=p32619 lab=_74145_/A }
C {devices/lab_pin.sym} 32920 -14200 0 0 {name=p32620 lab=_72795_/A }
C {devices/lab_pin.sym} 33040 -14220 0 1 {name=p32621 lab=_74145_/Y }
C {sky130_stdcells/nor2_4.sym} 32980 -14220 0 0 {name=X_74145_ }
C {devices/lab_pin.sym} 32900 -14110 0 0 {name=p32622 lab=_40504_/X }
C {devices/lab_pin.sym} 32900 -14070 0 0 {name=p32623 lab=_82308_/Q }
C {devices/lab_pin.sym} 32900 -14030 0 0 {name=p32624 lab=_40536_/X }
C {devices/lab_pin.sym} 33060 -14070 0 1 {name=p32625 lab=_40537_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -14070 0 0 {name=X_40537_ }
C {devices/lab_pin.sym} 32940 -13930 0 0 {name=p32626 lab=_47093_/A }
C {devices/lab_pin.sym} 33020 -13930 0 1 {name=p32627 lab=_52853_/D }
C {sky130_stdcells/buf_2.sym} 32980 -13930 0 0 {name=X_47093_ }
C {devices/lab_pin.sym} 32920 -13840 0 0 {name=p32628 lab=_71504_/C }
C {devices/lab_pin.sym} 32920 -13800 0 0 {name=p32629 lab=_71351_/X }
C {devices/lab_pin.sym} 32920 -13760 0 0 {name=p32630 lab=_71427_/C }
C {devices/lab_pin.sym} 32920 -13720 0 0 {name=p32631 lab=_71363_/D }
C {devices/lab_pin.sym} 33040 -13780 0 1 {name=p32632 lab=_71357_/X }
C {sky130_stdcells/and4_4.sym} 32980 -13780 0 0 {name=X_71357_ }
C {devices/lab_pin.sym} 32940 -13630 0 0 {name=p32633 lab=_64565_/A }
C {devices/lab_pin.sym} 33020 -13630 0 1 {name=p32634 lab=_64776_/A }
C {sky130_stdcells/buf_2.sym} 32980 -13630 0 0 {name=X_59079_ }
C {devices/lab_pin.sym} 32940 -13510 0 0 {name=p32635 lab=clkbuf_9_370_0_CLK/A }
C {devices/lab_pin.sym} 33020 -13510 0 1 {name=p32636 lab=clkbuf_9_370_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 32980 -13510 0 0 {name=Xclkbuf_9_370_0_CLK }
C {devices/lab_pin.sym} 32900 -13410 0 0 {name=p32637 lab=_61230_/C }
C {devices/lab_pin.sym} 32900 -13370 0 0 {name=p32638 lab=_61107_/X }
C {devices/lab_pin.sym} 32900 -13330 0 0 {name=p32639 lab=_61109_/X }
C {devices/lab_pin.sym} 33060 -13370 0 1 {name=p32640 lab=_61110_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -13370 0 0 {name=X_61110_ }
C {devices/lab_pin.sym} 32920 -13260 0 0 {name=p32641 lab=_70296_/X }
C {devices/lab_pin.sym} 32920 -13220 0 0 {name=p32642 lab=_70297_/X }
C {devices/lab_pin.sym} 32920 -13180 0 0 {name=p32643 lab=_83098_/Q }
C {devices/lab_pin.sym} 32920 -13140 0 0 {name=p32644 lab=_70301_/D }
C {devices/lab_pin.sym} 33040 -13200 0 1 {name=p32645 lab=_70308_/X }
C {sky130_stdcells/and4_4.sym} 32980 -13200 0 0 {name=X_70308_ }
C {devices/lab_pin.sym} 32940 -13050 0 0 {name=p32646 lab=_45975_/X }
C {devices/lab_pin.sym} 33020 -13050 0 1 {name=p32647 lab=_46044_/X }
C {sky130_stdcells/buf_2.sym} 32980 -13050 0 0 {name=X_46044_ }
C {devices/lab_pin.sym} 32900 -12970 0 0 {name=p32648 lab=_43241_/X }
C {devices/lab_pin.sym} 32900 -12930 0 0 {name=p32649 lab=_43244_/X }
C {devices/lab_pin.sym} 32900 -12890 0 0 {name=p32650 lab=_41076_/X }
C {devices/lab_pin.sym} 32900 -12850 0 0 {name=p32651 lab=_87514_/Q }
C {devices/lab_pin.sym} 32900 -12810 0 0 {name=p32652 lab=_43250_/X }
C {devices/lab_pin.sym} 33060 -12890 0 1 {name=p32653 lab=_43256_/Y }
C {sky130_stdcells/o32ai_4.sym} 32980 -12890 0 0 {name=X_43256_ }
C {devices/lab_pin.sym} 32920 -12750 0 0 {name=p32654 lab=_62050_/X }
C {devices/lab_pin.sym} 32920 -12710 0 0 {name=p32655 lab=_62090_/B }
C {devices/lab_pin.sym} 32920 -12670 0 0 {name=p32656 lab=_78057_/B }
C {devices/lab_pin.sym} 33040 -12710 0 1 {name=p32657 lab=_62090_/Y }
C {sky130_stdcells/nor3_4.sym} 32980 -12710 0 0 {name=X_62090_ }
C {devices/lab_pin.sym} 32940 -12570 0 0 {name=p32658 lab=clkbuf_9_132_0_CLK/X }
C {devices/lab_pin.sym} 33020 -12570 0 1 {name=p32659 lab=_84829_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32980 -12570 0 0 {name=Xclkbuf_10_264_0_CLK }
C {devices/lab_pin.sym} 32940 -12450 0 0 {name=p32660 lab=_78953_/A }
C {devices/lab_pin.sym} 33020 -12450 0 1 {name=p32661 lab=_82513_/D }
C {sky130_stdcells/inv_2.sym} 32980 -12450 0 0 {name=X_78953_ }
C {devices/lab_pin.sym} 32900 -12350 0 0 {name=p32662 lab=_74072_/X }
C {devices/lab_pin.sym} 32900 -12310 0 0 {name=p32663 lab=_74075_/X }
C {devices/lab_pin.sym} 32900 -12270 0 0 {name=p32664 lab=_73489_/X }
C {devices/lab_pin.sym} 33060 -12310 0 1 {name=p32665 lab=_74079_/A }
C {sky130_stdcells/a21o_4.sym} 32980 -12310 0 0 {name=X_74076_ }
C {devices/lab_pin.sym} 32900 -12190 0 0 {name=p32666 lab=_40463_/X }
C {devices/lab_pin.sym} 32900 -12150 0 0 {name=p32667 lab=_81169_/Q }
C {devices/lab_pin.sym} 32900 -12110 0 0 {name=p32668 lab=_40467_/X }
C {devices/lab_pin.sym} 33060 -12150 0 1 {name=p32669 lab=_40468_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -12150 0 0 {name=X_40468_ }
C {devices/lab_pin.sym} 32940 -12010 0 0 {name=p32670 lab=_71287_/Y }
C {devices/lab_pin.sym} 33020 -12010 0 1 {name=p32671 lab=_71289_/B }
C {sky130_stdcells/buf_2.sym} 32980 -12010 0 0 {name=X_71288_ }
C {devices/lab_pin.sym} 32940 -11890 0 0 {name=p32672 lab=clkbuf_9_447_0_CLK/X }
C {devices/lab_pin.sym} 33020 -11890 0 1 {name=p32673 lab=_85536_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32980 -11890 0 0 {name=Xclkbuf_10_894_0_CLK }
C {devices/lab_pin.sym} 32940 -11770 0 0 {name=p32674 lab=_42206_/Y }
C {devices/lab_pin.sym} 33020 -11770 0 1 {name=p32675 lab=_87980_/D }
C {sky130_stdcells/inv_2.sym} 32980 -11770 0 0 {name=X_42207_ }
C {devices/lab_pin.sym} 32900 -11690 0 0 {name=p32676 lab=_64172_/C }
C {devices/lab_pin.sym} 32900 -11650 0 0 {name=p32677 lab=_64182_/C }
C {devices/lab_pin.sym} 32900 -11610 0 0 {name=p32678 lab=_60992_/X }
C {devices/lab_pin.sym} 32900 -11570 0 0 {name=p32679 lab=_60014_/X }
C {devices/lab_pin.sym} 32900 -11530 0 0 {name=p32680 lab=_60111_/X }
C {devices/lab_pin.sym} 33060 -11610 0 1 {name=p32681 lab=_61041_/Y }
C {sky130_stdcells/a32oi_4.sym} 32980 -11610 0 0 {name=X_61041_ }
C {devices/lab_pin.sym} 32920 -11460 0 0 {name=p32682 lab=_77904_/A }
C {devices/lab_pin.sym} 32920 -11420 0 0 {name=p32683 lab=_77903_/Y }
C {devices/lab_pin.sym} 33040 -11440 0 1 {name=p32684 lab=_82037_/D }
C {sky130_stdcells/xor2_4.sym} 32980 -11440 0 0 {name=X_77904_ }
C {devices/lab_pin.sym} 32940 -11310 0 0 {name=p32685 lab=_73067_/A }
C {devices/lab_pin.sym} 33020 -11310 0 1 {name=p32686 lab=_73704_/A }
C {sky130_stdcells/buf_2.sym} 32980 -11310 0 0 {name=X_73027_ }
C {devices/lab_pin.sym} 32920 -11220 0 0 {name=p32687 lab=_70239_/A }
C {devices/lab_pin.sym} 32920 -11180 0 0 {name=p32688 lab=_70239_/B }
C {devices/lab_pin.sym} 32920 -11140 0 0 {name=p32689 lab=_70239_/C }
C {devices/lab_pin.sym} 32920 -11100 0 0 {name=p32690 lab=_70239_/D }
C {devices/lab_pin.sym} 33040 -11160 0 1 {name=p32691 lab=_70239_/X }
C {sky130_stdcells/and4_4.sym} 32980 -11160 0 0 {name=X_70239_ }
C {devices/lab_pin.sym} 32900 -11050 0 0 {name=p32692 lab=_43162_/X }
C {devices/lab_pin.sym} 32900 -11010 0 0 {name=p32693 lab=_43167_/X }
C {devices/lab_pin.sym} 32900 -10970 0 0 {name=p32694 lab=_40894_/X }
C {devices/lab_pin.sym} 32900 -10930 0 0 {name=p32695 lab=_73374_/A }
C {devices/lab_pin.sym} 32900 -10890 0 0 {name=p32696 lab=_43172_/X }
C {devices/lab_pin.sym} 33060 -10970 0 1 {name=p32697 lab=_43188_/A }
C {sky130_stdcells/o32ai_4.sym} 32980 -10970 0 0 {name=X_43187_ }
C {devices/lab_pin.sym} 32920 -10820 0 0 {name=p32698 lab=_82843_/Q }
C {devices/lab_pin.sym} 32920 -10780 0 0 {name=p32699 lab=_82555_/Q }
C {devices/lab_pin.sym} 33040 -10800 0 1 {name=p32700 lab=_78885_/B }
C {sky130_stdcells/xnor2_4.sym} 32980 -10800 0 0 {name=X_78884_ }
C {devices/lab_pin.sym} 32900 -10690 0 0 {name=p32701 lab=_40381_/X }
C {devices/lab_pin.sym} 32900 -10650 0 0 {name=p32702 lab=_81179_/Q }
C {devices/lab_pin.sym} 32900 -10610 0 0 {name=p32703 lab=_40398_/X }
C {devices/lab_pin.sym} 33060 -10650 0 1 {name=p32704 lab=_40399_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -10650 0 0 {name=X_40399_ }
C {devices/lab_pin.sym} 32940 -10510 0 0 {name=p32705 lab=clkbuf_9_23_0_CLK/X }
C {devices/lab_pin.sym} 33020 -10510 0 1 {name=p32706 lab=_83835_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32980 -10510 0 0 {name=Xclkbuf_10_46_0_CLK }
C {devices/lab_pin.sym} 32900 -10410 0 0 {name=p32707 lab=_49801_/Y }
C {devices/lab_pin.sym} 32900 -10370 0 0 {name=p32708 lab=_49787_/X }
C {devices/lab_pin.sym} 32900 -10330 0 0 {name=p32709 lab=_49802_/X }
C {devices/lab_pin.sym} 33060 -10370 0 1 {name=p32710 lab=_86321_/D }
C {sky130_stdcells/a21oi_4.sym} 32980 -10370 0 0 {name=X_49803_ }
C {devices/lab_pin.sym} 32940 -10230 0 0 {name=p32711 lab=clkbuf_8_192_0_CLK/X }
C {devices/lab_pin.sym} 33020 -10230 0 1 {name=p32712 lab=clkbuf_9_385_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 32980 -10230 0 0 {name=Xclkbuf_9_385_0_CLK }
C {devices/lab_pin.sym} 32940 -10110 0 0 {name=p32713 lab=_41912_/A }
C {devices/lab_pin.sym} 33020 -10110 0 1 {name=p32714 lab=_42138_/X }
C {sky130_stdcells/buf_2.sym} 32980 -10110 0 0 {name=X_42138_ }
C {devices/lab_pin.sym} 32920 -10000 0 0 {name=p32715 lab=_77835_/A }
C {devices/lab_pin.sym} 32920 -9960 0 0 {name=p32716 lab=_77835_/B }
C {devices/lab_pin.sym} 33040 -9980 0 1 {name=p32717 lab=_77836_/B }
C {sky130_stdcells/and2_4.sym} 32980 -9980 0 0 {name=X_77835_ }
C {devices/lab_pin.sym} 32940 -9850 0 0 {name=p32718 lab=_52573_/B }
C {devices/lab_pin.sym} 33020 -9850 0 1 {name=p32719 lab=_48069_/B }
C {sky130_stdcells/buf_2.sym} 32980 -9850 0 0 {name=X_47995_ }
C {devices/lab_pin.sym} 32920 -9740 0 0 {name=p32720 lab=_64800_/A }
C {devices/lab_pin.sym} 32920 -9700 0 0 {name=p32721 lab=_64800_/B }
C {devices/lab_pin.sym} 33040 -9720 0 1 {name=p32722 lab=_64800_/Y }
C {sky130_stdcells/nand2_4.sym} 32980 -9720 0 0 {name=X_64800_ }
C {devices/lab_pin.sym} 32940 -9590 0 0 {name=p32723 lab=clkbuf_9_139_0_CLK/X }
C {devices/lab_pin.sym} 33020 -9590 0 1 {name=p32724 lab=_85499_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32980 -9590 0 0 {name=Xclkbuf_10_279_0_CLK }
C {devices/lab_pin.sym} 32920 -9500 0 0 {name=p32725 lab=_49751_/A }
C {devices/lab_pin.sym} 32920 -9460 0 0 {name=p32726 lab=_49724_/B }
C {devices/lab_pin.sym} 32920 -9420 0 0 {name=p32727 lab=_49724_/C }
C {devices/lab_pin.sym} 32920 -9380 0 0 {name=p32728 lab=_52948_/D }
C {devices/lab_pin.sym} 33040 -9440 0 1 {name=p32729 lab=_49734_/X }
C {sky130_stdcells/and4_4.sym} 32980 -9440 0 0 {name=X_49734_ }
C {devices/lab_pin.sym} 32940 -9290 0 0 {name=p32730 lab=_83718_/Q }
C {devices/lab_pin.sym} 33020 -9290 0 1 {name=p32731 lab=_54460_/B }
C {sky130_stdcells/inv_2.sym} 32980 -9290 0 0 {name=X_46946_ }
C {devices/lab_pin.sym} 32900 -9200 0 0 {name=p32732 lab=_40955_/X }
C {devices/lab_pin.sym} 32900 -9160 0 0 {name=p32733 lab=_41907_/X }
C {devices/lab_pin.sym} 32900 -9120 0 0 {name=p32734 lab=_88048_/Q }
C {devices/lab_pin.sym} 32900 -9080 0 0 {name=p32735 lab=_41912_/X }
C {devices/lab_pin.sym} 33060 -9140 0 1 {name=p32736 lab=_88048_/D }
C {sky130_stdcells/a2bb2o_4.sym} 32980 -9140 0 0 {name=X_42069_ }
C {devices/lab_pin.sym} 32900 -9020 0 0 {name=p32737 lab=_65717_/X }
C {devices/lab_pin.sym} 32900 -8980 0 0 {name=p32738 lab=_85578_/Q }
C {devices/lab_pin.sym} 32900 -8940 0 0 {name=p32739 lab=_65718_/X }
C {devices/lab_pin.sym} 32900 -8900 0 0 {name=p32740 lab=_65779_/X }
C {devices/lab_pin.sym} 33060 -8960 0 1 {name=p32741 lab=_65780_/X }
C {sky130_stdcells/a211o_4.sym} 32980 -8960 0 0 {name=X_65780_ }
C {devices/lab_pin.sym} 32900 -8830 0 0 {name=p32742 lab=_77759_/Y }
C {devices/lab_pin.sym} 32900 -8790 0 0 {name=p32743 lab=_77764_/Y }
C {devices/lab_pin.sym} 32900 -8750 0 0 {name=p32744 lab=_77765_/Y }
C {devices/lab_pin.sym} 33060 -8790 0 1 {name=p32745 lab=_77766_/Y }
C {sky130_stdcells/a21oi_4.sym} 32980 -8790 0 0 {name=X_77766_ }
C {devices/lab_pin.sym} 32900 -8690 0 0 {name=p32746 lab=_62642_/Y }
C {devices/lab_pin.sym} 32900 -8650 0 0 {name=p32747 lab=_62990_/Y }
C {devices/lab_pin.sym} 32900 -8610 0 0 {name=p32748 lab=_62991_/X }
C {devices/lab_pin.sym} 32900 -8570 0 0 {name=p32749 lab=_58374_/A }
C {devices/lab_pin.sym} 32900 -8530 0 0 {name=p32750 lab=_62650_/X }
C {devices/lab_pin.sym} 33060 -8610 0 1 {name=p32751 lab=_62992_/Y }
C {sky130_stdcells/o32ai_4.sym} 32980 -8610 0 0 {name=X_62992_ }
C {devices/lab_pin.sym} 32920 -8460 0 0 {name=p32752 lab=_80948_/Q }
C {devices/lab_pin.sym} 32920 -8420 0 0 {name=p32753 lab=_74978_/B }
C {devices/lab_pin.sym} 33040 -8440 0 1 {name=p32754 lab=_74978_/X }
C {sky130_stdcells/xor2_4.sym} 32980 -8440 0 0 {name=X_74978_ }
C {devices/lab_pin.sym} 32920 -8320 0 0 {name=p32755 lab=_79505_/A }
C {devices/lab_pin.sym} 32920 -8280 0 0 {name=p32756 lab=_79505_/B }
C {devices/lab_pin.sym} 33040 -8300 0 1 {name=p32757 lab=_79505_/Y }
C {sky130_stdcells/nand2_4.sym} 32980 -8300 0 0 {name=X_79505_ }
C {devices/lab_pin.sym} 32940 -8170 0 0 {name=p32758 lab=_64731_/A }
C {devices/lab_pin.sym} 33020 -8170 0 1 {name=p32759 lab=_64732_/A }
C {sky130_stdcells/buf_2.sym} 32980 -8170 0 0 {name=X_64731_ }
C {devices/lab_pin.sym} 32920 -8060 0 0 {name=p32760 lab=_76697_/Y }
C {devices/lab_pin.sym} 32920 -8020 0 0 {name=p32761 lab=_76712_/A }
C {devices/lab_pin.sym} 33040 -8040 0 1 {name=p32762 lab=_76719_/A }
C {sky130_stdcells/nor2_4.sym} 32980 -8040 0 0 {name=X_76717_ }
C {devices/lab_pin.sym} 32900 -7930 0 0 {name=p32763 lab=_49663_/Y }
C {devices/lab_pin.sym} 32900 -7890 0 0 {name=p32764 lab=_49650_/X }
C {devices/lab_pin.sym} 32900 -7850 0 0 {name=p32765 lab=_49664_/X }
C {devices/lab_pin.sym} 33060 -7890 0 1 {name=p32766 lab=_49665_/Y }
C {sky130_stdcells/a21oi_4.sym} 32980 -7890 0 0 {name=X_49665_ }
C {devices/lab_pin.sym} 32920 -7770 0 0 {name=p32767 lab=_61960_/A }
C {devices/lab_pin.sym} 32920 -7730 0 0 {name=p32768 lab=_61960_/B }
C {devices/lab_pin.sym} 32920 -7690 0 0 {name=p32769 lab=_78067_/B }
C {devices/lab_pin.sym} 33040 -7730 0 1 {name=p32770 lab=_61943_/Y }
C {sky130_stdcells/nor3_4.sym} 32980 -7730 0 0 {name=X_61943_ }
C {devices/lab_pin.sym} 32900 -7610 0 0 {name=p32771 lab=_73926_/X }
C {devices/lab_pin.sym} 32900 -7570 0 0 {name=p32772 lab=_73928_/X }
C {devices/lab_pin.sym} 32900 -7530 0 0 {name=p32773 lab=_72735_/X }
C {devices/lab_pin.sym} 33060 -7570 0 1 {name=p32774 lab=_73933_/A }
C {sky130_stdcells/a21o_4.sym} 32980 -7570 0 0 {name=X_73929_ }
C {devices/lab_pin.sym} 32900 -7450 0 0 {name=p32775 lab=_46873_/Y }
C {devices/lab_pin.sym} 32900 -7410 0 0 {name=p32776 lab=_46844_/X }
C {devices/lab_pin.sym} 32900 -7370 0 0 {name=p32777 lab=_46876_/X }
C {devices/lab_pin.sym} 33060 -7410 0 1 {name=p32778 lab=_86694_/D }
C {sky130_stdcells/a21oi_4.sym} 32980 -7410 0 0 {name=X_46877_ }
C {devices/lab_pin.sym} 32900 -7290 0 0 {name=p32779 lab=_77676_/A }
C {devices/lab_pin.sym} 32900 -7250 0 0 {name=p32780 lab=_77673_/Y }
C {devices/lab_pin.sym} 32900 -7210 0 0 {name=p32781 lab=_77675_/A }
C {devices/lab_pin.sym} 33060 -7250 0 1 {name=p32782 lab=_77701_/A }
C {sky130_stdcells/o21a_4.sym} 32980 -7250 0 0 {name=X_77697_ }
C {devices/lab_pin.sym} 32920 -7120 0 0 {name=p32783 lab=_48661_/A }
C {devices/lab_pin.sym} 32920 -7080 0 0 {name=p32784 lab=_52216_/B }
C {devices/lab_pin.sym} 33040 -7100 0 1 {name=p32785 lab=_48616_/Y }
C {sky130_stdcells/nand2_4.sym} 32980 -7100 0 0 {name=X_48616_ }
C {devices/lab_pin.sym} 32920 -6980 0 0 {name=p32786 lab=_79436_/A }
C {devices/lab_pin.sym} 32920 -6940 0 0 {name=p32787 lab=_79436_/B }
C {devices/lab_pin.sym} 33040 -6960 0 1 {name=p32788 lab=_79444_/B }
C {sky130_stdcells/xor2_4.sym} 32980 -6960 0 0 {name=X_79436_ }
C {devices/lab_pin.sym} 32940 -6830 0 0 {name=p32789 lab=clkbuf_8_207_0_CLK/A }
C {devices/lab_pin.sym} 33020 -6830 0 1 {name=p32790 lab=clkbuf_9_415_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 32980 -6830 0 0 {name=Xclkbuf_8_207_0_CLK }
C {devices/lab_pin.sym} 32940 -6710 0 0 {name=p32791 lab=_67093_/X }
C {devices/lab_pin.sym} 33020 -6710 0 1 {name=p32792 lab=_67497_/A }
C {sky130_stdcells/buf_2.sym} 32980 -6710 0 0 {name=X_67450_ }
C {devices/lab_pin.sym} 32900 -6620 0 0 {name=p32793 lab=_45826_/Y }
C {devices/lab_pin.sym} 32900 -6580 0 0 {name=p32794 lab=_45570_/X }
C {devices/lab_pin.sym} 32900 -6540 0 0 {name=p32795 lab=_44875_/X }
C {devices/lab_pin.sym} 32900 -6500 0 0 {name=p32796 lab=_45827_/Y }
C {devices/lab_pin.sym} 33060 -6560 0 1 {name=p32797 lab=_45828_/X }
C {sky130_stdcells/a211o_4.sym} 32980 -6560 0 0 {name=X_45828_ }
C {devices/lab_pin.sym} 32940 -6410 0 0 {name=p32798 lab=_64939_/A }
C {devices/lab_pin.sym} 33020 -6410 0 1 {name=p32799 lab=_64662_/X }
C {sky130_stdcells/buf_2.sym} 32980 -6410 0 0 {name=X_64662_ }
C {devices/lab_pin.sym} 32920 -6300 0 0 {name=p32800 lab=_76648_/A }
C {devices/lab_pin.sym} 32920 -6260 0 0 {name=p32801 lab=_76965_/A }
C {devices/lab_pin.sym} 33040 -6280 0 1 {name=p32802 lab=_76649_/B }
C {sky130_stdcells/xor2_4.sym} 32980 -6280 0 0 {name=X_76648_ }
C {devices/lab_pin.sym} 32940 -6150 0 0 {name=p32803 lab=clkbuf_9_101_0_CLK/X }
C {devices/lab_pin.sym} 33020 -6150 0 1 {name=p32804 lab=_81084_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32980 -6150 0 0 {name=Xclkbuf_10_202_0_CLK }
C {devices/lab_pin.sym} 32940 -6030 0 0 {name=p32805 lab=_49570_/A }
C {devices/lab_pin.sym} 33020 -6030 0 1 {name=p32806 lab=_49596_/X }
C {sky130_stdcells/buf_2.sym} 32980 -6030 0 0 {name=X_49596_ }
C {devices/lab_pin.sym} 32920 -5940 0 0 {name=p32807 lab=_61438_/X }
C {devices/lab_pin.sym} 32920 -5900 0 0 {name=p32808 lab=_61874_/B }
C {devices/lab_pin.sym} 32920 -5860 0 0 {name=p32809 lab=_61809_/C }
C {devices/lab_pin.sym} 32920 -5820 0 0 {name=p32810 lab=_61874_/D }
C {devices/lab_pin.sym} 33040 -5880 0 1 {name=p32811 lab=_61879_/B }
C {sky130_stdcells/nand4_4.sym} 32980 -5880 0 0 {name=X_61874_ }
C {devices/lab_pin.sym} 32940 -5730 0 0 {name=p32812 lab=_79435_/B }
C {devices/lab_pin.sym} 33020 -5730 0 1 {name=p32813 lab=_66402_/C }
C {sky130_stdcells/inv_2.sym} 32980 -5730 0 0 {name=X_66401_ }
C {devices/lab_pin.sym} 32940 -5610 0 0 {name=p32814 lab=clkbuf_9_416_0_CLK/X }
C {devices/lab_pin.sym} 33020 -5610 0 1 {name=p32815 lab=_84220_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32980 -5610 0 0 {name=Xclkbuf_10_832_0_CLK }
C {devices/lab_pin.sym} 32920 -5520 0 0 {name=p32816 lab=_58452_/A }
C {devices/lab_pin.sym} 32920 -5480 0 0 {name=p32817 lab=_63600_/X }
C {devices/lab_pin.sym} 32920 -5440 0 0 {name=p32818 lab=_63575_/C }
C {devices/lab_pin.sym} 32920 -5400 0 0 {name=p32819 lab=_63661_/D }
C {devices/lab_pin.sym} 33040 -5460 0 1 {name=p32820 lab=_63613_/Y }
C {sky130_stdcells/nand4_4.sym} 32980 -5460 0 0 {name=X_63613_ }
C {devices/lab_pin.sym} 32900 -5330 0 0 {name=p32821 lab=_48541_/Y }
C {devices/lab_pin.sym} 32900 -5290 0 0 {name=p32822 lab=_48517_/X }
C {devices/lab_pin.sym} 32900 -5250 0 0 {name=p32823 lab=_48546_/X }
C {devices/lab_pin.sym} 33060 -5290 0 1 {name=p32824 lab=_48547_/Y }
C {sky130_stdcells/a21oi_4.sym} 32980 -5290 0 0 {name=X_48547_ }
C {devices/lab_pin.sym} 32900 -5190 0 0 {name=p32825 lab=_60736_/X }
C {devices/lab_pin.sym} 32900 -5150 0 0 {name=p32826 lab=_60804_/C }
C {devices/lab_pin.sym} 32900 -5110 0 0 {name=p32827 lab=_63389_/B }
C {devices/lab_pin.sym} 32900 -5070 0 0 {name=p32828 lab=_63389_/D }
C {devices/lab_pin.sym} 32900 -5040 0 0 {name=p32829 lab=_63130_/A }
C {devices/lab_pin.sym} 33060 -5110 0 1 {name=p32830 lab=_60825_/Y }
C {sky130_stdcells/a41oi_4.sym} 32980 -5110 0 0 {name=X_60825_ }
C {devices/lab_pin.sym} 32920 -4960 0 0 {name=p32831 lab=_67381_/A }
C {devices/lab_pin.sym} 32920 -4920 0 0 {name=p32832 lab=_67381_/B }
C {devices/lab_pin.sym} 33040 -4940 0 1 {name=p32833 lab=_67381_/X }
C {sky130_stdcells/and2_4.sym} 32980 -4940 0 0 {name=X_67381_ }
C {devices/lab_pin.sym} 32900 -4830 0 0 {name=p32834 lab=_79358_/Y }
C {devices/lab_pin.sym} 32900 -4790 0 0 {name=p32835 lab=_79354_/X }
C {devices/lab_pin.sym} 32900 -4750 0 0 {name=p32836 lab=_79366_/X }
C {devices/lab_pin.sym} 33060 -4790 0 1 {name=p32837 lab=_79368_/B }
C {sky130_stdcells/a21boi_4.sym} 32980 -4790 0 0 {name=X_79367_ }
C {devices/lab_pin.sym} 32900 -4670 0 0 {name=p32838 lab=_85130_/Q }
C {devices/lab_pin.sym} 32900 -4630 0 0 {name=p32839 lab=_45709_/X }
C {devices/lab_pin.sym} 32900 -4590 0 0 {name=p32840 lab=_45743_/X }
C {devices/lab_pin.sym} 33060 -4630 0 1 {name=p32841 lab=_45759_/X }
C {sky130_stdcells/o21a_4.sym} 32980 -4630 0 0 {name=X_45759_ }
C {devices/lab_pin.sym} 32920 -4500 0 0 {name=p32842 lab=_64593_/A }
C {devices/lab_pin.sym} 32920 -4460 0 0 {name=p32843 lab=_86273_/Q }
C {devices/lab_pin.sym} 33040 -4480 0 1 {name=p32844 lab=_64593_/X }
C {sky130_stdcells/and2_4.sym} 32980 -4480 0 0 {name=X_64593_ }
C {devices/lab_pin.sym} 32940 -4350 0 0 {name=p32845 lab=_76578_/X }
C {devices/lab_pin.sym} 33020 -4350 0 1 {name=p32846 lab=_76579_/Y }
C {sky130_stdcells/inv_2.sym} 32980 -4350 0 0 {name=X_76579_ }
C {devices/lab_pin.sym} 32900 -4250 0 0 {name=p32847 lab=_69117_/X }
C {devices/lab_pin.sym} 32900 -4210 0 0 {name=p32848 lab=_69119_/X }
C {devices/lab_pin.sym} 32900 -4170 0 0 {name=p32849 lab=_60014_/X }
C {devices/lab_pin.sym} 33060 -4210 0 1 {name=p32850 lab=_69120_/Y }
C {sky130_stdcells/a21oi_4.sym} 32980 -4210 0 0 {name=X_69120_ }
C {devices/lab_pin.sym} 32920 -4090 0 0 {name=p32851 lab=_66177_/A }
C {devices/lab_pin.sym} 32920 -4050 0 0 {name=p32852 lab=_66389_/B }
C {devices/lab_pin.sym} 32920 -4010 0 0 {name=p32853 lab=_66332_/C }
C {devices/lab_pin.sym} 33040 -4050 0 1 {name=p32854 lab=_66332_/Y }
C {sky130_stdcells/nor3_4.sym} 32980 -4050 0 0 {name=X_66332_ }
C {devices/lab_pin.sym} 32920 -3930 0 0 {name=p32855 lab=_78318_/A }
C {devices/lab_pin.sym} 32920 -3890 0 0 {name=p32856 lab=_78318_/B }
C {devices/lab_pin.sym} 32920 -3850 0 0 {name=p32857 lab=_78335_/B }
C {devices/lab_pin.sym} 33040 -3890 0 1 {name=p32858 lab=_78335_/A }
C {sky130_stdcells/nand3_4.sym} 32980 -3890 0 0 {name=X_78318_ }
C {devices/lab_pin.sym} 32900 -3770 0 0 {name=p32859 lab=_63542_/Y }
C {devices/lab_pin.sym} 32900 -3730 0 0 {name=p32860 lab=_63516_/X }
C {devices/lab_pin.sym} 32900 -3690 0 0 {name=p32861 lab=_63543_/Y }
C {devices/lab_pin.sym} 33060 -3730 0 1 {name=p32862 lab=_63544_/Y }
C {sky130_stdcells/a21oi_4.sym} 32980 -3730 0 0 {name=X_63544_ }
C {devices/lab_pin.sym} 32940 -3590 0 0 {name=p32863 lab=clkbuf_9_323_0_CLK/A }
C {devices/lab_pin.sym} 33020 -3590 0 1 {name=p32864 lab=clkbuf_9_323_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 32980 -3590 0 0 {name=Xclkbuf_9_323_0_CLK }
C {devices/lab_pin.sym} 32900 -3510 0 0 {name=p32865 lab=_60707_/X }
C {devices/lab_pin.sym} 32900 -3470 0 0 {name=p32866 lab=_60692_/X }
C {devices/lab_pin.sym} 32900 -3430 0 0 {name=p32867 lab=_60732_/Y }
C {devices/lab_pin.sym} 32900 -3390 0 0 {name=p32868 lab=_60754_/X }
C {devices/lab_pin.sym} 32900 -3360 0 0 {name=p32869 lab=_60755_/Y }
C {devices/lab_pin.sym} 33060 -3430 0 1 {name=p32870 lab=_84574_/D }
C {sky130_stdcells/a41oi_4.sym} 32980 -3430 0 0 {name=X_60756_ }
C {devices/lab_pin.sym} 32940 -3270 0 0 {name=p32871 lab=_48478_/A }
C {devices/lab_pin.sym} 33020 -3270 0 1 {name=p32872 lab=_48478_/X }
C {sky130_stdcells/buf_2.sym} 32980 -3270 0 0 {name=X_48478_ }
C {devices/lab_pin.sym} 32920 -3160 0 0 {name=p32873 lab=_84796_/Q }
C {devices/lab_pin.sym} 32920 -3120 0 0 {name=p32874 lab=_84116_/Q }
C {devices/lab_pin.sym} 33040 -3140 0 1 {name=p32875 lab=_79298_/Y }
C {sky130_stdcells/nand2_4.sym} 32980 -3140 0 0 {name=X_79298_ }
C {devices/lab_pin.sym} 32940 -3010 0 0 {name=p32876 lab=_69478_/A }
C {devices/lab_pin.sym} 33020 -3010 0 1 {name=p32877 lab=_69051_/X }
C {sky130_stdcells/buf_2.sym} 32980 -3010 0 0 {name=X_69051_ }
C {devices/lab_pin.sym} 32940 -2890 0 0 {name=p32878 lab=clkbuf_9_108_0_CLK/X }
C {devices/lab_pin.sym} 33020 -2890 0 1 {name=p32879 lab=_84501_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32980 -2890 0 0 {name=Xclkbuf_10_217_0_CLK }
C {devices/lab_pin.sym} 32940 -2770 0 0 {name=p32880 lab=_47382_/A }
C {devices/lab_pin.sym} 33020 -2770 0 1 {name=p32881 lab=_47429_/X }
C {sky130_stdcells/buf_2.sym} 32980 -2770 0 0 {name=X_47429_ }
C {devices/lab_pin.sym} 32940 -2650 0 0 {name=p32882 lab=_84145_/Q }
C {devices/lab_pin.sym} 33020 -2650 0 1 {name=p32883 lab=_66264_/C }
C {sky130_stdcells/inv_2.sym} 32980 -2650 0 0 {name=X_66263_ }
C {devices/lab_pin.sym} 32920 -2540 0 0 {name=p32884 lab=_78248_/A }
C {devices/lab_pin.sym} 32920 -2500 0 0 {name=p32885 lab=_78248_/B }
C {devices/lab_pin.sym} 33040 -2520 0 1 {name=p32886 lab=_78250_/A }
C {sky130_stdcells/nand2_4.sym} 32980 -2520 0 0 {name=X_78249_ }
C {devices/lab_pin.sym} 32940 -2390 0 0 {name=p32887 lab=_63413_/A }
C {devices/lab_pin.sym} 33020 -2390 0 1 {name=p32888 lab=_63476_/C }
C {sky130_stdcells/buf_2.sym} 32980 -2390 0 0 {name=X_63475_ }
C {devices/lab_pin.sym} 32940 -2270 0 0 {name=p32889 lab=_60687_/A }
C {devices/lab_pin.sym} 33020 -2270 0 1 {name=p32890 lab=_60711_/A }
C {sky130_stdcells/buf_2.sym} 32980 -2270 0 0 {name=X_60687_ }
C {devices/lab_pin.sym} 32940 -2150 0 0 {name=p32891 lab=clkbuf_9_423_0_CLK/X }
C {devices/lab_pin.sym} 33020 -2150 0 1 {name=p32892 lab=_86119_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 32980 -2150 0 0 {name=Xclkbuf_10_847_0_CLK }
C {devices/lab_pin.sym} 32900 -2050 0 0 {name=p32893 lab=_67999_/X }
C {devices/lab_pin.sym} 32900 -2010 0 0 {name=p32894 lab=_68001_/X }
C {devices/lab_pin.sym} 32900 -1970 0 0 {name=p32895 lab=_67977_/X }
C {devices/lab_pin.sym} 33060 -2010 0 1 {name=p32896 lab=_68002_/X }
C {sky130_stdcells/a21o_4.sym} 32980 -2010 0 0 {name=X_68002_ }
C {devices/lab_pin.sym} 32900 -1900 0 0 {name=p32897 lab=_65211_/X }
C {devices/lab_pin.sym} 32900 -1860 0 0 {name=p32898 lab=_85514_/Q }
C {devices/lab_pin.sym} 32900 -1820 0 0 {name=p32899 lab=_65212_/X }
C {devices/lab_pin.sym} 32900 -1780 0 0 {name=p32900 lab=_65213_/X }
C {devices/lab_pin.sym} 33060 -1840 0 1 {name=p32901 lab=_65214_/X }
C {sky130_stdcells/a211o_4.sym} 32980 -1840 0 0 {name=X_65214_ }
C {devices/lab_pin.sym} 32920 -1700 0 0 {name=p32902 lab=_50439_/X }
C {devices/lab_pin.sym} 32920 -1660 0 0 {name=p32903 lab=_50440_/B }
C {devices/lab_pin.sym} 33040 -1680 0 1 {name=p32904 lab=_50440_/Y }
C {sky130_stdcells/nand2_4.sym} 32980 -1680 0 0 {name=X_50440_ }
C {devices/lab_pin.sym} 32920 -1570 0 0 {name=p32905 lab=_62411_/X }
C {devices/lab_pin.sym} 32920 -1530 0 0 {name=p32906 lab=_62412_/X }
C {devices/lab_pin.sym} 32920 -1490 0 0 {name=p32907 lab=_62426_/C }
C {devices/lab_pin.sym} 33040 -1530 0 1 {name=p32908 lab=_62426_/Y }
C {sky130_stdcells/nor3_4.sym} 32980 -1530 0 0 {name=X_62426_ }
C {devices/lab_pin.sym} 32890 -1390 0 0 {name=p32909 lab=_81260_/CLK }
C {devices/lab_pin.sym} 32890 -1370 0 0 {name=p32910 lab=_81260_/D }
C {devices/lab_pin.sym} 33070 -1390 0 1 {name=p32911 lab=_76289_/A }
C {sky130_stdcells/dfxtp_4.sym} 32980 -1380 0 0 {name=X_81260_ }
C {devices/lab_pin.sym} 32900 -1270 0 0 {name=p32912 lab=_66191_/Y }
C {devices/lab_pin.sym} 32900 -1230 0 0 {name=p32913 lab=_66137_/X }
C {devices/lab_pin.sym} 32900 -1190 0 0 {name=p32914 lab=_66193_/Y }
C {devices/lab_pin.sym} 33060 -1230 0 1 {name=p32915 lab=_84150_/D }
C {sky130_stdcells/a21o_4.sym} 32980 -1230 0 0 {name=X_66194_ }
C {devices/lab_pin.sym} 32920 -1100 0 0 {name=p32916 lab=_80208_/X }
C {devices/lab_pin.sym} 32920 -1060 0 0 {name=p32917 lab=_80210_/Y }
C {devices/lab_pin.sym} 33040 -1080 0 1 {name=p32918 lab=_80211_/X }
C {sky130_stdcells/xor2_4.sym} 32980 -1080 0 0 {name=X_80211_ }
C {devices/lab_pin.sym} 32940 -950 0 0 {name=p32919 lab=clkbuf_9_339_0_CLK/A }
C {devices/lab_pin.sym} 33020 -950 0 1 {name=p32920 lab=clkbuf_9_338_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 32980 -950 0 0 {name=Xclkbuf_9_338_0_CLK }
C {devices/lab_pin.sym} 32900 -860 0 0 {name=p32921 lab=_64944_/X }
C {devices/lab_pin.sym} 32900 -820 0 0 {name=p32922 lab=_86124_/Q }
C {devices/lab_pin.sym} 32900 -780 0 0 {name=p32923 lab=_65022_/X }
C {devices/lab_pin.sym} 32900 -740 0 0 {name=p32924 lab=_65144_/X }
C {devices/lab_pin.sym} 33060 -800 0 1 {name=p32925 lab=_65145_/X }
C {sky130_stdcells/a211o_4.sym} 32980 -800 0 0 {name=X_65145_ }
C {devices/lab_pin.sym} 32900 -670 0 0 {name=p32926 lab=_86214_/Q }
C {devices/lab_pin.sym} 32900 -630 0 0 {name=p32927 lab=_50363_/X }
C {devices/lab_pin.sym} 32900 -590 0 0 {name=p32928 lab=_50370_/Y }
C {devices/lab_pin.sym} 33060 -630 0 1 {name=p32929 lab=_50371_/Y }
C {sky130_stdcells/o21ai_4.sym} 32980 -630 0 0 {name=X_50371_ }
C {devices/lab_pin.sym} 33810 -42150 0 0 {name=p32930 lab=_81216_/CLK }
C {devices/lab_pin.sym} 33810 -42130 0 0 {name=p32931 lab=_81191_/D }
C {devices/lab_pin.sym} 33990 -42150 0 1 {name=p32932 lab=_49148_/A }
C {sky130_stdcells/dfxtp_4.sym} 33900 -42140 0 0 {name=X_81191_ }
C {devices/lab_pin.sym} 33860 -42010 0 0 {name=p32933 lab=_62501_/A }
C {devices/lab_pin.sym} 33940 -42010 0 1 {name=p32934 lab=_62386_/C }
C {sky130_stdcells/buf_2.sym} 33900 -42010 0 0 {name=X_62357_ }
C {devices/lab_pin.sym} 33820 -41910 0 0 {name=p32935 lab=_52106_/Y }
C {devices/lab_pin.sym} 33820 -41870 0 0 {name=p32936 lab=_52108_/X }
C {devices/lab_pin.sym} 33820 -41830 0 0 {name=p32937 lab=_52109_/X }
C {devices/lab_pin.sym} 33980 -41870 0 1 {name=p32938 lab=_85887_/D }
C {sky130_stdcells/a21oi_4.sym} 33900 -41870 0 0 {name=X_52110_ }
C {devices/lab_pin.sym} 33860 -41730 0 0 {name=p32939 lab=_61308_/A }
C {devices/lab_pin.sym} 33940 -41730 0 1 {name=p32940 lab=_72550_/A }
C {sky130_stdcells/buf_2.sym} 33900 -41730 0 0 {name=X_61308_ }
C {devices/lab_pin.sym} 33820 -41630 0 0 {name=p32941 lab=_57883_/Y }
C {devices/lab_pin.sym} 33820 -41590 0 0 {name=p32942 lab=_65605_/C }
C {devices/lab_pin.sym} 33820 -41550 0 0 {name=p32943 lab=_80141_/Y }
C {devices/lab_pin.sym} 33980 -41590 0 1 {name=p32944 lab=_80142_/X }
C {sky130_stdcells/o21a_4.sym} 33900 -41590 0 0 {name=X_80142_ }
C {devices/lab_pin.sym} 33840 -41480 0 0 {name=p32945 lab=_53107_/A }
C {devices/lab_pin.sym} 33840 -41440 0 0 {name=p32946 lab=_53069_/X }
C {devices/lab_pin.sym} 33840 -41400 0 0 {name=p32947 lab=_53107_/C }
C {devices/lab_pin.sym} 33840 -41360 0 0 {name=p32948 lab=_53090_/D }
C {devices/lab_pin.sym} 33960 -41420 0 1 {name=p32949 lab=_53090_/X }
C {sky130_stdcells/and4_4.sym} 33900 -41420 0 0 {name=X_53090_ }
C {devices/lab_pin.sym} 33840 -41280 0 0 {name=p32950 lab=_58785_/A }
C {devices/lab_pin.sym} 33840 -41240 0 0 {name=p32951 lab=_86031_/Q }
C {devices/lab_pin.sym} 33960 -41260 0 1 {name=p32952 lab=_65076_/X }
C {sky130_stdcells/and2_4.sym} 33900 -41260 0 0 {name=X_65076_ }
C {devices/lab_pin.sym} 33820 -41160 0 0 {name=p32953 lab=_69943_/X }
C {devices/lab_pin.sym} 33820 -41120 0 0 {name=p32954 lab=_69951_/Y }
C {devices/lab_pin.sym} 33820 -41080 0 0 {name=p32955 lab=_69938_/X }
C {devices/lab_pin.sym} 33820 -41040 0 0 {name=p32956 lab=_69952_/Y }
C {devices/lab_pin.sym} 33980 -41100 0 1 {name=p32957 lab=_69953_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -41100 0 0 {name=X_69953_ }
C {devices/lab_pin.sym} 33860 -40950 0 0 {name=p32958 lab=_62288_/A }
C {devices/lab_pin.sym} 33940 -40950 0 1 {name=p32959 lab=_62288_/X }
C {sky130_stdcells/buf_2.sym} 33900 -40950 0 0 {name=X_62288_ }
C {devices/lab_pin.sym} 33860 -40830 0 0 {name=p32960 lab=_51928_/X }
C {devices/lab_pin.sym} 33940 -40830 0 1 {name=p32961 lab=_52041_/X }
C {sky130_stdcells/buf_2.sym} 33900 -40830 0 0 {name=X_52041_ }
C {devices/lab_pin.sym} 33820 -40730 0 0 {name=p32962 lab=_68900_/X }
C {devices/lab_pin.sym} 33820 -40690 0 0 {name=p32963 lab=_68903_/X }
C {devices/lab_pin.sym} 33820 -40650 0 0 {name=p32964 lab=_68878_/X }
C {devices/lab_pin.sym} 33980 -40690 0 1 {name=p32965 lab=_68904_/Y }
C {sky130_stdcells/a21oi_4.sym} 33900 -40690 0 0 {name=X_68904_ }
C {devices/lab_pin.sym} 33840 -40580 0 0 {name=p32966 lab=_64422_/C }
C {devices/lab_pin.sym} 33840 -40540 0 0 {name=p32967 lab=_64091_/B }
C {devices/lab_pin.sym} 33840 -40500 0 0 {name=p32968 lab=_64091_/C }
C {devices/lab_pin.sym} 33840 -40460 0 0 {name=p32969 lab=_64027_/D }
C {devices/lab_pin.sym} 33960 -40520 0 1 {name=p32970 lab=_64027_/Y }
C {sky130_stdcells/nand4_4.sym} 33900 -40520 0 0 {name=X_64027_ }
C {devices/lab_pin.sym} 33820 -40400 0 0 {name=p32971 lab=_75903_/A }
C {devices/lab_pin.sym} 33820 -40360 0 0 {name=p32972 lab=_60719_/X }
C {devices/lab_pin.sym} 33820 -40320 0 0 {name=p32973 lab=_61237_/Y }
C {devices/lab_pin.sym} 33820 -40280 0 0 {name=p32974 lab=_61238_/Y }
C {devices/lab_pin.sym} 33980 -40340 0 1 {name=p32975 lab=_84501_/D }
C {sky130_stdcells/o22a_4.sym} 33900 -40340 0 0 {name=X_61239_ }
C {devices/lab_pin.sym} 33810 -40190 0 0 {name=p32976 lab=_85407_/CLK }
C {devices/lab_pin.sym} 33810 -40170 0 0 {name=p32977 lab=_84950_/D }
C {devices/lab_pin.sym} 33990 -40190 0 1 {name=p32978 lab=_84950_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -40180 0 0 {name=X_84950_ }
C {devices/lab_pin.sym} 33840 -40060 0 0 {name=p32979 lab=_80073_/A }
C {devices/lab_pin.sym} 33840 -40020 0 0 {name=p32980 lab=_80073_/B }
C {devices/lab_pin.sym} 33960 -40040 0 1 {name=p32981 lab=_80073_/X }
C {sky130_stdcells/and2_4.sym} 33900 -40040 0 0 {name=X_80073_ }
C {devices/lab_pin.sym} 33820 -39940 0 0 {name=p32982 lab=_73372_/A }
C {devices/lab_pin.sym} 33820 -39900 0 0 {name=p32983 lab=_69833_/X }
C {devices/lab_pin.sym} 33820 -39860 0 0 {name=p32984 lab=_69617_/X }
C {devices/lab_pin.sym} 33820 -39820 0 0 {name=p32985 lab=_69883_/Y }
C {devices/lab_pin.sym} 33980 -39880 0 1 {name=p32986 lab=_69884_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -39880 0 0 {name=X_69884_ }
C {devices/lab_pin.sym} 33810 -39730 0 0 {name=p32987 lab=_81975_/CLK }
C {devices/lab_pin.sym} 33810 -39710 0 0 {name=p32988 lab=_83901_/D }
C {devices/lab_pin.sym} 33990 -39730 0 1 {name=p32989 lab=_83901_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -39720 0 0 {name=X_83901_ }
C {devices/lab_pin.sym} 33820 -39610 0 0 {name=p32990 lab=_68831_/X }
C {devices/lab_pin.sym} 33820 -39570 0 0 {name=p32991 lab=_68834_/X }
C {devices/lab_pin.sym} 33820 -39530 0 0 {name=p32992 lab=_68737_/X }
C {devices/lab_pin.sym} 33980 -39570 0 1 {name=p32993 lab=_68835_/Y }
C {sky130_stdcells/a21oi_4.sym} 33900 -39570 0 0 {name=X_68835_ }
C {devices/lab_pin.sym} 33810 -39430 0 0 {name=p32994 lab=_84877_/CLK }
C {devices/lab_pin.sym} 33810 -39410 0 0 {name=p32995 lab=_58315_/X }
C {devices/lab_pin.sym} 33990 -39430 0 1 {name=p32996 lab=_84881_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -39420 0 0 {name=X_84881_ }
C {devices/lab_pin.sym} 33860 -39290 0 0 {name=p32997 lab=_55800_/A }
C {devices/lab_pin.sym} 33940 -39290 0 1 {name=p32998 lab=_55801_/D }
C {sky130_stdcells/buf_2.sym} 33900 -39290 0 0 {name=X_55800_ }
C {devices/lab_pin.sym} 33810 -39170 0 0 {name=p32999 lab=_85981_/CLK }
C {devices/lab_pin.sym} 33810 -39150 0 0 {name=p33000 lab=_47580_/Y }
C {devices/lab_pin.sym} 33990 -39170 0 1 {name=p33001 lab=_72188_/A }
C {sky130_stdcells/dfxtp_4.sym} 33900 -39160 0 0 {name=X_86620_ }
C {devices/lab_pin.sym} 33810 -39030 0 0 {name=p33002 lab=_83191_/CLK }
C {devices/lab_pin.sym} 33810 -39010 0 0 {name=p33003 lab=_70222_/X }
C {devices/lab_pin.sym} 33990 -39030 0 1 {name=p33004 lab=_83832_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -39020 0 0 {name=X_83832_ }
C {devices/lab_pin.sym} 33820 -38920 0 0 {name=p33005 lab=_56764_/B }
C {devices/lab_pin.sym} 33820 -38880 0 0 {name=p33006 lab=_56773_/Y }
C {devices/lab_pin.sym} 33820 -38840 0 0 {name=p33007 lab=_56774_/Y }
C {devices/lab_pin.sym} 33820 -38800 0 0 {name=p33008 lab=_56779_/Y }
C {devices/lab_pin.sym} 33980 -38860 0 1 {name=p33009 lab=_56780_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -38860 0 0 {name=X_56780_ }
C {devices/lab_pin.sym} 33820 -38740 0 0 {name=p33010 lab=_68666_/X }
C {devices/lab_pin.sym} 33820 -38700 0 0 {name=p33011 lab=_68612_/X }
C {devices/lab_pin.sym} 33820 -38660 0 0 {name=p33012 lab=_68752_/Y }
C {devices/lab_pin.sym} 33820 -38620 0 0 {name=p33013 lab=_68765_/Y }
C {devices/lab_pin.sym} 33980 -38680 0 1 {name=p33014 lab=_68766_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -38680 0 0 {name=X_68766_ }
C {devices/lab_pin.sym} 33820 -38550 0 0 {name=p33015 lab=_85527_/Q }
C {devices/lab_pin.sym} 33820 -38510 0 0 {name=p33016 lab=_53989_/X }
C {devices/lab_pin.sym} 33820 -38470 0 0 {name=p33017 lab=_53991_/Y }
C {devices/lab_pin.sym} 33980 -38510 0 1 {name=p33018 lab=_53992_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -38510 0 0 {name=X_53992_ }
C {devices/lab_pin.sym} 33820 -38400 0 0 {name=p33019 lab=_65876_/X }
C {devices/lab_pin.sym} 33820 -38360 0 0 {name=p33020 lab=_85628_/Q }
C {devices/lab_pin.sym} 33820 -38320 0 0 {name=p33021 lab=_65976_/X }
C {devices/lab_pin.sym} 33820 -38280 0 0 {name=p33022 lab=_65977_/X }
C {devices/lab_pin.sym} 33980 -38340 0 1 {name=p33023 lab=_65978_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -38340 0 0 {name=X_65978_ }
C {devices/lab_pin.sym} 33820 -38220 0 0 {name=p33024 lab=_85253_/Q }
C {devices/lab_pin.sym} 33820 -38180 0 0 {name=p33025 lab=_55244_/A }
C {devices/lab_pin.sym} 33820 -38140 0 0 {name=p33026 lab=_44043_/X }
C {devices/lab_pin.sym} 33820 -38100 0 0 {name=p33027 lab=_55730_/X }
C {devices/lab_pin.sym} 33980 -38160 0 1 {name=p33028 lab=_55731_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -38160 0 0 {name=X_55731_ }
C {devices/lab_pin.sym} 33860 -38010 0 0 {name=p33029 lab=_68640_/A }
C {devices/lab_pin.sym} 33940 -38010 0 1 {name=p33030 lab=_67717_/X }
C {sky130_stdcells/buf_2.sym} 33900 -38010 0 0 {name=X_67717_ }
C {devices/lab_pin.sym} 33810 -37890 0 0 {name=p33031 lab=_86554_/CLK }
C {devices/lab_pin.sym} 33810 -37870 0 0 {name=p33032 lab=_48235_/Y }
C {devices/lab_pin.sym} 33990 -37890 0 1 {name=p33033 lab=_86551_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -37880 0 0 {name=X_86551_ }
C {devices/lab_pin.sym} 33840 -37760 0 0 {name=p33034 lab=_64929_/A }
C {devices/lab_pin.sym} 33840 -37720 0 0 {name=p33035 lab=_85845_/Q }
C {devices/lab_pin.sym} 33960 -37740 0 1 {name=p33036 lab=_64929_/X }
C {sky130_stdcells/and2_4.sym} 33900 -37740 0 0 {name=X_64929_ }
C {devices/lab_pin.sym} 33820 -37630 0 0 {name=p33037 lab=_52941_/Y }
C {devices/lab_pin.sym} 33820 -37590 0 0 {name=p33038 lab=_52920_/X }
C {devices/lab_pin.sym} 33820 -37550 0 0 {name=p33039 lab=_52942_/X }
C {devices/lab_pin.sym} 33980 -37590 0 1 {name=p33040 lab=_85726_/D }
C {sky130_stdcells/a21oi_4.sym} 33900 -37590 0 0 {name=X_52943_ }
C {devices/lab_pin.sym} 33810 -37450 0 0 {name=p33041 lab=_83763_/CLK }
C {devices/lab_pin.sym} 33810 -37430 0 0 {name=p33042 lab=_83763_/D }
C {devices/lab_pin.sym} 33990 -37450 0 1 {name=p33043 lab=_83763_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -37440 0 0 {name=X_83763_ }
C {devices/lab_pin.sym} 33810 -37310 0 0 {name=p33044 lab=_81059_/CLK }
C {devices/lab_pin.sym} 33810 -37290 0 0 {name=p33045 lab=_75693_/X }
C {devices/lab_pin.sym} 33990 -37310 0 1 {name=p33046 lab=_75082_/B }
C {sky130_stdcells/dfxtp_4.sym} 33900 -37300 0 0 {name=X_80975_ }
C {devices/lab_pin.sym} 33860 -37170 0 0 {name=p33047 lab=_69768_/A }
C {devices/lab_pin.sym} 33940 -37170 0 1 {name=p33048 lab=_68697_/X }
C {sky130_stdcells/buf_2.sym} 33900 -37170 0 0 {name=X_68697_ }
C {devices/lab_pin.sym} 33810 -37050 0 0 {name=p33049 lab=_85505_/CLK }
C {devices/lab_pin.sym} 33810 -37030 0 0 {name=p33050 lab=_54112_/Y }
C {devices/lab_pin.sym} 33990 -37050 0 1 {name=p33051 lab=_85502_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -37040 0 0 {name=X_85502_ }
C {devices/lab_pin.sym} 33860 -36910 0 0 {name=p33052 lab=_63244_/A }
C {devices/lab_pin.sym} 33940 -36910 0 1 {name=p33053 lab=_58452_/A }
C {sky130_stdcells/buf_2.sym} 33900 -36910 0 0 {name=X_58450_ }
C {devices/lab_pin.sym} 33810 -36790 0 0 {name=p33054 lab=_82715_/CLK }
C {devices/lab_pin.sym} 33810 -36770 0 0 {name=p33055 lab=_79028_/X }
C {devices/lab_pin.sym} 33990 -36790 0 1 {name=p33056 lab=_82670_/D }
C {sky130_stdcells/dfxtp_4.sym} 33900 -36780 0 0 {name=X_82714_ }
C {devices/lab_pin.sym} 33840 -36660 0 0 {name=p33057 lab=_55243_/A }
C {devices/lab_pin.sym} 33840 -36620 0 0 {name=p33058 lab=_55243_/B }
C {devices/lab_pin.sym} 33960 -36640 0 1 {name=p33059 lab=_55662_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -36640 0 0 {name=X_55662_ }
C {devices/lab_pin.sym} 33820 -36540 0 0 {name=p33060 lab=_86962_/Q }
C {devices/lab_pin.sym} 33820 -36500 0 0 {name=p33061 lab=_67551_/X }
C {devices/lab_pin.sym} 33820 -36460 0 0 {name=p33062 lab=_67552_/X }
C {devices/lab_pin.sym} 33820 -36420 0 0 {name=p33063 lab=_67647_/X }
C {devices/lab_pin.sym} 33980 -36480 0 1 {name=p33064 lab=_67649_/B }
C {sky130_stdcells/a211o_4.sym} 33900 -36480 0 0 {name=X_67648_ }
C {devices/lab_pin.sym} 33810 -36330 0 0 {name=p33065 lab=_86193_/CLK }
C {devices/lab_pin.sym} 33810 -36310 0 0 {name=p33066 lab=_48792_/Y }
C {devices/lab_pin.sym} 33990 -36330 0 1 {name=p33067 lab=_86482_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -36320 0 0 {name=X_86482_ }
C {devices/lab_pin.sym} 33860 -36190 0 0 {name=p33068 lab=_52821_/A }
C {devices/lab_pin.sym} 33940 -36190 0 1 {name=p33069 lab=_52874_/X }
C {sky130_stdcells/buf_2.sym} 33900 -36190 0 0 {name=X_52874_ }
C {devices/lab_pin.sym} 33810 -36070 0 0 {name=p33070 lab=_82381_/CLK }
C {devices/lab_pin.sym} 33810 -36050 0 0 {name=p33071 lab=_70815_/Y }
C {devices/lab_pin.sym} 33990 -36070 0 1 {name=p33072 lab=_83694_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -36060 0 0 {name=X_83694_ }
C {devices/lab_pin.sym} 33840 -35950 0 0 {name=p33073 lab=_57650_/A }
C {devices/lab_pin.sym} 33840 -35910 0 0 {name=p33074 lab=_57401_/B }
C {devices/lab_pin.sym} 33840 -35870 0 0 {name=p33075 lab=_57400_/X }
C {devices/lab_pin.sym} 33960 -35910 0 1 {name=p33076 lab=_57401_/Y }
C {sky130_stdcells/nor3_4.sym} 33900 -35910 0 0 {name=X_57401_ }
C {devices/lab_pin.sym} 33810 -35770 0 0 {name=p33077 lab=_87141_/CLK }
C {devices/lab_pin.sym} 33810 -35750 0 0 {name=p33078 lab=_41405_/Y }
C {devices/lab_pin.sym} 33990 -35770 0 1 {name=p33079 lab=_67860_/B }
C {sky130_stdcells/dfxtp_4.sym} 33900 -35760 0 0 {name=X_88221_ }
C {devices/lab_pin.sym} 33820 -35650 0 0 {name=p33080 lab=_54610_/Y }
C {devices/lab_pin.sym} 33820 -35610 0 0 {name=p33081 lab=_54611_/X }
C {devices/lab_pin.sym} 33820 -35570 0 0 {name=p33082 lab=_54612_/X }
C {devices/lab_pin.sym} 33980 -35610 0 1 {name=p33083 lab=_54613_/Y }
C {sky130_stdcells/a21oi_4.sym} 33900 -35610 0 0 {name=X_54613_ }
C {devices/lab_pin.sym} 33810 -35470 0 0 {name=p33084 lab=_85433_/CLK }
C {devices/lab_pin.sym} 33810 -35450 0 0 {name=p33085 lab=_54490_/Y }
C {devices/lab_pin.sym} 33990 -35470 0 1 {name=p33086 lab=_85433_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -35460 0 0 {name=X_85433_ }
C {devices/lab_pin.sym} 33820 -35350 0 0 {name=p33087 lab=_51821_/Y }
C {devices/lab_pin.sym} 33820 -35310 0 0 {name=p33088 lab=_51823_/X }
C {devices/lab_pin.sym} 33820 -35270 0 0 {name=p33089 lab=_51824_/X }
C {devices/lab_pin.sym} 33980 -35310 0 1 {name=p33090 lab=_51825_/Y }
C {sky130_stdcells/a21oi_4.sym} 33900 -35310 0 0 {name=X_51825_ }
C {devices/lab_pin.sym} 33820 -35190 0 0 {name=p33091 lab=_58366_/X }
C {devices/lab_pin.sym} 33820 -35150 0 0 {name=p33092 lab=_83352_/Q }
C {devices/lab_pin.sym} 33820 -35110 0 0 {name=p33093 lab=_58380_/Y }
C {devices/lab_pin.sym} 33980 -35150 0 1 {name=p33094 lab=_58381_/X }
C {sky130_stdcells/o21a_4.sym} 33900 -35150 0 0 {name=X_58381_ }
C {devices/lab_pin.sym} 33810 -35010 0 0 {name=p33095 lab=_82642_/CLK }
C {devices/lab_pin.sym} 33810 -34990 0 0 {name=p33096 lab=_83997_/Q }
C {devices/lab_pin.sym} 33990 -35010 0 1 {name=p33097 lab=_82645_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -35000 0 0 {name=X_82645_ }
C {devices/lab_pin.sym} 33860 -34870 0 0 {name=p33098 lab=_55592_/X }
C {devices/lab_pin.sym} 33940 -34870 0 1 {name=p33099 lab=_72643_/C }
C {sky130_stdcells/buf_2.sym} 33900 -34870 0 0 {name=X_55593_ }
C {devices/lab_pin.sym} 33840 -34760 0 0 {name=p33100 lab=_67675_/A }
C {devices/lab_pin.sym} 33840 -34720 0 0 {name=p33101 lab=_87721_/Q }
C {devices/lab_pin.sym} 33960 -34740 0 1 {name=p33102 lab=_67579_/X }
C {sky130_stdcells/and2_4.sym} 33900 -34740 0 0 {name=X_67579_ }
C {devices/lab_pin.sym} 33820 -34650 0 0 {name=p33103 lab=_56785_/B }
C {devices/lab_pin.sym} 33820 -34610 0 0 {name=p33104 lab=_56787_/X }
C {devices/lab_pin.sym} 33820 -34570 0 0 {name=p33105 lab=_56788_/A }
C {devices/lab_pin.sym} 33820 -34530 0 0 {name=p33106 lab=_57319_/D }
C {devices/lab_pin.sym} 33820 -34500 0 0 {name=p33107 lab=_45955_/X }
C {devices/lab_pin.sym} 33980 -34570 0 1 {name=p33108 lab=_57332_/Y }
C {sky130_stdcells/a41oi_4.sym} 33900 -34570 0 0 {name=X_57332_ }
C {devices/lab_pin.sym} 33840 -34420 0 0 {name=p33109 lab=_69288_/A }
C {devices/lab_pin.sym} 33840 -34380 0 0 {name=p33110 lab=_69318_/B }
C {devices/lab_pin.sym} 33960 -34400 0 1 {name=p33111 lab=_69318_/X }
C {sky130_stdcells/and2_4.sym} 33900 -34400 0 0 {name=X_69318_ }
C {devices/lab_pin.sym} 33810 -34270 0 0 {name=p33112 lab=_88208_/CLK }
C {devices/lab_pin.sym} 33810 -34250 0 0 {name=p33113 lab=_88152_/D }
C {devices/lab_pin.sym} 33990 -34270 0 1 {name=p33114 lab=_67992_/B }
C {sky130_stdcells/dfxtp_4.sym} 33900 -34260 0 0 {name=X_88152_ }
C {devices/lab_pin.sym} 33840 -34160 0 0 {name=p33115 lab=_54538_/A }
C {devices/lab_pin.sym} 33840 -34120 0 0 {name=p33116 lab=_54526_/B }
C {devices/lab_pin.sym} 33840 -34080 0 0 {name=p33117 lab=_54538_/C }
C {devices/lab_pin.sym} 33840 -34040 0 0 {name=p33118 lab=_47093_/A }
C {devices/lab_pin.sym} 33960 -34100 0 1 {name=p33119 lab=_54544_/X }
C {sky130_stdcells/and4_4.sym} 33900 -34100 0 0 {name=X_54544_ }
C {devices/lab_pin.sym} 33810 -33950 0 0 {name=p33120 lab=_83630_/CLK }
C {devices/lab_pin.sym} 33810 -33930 0 0 {name=p33121 lab=_85364_/D }
C {devices/lab_pin.sym} 33990 -33950 0 1 {name=p33122 lab=_85364_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -33940 0 0 {name=X_85364_ }
C {devices/lab_pin.sym} 33840 -33840 0 0 {name=p33123 lab=_51768_/A }
C {devices/lab_pin.sym} 33840 -33800 0 0 {name=p33124 lab=_51749_/X }
C {devices/lab_pin.sym} 33840 -33760 0 0 {name=p33125 lab=_51755_/X }
C {devices/lab_pin.sym} 33840 -33720 0 0 {name=p33126 lab=_51756_/D }
C {devices/lab_pin.sym} 33960 -33780 0 1 {name=p33127 lab=_51756_/X }
C {sky130_stdcells/and4_4.sym} 33900 -33780 0 0 {name=X_51756_ }
C {devices/lab_pin.sym} 33860 -33630 0 0 {name=p33128 lab=_70959_/C }
C {devices/lab_pin.sym} 33940 -33630 0 1 {name=p33129 lab=_70591_/A }
C {sky130_stdcells/buf_2.sym} 33900 -33630 0 0 {name=X_70590_ }
C {devices/lab_pin.sym} 33810 -33510 0 0 {name=p33130 lab=_82702_/CLK }
C {devices/lab_pin.sym} 33810 -33490 0 0 {name=p33131 lab=_82576_/D }
C {devices/lab_pin.sym} 33990 -33510 0 1 {name=p33132 lab=_78193_/B }
C {sky130_stdcells/dfxtp_4.sym} 33900 -33500 0 0 {name=X_82576_ }
C {devices/lab_pin.sym} 33810 -33370 0 0 {name=p33133 lab=_87103_/CLK }
C {devices/lab_pin.sym} 33810 -33350 0 0 {name=p33134 lab=_44451_/Y }
C {devices/lab_pin.sym} 33990 -33370 0 1 {name=p33135 lab=_87103_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -33360 0 0 {name=X_87103_ }
C {devices/lab_pin.sym} 33810 -33230 0 0 {name=p33136 lab=_84314_/CLK }
C {devices/lab_pin.sym} 33810 -33210 0 0 {name=p33137 lab=_63544_/Y }
C {devices/lab_pin.sym} 33990 -33230 0 1 {name=p33138 lab=_80475_/B }
C {sky130_stdcells/dfxtp_4.sym} 33900 -33220 0 0 {name=X_84315_ }
C {devices/lab_pin.sym} 33860 -33090 0 0 {name=p33139 lab=_50596_/A }
C {devices/lab_pin.sym} 33940 -33090 0 1 {name=p33140 lab=_50738_/A }
C {sky130_stdcells/buf_2.sym} 33900 -33090 0 0 {name=X_50707_ }
C {devices/lab_pin.sym} 33820 -33000 0 0 {name=p33141 lab=_57261_/X }
C {devices/lab_pin.sym} 33820 -32960 0 0 {name=p33142 lab=_56643_/X }
C {devices/lab_pin.sym} 33820 -32920 0 0 {name=p33143 lab=_45617_/A }
C {devices/lab_pin.sym} 33820 -32880 0 0 {name=p33144 lab=_57236_/X }
C {devices/lab_pin.sym} 33980 -32940 0 1 {name=p33145 lab=_85043_/D }
C {sky130_stdcells/a2bb2o_4.sym} 33900 -32940 0 0 {name=X_57263_ }
C {devices/lab_pin.sym} 33810 -32790 0 0 {name=p33146 lab=_84079_/CLK }
C {devices/lab_pin.sym} 33810 -32770 0 0 {name=p33147 lab=_81539_/Q }
C {devices/lab_pin.sym} 33990 -32790 0 1 {name=p33148 lab=_81527_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -32780 0 0 {name=X_81527_ }
C {devices/lab_pin.sym} 33840 -32660 0 0 {name=p33149 lab=_69179_/A }
C {devices/lab_pin.sym} 33840 -32620 0 0 {name=p33150 lab=_87275_/Q }
C {devices/lab_pin.sym} 33960 -32640 0 1 {name=p33151 lab=_69249_/X }
C {sky130_stdcells/and2_4.sym} 33900 -32640 0 0 {name=X_69249_ }
C {devices/lab_pin.sym} 33810 -32510 0 0 {name=p33152 lab=_87826_/CLK }
C {devices/lab_pin.sym} 33810 -32490 0 0 {name=p33153 lab=_88083_/D }
C {devices/lab_pin.sym} 33990 -32510 0 1 {name=p33154 lab=_41980_/A }
C {sky130_stdcells/dfxtp_4.sym} 33900 -32500 0 0 {name=X_88083_ }
C {devices/lab_pin.sym} 33860 -32370 0 0 {name=p33155 lab=_54475_/A }
C {devices/lab_pin.sym} 33940 -32370 0 1 {name=p33156 lab=_54475_/X }
C {sky130_stdcells/buf_2.sym} 33900 -32370 0 0 {name=X_54475_ }
C {devices/lab_pin.sym} 33810 -32250 0 0 {name=p33157 lab=_83022_/CLK }
C {devices/lab_pin.sym} 33810 -32230 0 0 {name=p33158 lab=_56106_/Y }
C {devices/lab_pin.sym} 33990 -32250 0 1 {name=p33159 lab=_55826_/B }
C {sky130_stdcells/dfxtp_4.sym} 33900 -32240 0 0 {name=X_85295_ }
C {devices/lab_pin.sym} 33820 -32130 0 0 {name=p33160 lab=_85964_/Q }
C {devices/lab_pin.sym} 33820 -32090 0 0 {name=p33161 lab=_51675_/X }
C {devices/lab_pin.sym} 33820 -32050 0 0 {name=p33162 lab=_51686_/Y }
C {devices/lab_pin.sym} 33980 -32090 0 1 {name=p33163 lab=_51687_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -32090 0 0 {name=X_51687_ }
C {devices/lab_pin.sym} 33820 -31970 0 0 {name=p33164 lab=_58904_/X }
C {devices/lab_pin.sym} 33820 -31930 0 0 {name=p33165 lab=_85761_/Q }
C {devices/lab_pin.sym} 33820 -31890 0 0 {name=p33166 lab=_58928_/X }
C {devices/lab_pin.sym} 33980 -31930 0 1 {name=p33167 lab=_59002_/X }
C {sky130_stdcells/o21a_4.sym} 33900 -31930 0 0 {name=X_59002_ }
C {devices/lab_pin.sym} 33840 -31810 0 0 {name=p33168 lab=_56214_/A }
C {devices/lab_pin.sym} 33840 -31770 0 0 {name=p33169 lab=_56205_/X }
C {devices/lab_pin.sym} 33840 -31730 0 0 {name=p33170 lab=_85273_/Q }
C {devices/lab_pin.sym} 33960 -31770 0 1 {name=p33171 lab=_56214_/Y }
C {sky130_stdcells/nand3_4.sym} 33900 -31770 0 0 {name=X_56214_ }
C {devices/lab_pin.sym} 33840 -31640 0 0 {name=p33172 lab=_41440_/A }
C {devices/lab_pin.sym} 33840 -31600 0 0 {name=p33173 lab=_41471_/B }
C {devices/lab_pin.sym} 33960 -31620 0 1 {name=p33174 lab=_41440_/X }
C {sky130_stdcells/or2_4.sym} 33900 -31620 0 0 {name=X_41440_ }
C {devices/lab_pin.sym} 33810 -31490 0 0 {name=p33175 lab=_86989_/CLK }
C {devices/lab_pin.sym} 33810 -31470 0 0 {name=p33176 lab=_87034_/D }
C {devices/lab_pin.sym} 33990 -31490 0 1 {name=p33177 lab=_87034_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -31480 0 0 {name=X_87034_ }
C {devices/lab_pin.sym} 33840 -31360 0 0 {name=p33178 lab=_53405_/X }
C {devices/lab_pin.sym} 33840 -31320 0 0 {name=p33179 lab=_53426_/B }
C {devices/lab_pin.sym} 33960 -31340 0 1 {name=p33180 lab=_53426_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -31340 0 0 {name=X_53426_ }
C {devices/lab_pin.sym} 33820 -31230 0 0 {name=p33181 lab=_72209_/X }
C {devices/lab_pin.sym} 33820 -31190 0 0 {name=p33182 lab=_85974_/Q }
C {devices/lab_pin.sym} 33820 -31150 0 0 {name=p33183 lab=_72259_/X }
C {devices/lab_pin.sym} 33980 -31190 0 1 {name=p33184 lab=_72260_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -31190 0 0 {name=X_72260_ }
C {devices/lab_pin.sym} 33810 -31050 0 0 {name=p33185 lab=_82436_/CLK }
C {devices/lab_pin.sym} 33810 -31030 0 0 {name=p33186 lab=_64444_/X }
C {devices/lab_pin.sym} 33990 -31050 0 1 {name=p33187 lab=_84246_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -31040 0 0 {name=X_84246_ }
C {devices/lab_pin.sym} 33860 -30910 0 0 {name=p33188 lab=_50638_/A }
C {devices/lab_pin.sym} 33940 -30910 0 1 {name=p33189 lab=_50718_/A }
C {sky130_stdcells/buf_2.sym} 33900 -30910 0 0 {name=X_50638_ }
C {devices/lab_pin.sym} 33810 -30790 0 0 {name=p33190 lab=_83926_/CLK }
C {devices/lab_pin.sym} 33810 -30770 0 0 {name=p33191 lab=_76802_/B }
C {devices/lab_pin.sym} 33990 -30790 0 1 {name=p33192 lab=_81426_/D }
C {sky130_stdcells/dfxtp_4.sym} 33900 -30780 0 0 {name=X_81458_ }
C {devices/lab_pin.sym} 33820 -30690 0 0 {name=p33193 lab=_56698_/Y }
C {devices/lab_pin.sym} 33820 -30650 0 0 {name=p33194 lab=_57193_/Y }
C {devices/lab_pin.sym} 33820 -30610 0 0 {name=p33195 lab=_56671_/X }
C {devices/lab_pin.sym} 33820 -30570 0 0 {name=p33196 lab=_57182_/X }
C {devices/lab_pin.sym} 33820 -30530 0 0 {name=p33197 lab=_44239_/A }
C {devices/lab_pin.sym} 33980 -30610 0 1 {name=p33198 lab=_57195_/C }
C {sky130_stdcells/a2111o_4.sym} 33900 -30610 0 0 {name=X_57194_ }
C {devices/lab_pin.sym} 33860 -30450 0 0 {name=p33199 lab=_44267_/A }
C {devices/lab_pin.sym} 33940 -30450 0 1 {name=p33200 lab=_44279_/D }
C {sky130_stdcells/buf_2.sym} 33900 -30450 0 0 {name=Xpsn_inst_psn_buff_2 }
C {devices/lab_pin.sym} 33840 -30350 0 0 {name=p33201 lab=_71211_/A }
C {devices/lab_pin.sym} 33840 -30310 0 0 {name=p33202 lab=_71232_/B }
C {devices/lab_pin.sym} 33840 -30270 0 0 {name=p33203 lab=_71219_/C }
C {devices/lab_pin.sym} 33960 -30310 0 1 {name=p33204 lab=_71211_/Y }
C {sky130_stdcells/nand3_4.sym} 33900 -30310 0 0 {name=X_71211_ }
C {devices/lab_pin.sym} 33860 -30170 0 0 {name=p33205 lab=_86500_/CLK }
C {devices/lab_pin.sym} 33940 -30170 0 1 {name=p33206 lab=_85865_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 33900 -30170 0 0 {name=Xclkbuf_opt_28_CLK }
C {devices/lab_pin.sym} 33840 -30060 0 0 {name=p33207 lab=_80409_/A }
C {devices/lab_pin.sym} 33840 -30020 0 0 {name=p33208 lab=_80408_/Y }
C {devices/lab_pin.sym} 33960 -30040 0 1 {name=p33209 lab=_80409_/X }
C {sky130_stdcells/xor2_4.sym} 33900 -30040 0 0 {name=X_80409_ }
C {devices/lab_pin.sym} 33840 -29930 0 0 {name=p33210 lab=_56140_/A }
C {devices/lab_pin.sym} 33840 -29890 0 0 {name=p33211 lab=_56140_/B }
C {devices/lab_pin.sym} 33840 -29850 0 0 {name=p33212 lab=_56145_/C }
C {devices/lab_pin.sym} 33960 -29890 0 1 {name=p33213 lab=_56145_/Y }
C {sky130_stdcells/nand3_4.sym} 33900 -29890 0 0 {name=X_56145_ }
C {devices/lab_pin.sym} 33860 -29750 0 0 {name=p33214 lab=_41370_/Y }
C {devices/lab_pin.sym} 33940 -29750 0 1 {name=p33215 lab=_41371_/X }
C {sky130_stdcells/buf_2.sym} 33900 -29750 0 0 {name=X_41371_ }
C {devices/lab_pin.sym} 33860 -29630 0 0 {name=p33216 lab=_53357_/A }
C {devices/lab_pin.sym} 33940 -29630 0 1 {name=p33217 lab=_53371_/C }
C {sky130_stdcells/buf_2.sym} 33900 -29630 0 0 {name=X_53357_ }
C {devices/lab_pin.sym} 33820 -29540 0 0 {name=p33218 lab=_72179_/Y }
C {devices/lab_pin.sym} 33820 -29500 0 0 {name=p33219 lab=_72152_/X }
C {devices/lab_pin.sym} 33820 -29460 0 0 {name=p33220 lab=_72186_/X }
C {devices/lab_pin.sym} 33820 -29420 0 0 {name=p33221 lab=_72190_/X }
C {devices/lab_pin.sym} 33980 -29480 0 1 {name=p33222 lab=_83276_/D }
C {sky130_stdcells/a22oi_4.sym} 33900 -29480 0 0 {name=X_72191_ }
C {devices/lab_pin.sym} 33810 -29330 0 0 {name=p33223 lab=_84177_/CLK }
C {devices/lab_pin.sym} 33810 -29310 0 0 {name=p33224 lab=_84177_/D }
C {devices/lab_pin.sym} 33990 -29330 0 1 {name=p33225 lab=_84177_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -29320 0 0 {name=X_84177_ }
C {devices/lab_pin.sym} 33820 -29210 0 0 {name=p33226 lab=_50566_/Y }
C {devices/lab_pin.sym} 33820 -29170 0 0 {name=p33227 lab=_50551_/X }
C {devices/lab_pin.sym} 33820 -29130 0 0 {name=p33228 lab=_50568_/X }
C {devices/lab_pin.sym} 33980 -29170 0 1 {name=p33229 lab=_50569_/Y }
C {sky130_stdcells/a21oi_4.sym} 33900 -29170 0 0 {name=X_50569_ }
C {devices/lab_pin.sym} 33810 -29030 0 0 {name=p33230 lab=_81265_/CLK }
C {devices/lab_pin.sym} 33810 -29010 0 0 {name=p33231 lab=_83925_/Q }
C {devices/lab_pin.sym} 33990 -29030 0 1 {name=p33232 lab=_76895_/B }
C {sky130_stdcells/dfxtp_4.sym} 33900 -29020 0 0 {name=X_81389_ }
C {devices/lab_pin.sym} 33860 -28890 0 0 {name=p33233 lab=_43017_/A }
C {devices/lab_pin.sym} 33940 -28890 0 1 {name=p33234 lab=_43110_/X }
C {sky130_stdcells/buf_2.sym} 33900 -28890 0 0 {name=X_43110_ }
C {devices/lab_pin.sym} 33860 -28770 0 0 {name=p33235 lab=_46526_/A }
C {devices/lab_pin.sym} 33940 -28770 0 1 {name=p33236 lab=_48135_/A }
C {sky130_stdcells/buf_2.sym} 33900 -28770 0 0 {name=X_40322_ }
C {devices/lab_pin.sym} 33820 -28670 0 0 {name=p33237 lab=_64844_/B }
C {devices/lab_pin.sym} 33820 -28630 0 0 {name=p33238 lab=_52297_/X }
C {devices/lab_pin.sym} 33820 -28590 0 0 {name=p33239 lab=_52307_/Y }
C {devices/lab_pin.sym} 33980 -28630 0 1 {name=p33240 lab=_52308_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -28630 0 0 {name=X_52308_ }
C {devices/lab_pin.sym} 33820 -28510 0 0 {name=p33241 lab=_48358_/X }
C {devices/lab_pin.sym} 33820 -28470 0 0 {name=p33242 lab=_71138_/X }
C {devices/lab_pin.sym} 33820 -28430 0 0 {name=p33243 lab=_71141_/Y }
C {devices/lab_pin.sym} 33980 -28470 0 1 {name=p33244 lab=_71142_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -28470 0 0 {name=X_71142_ }
C {devices/lab_pin.sym} 33810 -28330 0 0 {name=p33245 lab=_83561_/CLK }
C {devices/lab_pin.sym} 33810 -28310 0 0 {name=p33246 lab=_83128_/D }
C {devices/lab_pin.sym} 33990 -28330 0 1 {name=p33247 lab=_83128_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -28320 0 0 {name=X_83128_ }
C {devices/lab_pin.sym} 33840 -28200 0 0 {name=p33248 lab=_44090_/A }
C {devices/lab_pin.sym} 33840 -28160 0 0 {name=p33249 lab=_44090_/B }
C {devices/lab_pin.sym} 33960 -28180 0 1 {name=p33250 lab=_44090_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -28180 0 0 {name=X_44090_ }
C {devices/lab_pin.sym} 33840 -28070 0 0 {name=p33251 lab=_56100_/A }
C {devices/lab_pin.sym} 33840 -28030 0 0 {name=p33252 lab=_56086_/B }
C {devices/lab_pin.sym} 33840 -27990 0 0 {name=p33253 lab=_55870_/B }
C {devices/lab_pin.sym} 33960 -28030 0 1 {name=p33254 lab=_56076_/Y }
C {sky130_stdcells/nand3_4.sym} 33900 -28030 0 0 {name=X_56076_ }
C {devices/lab_pin.sym} 33840 -27920 0 0 {name=p33255 lab=_53293_/A }
C {devices/lab_pin.sym} 33840 -27880 0 0 {name=p33256 lab=_53274_/B }
C {devices/lab_pin.sym} 33840 -27840 0 0 {name=p33257 lab=_53293_/C }
C {devices/lab_pin.sym} 33840 -27800 0 0 {name=p33258 lab=_52775_/D }
C {devices/lab_pin.sym} 33960 -27860 0 1 {name=p33259 lab=_53288_/X }
C {sky130_stdcells/and4_4.sym} 33900 -27860 0 0 {name=X_53288_ }
C {devices/lab_pin.sym} 33820 -27730 0 0 {name=p33260 lab=_55023_/Y }
C {devices/lab_pin.sym} 33820 -27690 0 0 {name=p33261 lab=_55024_/X }
C {devices/lab_pin.sym} 33820 -27650 0 0 {name=p33262 lab=_55026_/X }
C {devices/lab_pin.sym} 33980 -27690 0 1 {name=p33263 lab=_55027_/Y }
C {sky130_stdcells/a21oi_4.sym} 33900 -27690 0 0 {name=X_55027_ }
C {devices/lab_pin.sym} 33840 -27570 0 0 {name=p33264 lab=_60162_/A }
C {devices/lab_pin.sym} 33840 -27530 0 0 {name=p33265 lab=_59904_/B }
C {devices/lab_pin.sym} 33840 -27490 0 0 {name=p33266 lab=_60403_/A }
C {devices/lab_pin.sym} 33960 -27530 0 1 {name=p33267 lab=_59909_/A }
C {sky130_stdcells/and3_4.sym} 33900 -27530 0 0 {name=X_59904_ }
C {devices/lab_pin.sym} 33860 -27390 0 0 {name=p33268 lab=_87597_/Q }
C {devices/lab_pin.sym} 33940 -27390 0 1 {name=p33269 lab=_43041_/Y }
C {sky130_stdcells/inv_2.sym} 33900 -27390 0 0 {name=X_43041_ }
C {devices/lab_pin.sym} 33860 -27270 0 0 {name=p33270 lab=_52214_/A }
C {devices/lab_pin.sym} 33940 -27270 0 1 {name=p33271 lab=_52239_/X }
C {sky130_stdcells/buf_2.sym} 33900 -27270 0 0 {name=X_52239_ }
C {devices/lab_pin.sym} 33840 -27170 0 0 {name=p33272 lab=_71078_/A }
C {devices/lab_pin.sym} 33840 -27130 0 0 {name=p33273 lab=_71073_/B }
C {devices/lab_pin.sym} 33840 -27090 0 0 {name=p33274 lab=_71078_/C }
C {devices/lab_pin.sym} 33960 -27130 0 1 {name=p33275 lab=_71073_/Y }
C {sky130_stdcells/nand3_4.sym} 33900 -27130 0 0 {name=X_71073_ }
C {devices/lab_pin.sym} 33840 -27000 0 0 {name=p33276 lab=_75950_/A }
C {devices/lab_pin.sym} 33840 -26960 0 0 {name=p33277 lab=_81734_/D }
C {devices/lab_pin.sym} 33960 -26980 0 1 {name=p33278 lab=_75950_/X }
C {sky130_stdcells/xor2_4.sym} 33900 -26980 0 0 {name=X_75950_ }
C {devices/lab_pin.sym} 33810 -26850 0 0 {name=p33279 lab=_83572_/CLK }
C {devices/lab_pin.sym} 33810 -26830 0 0 {name=p33280 lab=_83059_/D }
C {devices/lab_pin.sym} 33990 -26850 0 1 {name=p33281 lab=_83059_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -26840 0 0 {name=X_83059_ }
C {devices/lab_pin.sym} 33810 -26710 0 0 {name=p33282 lab=_82888_/CLK }
C {devices/lab_pin.sym} 33810 -26690 0 0 {name=p33283 lab=_87936_/D }
C {devices/lab_pin.sym} 33990 -26710 0 1 {name=p33284 lab=_87936_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -26700 0 0 {name=X_87936_ }
C {devices/lab_pin.sym} 33820 -26590 0 0 {name=p33285 lab=_81129_/D }
C {devices/lab_pin.sym} 33820 -26550 0 0 {name=p33286 lab=_74891_/B }
C {devices/lab_pin.sym} 33820 -26510 0 0 {name=p33287 lab=_74900_/Y }
C {devices/lab_pin.sym} 33980 -26550 0 1 {name=p33288 lab=_74901_/X }
C {sky130_stdcells/o21a_4.sym} 33900 -26550 0 0 {name=X_74901_ }
C {devices/lab_pin.sym} 33820 -26440 0 0 {name=p33289 lab=_70011_/X }
C {devices/lab_pin.sym} 33820 -26400 0 0 {name=p33290 lab=_68647_/Y }
C {devices/lab_pin.sym} 33820 -26360 0 0 {name=p33291 lab=_70012_/X }
C {devices/lab_pin.sym} 33820 -26320 0 0 {name=p33292 lab=_70023_/Y }
C {devices/lab_pin.sym} 33980 -26380 0 1 {name=p33293 lab=_70024_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -26380 0 0 {name=X_70024_ }
C {devices/lab_pin.sym} 33820 -26250 0 0 {name=p33294 lab=_59829_/X }
C {devices/lab_pin.sym} 33820 -26210 0 0 {name=p33295 lab=_59830_/Y }
C {devices/lab_pin.sym} 33820 -26170 0 0 {name=p33296 lab=_59834_/X }
C {devices/lab_pin.sym} 33980 -26210 0 1 {name=p33297 lab=_59835_/X }
C {sky130_stdcells/o21a_4.sym} 33900 -26210 0 0 {name=X_59835_ }
C {devices/lab_pin.sym} 33860 -26070 0 0 {name=p33298 lab=_75714_/Y }
C {devices/lab_pin.sym} 33940 -26070 0 1 {name=p33299 lab=_80786_/D }
C {sky130_stdcells/inv_2.sym} 33900 -26070 0 0 {name=X_75881_ }
C {devices/lab_pin.sym} 33810 -25950 0 0 {name=p33300 lab=_87086_/CLK }
C {devices/lab_pin.sym} 33810 -25930 0 0 {name=p33301 lab=_42432_/Y }
C {devices/lab_pin.sym} 33990 -25950 0 1 {name=p33302 lab=_87867_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -25940 0 0 {name=X_87867_ }
C {devices/lab_pin.sym} 33860 -25810 0 0 {name=p33303 lab=_82958_/Q }
C {devices/lab_pin.sym} 33940 -25810 0 1 {name=p33304 lab=_46800_/Y }
C {sky130_stdcells/inv_2.sym} 33900 -25810 0 0 {name=X_46800_ }
C {devices/lab_pin.sym} 33840 -25700 0 0 {name=p33305 lab=_77664_/C }
C {devices/lab_pin.sym} 33840 -25660 0 0 {name=p33306 lab=_77666_/A }
C {devices/lab_pin.sym} 33960 -25680 0 1 {name=p33307 lab=_77621_/A }
C {sky130_stdcells/and2_4.sym} 33900 -25680 0 0 {name=X_77620_ }
C {devices/lab_pin.sym} 33840 -25560 0 0 {name=p33308 lab=_74844_/A }
C {devices/lab_pin.sym} 33840 -25520 0 0 {name=p33309 lab=_46115_/A }
C {devices/lab_pin.sym} 33960 -25540 0 1 {name=p33310 lab=_74832_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -25540 0 0 {name=X_74832_ }
C {devices/lab_pin.sym} 33810 -25410 0 0 {name=p33311 lab=_86814_/CLK }
C {devices/lab_pin.sym} 33810 -25390 0 0 {name=p33312 lab=_46006_/Y }
C {devices/lab_pin.sym} 33990 -25410 0 1 {name=p33313 lab=_86818_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -25400 0 0 {name=X_86818_ }
C {devices/lab_pin.sym} 33860 -25270 0 0 {name=p33314 lab=_47780_/A }
C {devices/lab_pin.sym} 33940 -25270 0 1 {name=p33315 lab=_53240_/B }
C {sky130_stdcells/buf_2.sym} 33900 -25270 0 0 {name=X_47780_ }
C {devices/lab_pin.sym} 33860 -25150 0 0 {name=p33316 lab=_59664_/A }
C {devices/lab_pin.sym} 33940 -25150 0 1 {name=p33317 lab=_59766_/X }
C {sky130_stdcells/buf_2.sym} 33900 -25150 0 0 {name=X_59766_ }
C {devices/lab_pin.sym} 33820 -25050 0 0 {name=p33318 lab=_56975_/Y }
C {devices/lab_pin.sym} 33820 -25010 0 0 {name=p33319 lab=_56977_/Y }
C {devices/lab_pin.sym} 33820 -24970 0 0 {name=p33320 lab=_45909_/A }
C {devices/lab_pin.sym} 33980 -25010 0 1 {name=p33321 lab=_56978_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -25010 0 0 {name=X_56978_ }
C {devices/lab_pin.sym} 33860 -24870 0 0 {name=p33322 lab=_64275_/B }
C {devices/lab_pin.sym} 33940 -24870 0 1 {name=p33323 lab=_61386_/B }
C {sky130_stdcells/buf_2.sym} 33900 -24870 0 0 {name=X_44992_ }
C {devices/lab_pin.sym} 33810 -24750 0 0 {name=p33324 lab=_87285_/CLK }
C {devices/lab_pin.sym} 33810 -24730 0 0 {name=p33325 lab=_42621_/Y }
C {devices/lab_pin.sym} 33990 -24750 0 1 {name=p33326 lab=_73484_/A }
C {sky130_stdcells/dfxtp_4.sym} 33900 -24740 0 0 {name=X_87798_ }
C {devices/lab_pin.sym} 33820 -24630 0 0 {name=p33327 lab=_58714_/X }
C {devices/lab_pin.sym} 33820 -24590 0 0 {name=p33328 lab=_85781_/Q }
C {devices/lab_pin.sym} 33820 -24550 0 0 {name=p33329 lab=_58716_/X }
C {devices/lab_pin.sym} 33980 -24590 0 1 {name=p33330 lab=_58717_/X }
C {sky130_stdcells/o21a_4.sym} 33900 -24590 0 0 {name=X_58717_ }
C {devices/lab_pin.sym} 33860 -24450 0 0 {name=p33331 lab=_83677_/Q }
C {devices/lab_pin.sym} 33940 -24450 0 1 {name=p33332 lab=_54332_/B }
C {sky130_stdcells/inv_2.sym} 33900 -24450 0 0 {name=X_46731_ }
C {devices/lab_pin.sym} 33840 -24340 0 0 {name=p33333 lab=_77551_/A }
C {devices/lab_pin.sym} 33840 -24300 0 0 {name=p33334 lab=_82116_/Q }
C {devices/lab_pin.sym} 33960 -24320 0 1 {name=p33335 lab=_77552_/A }
C {sky130_stdcells/nand2_4.sym} 33900 -24320 0 0 {name=X_77551_ }
C {devices/lab_pin.sym} 33860 -24190 0 0 {name=p33336 lab=_80667_/Q }
C {devices/lab_pin.sym} 33940 -24190 0 1 {name=p33337 lab=_43944_/A }
C {sky130_stdcells/buf_2.sym} 33900 -24190 0 0 {name=X_43943_ }
C {devices/lab_pin.sym} 33840 -24100 0 0 {name=p33338 lab=_71735_/A }
C {devices/lab_pin.sym} 33840 -24060 0 0 {name=p33339 lab=_70630_/B }
C {devices/lab_pin.sym} 33840 -24020 0 0 {name=p33340 lab=_74763_/C }
C {devices/lab_pin.sym} 33840 -23980 0 0 {name=p33341 lab=_71010_/X }
C {devices/lab_pin.sym} 33960 -24040 0 1 {name=p33342 lab=_74763_/X }
C {sky130_stdcells/and4_4.sym} 33900 -24040 0 0 {name=X_74763_ }
C {devices/lab_pin.sym} 33840 -23900 0 0 {name=p33343 lab=_55947_/A }
C {devices/lab_pin.sym} 33840 -23860 0 0 {name=p33344 lab=_56303_/C }
C {devices/lab_pin.sym} 33960 -23880 0 1 {name=p33345 lab=_55929_/X }
C {sky130_stdcells/and2_4.sym} 33900 -23880 0 0 {name=X_55929_ }
C {devices/lab_pin.sym} 33810 -23750 0 0 {name=p33346 lab=_86749_/CLK }
C {devices/lab_pin.sym} 33810 -23730 0 0 {name=p33347 lab=_86749_/D }
C {devices/lab_pin.sym} 33990 -23750 0 1 {name=p33348 lab=_86749_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -23740 0 0 {name=X_86749_ }
C {devices/lab_pin.sym} 33820 -23630 0 0 {name=p33349 lab=_71973_/Y }
C {devices/lab_pin.sym} 33820 -23590 0 0 {name=p33350 lab=_71969_/X }
C {devices/lab_pin.sym} 33820 -23550 0 0 {name=p33351 lab=_71974_/Y }
C {devices/lab_pin.sym} 33980 -23590 0 1 {name=p33352 lab=_71975_/Y }
C {sky130_stdcells/a21boi_4.sym} 33900 -23590 0 0 {name=X_71975_ }
C {devices/lab_pin.sym} 33820 -23490 0 0 {name=p33353 lab=_59680_/Y }
C {devices/lab_pin.sym} 33820 -23450 0 0 {name=p33354 lab=_59688_/X }
C {devices/lab_pin.sym} 33820 -23410 0 0 {name=p33355 lab=_59689_/Y }
C {devices/lab_pin.sym} 33820 -23370 0 0 {name=p33356 lab=_59695_/Y }
C {devices/lab_pin.sym} 33820 -23340 0 0 {name=p33357 lab=_59696_/Y }
C {devices/lab_pin.sym} 33980 -23410 0 1 {name=p33358 lab=_59697_/Y }
C {sky130_stdcells/a41oi_4.sym} 33900 -23410 0 0 {name=X_59697_ }
C {devices/lab_pin.sym} 33840 -23260 0 0 {name=p33359 lab=_76503_/A }
C {devices/lab_pin.sym} 33840 -23220 0 0 {name=p33360 lab=_81542_/Q }
C {devices/lab_pin.sym} 33960 -23240 0 1 {name=p33361 lab=_76502_/Y }
C {sky130_stdcells/nor2_4.sym} 33900 -23240 0 0 {name=X_76502_ }
C {devices/lab_pin.sym} 33820 -23130 0 0 {name=p33362 lab=_86385_/Q }
C {devices/lab_pin.sym} 33820 -23090 0 0 {name=p33363 lab=_49443_/X }
C {devices/lab_pin.sym} 33820 -23050 0 0 {name=p33364 lab=_49449_/Y }
C {devices/lab_pin.sym} 33980 -23090 0 1 {name=p33365 lab=_49450_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -23090 0 0 {name=X_49450_ }
C {devices/lab_pin.sym} 33840 -22960 0 0 {name=p33366 lab=_73641_/A }
C {devices/lab_pin.sym} 33840 -22920 0 0 {name=p33367 lab=_65997_/B }
C {devices/lab_pin.sym} 33960 -22940 0 1 {name=p33368 lab=_73714_/X }
C {sky130_stdcells/and2_4.sym} 33900 -22940 0 0 {name=X_73714_ }
C {devices/lab_pin.sym} 33860 -22810 0 0 {name=p33369 lab=_46662_/A }
C {devices/lab_pin.sym} 33940 -22810 0 1 {name=p33370 lab=_46662_/X }
C {sky130_stdcells/buf_2.sym} 33900 -22810 0 0 {name=X_46662_ }
C {devices/lab_pin.sym} 33840 -22720 0 0 {name=p33371 lab=_70873_/A }
C {devices/lab_pin.sym} 33840 -22680 0 0 {name=p33372 lab=_70863_/C }
C {devices/lab_pin.sym} 33840 -22640 0 0 {name=p33373 lab=_70925_/X }
C {devices/lab_pin.sym} 33840 -22600 0 0 {name=p33374 lab=_70919_/D }
C {devices/lab_pin.sym} 33960 -22660 0 1 {name=p33375 lab=_70926_/Y }
C {sky130_stdcells/nand4_4.sym} 33900 -22660 0 0 {name=X_70926_ }
C {devices/lab_pin.sym} 33840 -22520 0 0 {name=p33376 lab=_58659_/A }
C {devices/lab_pin.sym} 33840 -22480 0 0 {name=p33377 lab=_86395_/Q }
C {devices/lab_pin.sym} 33960 -22500 0 1 {name=p33378 lab=_58648_/Y }
C {sky130_stdcells/nor2_4.sym} 33900 -22500 0 0 {name=X_58648_ }
C {devices/lab_pin.sym} 33840 -22380 0 0 {name=p33379 lab=_77465_/B }
C {devices/lab_pin.sym} 33840 -22340 0 0 {name=p33380 lab=_77458_/X }
C {devices/lab_pin.sym} 33960 -22360 0 1 {name=p33381 lab=_77482_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -22360 0 0 {name=X_77482_ }
C {devices/lab_pin.sym} 33820 -22260 0 0 {name=p33382 lab=_41268_/X }
C {devices/lab_pin.sym} 33820 -22220 0 0 {name=p33383 lab=_43868_/X }
C {devices/lab_pin.sym} 33820 -22180 0 0 {name=p33384 lab=_69045_/B }
C {devices/lab_pin.sym} 33820 -22140 0 0 {name=p33385 lab=_43870_/X }
C {devices/lab_pin.sym} 33980 -22200 0 1 {name=p33386 lab=_43874_/X }
C {sky130_stdcells/a2bb2o_4.sym} 33900 -22200 0 0 {name=X_43874_ }
C {devices/lab_pin.sym} 33840 -22060 0 0 {name=p33387 lab=_74694_/A }
C {devices/lab_pin.sym} 33840 -22020 0 0 {name=p33388 lab=_74694_/B }
C {devices/lab_pin.sym} 33960 -22040 0 1 {name=p33389 lab=_74694_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -22040 0 0 {name=X_74694_ }
C {devices/lab_pin.sym} 33840 -21920 0 0 {name=p33390 lab=_48401_/A }
C {devices/lab_pin.sym} 33840 -21880 0 0 {name=p33391 lab=_48401_/B }
C {devices/lab_pin.sym} 33960 -21900 0 1 {name=p33392 lab=_48401_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -21900 0 0 {name=X_48401_ }
C {devices/lab_pin.sym} 33860 -21770 0 0 {name=p33393 lab=_79220_/Y }
C {devices/lab_pin.sym} 33940 -21770 0 1 {name=p33394 lab=_79221_/Y }
C {sky130_stdcells/inv_2.sym} 33900 -21770 0 0 {name=X_79221_ }
C {devices/lab_pin.sym} 33840 -21660 0 0 {name=p33395 lab=_85107_/Q }
C {devices/lab_pin.sym} 33840 -21620 0 0 {name=p33396 lab=_45793_/B }
C {devices/lab_pin.sym} 33960 -21640 0 1 {name=p33397 lab=_45613_/Y }
C {sky130_stdcells/nor2_4.sym} 33900 -21640 0 0 {name=X_45613_ }
C {devices/lab_pin.sym} 33840 -21520 0 0 {name=p33398 lab=_76425_/X }
C {devices/lab_pin.sym} 33840 -21480 0 0 {name=p33399 lab=_76432_/X }
C {devices/lab_pin.sym} 33960 -21500 0 1 {name=p33400 lab=_76433_/X }
C {sky130_stdcells/xor2_4.sym} 33900 -21500 0 0 {name=X_76433_ }
C {devices/lab_pin.sym} 33820 -21400 0 0 {name=p33401 lab=_41461_/X }
C {devices/lab_pin.sym} 33820 -21360 0 0 {name=p33402 lab=_42821_/X }
C {devices/lab_pin.sym} 33820 -21320 0 0 {name=p33403 lab=_66535_/B }
C {devices/lab_pin.sym} 33820 -21280 0 0 {name=p33404 lab=_42822_/X }
C {devices/lab_pin.sym} 33980 -21340 0 1 {name=p33405 lab=_42825_/X }
C {sky130_stdcells/a2bb2o_4.sym} 33900 -21340 0 0 {name=X_42825_ }
C {devices/lab_pin.sym} 33820 -21210 0 0 {name=p33406 lab=_49377_/Y }
C {devices/lab_pin.sym} 33820 -21170 0 0 {name=p33407 lab=_49378_/X }
C {devices/lab_pin.sym} 33820 -21130 0 0 {name=p33408 lab=_49380_/X }
C {devices/lab_pin.sym} 33980 -21170 0 1 {name=p33409 lab=_86398_/D }
C {sky130_stdcells/a21oi_4.sym} 33900 -21170 0 0 {name=X_49381_ }
C {devices/lab_pin.sym} 33820 -21050 0 0 {name=p33410 lab=_73646_/B }
C {devices/lab_pin.sym} 33820 -21010 0 0 {name=p33411 lab=_73635_/X }
C {devices/lab_pin.sym} 33820 -20970 0 0 {name=p33412 lab=_73644_/X }
C {devices/lab_pin.sym} 33980 -21010 0 1 {name=p33413 lab=_73645_/X }
C {sky130_stdcells/a21o_4.sym} 33900 -21010 0 0 {name=X_73645_ }
C {devices/lab_pin.sym} 33820 -20890 0 0 {name=p33414 lab=_46588_/Y }
C {devices/lab_pin.sym} 33820 -20850 0 0 {name=p33415 lab=_46576_/X }
C {devices/lab_pin.sym} 33820 -20810 0 0 {name=p33416 lab=_46592_/Y }
C {devices/lab_pin.sym} 33980 -20850 0 1 {name=p33417 lab=_46593_/Y }
C {sky130_stdcells/a21boi_4.sym} 33900 -20850 0 0 {name=X_46593_ }
C {devices/lab_pin.sym} 33860 -20710 0 0 {name=p33418 lab=_71068_/B }
C {devices/lab_pin.sym} 33940 -20710 0 1 {name=p33419 lab=_71072_/A }
C {sky130_stdcells/buf_2.sym} 33900 -20710 0 0 {name=X_70857_ }
C {devices/lab_pin.sym} 33820 -20610 0 0 {name=p33420 lab=_58100_/X }
C {devices/lab_pin.sym} 33820 -20570 0 0 {name=p33421 lab=_85952_/Q }
C {devices/lab_pin.sym} 33820 -20530 0 0 {name=p33422 lab=_58568_/X }
C {devices/lab_pin.sym} 33980 -20570 0 1 {name=p33423 lab=_58579_/X }
C {sky130_stdcells/o21a_4.sym} 33900 -20570 0 0 {name=X_58579_ }
C {devices/lab_pin.sym} 33860 -20430 0 0 {name=p33424 lab=clkbuf_6_26_0_CLK/X }
C {devices/lab_pin.sym} 33940 -20430 0 1 {name=p33425 lab=clkbuf_7_53_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 33900 -20430 0 0 {name=Xclkbuf_7_53_0_CLK }
C {devices/lab_pin.sym} 33840 -20330 0 0 {name=p33426 lab=_60610_/A }
C {devices/lab_pin.sym} 33840 -20290 0 0 {name=p33427 lab=_60513_/B }
C {devices/lab_pin.sym} 33840 -20250 0 0 {name=p33428 lab=_79127_/A }
C {devices/lab_pin.sym} 33960 -20290 0 1 {name=p33429 lab=_60610_/X }
C {sky130_stdcells/or3_4.sym} 33900 -20290 0 0 {name=X_60610_ }
C {devices/lab_pin.sym} 33860 -20150 0 0 {name=p33430 lab=_48897_/A }
C {devices/lab_pin.sym} 33940 -20150 0 1 {name=p33431 lab=_48548_/A }
C {sky130_stdcells/buf_2.sym} 33900 -20150 0 0 {name=X_48332_ }
C {devices/lab_pin.sym} 33840 -20040 0 0 {name=p33432 lab=_79152_/A }
C {devices/lab_pin.sym} 33840 -20000 0 0 {name=p33433 lab=_79152_/B }
C {devices/lab_pin.sym} 33960 -20020 0 1 {name=p33434 lab=_79152_/X }
C {sky130_stdcells/xor2_4.sym} 33900 -20020 0 0 {name=X_79152_ }
C {devices/lab_pin.sym} 33860 -19890 0 0 {name=p33435 lab=_63110_/B }
C {devices/lab_pin.sym} 33940 -19890 0 1 {name=p33436 lab=_61440_/A }
C {sky130_stdcells/buf_2.sym} 33900 -19890 0 0 {name=X_45544_ }
C {devices/lab_pin.sym} 33820 -19790 0 0 {name=p33437 lab=_76344_/Y }
C {devices/lab_pin.sym} 33820 -19750 0 0 {name=p33438 lab=_76348_/B }
C {devices/lab_pin.sym} 33820 -19710 0 0 {name=p33439 lab=_76347_/A }
C {devices/lab_pin.sym} 33980 -19750 0 1 {name=p33440 lab=_76364_/X }
C {sky130_stdcells/o21a_4.sym} 33900 -19750 0 0 {name=X_76364_ }
C {devices/lab_pin.sym} 33820 -19640 0 0 {name=p33441 lab=_41268_/X }
C {devices/lab_pin.sym} 33820 -19600 0 0 {name=p33442 lab=_42745_/X }
C {devices/lab_pin.sym} 33820 -19560 0 0 {name=p33443 lab=_69042_/B }
C {devices/lab_pin.sym} 33820 -19520 0 0 {name=p33444 lab=_42746_/X }
C {devices/lab_pin.sym} 33980 -19580 0 1 {name=p33445 lab=_42756_/X }
C {sky130_stdcells/a2bb2o_4.sym} 33900 -19580 0 0 {name=X_42756_ }
C {devices/lab_pin.sym} 33840 -19450 0 0 {name=p33446 lab=_61558_/A }
C {devices/lab_pin.sym} 33840 -19410 0 0 {name=p33447 lab=_61590_/B }
C {devices/lab_pin.sym} 33840 -19370 0 0 {name=p33448 lab=_61590_/C }
C {devices/lab_pin.sym} 33960 -19410 0 1 {name=p33449 lab=_61590_/Y }
C {sky130_stdcells/nand3_4.sym} 33900 -19410 0 0 {name=X_61590_ }
C {devices/lab_pin.sym} 33820 -19300 0 0 {name=p33450 lab=_68380_/Y }
C {devices/lab_pin.sym} 33820 -19260 0 0 {name=p33451 lab=_73319_/X }
C {devices/lab_pin.sym} 33820 -19220 0 0 {name=p33452 lab=_73551_/X }
C {devices/lab_pin.sym} 33820 -19180 0 0 {name=p33453 lab=_73575_/Y }
C {devices/lab_pin.sym} 33980 -19240 0 1 {name=p33454 lab=_73576_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -19240 0 0 {name=X_73576_ }
C {devices/lab_pin.sym} 33860 -19090 0 0 {name=p33455 lab=clkbuf_7_96_0_CLK/X }
C {devices/lab_pin.sym} 33940 -19090 0 1 {name=p33456 lab=clkbuf_9_387_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 33900 -19090 0 0 {name=Xclkbuf_8_193_0_CLK }
C {devices/lab_pin.sym} 33820 -18990 0 0 {name=p33457 lab=_52863_/B }
C {devices/lab_pin.sym} 33820 -18950 0 0 {name=p33458 lab=_70761_/A }
C {devices/lab_pin.sym} 33820 -18910 0 0 {name=p33459 lab=_70787_/Y }
C {devices/lab_pin.sym} 33980 -18950 0 1 {name=p33460 lab=_70788_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -18950 0 0 {name=X_70788_ }
C {devices/lab_pin.sym} 33840 -18820 0 0 {name=p33461 lab=_82565_/Q }
C {devices/lab_pin.sym} 33840 -18780 0 0 {name=p33462 lab=_78103_/B }
C {devices/lab_pin.sym} 33960 -18800 0 1 {name=p33463 lab=_78103_/Y }
C {sky130_stdcells/nor2_4.sym} 33900 -18800 0 0 {name=X_78103_ }
C {devices/lab_pin.sym} 33840 -18680 0 0 {name=p33464 lab=_80691_/Q }
C {devices/lab_pin.sym} 33840 -18640 0 0 {name=p33465 lab=_80991_/Q }
C {devices/lab_pin.sym} 33960 -18660 0 1 {name=p33466 lab=_75315_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -18660 0 0 {name=X_75315_ }
C {devices/lab_pin.sym} 33860 -18530 0 0 {name=p33467 lab=_41707_/A }
C {devices/lab_pin.sym} 33940 -18530 0 1 {name=p33468 lab=_88165_/D }
C {sky130_stdcells/inv_2.sym} 33900 -18530 0 0 {name=X_41707_ }
C {devices/lab_pin.sym} 33860 -18410 0 0 {name=p33469 lab=_48478_/A }
C {devices/lab_pin.sym} 33940 -18410 0 1 {name=p33470 lab=_48263_/X }
C {sky130_stdcells/buf_2.sym} 33900 -18410 0 0 {name=X_48263_ }
C {devices/lab_pin.sym} 33840 -18310 0 0 {name=p33471 lab=_63301_/C }
C {devices/lab_pin.sym} 33840 -18270 0 0 {name=p33472 lab=_60541_/B }
C {devices/lab_pin.sym} 33840 -18230 0 0 {name=p33473 lab=_60541_/C }
C {devices/lab_pin.sym} 33960 -18270 0 1 {name=p33474 lab=_60541_/Y }
C {sky130_stdcells/nor3_4.sym} 33900 -18270 0 0 {name=X_60541_ }
C {devices/lab_pin.sym} 33840 -18150 0 0 {name=p33475 lab=_72527_/A }
C {devices/lab_pin.sym} 33840 -18110 0 0 {name=p33476 lab=_72527_/B }
C {devices/lab_pin.sym} 33840 -18070 0 0 {name=p33477 lab=_79493_/B }
C {devices/lab_pin.sym} 33960 -18110 0 1 {name=p33478 lab=_72527_/Y }
C {sky130_stdcells/nand3_4.sym} 33900 -18110 0 0 {name=X_72527_ }
C {devices/lab_pin.sym} 33840 -17980 0 0 {name=p33479 lab=_79080_/A }
C {devices/lab_pin.sym} 33840 -17940 0 0 {name=p33480 lab=_82751_/Q }
C {devices/lab_pin.sym} 33960 -17960 0 1 {name=p33481 lab=_79083_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -17960 0 0 {name=X_79083_ }
C {devices/lab_pin.sym} 33860 -17830 0 0 {name=p33482 lab=_44932_/A }
C {devices/lab_pin.sym} 33940 -17830 0 1 {name=p33483 lab=_45490_/B }
C {sky130_stdcells/buf_2.sym} 33900 -17830 0 0 {name=X_45475_ }
C {devices/lab_pin.sym} 33820 -17730 0 0 {name=p33484 lab=_76272_/Y }
C {devices/lab_pin.sym} 33820 -17690 0 0 {name=p33485 lab=_76293_/Y }
C {devices/lab_pin.sym} 33820 -17650 0 0 {name=p33486 lab=_76294_/Y }
C {devices/lab_pin.sym} 33980 -17690 0 1 {name=p33487 lab=_76295_/Y }
C {sky130_stdcells/a21oi_4.sym} 33900 -17690 0 0 {name=X_76295_ }
C {devices/lab_pin.sym} 33860 -17550 0 0 {name=p33488 lab=_42590_/A }
C {devices/lab_pin.sym} 33940 -17550 0 1 {name=p33489 lab=_42687_/X }
C {sky130_stdcells/buf_2.sym} 33900 -17550 0 0 {name=X_42687_ }
C {devices/lab_pin.sym} 33840 -17440 0 0 {name=p33490 lab=_47196_/A }
C {devices/lab_pin.sym} 33840 -17400 0 0 {name=p33491 lab=_52918_/B }
C {devices/lab_pin.sym} 33960 -17420 0 1 {name=p33492 lab=_47214_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -17420 0 0 {name=X_47214_ }
C {devices/lab_pin.sym} 33860 -17290 0 0 {name=p33493 lab=_82177_/Q }
C {devices/lab_pin.sym} 33940 -17290 0 1 {name=p33494 lab=_78034_/Y }
C {sky130_stdcells/inv_2.sym} 33900 -17290 0 0 {name=X_78034_ }
C {devices/lab_pin.sym} 33860 -17170 0 0 {name=p33495 lab=_40362_/X }
C {devices/lab_pin.sym} 33940 -17170 0 1 {name=p33496 lab=_44548_/A }
C {sky130_stdcells/buf_2.sym} 33900 -17170 0 0 {name=X_44426_ }
C {devices/lab_pin.sym} 33820 -17090 0 0 {name=p33497 lab=_58396_/Y }
C {devices/lab_pin.sym} 33820 -17050 0 0 {name=p33498 lab=_63259_/X }
C {devices/lab_pin.sym} 33820 -17010 0 0 {name=p33499 lab=_63234_/X }
C {devices/lab_pin.sym} 33820 -16970 0 0 {name=p33500 lab=_58274_/A }
C {devices/lab_pin.sym} 33820 -16930 0 0 {name=p33501 lab=_63235_/X }
C {devices/lab_pin.sym} 33980 -17010 0 1 {name=p33502 lab=_63260_/Y }
C {sky130_stdcells/o32ai_4.sym} 33900 -17010 0 0 {name=X_63260_ }
C {devices/lab_pin.sym} 33820 -16870 0 0 {name=p33503 lab=_75230_/B }
C {devices/lab_pin.sym} 33820 -16830 0 0 {name=p33504 lab=_75228_/X }
C {devices/lab_pin.sym} 33820 -16790 0 0 {name=p33505 lab=_75223_/Y }
C {devices/lab_pin.sym} 33980 -16830 0 1 {name=p33506 lab=_75246_/Y }
C {sky130_stdcells/a21boi_4.sym} 33900 -16830 0 0 {name=X_75246_ }
C {devices/lab_pin.sym} 33860 -16690 0 0 {name=p33507 lab=_41799_/A }
C {devices/lab_pin.sym} 33940 -16690 0 1 {name=p33508 lab=_41638_/X }
C {sky130_stdcells/buf_2.sym} 33900 -16690 0 0 {name=X_41638_ }
C {devices/lab_pin.sym} 33820 -16590 0 0 {name=p33509 lab=_72361_/X }
C {devices/lab_pin.sym} 33820 -16550 0 0 {name=p33510 lab=_85668_/Q }
C {devices/lab_pin.sym} 33820 -16510 0 0 {name=p33511 lab=_72362_/X }
C {devices/lab_pin.sym} 33980 -16550 0 1 {name=p33512 lab=_72458_/X }
C {sky130_stdcells/o21a_4.sym} 33900 -16550 0 0 {name=X_72458_ }
C {devices/lab_pin.sym} 33860 -16410 0 0 {name=p33513 lab=_48193_/X }
C {devices/lab_pin.sym} 33940 -16410 0 1 {name=p33514 lab=_48194_/X }
C {sky130_stdcells/buf_2.sym} 33900 -16410 0 0 {name=X_48194_ }
C {devices/lab_pin.sym} 33840 -16320 0 0 {name=p33515 lab=_60472_/A }
C {devices/lab_pin.sym} 33840 -16280 0 0 {name=p33516 lab=_60606_/A }
C {devices/lab_pin.sym} 33840 -16240 0 0 {name=p33517 lab=_60430_/Y }
C {devices/lab_pin.sym} 33840 -16200 0 0 {name=p33518 lab=_60443_/A }
C {devices/lab_pin.sym} 33960 -16260 0 1 {name=p33519 lab=_60493_/A }
C {sky130_stdcells/nand4_4.sym} 33900 -16260 0 0 {name=X_60472_ }
C {devices/lab_pin.sym} 33860 -16110 0 0 {name=p33520 lab=clkbuf_7_69_0_CLK/A }
C {devices/lab_pin.sym} 33940 -16110 0 1 {name=p33521 lab=clkbuf_7_68_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 33900 -16110 0 0 {name=Xclkbuf_7_68_0_CLK }
C {devices/lab_pin.sym} 33860 -15990 0 0 {name=p33522 lab=_85557_/CLK }
C {devices/lab_pin.sym} 33940 -15990 0 1 {name=p33523 lab=_83297_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 33900 -15990 0 0 {name=Xclkbuf_opt_19_CLK }
C {devices/lab_pin.sym} 33840 -15900 0 0 {name=p33524 lab=_61301_/X }
C {devices/lab_pin.sym} 33840 -15860 0 0 {name=p33525 lab=_62560_/B }
C {devices/lab_pin.sym} 33840 -15820 0 0 {name=p33526 lab=_62560_/C }
C {devices/lab_pin.sym} 33840 -15780 0 0 {name=p33527 lab=_62211_/D }
C {devices/lab_pin.sym} 33960 -15840 0 1 {name=p33528 lab=_62211_/Y }
C {sky130_stdcells/nand4_4.sym} 33900 -15840 0 0 {name=X_62211_ }
C {devices/lab_pin.sym} 33860 -15690 0 0 {name=p33529 lab=_47004_/A }
C {devices/lab_pin.sym} 33940 -15690 0 1 {name=p33530 lab=_47145_/X }
C {sky130_stdcells/buf_2.sym} 33900 -15690 0 0 {name=X_47145_ }
C {devices/lab_pin.sym} 33840 -15590 0 0 {name=p33531 lab=_70682_/A }
C {devices/lab_pin.sym} 33840 -15550 0 0 {name=p33532 lab=_71411_/B }
C {devices/lab_pin.sym} 33840 -15510 0 0 {name=p33533 lab=_71411_/C }
C {devices/lab_pin.sym} 33960 -15550 0 1 {name=p33534 lab=_71409_/Y }
C {sky130_stdcells/nor3_4.sym} 33900 -15550 0 0 {name=X_71409_ }
C {devices/lab_pin.sym} 33820 -15440 0 0 {name=p33535 lab=_41721_/X }
C {devices/lab_pin.sym} 33820 -15400 0 0 {name=p33536 lab=_44345_/X }
C {devices/lab_pin.sym} 33820 -15360 0 0 {name=p33537 lab=_87150_/Q }
C {devices/lab_pin.sym} 33820 -15320 0 0 {name=p33538 lab=_44346_/X }
C {devices/lab_pin.sym} 33980 -15380 0 1 {name=p33539 lab=_44357_/X }
C {sky130_stdcells/a2bb2o_4.sym} 33900 -15380 0 0 {name=X_44357_ }
C {devices/lab_pin.sym} 33820 -15270 0 0 {name=p33540 lab=_58377_/A }
C {devices/lab_pin.sym} 33820 -15230 0 0 {name=p33541 lab=_63190_/X }
C {devices/lab_pin.sym} 33820 -15190 0 0 {name=p33542 lab=_63175_/X }
C {devices/lab_pin.sym} 33820 -15150 0 0 {name=p33543 lab=_58251_/A }
C {devices/lab_pin.sym} 33820 -15110 0 0 {name=p33544 lab=_63176_/X }
C {devices/lab_pin.sym} 33980 -15190 0 1 {name=p33545 lab=_63191_/Y }
C {sky130_stdcells/o32ai_4.sym} 33900 -15190 0 0 {name=X_63191_ }
C {devices/lab_pin.sym} 33820 -15050 0 0 {name=p33546 lab=_75178_/A }
C {devices/lab_pin.sym} 33820 -15010 0 0 {name=p33547 lab=_75178_/B }
C {devices/lab_pin.sym} 33820 -14970 0 0 {name=p33548 lab=_75178_/C }
C {devices/lab_pin.sym} 33980 -15010 0 1 {name=p33549 lab=_75180_/A }
C {sky130_stdcells/a21oi_4.sym} 33900 -15010 0 0 {name=X_75177_ }
C {devices/lab_pin.sym} 33820 -14890 0 0 {name=p33550 lab=_41548_/X }
C {devices/lab_pin.sym} 33820 -14850 0 0 {name=p33551 lab=_82316_/Q }
C {devices/lab_pin.sym} 33820 -14810 0 0 {name=p33552 lab=_41568_/X }
C {devices/lab_pin.sym} 33980 -14850 0 1 {name=p33553 lab=_41569_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -14850 0 0 {name=X_41569_ }
C {devices/lab_pin.sym} 33860 -14710 0 0 {name=p33554 lab=_72123_/A }
C {devices/lab_pin.sym} 33940 -14710 0 1 {name=p33555 lab=_72389_/X }
C {sky130_stdcells/buf_2.sym} 33900 -14710 0 0 {name=X_72389_ }
C {devices/lab_pin.sym} 33860 -14590 0 0 {name=p33556 lab=_43212_/A }
C {devices/lab_pin.sym} 33940 -14590 0 1 {name=p33557 lab=_43308_/X }
C {sky130_stdcells/buf_2.sym} 33900 -14590 0 0 {name=X_43308_ }
C {devices/lab_pin.sym} 33840 -14500 0 0 {name=p33558 lab=_62142_/A }
C {devices/lab_pin.sym} 33840 -14460 0 0 {name=p33559 lab=_62138_/Y }
C {devices/lab_pin.sym} 33840 -14420 0 0 {name=p33560 lab=_62139_/Y }
C {devices/lab_pin.sym} 33840 -14380 0 0 {name=p33561 lab=_62141_/Y }
C {devices/lab_pin.sym} 33960 -14440 0 1 {name=p33562 lab=_62142_/Y }
C {sky130_stdcells/nand4_4.sym} 33900 -14440 0 0 {name=X_62142_ }
C {devices/lab_pin.sym} 33820 -14320 0 0 {name=p33563 lab=_74080_/X }
C {devices/lab_pin.sym} 33820 -14280 0 0 {name=p33564 lab=_86217_/Q }
C {devices/lab_pin.sym} 33820 -14240 0 0 {name=p33565 lab=_74103_/X }
C {devices/lab_pin.sym} 33820 -14200 0 0 {name=p33566 lab=_74127_/X }
C {devices/lab_pin.sym} 33980 -14260 0 1 {name=p33567 lab=_74128_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -14260 0 0 {name=X_74128_ }
C {devices/lab_pin.sym} 33820 -14130 0 0 {name=p33568 lab=_47072_/Y }
C {devices/lab_pin.sym} 33820 -14090 0 0 {name=p33569 lab=_47035_/X }
C {devices/lab_pin.sym} 33820 -14050 0 0 {name=p33570 lab=_47075_/X }
C {devices/lab_pin.sym} 33980 -14090 0 1 {name=p33571 lab=_86673_/D }
C {sky130_stdcells/a21oi_4.sym} 33900 -14090 0 0 {name=X_47076_ }
C {devices/lab_pin.sym} 33860 -13950 0 0 {name=p33572 lab=_44287_/X }
C {devices/lab_pin.sym} 33940 -13950 0 1 {name=p33573 lab=_44288_/X }
C {sky130_stdcells/buf_2.sym} 33900 -13950 0 0 {name=X_44288_ }
C {devices/lab_pin.sym} 33840 -13840 0 0 {name=p33574 lab=_79985_/A }
C {devices/lab_pin.sym} 33840 -13800 0 0 {name=p33575 lab=_79985_/B }
C {devices/lab_pin.sym} 33960 -13820 0 1 {name=p33576 lab=_79985_/Y }
C {sky130_stdcells/xnor2_4.sym} 33900 -13820 0 0 {name=X_79985_ }
C {devices/lab_pin.sym} 33820 -13720 0 0 {name=p33577 lab=_41460_/Y }
C {devices/lab_pin.sym} 33820 -13680 0 0 {name=p33578 lab=_46022_/X }
C {devices/lab_pin.sym} 33820 -13640 0 0 {name=p33579 lab=_66544_/B }
C {devices/lab_pin.sym} 33820 -13600 0 0 {name=p33580 lab=_46023_/X }
C {devices/lab_pin.sym} 33980 -13660 0 1 {name=p33581 lab=_46027_/X }
C {sky130_stdcells/a2bb2o_4.sym} 33900 -13660 0 0 {name=X_46027_ }
C {devices/lab_pin.sym} 33820 -13540 0 0 {name=p33582 lab=_41028_/X }
C {devices/lab_pin.sym} 33820 -13500 0 0 {name=p33583 lab=_43216_/X }
C {devices/lab_pin.sym} 33820 -13460 0 0 {name=p33584 lab=_87523_/Q }
C {devices/lab_pin.sym} 33820 -13420 0 0 {name=p33585 lab=_43218_/X }
C {devices/lab_pin.sym} 33980 -13480 0 1 {name=p33586 lab=_87523_/D }
C {sky130_stdcells/a2bb2o_4.sym} 33900 -13480 0 0 {name=X_43239_ }
C {devices/lab_pin.sym} 33820 -13360 0 0 {name=p33587 lab=_74012_/X }
C {devices/lab_pin.sym} 33820 -13320 0 0 {name=p33588 lab=_86220_/Q }
C {devices/lab_pin.sym} 33820 -13280 0 0 {name=p33589 lab=_73948_/X }
C {devices/lab_pin.sym} 33820 -13240 0 0 {name=p33590 lab=_74058_/X }
C {devices/lab_pin.sym} 33980 -13300 0 1 {name=p33591 lab=_74059_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -13300 0 0 {name=X_74059_ }
C {devices/lab_pin.sym} 33840 -13160 0 0 {name=p33592 lab=_66902_/X }
C {devices/lab_pin.sym} 33840 -13120 0 0 {name=p33593 lab=_86822_/Q }
C {devices/lab_pin.sym} 33960 -13140 0 1 {name=p33594 lab=_66950_/X }
C {sky130_stdcells/and2_4.sym} 33900 -13140 0 0 {name=X_66950_ }
C {devices/lab_pin.sym} 33840 -13040 0 0 {name=p33595 lab=_61593_/B }
C {devices/lab_pin.sym} 33840 -13000 0 0 {name=p33596 lab=_62007_/X }
C {devices/lab_pin.sym} 33840 -12960 0 0 {name=p33597 lab=_62149_/C }
C {devices/lab_pin.sym} 33840 -12920 0 0 {name=p33598 lab=_62008_/X }
C {devices/lab_pin.sym} 33960 -12980 0 1 {name=p33599 lab=_62077_/B }
C {sky130_stdcells/nand4_4.sym} 33900 -12980 0 0 {name=X_62073_ }
C {devices/lab_pin.sym} 33820 -12850 0 0 {name=p33600 lab=_78921_/A }
C {devices/lab_pin.sym} 33820 -12810 0 0 {name=p33601 lab=_82511_/D }
C {devices/lab_pin.sym} 33820 -12770 0 0 {name=p33602 lab=_78935_/X }
C {devices/lab_pin.sym} 33980 -12810 0 1 {name=p33603 lab=_78937_/B }
C {sky130_stdcells/o21ai_4.sym} 33900 -12810 0 0 {name=X_78936_ }
C {devices/lab_pin.sym} 33860 -12670 0 0 {name=p33604 lab=clkbuf_7_65_0_CLK/X }
C {devices/lab_pin.sym} 33940 -12670 0 1 {name=p33605 lab=clkbuf_9_262_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 33900 -12670 0 0 {name=Xclkbuf_8_131_0_CLK }
C {devices/lab_pin.sym} 33840 -12570 0 0 {name=p33606 lab=_65916_/A }
C {devices/lab_pin.sym} 33840 -12530 0 0 {name=p33607 lab=_65916_/B }
C {devices/lab_pin.sym} 33840 -12490 0 0 {name=p33608 lab=_65901_/C }
C {devices/lab_pin.sym} 33960 -12530 0 1 {name=p33609 lab=_65901_/X }
C {sky130_stdcells/and3_4.sym} 33900 -12530 0 0 {name=X_65901_ }
C {devices/lab_pin.sym} 33840 -12400 0 0 {name=p33610 lab=_60937_/B }
C {devices/lab_pin.sym} 33840 -12360 0 0 {name=p33611 lab=_61024_/B }
C {devices/lab_pin.sym} 33960 -12380 0 1 {name=p33612 lab=_61024_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -12380 0 0 {name=X_61024_ }
C {devices/lab_pin.sym} 33820 -12280 0 0 {name=p33613 lab=_87430_/Q }
C {devices/lab_pin.sym} 33820 -12240 0 0 {name=p33614 lab=_66878_/X }
C {devices/lab_pin.sym} 33820 -12200 0 0 {name=p33615 lab=_66879_/X }
C {devices/lab_pin.sym} 33820 -12160 0 0 {name=p33616 lab=_66880_/X }
C {devices/lab_pin.sym} 33980 -12220 0 1 {name=p33617 lab=_66881_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -12220 0 0 {name=X_66881_ }
C {devices/lab_pin.sym} 33840 -12080 0 0 {name=p33618 lab=_78865_/X }
C {devices/lab_pin.sym} 33840 -12040 0 0 {name=p33619 lab=_78867_/B }
C {devices/lab_pin.sym} 33960 -12060 0 1 {name=p33620 lab=_78867_/Y }
C {sky130_stdcells/nor2_4.sym} 33900 -12060 0 0 {name=X_78867_ }
C {devices/lab_pin.sym} 33820 -11950 0 0 {name=p33621 lab=_68616_/X }
C {devices/lab_pin.sym} 33820 -11910 0 0 {name=p33622 lab=_68619_/X }
C {devices/lab_pin.sym} 33820 -11870 0 0 {name=p33623 lab=_68470_/X }
C {devices/lab_pin.sym} 33980 -11910 0 1 {name=p33624 lab=_68620_/X }
C {sky130_stdcells/a21o_4.sym} 33900 -11910 0 0 {name=X_68620_ }
C {devices/lab_pin.sym} 33820 -11790 0 0 {name=p33625 lab=_65829_/Y }
C {devices/lab_pin.sym} 33820 -11750 0 0 {name=p33626 lab=_65830_/X }
C {devices/lab_pin.sym} 33820 -11710 0 0 {name=p33627 lab=_65831_/X }
C {devices/lab_pin.sym} 33980 -11750 0 1 {name=p33628 lab=_65832_/X }
C {sky130_stdcells/a21o_4.sym} 33900 -11750 0 0 {name=X_65832_ }
C {devices/lab_pin.sym} 33860 -11610 0 0 {name=p33629 lab=_77807_/Y }
C {devices/lab_pin.sym} 33940 -11610 0 1 {name=p33630 lab=_77818_/Y }
C {sky130_stdcells/inv_2.sym} 33900 -11610 0 0 {name=X_77818_ }
C {devices/lab_pin.sym} 33860 -11490 0 0 {name=p33631 lab=_47978_/A }
C {devices/lab_pin.sym} 33940 -11490 0 1 {name=p33632 lab=_50302_/B }
C {sky130_stdcells/buf_2.sym} 33900 -11490 0 0 {name=X_47978_ }
C {devices/lab_pin.sym} 33860 -11370 0 0 {name=p33633 lab=_78798_/A }
C {devices/lab_pin.sym} 33940 -11370 0 1 {name=p33634 lab=_78799_/B }
C {sky130_stdcells/inv_2.sym} 33900 -11370 0 0 {name=X_78798_ }
C {devices/lab_pin.sym} 33840 -11260 0 0 {name=p33635 lab=_49716_/X }
C {devices/lab_pin.sym} 33840 -11220 0 0 {name=p33636 lab=_52931_/B }
C {devices/lab_pin.sym} 33960 -11240 0 1 {name=p33637 lab=_49717_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -11240 0 0 {name=X_49717_ }
C {devices/lab_pin.sym} 33840 -11120 0 0 {name=p33638 lab=_68548_/X }
C {devices/lab_pin.sym} 33840 -11080 0 0 {name=p33639 lab=_68551_/B }
C {devices/lab_pin.sym} 33960 -11100 0 1 {name=p33640 lab=_68551_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -11100 0 0 {name=X_68551_ }
C {devices/lab_pin.sym} 33860 -10970 0 0 {name=p33641 lab=_54446_/B }
C {devices/lab_pin.sym} 33940 -10970 0 1 {name=p33642 lab=_52752_/B }
C {sky130_stdcells/buf_2.sym} 33900 -10970 0 0 {name=X_46929_ }
C {devices/lab_pin.sym} 33860 -10850 0 0 {name=p33643 lab=clkbuf_7_73_0_CLK/X }
C {devices/lab_pin.sym} 33940 -10850 0 1 {name=p33644 lab=clkbuf_8_146_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 33900 -10850 0 0 {name=Xclkbuf_8_146_0_CLK }
C {devices/lab_pin.sym} 33840 -10740 0 0 {name=p33645 lab=_65763_/A }
C {devices/lab_pin.sym} 33840 -10700 0 0 {name=p33646 lab=_85867_/Q }
C {devices/lab_pin.sym} 33960 -10720 0 1 {name=p33647 lab=_65763_/X }
C {sky130_stdcells/and2_4.sym} 33900 -10720 0 0 {name=X_65763_ }
C {devices/lab_pin.sym} 33860 -10590 0 0 {name=p33648 lab=_82052_/Q }
C {devices/lab_pin.sym} 33940 -10590 0 1 {name=p33649 lab=_77751_/B }
C {sky130_stdcells/inv_2.sym} 33900 -10590 0 0 {name=X_77749_ }
C {devices/lab_pin.sym} 33840 -10500 0 0 {name=p33650 lab=_62967_/A }
C {devices/lab_pin.sym} 33840 -10460 0 0 {name=p33651 lab=_63335_/A }
C {devices/lab_pin.sym} 33840 -10420 0 0 {name=p33652 lab=_62939_/X }
C {devices/lab_pin.sym} 33840 -10380 0 0 {name=p33653 lab=_62975_/D }
C {devices/lab_pin.sym} 33960 -10440 0 1 {name=p33654 lab=_62975_/X }
C {sky130_stdcells/and4_4.sym} 33900 -10440 0 0 {name=X_62975_ }
C {devices/lab_pin.sym} 33860 -10290 0 0 {name=p33655 lab=clkbuf_9_70_0_CLK/X }
C {devices/lab_pin.sym} 33940 -10290 0 1 {name=p33656 lab=_81259_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 33900 -10290 0 0 {name=Xclkbuf_10_141_0_CLK }
C {devices/lab_pin.sym} 33860 -10170 0 0 {name=p33657 lab=_67025_/X }
C {devices/lab_pin.sym} 33940 -10170 0 1 {name=p33658 lab=_67502_/X }
C {sky130_stdcells/buf_2.sym} 33900 -10170 0 0 {name=X_67502_ }
C {devices/lab_pin.sym} 33860 -10050 0 0 {name=p33659 lab=_64752_/A }
C {devices/lab_pin.sym} 33940 -10050 0 1 {name=p33660 lab=_64714_/X }
C {sky130_stdcells/buf_2.sym} 33900 -10050 0 0 {name=X_64714_ }
C {devices/lab_pin.sym} 33840 -9940 0 0 {name=p33661 lab=_49638_/A }
C {devices/lab_pin.sym} 33840 -9900 0 0 {name=p33662 lab=_52863_/B }
C {devices/lab_pin.sym} 33960 -9920 0 1 {name=p33663 lab=_49648_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -9920 0 0 {name=X_49648_ }
C {devices/lab_pin.sym} 33820 -9830 0 0 {name=p33664 lab=_61915_/X }
C {devices/lab_pin.sym} 33820 -9790 0 0 {name=p33665 lab=_61918_/X }
C {devices/lab_pin.sym} 33820 -9750 0 0 {name=p33666 lab=_61925_/Y }
C {devices/lab_pin.sym} 33820 -9710 0 0 {name=p33667 lab=_84741_/Q }
C {devices/lab_pin.sym} 33820 -9670 0 0 {name=p33668 lab=_61895_/X }
C {devices/lab_pin.sym} 33980 -9750 0 1 {name=p33669 lab=_61926_/Y }
C {sky130_stdcells/o32ai_4.sym} 33900 -9750 0 0 {name=X_61926_ }
C {devices/lab_pin.sym} 33860 -9590 0 0 {name=p33670 lab=clkbuf_9_385_0_CLK/X }
C {devices/lab_pin.sym} 33940 -9590 0 1 {name=p33671 lab=_82532_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 33900 -9590 0 0 {name=Xclkbuf_10_771_0_CLK }
C {devices/lab_pin.sym} 33810 -9470 0 0 {name=p33672 lab=_80792_/CLK }
C {devices/lab_pin.sym} 33810 -9450 0 0 {name=p33673 lab=_80760_/D }
C {devices/lab_pin.sym} 33990 -9470 0 1 {name=p33674 lab=_81136_/D }
C {sky130_stdcells/dfxtp_4.sym} 33900 -9460 0 0 {name=X_80760_ }
C {devices/lab_pin.sym} 33840 -9340 0 0 {name=p33675 lab=_68452_/A }
C {devices/lab_pin.sym} 33840 -9300 0 0 {name=p33676 lab=_87247_/Q }
C {devices/lab_pin.sym} 33960 -9320 0 1 {name=p33677 lab=_68482_/X }
C {sky130_stdcells/and2_4.sym} 33900 -9320 0 0 {name=X_68482_ }
C {devices/lab_pin.sym} 33840 -9200 0 0 {name=p33678 lab=_65694_/A }
C {devices/lab_pin.sym} 33840 -9160 0 0 {name=p33679 lab=_65694_/B }
C {devices/lab_pin.sym} 33960 -9180 0 1 {name=p33680 lab=_65694_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -9180 0 0 {name=X_65694_ }
C {devices/lab_pin.sym} 33860 -9050 0 0 {name=p33681 lab=_67312_/X }
C {devices/lab_pin.sym} 33940 -9050 0 1 {name=p33682 lab=_67433_/X }
C {sky130_stdcells/buf_2.sym} 33900 -9050 0 0 {name=X_67433_ }
C {devices/lab_pin.sym} 33840 -8940 0 0 {name=p33683 lab=_79419_/A }
C {devices/lab_pin.sym} 33840 -8900 0 0 {name=p33684 lab=_79419_/B }
C {devices/lab_pin.sym} 33960 -8920 0 1 {name=p33685 lab=_79419_/X }
C {sky130_stdcells/or2_4.sym} 33900 -8920 0 0 {name=X_79419_ }
C {devices/lab_pin.sym} 33820 -8810 0 0 {name=p33686 lab=_64641_/X }
C {devices/lab_pin.sym} 33820 -8770 0 0 {name=p33687 lab=_64644_/X }
C {devices/lab_pin.sym} 33820 -8730 0 0 {name=p33688 lab=_64619_/X }
C {devices/lab_pin.sym} 33980 -8770 0 1 {name=p33689 lab=_64649_/A }
C {sky130_stdcells/a21o_4.sym} 33900 -8770 0 0 {name=X_64645_ }
C {devices/lab_pin.sym} 33860 -8630 0 0 {name=p33690 lab=clkbuf_9_262_0_CLK/A }
C {devices/lab_pin.sym} 33940 -8630 0 1 {name=p33691 lab=clkbuf_9_262_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 33900 -8630 0 0 {name=Xclkbuf_9_262_0_CLK }
C {devices/lab_pin.sym} 33860 -8510 0 0 {name=p33692 lab=_49496_/A }
C {devices/lab_pin.sym} 33940 -8510 0 1 {name=p33693 lab=_49579_/X }
C {sky130_stdcells/buf_2.sym} 33900 -8510 0 0 {name=X_49579_ }
C {devices/lab_pin.sym} 33810 -8390 0 0 {name=p33694 lab=_80676_/CLK }
C {devices/lab_pin.sym} 33810 -8370 0 0 {name=p33695 lab=_80691_/D }
C {devices/lab_pin.sym} 33990 -8390 0 1 {name=p33696 lab=_80691_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -8380 0 0 {name=X_80691_ }
C {devices/lab_pin.sym} 33840 -8280 0 0 {name=p33697 lab=_61428_/X }
C {devices/lab_pin.sym} 33840 -8240 0 0 {name=p33698 lab=_61874_/B }
C {devices/lab_pin.sym} 33840 -8200 0 0 {name=p33699 lab=_61809_/C }
C {devices/lab_pin.sym} 33840 -8160 0 0 {name=p33700 lab=_61874_/D }
C {devices/lab_pin.sym} 33960 -8220 0 1 {name=p33701 lab=_61857_/Y }
C {sky130_stdcells/nand4_4.sym} 33900 -8220 0 0 {name=X_61857_ }
C {devices/lab_pin.sym} 33820 -8090 0 0 {name=p33702 lab=_51606_/Y }
C {devices/lab_pin.sym} 33820 -8050 0 0 {name=p33703 lab=_51585_/X }
C {devices/lab_pin.sym} 33820 -8010 0 0 {name=p33704 lab=_51609_/X }
C {devices/lab_pin.sym} 33980 -8050 0 1 {name=p33705 lab=_51610_/Y }
C {sky130_stdcells/a21oi_4.sym} 33900 -8050 0 0 {name=X_51610_ }
C {devices/lab_pin.sym} 33810 -7910 0 0 {name=p33706 lab=_84119_/CLK }
C {devices/lab_pin.sym} 33810 -7890 0 0 {name=p33707 lab=_82462_/Q }
C {devices/lab_pin.sym} 33990 -7910 0 1 {name=p33708 lab=_78729_/A }
C {sky130_stdcells/dfxtp_4.sym} 33900 -7900 0 0 {name=X_82430_ }
C {devices/lab_pin.sym} 33820 -7810 0 0 {name=p33709 lab=_60805_/Y }
C {devices/lab_pin.sym} 33820 -7770 0 0 {name=p33710 lab=_60743_/X }
C {devices/lab_pin.sym} 33820 -7730 0 0 {name=p33711 lab=_60696_/Y }
C {devices/lab_pin.sym} 33820 -7690 0 0 {name=p33712 lab=_60781_/Y }
C {devices/lab_pin.sym} 33820 -7660 0 0 {name=p33713 lab=_60807_/Y }
C {devices/lab_pin.sym} 33980 -7730 0 1 {name=p33714 lab=_84562_/D }
C {sky130_stdcells/a41oi_4.sym} 33900 -7730 0 0 {name=X_60808_ }
C {devices/lab_pin.sym} 33860 -7570 0 0 {name=p33715 lab=_67126_/X }
C {devices/lab_pin.sym} 33940 -7570 0 1 {name=p33716 lab=_67364_/X }
C {sky130_stdcells/buf_2.sym} 33900 -7570 0 0 {name=X_67364_ }
C {devices/lab_pin.sym} 33860 -7450 0 0 {name=p33717 lab=clkbuf_9_78_0_CLK/X }
C {devices/lab_pin.sym} 33940 -7450 0 1 {name=p33718 lab=_81279_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 33900 -7450 0 0 {name=Xclkbuf_10_156_0_CLK }
C {devices/lab_pin.sym} 33840 -7340 0 0 {name=p33719 lab=_52590_/A }
C {devices/lab_pin.sym} 33840 -7300 0 0 {name=p33720 lab=_52590_/B }
C {devices/lab_pin.sym} 33960 -7320 0 1 {name=p33721 lab=_52590_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -7320 0 0 {name=X_52590_ }
C {devices/lab_pin.sym} 33860 -7190 0 0 {name=p33722 lab=_58124_/A }
C {devices/lab_pin.sym} 33940 -7190 0 1 {name=p33723 lab=_64797_/A }
C {sky130_stdcells/buf_2.sym} 33900 -7190 0 0 {name=X_64576_ }
C {devices/lab_pin.sym} 33860 -7070 0 0 {name=p33724 lab=_61787_/X }
C {devices/lab_pin.sym} 33940 -7070 0 1 {name=p33725 lab=_61788_/X }
C {sky130_stdcells/buf_2.sym} 33900 -7070 0 0 {name=X_61788_ }
C {devices/lab_pin.sym} 33860 -6950 0 0 {name=p33726 lab=_69611_/A }
C {devices/lab_pin.sym} 33940 -6950 0 1 {name=p33727 lab=_69103_/X }
C {sky130_stdcells/buf_2.sym} 33900 -6950 0 0 {name=X_69103_ }
C {sky130_stdcells/decap_3.sym} 33900 -6800 0 0 {name=XPHY_709 }
C {devices/lab_pin.sym} 33840 -6660 0 0 {name=p33728 lab=_66312_/X }
C {devices/lab_pin.sym} 33840 -6620 0 0 {name=p33729 lab=_66314_/X }
C {devices/lab_pin.sym} 33960 -6640 0 1 {name=p33730 lab=_66315_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -6640 0 0 {name=X_66315_ }
C {devices/lab_pin.sym} 33860 -6510 0 0 {name=p33731 lab=clkbuf_9_393_0_CLK/X }
C {devices/lab_pin.sym} 33940 -6510 0 1 {name=p33732 lab=_82624_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 33900 -6510 0 0 {name=Xclkbuf_10_786_0_CLK }
C {devices/lab_pin.sym} 33840 -6400 0 0 {name=p33733 lab=_51545_/A }
C {devices/lab_pin.sym} 33840 -6360 0 0 {name=p33734 lab=_53067_/B }
C {devices/lab_pin.sym} 33960 -6380 0 1 {name=p33735 lab=_51541_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -6380 0 0 {name=X_51541_ }
C {devices/lab_pin.sym} 33820 -6290 0 0 {name=p33736 lab=_63495_/X }
C {devices/lab_pin.sym} 33820 -6250 0 0 {name=p33737 lab=_63520_/X }
C {devices/lab_pin.sym} 33820 -6210 0 0 {name=p33738 lab=_63521_/X }
C {devices/lab_pin.sym} 33820 -6170 0 0 {name=p33739 lab=_63525_/X }
C {devices/lab_pin.sym} 33820 -6130 0 0 {name=p33740 lab=_63526_/Y }
C {devices/lab_pin.sym} 33980 -6210 0 1 {name=p33741 lab=_63527_/Y }
C {sky130_stdcells/o41ai_4.sym} 33900 -6210 0 0 {name=X_63527_ }
C {devices/lab_pin.sym} 33810 -6050 0 0 {name=p33742 lab=_84981_/CLK }
C {devices/lab_pin.sym} 33810 -6030 0 0 {name=p33743 lab=_77220_/X }
C {devices/lab_pin.sym} 33990 -6050 0 1 {name=p33744 lab=_47926_/A }
C {sky130_stdcells/dfxtp_4.sym} 33900 -6040 0 0 {name=X_82361_ }
C {devices/lab_pin.sym} 33860 -5910 0 0 {name=p33745 lab=_60738_/Y }
C {devices/lab_pin.sym} 33940 -5910 0 1 {name=p33746 lab=_60739_/X }
C {sky130_stdcells/buf_2.sym} 33900 -5910 0 0 {name=X_60739_ }
C {devices/lab_pin.sym} 33820 -5820 0 0 {name=p33747 lab=_87925_/Q }
C {devices/lab_pin.sym} 33820 -5780 0 0 {name=p33748 lab=_67293_/X }
C {devices/lab_pin.sym} 33820 -5740 0 0 {name=p33749 lab=_67271_/X }
C {devices/lab_pin.sym} 33820 -5700 0 0 {name=p33750 lab=_67294_/X }
C {devices/lab_pin.sym} 33980 -5760 0 1 {name=p33751 lab=_67295_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -5760 0 0 {name=X_67295_ }
C {devices/lab_pin.sym} 33810 -5610 0 0 {name=p33752 lab=_84105_/CLK }
C {devices/lab_pin.sym} 33810 -5590 0 0 {name=p33753 lab=_66709_/X }
C {devices/lab_pin.sym} 33990 -5610 0 1 {name=p33754 lab=_84100_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -5600 0 0 {name=X_84100_ }
C {devices/lab_pin.sym} 33810 -5470 0 0 {name=p33755 lab=_81801_/CLK }
C {devices/lab_pin.sym} 33810 -5450 0 0 {name=p33756 lab=_77000_/X }
C {devices/lab_pin.sym} 33990 -5470 0 1 {name=p33757 lab=_81280_/D }
C {sky130_stdcells/dfxtp_4.sym} 33900 -5460 0 0 {name=X_81312_ }
C {devices/lab_pin.sym} 33820 -5360 0 0 {name=p33758 lab=_87480_/Q }
C {devices/lab_pin.sym} 33820 -5320 0 0 {name=p33759 lab=_68989_/X }
C {devices/lab_pin.sym} 33820 -5280 0 0 {name=p33760 lab=_69010_/X }
C {devices/lab_pin.sym} 33820 -5240 0 0 {name=p33761 lab=_69033_/X }
C {devices/lab_pin.sym} 33980 -5300 0 1 {name=p33762 lab=_69034_/X }
C {sky130_stdcells/a211o_4.sym} 33900 -5300 0 0 {name=X_69034_ }
C {devices/lab_pin.sym} 33820 -5170 0 0 {name=p33763 lab=_54258_/Y }
C {devices/lab_pin.sym} 33820 -5130 0 0 {name=p33764 lab=_54253_/X }
C {devices/lab_pin.sym} 33820 -5090 0 0 {name=p33765 lab=_54259_/X }
C {devices/lab_pin.sym} 33980 -5130 0 1 {name=p33766 lab=_85475_/D }
C {sky130_stdcells/a21oi_4.sym} 33900 -5130 0 0 {name=X_54260_ }
C {devices/lab_pin.sym} 33820 -5010 0 0 {name=p33767 lab=_66179_/X }
C {devices/lab_pin.sym} 33820 -4970 0 0 {name=p33768 lab=_66244_/Y }
C {devices/lab_pin.sym} 33820 -4930 0 0 {name=p33769 lab=_66245_/Y }
C {devices/lab_pin.sym} 33980 -4970 0 1 {name=p33770 lab=_66246_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -4970 0 0 {name=X_66246_ }
C {devices/lab_pin.sym} 33860 -4830 0 0 {name=p33771 lab=clkbuf_9_277_0_CLK/A }
C {devices/lab_pin.sym} 33940 -4830 0 1 {name=p33772 lab=clkbuf_9_277_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 33900 -4830 0 0 {name=Xclkbuf_9_277_0_CLK }
C {devices/lab_pin.sym} 33810 -4710 0 0 {name=p33773 lab=_85083_/CLK }
C {devices/lab_pin.sym} 33810 -4690 0 0 {name=p33774 lab=_85080_/D }
C {devices/lab_pin.sym} 33990 -4710 0 1 {name=p33775 lab=_85080_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -4700 0 0 {name=X_85080_ }
C {devices/lab_pin.sym} 33860 -4570 0 0 {name=p33776 lab=_51552_/A }
C {devices/lab_pin.sym} 33940 -4570 0 1 {name=p33777 lab=_51494_/C }
C {sky130_stdcells/buf_2.sym} 33900 -4570 0 0 {name=X_51472_ }
C {devices/lab_pin.sym} 33860 -4450 0 0 {name=p33778 lab=_63458_/A }
C {devices/lab_pin.sym} 33940 -4450 0 1 {name=p33779 lab=_63458_/X }
C {sky130_stdcells/buf_2.sym} 33900 -4450 0 0 {name=X_63458_ }
C {devices/lab_pin.sym} 33810 -4330 0 0 {name=p33780 lab=_82103_/CLK }
C {devices/lab_pin.sym} 33810 -4310 0 0 {name=p33781 lab=_81916_/Q }
C {devices/lab_pin.sym} 33990 -4330 0 1 {name=p33782 lab=_40829_/B }
C {sky130_stdcells/dfxtp_4.sym} 33900 -4320 0 0 {name=X_82292_ }
C {devices/lab_pin.sym} 33840 -4220 0 0 {name=p33783 lab=_53211_/A }
C {devices/lab_pin.sym} 33840 -4180 0 0 {name=p33784 lab=_53211_/B }
C {devices/lab_pin.sym} 33840 -4140 0 0 {name=p33785 lab=_53195_/X }
C {devices/lab_pin.sym} 33840 -4100 0 0 {name=p33786 lab=_53211_/D }
C {devices/lab_pin.sym} 33960 -4160 0 1 {name=p33787 lab=_53211_/X }
C {sky130_stdcells/and4_4.sym} 33900 -4160 0 0 {name=X_53211_ }
C {devices/lab_pin.sym} 33810 -4010 0 0 {name=p33788 lab=_81154_/CLK }
C {devices/lab_pin.sym} 33810 -3990 0 0 {name=p33789 lab=_68132_/X }
C {devices/lab_pin.sym} 33990 -4010 0 1 {name=p33790 lab=_82071_/D }
C {sky130_stdcells/dfxtp_4.sym} 33900 -4000 0 0 {name=X_84031_ }
C {devices/lab_pin.sym} 33840 -3880 0 0 {name=p33791 lab=_50432_/A }
C {devices/lab_pin.sym} 33840 -3840 0 0 {name=p33792 lab=_52128_/B }
C {devices/lab_pin.sym} 33960 -3860 0 1 {name=p33793 lab=_50423_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -3860 0 0 {name=X_50423_ }
C {devices/lab_pin.sym} 33820 -3770 0 0 {name=p33794 lab=_61489_/B }
C {devices/lab_pin.sym} 33820 -3730 0 0 {name=p33795 lab=_62390_/X }
C {devices/lab_pin.sym} 33820 -3690 0 0 {name=p33796 lab=_62363_/X }
C {devices/lab_pin.sym} 33820 -3650 0 0 {name=p33797 lab=_62407_/X }
C {devices/lab_pin.sym} 33820 -3620 0 0 {name=p33798 lab=_62408_/X }
C {devices/lab_pin.sym} 33980 -3690 0 1 {name=p33799 lab=_62409_/X }
C {sky130_stdcells/a41o_4.sym} 33900 -3690 0 0 {name=X_62409_ }
C {devices/lab_pin.sym} 33810 -3530 0 0 {name=p33800 lab=_85338_/CLK }
C {devices/lab_pin.sym} 33810 -3510 0 0 {name=p33801 lab=_81051_/Q }
C {devices/lab_pin.sym} 33990 -3530 0 1 {name=p33802 lab=_47585_/A }
C {sky130_stdcells/dfxtp_4.sym} 33900 -3520 0 0 {name=X_81243_ }
C {devices/lab_pin.sym} 33840 -3420 0 0 {name=p33803 lab=_54191_/A }
C {devices/lab_pin.sym} 33840 -3380 0 0 {name=p33804 lab=_54191_/B }
C {devices/lab_pin.sym} 33840 -3340 0 0 {name=p33805 lab=_54191_/C }
C {devices/lab_pin.sym} 33840 -3300 0 0 {name=p33806 lab=_53023_/D }
C {devices/lab_pin.sym} 33960 -3360 0 1 {name=p33807 lab=_54191_/X }
C {sky130_stdcells/and4_4.sym} 33900 -3360 0 0 {name=X_54191_ }
C {devices/lab_pin.sym} 33840 -3230 0 0 {name=p33808 lab=_66177_/A }
C {devices/lab_pin.sym} 33840 -3190 0 0 {name=p33809 lab=_66164_/B }
C {devices/lab_pin.sym} 33840 -3150 0 0 {name=p33810 lab=_66177_/C }
C {devices/lab_pin.sym} 33960 -3190 0 1 {name=p33811 lab=_66177_/Y }
C {sky130_stdcells/nor3_4.sym} 33900 -3190 0 0 {name=X_66177_ }
C {devices/lab_pin.sym} 33840 -3080 0 0 {name=p33812 lab=_63389_/A }
C {devices/lab_pin.sym} 33840 -3040 0 0 {name=p33813 lab=_63389_/B }
C {devices/lab_pin.sym} 33840 -3000 0 0 {name=p33814 lab=_63418_/C }
C {devices/lab_pin.sym} 33840 -2960 0 0 {name=p33815 lab=_63389_/D }
C {devices/lab_pin.sym} 33960 -3020 0 1 {name=p33816 lab=_63389_/Y }
C {sky130_stdcells/nand4_4.sym} 33900 -3020 0 0 {name=X_63389_ }
C {devices/lab_pin.sym} 33820 -2890 0 0 {name=p33817 lab=_85689_/Q }
C {devices/lab_pin.sym} 33820 -2850 0 0 {name=p33818 lab=_53120_/X }
C {devices/lab_pin.sym} 33820 -2810 0 0 {name=p33819 lab=_53141_/Y }
C {devices/lab_pin.sym} 33980 -2850 0 1 {name=p33820 lab=_53142_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -2850 0 0 {name=X_53142_ }
C {devices/lab_pin.sym} 33860 -2710 0 0 {name=p33821 lab=_64584_/X }
C {devices/lab_pin.sym} 33940 -2710 0 1 {name=p33822 lab=_65791_/A }
C {sky130_stdcells/buf_2.sym} 33900 -2710 0 0 {name=X_65128_ }
C {devices/lab_pin.sym} 33840 -2600 0 0 {name=p33823 lab=_50317_/X }
C {devices/lab_pin.sym} 33840 -2560 0 0 {name=p33824 lab=_48310_/B }
C {devices/lab_pin.sym} 33960 -2580 0 1 {name=p33825 lab=_50354_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -2580 0 0 {name=X_50354_ }
C {devices/lab_pin.sym} 33810 -2450 0 0 {name=p33826 lab=_83974_/CLK }
C {devices/lab_pin.sym} 33810 -2430 0 0 {name=p33827 lab=_74993_/B }
C {devices/lab_pin.sym} 33990 -2450 0 1 {name=p33828 lab=_40430_/B }
C {sky130_stdcells/dfxtp_4.sym} 33900 -2440 0 0 {name=X_81174_ }
C {devices/lab_pin.sym} 33860 -2310 0 0 {name=p33829 lab=clkbuf_9_201_0_CLK/A }
C {devices/lab_pin.sym} 33940 -2310 0 1 {name=p33830 lab=clkbuf_9_200_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 33900 -2310 0 0 {name=Xclkbuf_9_200_0_CLK }
C {devices/lab_pin.sym} 33860 -2190 0 0 {name=p33831 lab=_43018_/Y }
C {devices/lab_pin.sym} 33940 -2190 0 1 {name=p33832 lab=_53441_/A }
C {sky130_stdcells/buf_8.sym} 33900 -2190 0 0 {name=Xpsn_inst_psn_buff_20 }
C {devices/lab_pin.sym} 33860 -2070 0 0 {name=p33833 lab=_47002_/A }
C {devices/lab_pin.sym} 33940 -2070 0 1 {name=p33834 lab=_40372_/B1 }
C {sky130_stdcells/buf_2.sym} 33900 -2070 0 0 {name=Xpsn_inst_psn_buff_31 }
C {devices/lab_pin.sym} 33840 -1960 0 0 {name=p33835 lab=_80125_/A }
C {devices/lab_pin.sym} 33840 -1920 0 0 {name=p33836 lab=_80124_/X }
C {devices/lab_pin.sym} 33960 -1940 0 1 {name=p33837 lab=_80125_/Y }
C {sky130_stdcells/xnor2_4.sym} 33900 -1940 0 0 {name=X_80125_ }
C {devices/lab_pin.sym} 33820 -1830 0 0 {name=p33838 lab=_85702_/Q }
C {devices/lab_pin.sym} 33820 -1790 0 0 {name=p33839 lab=_53065_/X }
C {devices/lab_pin.sym} 33820 -1750 0 0 {name=p33840 lab=_53072_/Y }
C {devices/lab_pin.sym} 33980 -1790 0 1 {name=p33841 lab=_53073_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -1790 0 0 {name=X_53073_ }
C {devices/lab_pin.sym} 33820 -1670 0 0 {name=p33842 lab=_57926_/X }
C {devices/lab_pin.sym} 33820 -1630 0 0 {name=p33843 lab=_86001_/Q }
C {devices/lab_pin.sym} 33820 -1590 0 0 {name=p33844 lab=_57949_/X }
C {devices/lab_pin.sym} 33980 -1630 0 1 {name=p33845 lab=_57950_/Y }
C {sky130_stdcells/o21ai_4.sym} 33900 -1630 0 0 {name=X_57950_ }
C {devices/lab_pin.sym} 33860 -1490 0 0 {name=p33846 lab=_64828_/A }
C {devices/lab_pin.sym} 33940 -1490 0 1 {name=p33847 lab=_65059_/X }
C {sky130_stdcells/buf_2.sym} 33900 -1490 0 0 {name=X_65059_ }
C {devices/lab_pin.sym} 33820 -1400 0 0 {name=p33848 lab=_87043_/Q }
C {devices/lab_pin.sym} 33820 -1360 0 0 {name=p33849 lab=_44225_/B }
C {devices/lab_pin.sym} 33820 -1320 0 0 {name=p33850 lab=_57800_/A }
C {devices/lab_pin.sym} 33820 -1280 0 0 {name=p33851 lab=_69935_/X }
C {devices/lab_pin.sym} 33980 -1340 0 1 {name=p33852 lab=_69937_/B }
C {sky130_stdcells/a211o_4.sym} 33900 -1340 0 0 {name=X_69936_ }
C {devices/lab_pin.sym} 33840 -1200 0 0 {name=p33853 lab=_50285_/A }
C {devices/lab_pin.sym} 33840 -1160 0 0 {name=p33854 lab=_48231_/B }
C {devices/lab_pin.sym} 33960 -1180 0 1 {name=p33855 lab=_50285_/Y }
C {sky130_stdcells/nand2_4.sym} 33900 -1180 0 0 {name=X_50285_ }
C {devices/lab_pin.sym} 33810 -1050 0 0 {name=p33856 lab=_85692_/CLK }
C {devices/lab_pin.sym} 33810 -1030 0 0 {name=p33857 lab=_51593_/Y }
C {devices/lab_pin.sym} 33990 -1050 0 1 {name=p33858 lab=_85982_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -1040 0 0 {name=X_85982_ }
C {devices/lab_pin.sym} 33860 -910 0 0 {name=p33859 lab=_52431_/A }
C {devices/lab_pin.sym} 33940 -910 0 1 {name=p33860 lab=_52058_/A }
C {sky130_stdcells/buf_2.sym} 33900 -910 0 0 {name=X_52024_ }
C {devices/lab_pin.sym} 33860 -790 0 0 {name=p33861 lab=_56900_/X }
C {devices/lab_pin.sym} 33940 -790 0 1 {name=p33862 lab=_56901_/Y }
C {sky130_stdcells/inv_2.sym} 33900 -790 0 0 {name=X_56901_ }
C {devices/lab_pin.sym} 33810 -670 0 0 {name=p33863 lab=_87210_/CLK }
C {devices/lab_pin.sym} 33810 -650 0 0 {name=p33864 lab=_87721_/D }
C {devices/lab_pin.sym} 33990 -670 0 1 {name=p33865 lab=_87721_/Q }
C {sky130_stdcells/dfxtp_4.sym} 33900 -660 0 0 {name=X_87721_ }
C {devices/lab_pin.sym} 34780 -42150 0 0 {name=p33866 lab=clkbuf_9_362_0_CLK/X }
C {devices/lab_pin.sym} 34860 -42150 0 1 {name=p33867 lab=_82301_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 34820 -42150 0 0 {name=Xclkbuf_10_724_0_CLK }
C {devices/lab_pin.sym} 34730 -42030 0 0 {name=p33868 lab=_85379_/CLK }
C {devices/lab_pin.sym} 34730 -42010 0 0 {name=p33869 lab=_84933_/D }
C {devices/lab_pin.sym} 34910 -42030 0 1 {name=p33870 lab=_84933_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -42020 0 0 {name=X_84933_ }
C {devices/lab_pin.sym} 34760 -41900 0 0 {name=p33871 lab=_80073_/B }
C {devices/lab_pin.sym} 34760 -41860 0 0 {name=p33872 lab=_80056_/B }
C {devices/lab_pin.sym} 34880 -41880 0 1 {name=p33873 lab=_80056_/X }
C {sky130_stdcells/xor2_4.sym} 34820 -41880 0 0 {name=X_80056_ }
C {devices/lab_pin.sym} 34740 -41770 0 0 {name=p33874 lab=_57877_/Y }
C {devices/lab_pin.sym} 34740 -41730 0 0 {name=p33875 lab=_57880_/Y }
C {devices/lab_pin.sym} 34740 -41690 0 0 {name=p33876 lab=_57829_/X }
C {devices/lab_pin.sym} 34900 -41730 0 1 {name=p33877 lab=_57881_/X }
C {sky130_stdcells/a21o_4.sym} 34820 -41730 0 0 {name=X_57881_ }
C {devices/lab_pin.sym} 34740 -41610 0 0 {name=p33878 lab=_69864_/X }
C {devices/lab_pin.sym} 34740 -41570 0 0 {name=p33879 lab=_69866_/X }
C {devices/lab_pin.sym} 34740 -41530 0 0 {name=p33880 lab=_69742_/X }
C {devices/lab_pin.sym} 34900 -41570 0 1 {name=p33881 lab=_69867_/Y }
C {sky130_stdcells/a21oi_4.sym} 34820 -41570 0 0 {name=X_69867_ }
C {devices/lab_pin.sym} 34760 -41440 0 0 {name=p33882 lab=_60122_/A }
C {devices/lab_pin.sym} 34760 -41400 0 0 {name=p33883 lab=_60122_/C }
C {devices/lab_pin.sym} 34880 -41420 0 1 {name=p33884 lab=_59640_/A }
C {sky130_stdcells/and2_4.sym} 34820 -41420 0 0 {name=X_59620_ }
C {devices/lab_pin.sym} 34780 -41290 0 0 {name=p33885 lab=_56831_/X }
C {devices/lab_pin.sym} 34860 -41290 0 1 {name=p33886 lab=_56832_/X }
C {sky130_stdcells/buf_2.sym} 34820 -41290 0 0 {name=X_56832_ }
C {devices/lab_pin.sym} 34780 -41170 0 0 {name=p33887 lab=_69182_/A }
C {devices/lab_pin.sym} 34860 -41170 0 1 {name=p33888 lab=_68818_/X }
C {sky130_stdcells/buf_2.sym} 34820 -41170 0 0 {name=X_68818_ }
C {devices/lab_pin.sym} 34780 -41050 0 0 {name=p33889 lab=clkbuf_9_214_0_CLK/A }
C {devices/lab_pin.sym} 34860 -41050 0 1 {name=p33890 lab=clkbuf_9_215_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 34820 -41050 0 0 {name=Xclkbuf_9_215_0_CLK }
C {devices/lab_pin.sym} 34730 -40930 0 0 {name=p33891 lab=_87652_/CLK }
C {devices/lab_pin.sym} 34730 -40910 0 0 {name=p33892 lab=_87652_/D }
C {devices/lab_pin.sym} 34910 -40930 0 1 {name=p33893 lab=_67691_/B }
C {sky130_stdcells/dfxtp_4.sym} 34820 -40920 0 0 {name=X_87652_ }
C {devices/lab_pin.sym} 34730 -40790 0 0 {name=p33894 lab=_84344_/CLK }
C {devices/lab_pin.sym} 34730 -40770 0 0 {name=p33895 lab=_58381_/X }
C {devices/lab_pin.sym} 34910 -40790 0 1 {name=p33896 lab=_84864_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -40780 0 0 {name=X_84864_ }
C {devices/lab_pin.sym} 34760 -40660 0 0 {name=p33897 lab=_69770_/A }
C {devices/lab_pin.sym} 34760 -40620 0 0 {name=p33898 lab=_88322_/Q }
C {devices/lab_pin.sym} 34880 -40640 0 1 {name=p33899 lab=_69798_/X }
C {sky130_stdcells/and2_4.sym} 34820 -40640 0 0 {name=X_69798_ }
C {devices/lab_pin.sym} 34730 -40510 0 0 {name=p33900 lab=_85962_/CLK }
C {devices/lab_pin.sym} 34730 -40490 0 0 {name=p33901 lab=_47740_/Y }
C {devices/lab_pin.sym} 34910 -40510 0 1 {name=p33902 lab=_72384_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -40500 0 0 {name=X_86603_ }
C {devices/lab_pin.sym} 34730 -40370 0 0 {name=p33903 lab=_83842_/CLK }
C {devices/lab_pin.sym} 34730 -40350 0 0 {name=p33904 lab=_83815_/D }
C {devices/lab_pin.sym} 34910 -40370 0 1 {name=p33905 lab=_83815_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -40360 0 0 {name=X_83815_ }
C {devices/lab_pin.sym} 34780 -40230 0 0 {name=p33906 lab=clkbuf_9_54_0_CLK/X }
C {devices/lab_pin.sym} 34860 -40230 0 1 {name=p33907 lab=_84549_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 34820 -40230 0 0 {name=Xclkbuf_10_109_0_CLK }
C {devices/lab_pin.sym} 34780 -40110 0 0 {name=p33908 lab=_59551_/A }
C {devices/lab_pin.sym} 34860 -40110 0 1 {name=p33909 lab=_60407_/C }
C {sky130_stdcells/buf_2.sym} 34820 -40110 0 0 {name=X_59551_ }
C {devices/lab_pin.sym} 34740 -40030 0 0 {name=p33910 lab=_56740_/X }
C {devices/lab_pin.sym} 34740 -39990 0 0 {name=p33911 lab=_56756_/X }
C {devices/lab_pin.sym} 34740 -39950 0 0 {name=p33912 lab=_56758_/X }
C {devices/lab_pin.sym} 34740 -39910 0 0 {name=p33913 lab=_56761_/X }
C {devices/lab_pin.sym} 34740 -39880 0 0 {name=p33914 lab=_57003_/B }
C {devices/lab_pin.sym} 34900 -39950 0 1 {name=p33915 lab=_56764_/D }
C {sky130_stdcells/a41o_4.sym} 34820 -39950 0 0 {name=X_56763_ }
C {devices/lab_pin.sym} 34740 -39810 0 0 {name=p33916 lab=_68744_/X }
C {devices/lab_pin.sym} 34740 -39770 0 0 {name=p33917 lab=_68747_/X }
C {devices/lab_pin.sym} 34740 -39730 0 0 {name=p33918 lab=_68748_/X }
C {devices/lab_pin.sym} 34900 -39770 0 1 {name=p33919 lab=_68749_/X }
C {sky130_stdcells/a21o_4.sym} 34820 -39770 0 0 {name=X_68749_ }
C {devices/lab_pin.sym} 34730 -39630 0 0 {name=p33920 lab=_88111_/CLK }
C {devices/lab_pin.sym} 34730 -39610 0 0 {name=p33921 lab=_43082_/Y }
C {devices/lab_pin.sym} 34910 -39630 0 1 {name=p33922 lab=_74033_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -39620 0 0 {name=X_87583_ }
C {devices/lab_pin.sym} 34740 -39510 0 0 {name=p33923 lab=_53972_/Y }
C {devices/lab_pin.sym} 34740 -39470 0 0 {name=p33924 lab=_53948_/X }
C {devices/lab_pin.sym} 34740 -39430 0 0 {name=p33925 lab=_53974_/Y }
C {devices/lab_pin.sym} 34900 -39470 0 1 {name=p33926 lab=_85531_/D }
C {sky130_stdcells/a21boi_4.sym} 34820 -39470 0 0 {name=X_53975_ }
C {devices/lab_pin.sym} 34730 -39330 0 0 {name=p33927 lab=_86713_/CLK }
C {devices/lab_pin.sym} 34730 -39310 0 0 {name=p33928 lab=_84795_/D }
C {devices/lab_pin.sym} 34910 -39330 0 1 {name=p33929 lab=_84795_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -39320 0 0 {name=X_84795_ }
C {devices/lab_pin.sym} 34780 -39190 0 0 {name=p33930 lab=clkbuf_9_369_0_CLK/X }
C {devices/lab_pin.sym} 34860 -39190 0 1 {name=p33931 lab=_87225_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 34820 -39190 0 0 {name=Xclkbuf_10_739_0_CLK }
C {devices/lab_pin.sym} 34760 -39080 0 0 {name=p33932 lab=_63459_/B }
C {devices/lab_pin.sym} 34760 -39040 0 0 {name=p33933 lab=_58502_/B }
C {devices/lab_pin.sym} 34880 -39060 0 1 {name=p33934 lab=_58502_/Y }
C {sky130_stdcells/nor2_4.sym} 34820 -39060 0 0 {name=X_58502_ }
C {devices/lab_pin.sym} 34740 -38960 0 0 {name=p33935 lab=_56270_/C }
C {devices/lab_pin.sym} 34740 -38920 0 0 {name=p33936 lab=_55244_/A }
C {devices/lab_pin.sym} 34740 -38880 0 0 {name=p33937 lab=_44043_/X }
C {devices/lab_pin.sym} 34740 -38840 0 0 {name=p33938 lab=_55713_/X }
C {devices/lab_pin.sym} 34900 -38900 0 1 {name=p33939 lab=_55714_/X }
C {sky130_stdcells/a211o_4.sym} 34820 -38900 0 0 {name=X_55714_ }
C {devices/lab_pin.sym} 34780 -38750 0 0 {name=p33940 lab=clkbuf_3_0_1_CLK/X }
C {devices/lab_pin.sym} 34860 -38750 0 1 {name=p33941 lab=clkbuf_4_0_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 34820 -38750 0 0 {name=Xclkbuf_4_0_0_CLK }
C {devices/lab_pin.sym} 34730 -38630 0 0 {name=p33942 lab=_86534_/CLK }
C {devices/lab_pin.sym} 34730 -38610 0 0 {name=p33943 lab=_86534_/D }
C {devices/lab_pin.sym} 34910 -38630 0 1 {name=p33944 lab=_66301_/B }
C {sky130_stdcells/dfxtp_4.sym} 34820 -38620 0 0 {name=X_86534_ }
C {devices/lab_pin.sym} 34780 -38490 0 0 {name=p33945 lab=_40717_/X }
C {devices/lab_pin.sym} 34860 -38490 0 1 {name=p33946 lab=_40941_/A }
C {sky130_stdcells/buf_2.sym} 34820 -38490 0 0 {name=X_40940_ }
C {devices/lab_pin.sym} 34780 -38370 0 0 {name=p33947 lab=_52845_/A }
C {devices/lab_pin.sym} 34860 -38370 0 1 {name=p33948 lab=_52926_/X }
C {sky130_stdcells/buf_2.sym} 34820 -38370 0 0 {name=X_52926_ }
C {devices/lab_pin.sym} 34760 -38260 0 0 {name=p33949 lab=_70500_/D }
C {devices/lab_pin.sym} 34760 -38220 0 0 {name=p33950 lab=_70760_/B }
C {devices/lab_pin.sym} 34880 -38240 0 1 {name=p33951 lab=_71761_/A }
C {sky130_stdcells/nor2_4.sym} 34820 -38240 0 0 {name=X_71760_ }
C {devices/lab_pin.sym} 34760 -38120 0 0 {name=p33952 lab=_63369_/B }
C {devices/lab_pin.sym} 34760 -38080 0 0 {name=p33953 lab=_58532_/X }
C {devices/lab_pin.sym} 34880 -38100 0 1 {name=p33954 lab=_59482_/Y }
C {sky130_stdcells/nor2_4.sym} 34820 -38100 0 0 {name=X_59482_ }
C {devices/lab_pin.sym} 34730 -37970 0 0 {name=p33955 lab=_83749_/CLK }
C {devices/lab_pin.sym} 34730 -37950 0 0 {name=p33956 lab=_83746_/D }
C {devices/lab_pin.sym} 34910 -37970 0 1 {name=p33957 lab=_83746_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -37960 0 0 {name=X_83746_ }
C {devices/lab_pin.sym} 34760 -37850 0 0 {name=p33958 lab=_56694_/A }
C {devices/lab_pin.sym} 34760 -37810 0 0 {name=p33959 lab=_56664_/Y }
C {devices/lab_pin.sym} 34760 -37770 0 0 {name=p33960 lab=_56694_/C }
C {devices/lab_pin.sym} 34880 -37810 0 1 {name=p33961 lab=_56694_/Y }
C {sky130_stdcells/nand3_4.sym} 34820 -37810 0 0 {name=X_56694_ }
C {devices/lab_pin.sym} 34730 -37670 0 0 {name=p33962 lab=_83967_/CLK }
C {devices/lab_pin.sym} 34730 -37650 0 0 {name=p33963 lab=_80958_/D }
C {devices/lab_pin.sym} 34910 -37670 0 1 {name=p33964 lab=_80958_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -37660 0 0 {name=X_80958_ }
C {devices/lab_pin.sym} 34740 -37550 0 0 {name=p33965 lab=_52752_/B }
C {devices/lab_pin.sym} 34740 -37510 0 0 {name=p33966 lab=_70699_/X }
C {devices/lab_pin.sym} 34740 -37470 0 0 {name=p33967 lab=_70710_/Y }
C {devices/lab_pin.sym} 34900 -37510 0 1 {name=p33968 lab=_70711_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -37510 0 0 {name=X_70711_ }
C {devices/lab_pin.sym} 34780 -37370 0 0 {name=p33969 lab=_63198_/A }
C {devices/lab_pin.sym} 34860 -37370 0 1 {name=p33970 lab=_58434_/A }
C {sky130_stdcells/buf_2.sym} 34820 -37370 0 0 {name=X_58433_ }
C {devices/lab_pin.sym} 34740 -37270 0 0 {name=p33971 lab=_55447_/Y }
C {devices/lab_pin.sym} 34740 -37230 0 0 {name=p33972 lab=_55451_/B }
C {devices/lab_pin.sym} 34740 -37190 0 0 {name=p33973 lab=_55491_/X }
C {devices/lab_pin.sym} 34900 -37230 0 1 {name=p33974 lab=_56650_/B }
C {sky130_stdcells/a21boi_4.sym} 34820 -37230 0 0 {name=X_55645_ }
C {devices/lab_pin.sym} 34730 -37090 0 0 {name=p33975 lab=_83311_/CLK }
C {devices/lab_pin.sym} 34730 -37070 0 0 {name=p33976 lab=_86465_/D }
C {devices/lab_pin.sym} 34910 -37090 0 1 {name=p33977 lab=_86465_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -37080 0 0 {name=X_86465_ }
C {devices/lab_pin.sym} 34780 -36950 0 0 {name=p33978 lab=_40836_/A }
C {devices/lab_pin.sym} 34860 -36950 0 1 {name=p33979 lab=_40871_/X }
C {sky130_stdcells/buf_2.sym} 34820 -36950 0 0 {name=X_40871_ }
C {devices/lab_pin.sym} 34760 -36860 0 0 {name=p33980 lab=_52853_/A }
C {devices/lab_pin.sym} 34760 -36820 0 0 {name=p33981 lab=_52853_/B }
C {devices/lab_pin.sym} 34760 -36780 0 0 {name=p33982 lab=_52853_/C }
C {devices/lab_pin.sym} 34760 -36740 0 0 {name=p33983 lab=_52857_/D }
C {devices/lab_pin.sym} 34880 -36800 0 1 {name=p33984 lab=_52857_/X }
C {sky130_stdcells/and4_4.sym} 34820 -36800 0 0 {name=X_52857_ }
C {devices/lab_pin.sym} 34780 -36650 0 0 {name=p33985 lab=_71690_/Y }
C {devices/lab_pin.sym} 34860 -36650 0 1 {name=p33986 lab=_71691_/Y }
C {sky130_stdcells/inv_2.sym} 34820 -36650 0 0 {name=X_71691_ }
C {devices/lab_pin.sym} 34730 -36530 0 0 {name=p33987 lab=_83681_/CLK }
C {devices/lab_pin.sym} 34730 -36510 0 0 {name=p33988 lab=_70872_/Y }
C {devices/lab_pin.sym} 34910 -36530 0 1 {name=p33989 lab=_83677_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -36520 0 0 {name=X_83677_ }
C {devices/lab_pin.sym} 34730 -36390 0 0 {name=p33990 lab=_80818_/CLK }
C {devices/lab_pin.sym} 34730 -36370 0 0 {name=p33991 lab=_80889_/D }
C {devices/lab_pin.sym} 34910 -36390 0 1 {name=p33992 lab=_80889_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -36380 0 0 {name=X_80889_ }
C {devices/lab_pin.sym} 34730 -36250 0 0 {name=p33993 lab=_87436_/CLK }
C {devices/lab_pin.sym} 34730 -36230 0 0 {name=p33994 lab=_41500_/Y }
C {devices/lab_pin.sym} 34910 -36250 0 1 {name=p33995 lab=_66752_/B }
C {sky130_stdcells/dfxtp_4.sym} 34820 -36240 0 0 {name=X_88204_ }
C {devices/lab_pin.sym} 34780 -36110 0 0 {name=p33996 lab=_42610_/A }
C {devices/lab_pin.sym} 34860 -36110 0 1 {name=p33997 lab=_49210_/B }
C {sky130_stdcells/buf_2.sym} 34820 -36110 0 0 {name=X_42610_ }
C {devices/lab_pin.sym} 34740 -36020 0 0 {name=p33998 lab=_73359_/X }
C {devices/lab_pin.sym} 34740 -35980 0 0 {name=p33999 lab=_83055_/Q }
C {devices/lab_pin.sym} 34740 -35940 0 0 {name=p34000 lab=_73406_/X }
C {devices/lab_pin.sym} 34740 -35900 0 0 {name=p34001 lab=_73429_/X }
C {devices/lab_pin.sym} 34900 -35960 0 1 {name=p34002 lab=_73430_/X }
C {sky130_stdcells/a211o_4.sym} 34820 -35960 0 0 {name=X_73430_ }
C {devices/lab_pin.sym} 34730 -35810 0 0 {name=p34003 lab=_85643_/CLK }
C {devices/lab_pin.sym} 34730 -35790 0 0 {name=p34004 lab=_54581_/Y }
C {devices/lab_pin.sym} 34910 -35810 0 1 {name=p34005 lab=_85416_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -35800 0 0 {name=X_85416_ }
C {devices/lab_pin.sym} 34740 -35690 0 0 {name=p34006 lab=_85942_/Q }
C {devices/lab_pin.sym} 34740 -35650 0 0 {name=p34007 lab=_51789_/X }
C {devices/lab_pin.sym} 34740 -35610 0 0 {name=p34008 lab=_51807_/Y }
C {devices/lab_pin.sym} 34900 -35650 0 1 {name=p34009 lab=_51808_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -35650 0 0 {name=X_51808_ }
C {devices/lab_pin.sym} 34780 -35510 0 0 {name=p34010 lab=_70925_/A }
C {devices/lab_pin.sym} 34860 -35510 0 1 {name=p34011 lab=_70642_/X }
C {sky130_stdcells/buf_2.sym} 34820 -35510 0 0 {name=X_70642_ }
C {devices/lab_pin.sym} 34760 -35400 0 0 {name=p34012 lab=_58364_/A }
C {devices/lab_pin.sym} 34760 -35360 0 0 {name=p34013 lab=_58364_/B }
C {devices/lab_pin.sym} 34880 -35380 0 1 {name=p34014 lab=_58364_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -35380 0 0 {name=X_58364_ }
C {devices/lab_pin.sym} 34730 -35250 0 0 {name=p34015 lab=_87684_/CLK }
C {devices/lab_pin.sym} 34730 -35230 0 0 {name=p34016 lab=_82628_/D }
C {devices/lab_pin.sym} 34910 -35250 0 1 {name=p34017 lab=_82628_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -35240 0 0 {name=X_82628_ }
C {devices/lab_pin.sym} 34740 -35130 0 0 {name=p34018 lab=_47872_/A }
C {devices/lab_pin.sym} 34740 -35090 0 0 {name=p34019 lab=_43013_/X }
C {devices/lab_pin.sym} 34740 -35050 0 0 {name=p34020 lab=_47832_/A }
C {devices/lab_pin.sym} 34900 -35090 0 1 {name=p34021 lab=_43591_/A }
C {sky130_stdcells/a21oi_4.sym} 34820 -35090 0 0 {name=X_43590_ }
C {devices/lab_pin.sym} 34740 -34980 0 0 {name=p34022 lab=_85052_/Q }
C {devices/lab_pin.sym} 34740 -34940 0 0 {name=p34023 lab=_55571_/X }
C {devices/lab_pin.sym} 34740 -34900 0 0 {name=p34024 lab=_55513_/X }
C {devices/lab_pin.sym} 34740 -34860 0 0 {name=p34025 lab=_55575_/Y }
C {devices/lab_pin.sym} 34900 -34920 0 1 {name=p34026 lab=_55576_/X }
C {sky130_stdcells/a211o_4.sym} 34820 -34920 0 0 {name=X_55576_ }
C {devices/lab_pin.sym} 34730 -34770 0 0 {name=p34027 lab=_86398_/CLK }
C {devices/lab_pin.sym} 34730 -34750 0 0 {name=p34028 lab=_86396_/D }
C {devices/lab_pin.sym} 34910 -34770 0 1 {name=p34029 lab=_58633_/B }
C {sky130_stdcells/dfxtp_4.sym} 34820 -34760 0 0 {name=X_86396_ }
C {devices/lab_pin.sym} 34740 -34650 0 0 {name=p34030 lab=_85754_/Q }
C {devices/lab_pin.sym} 34740 -34610 0 0 {name=p34031 lab=_52765_/X }
C {devices/lab_pin.sym} 34740 -34570 0 0 {name=p34032 lab=_52787_/Y }
C {devices/lab_pin.sym} 34900 -34610 0 1 {name=p34033 lab=_52788_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -34610 0 0 {name=X_52788_ }
C {devices/lab_pin.sym} 34780 -34470 0 0 {name=p34034 lab=_57315_/A }
C {devices/lab_pin.sym} 34860 -34470 0 1 {name=p34035 lab=_57315_/Y }
C {sky130_stdcells/inv_2.sym} 34820 -34470 0 0 {name=X_57315_ }
C {devices/lab_pin.sym} 34730 -34350 0 0 {name=p34036 lab=_88133_/CLK }
C {devices/lab_pin.sym} 34730 -34330 0 0 {name=p34037 lab=_88135_/D }
C {devices/lab_pin.sym} 34910 -34350 0 1 {name=p34038 lab=_88135_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -34340 0 0 {name=X_88135_ }
C {devices/lab_pin.sym} 34740 -34250 0 0 {name=p34039 lab=_42521_/X }
C {devices/lab_pin.sym} 34740 -34210 0 0 {name=p34040 lab=_42522_/X }
C {devices/lab_pin.sym} 34740 -34170 0 0 {name=p34041 lab=_40762_/X }
C {devices/lab_pin.sym} 34740 -34130 0 0 {name=p34042 lab=_69110_/A }
C {devices/lab_pin.sym} 34740 -34090 0 0 {name=p34043 lab=_42540_/X }
C {devices/lab_pin.sym} 34900 -34170 0 1 {name=p34044 lab=_42542_/A }
C {sky130_stdcells/o32ai_4.sym} 34820 -34170 0 0 {name=X_42541_ }
C {devices/lab_pin.sym} 34740 -34030 0 0 {name=p34045 lab=_54525_/Y }
C {devices/lab_pin.sym} 34740 -33990 0 0 {name=p34046 lab=_54502_/X }
C {devices/lab_pin.sym} 34740 -33950 0 0 {name=p34047 lab=_54526_/X }
C {devices/lab_pin.sym} 34900 -33990 0 1 {name=p34048 lab=_54527_/Y }
C {sky130_stdcells/a21oi_4.sym} 34820 -33990 0 0 {name=X_54527_ }
C {devices/lab_pin.sym} 34740 -33880 0 0 {name=p34049 lab=_73359_/X }
C {devices/lab_pin.sym} 34740 -33840 0 0 {name=p34050 lab=_83058_/Q }
C {devices/lab_pin.sym} 34740 -33800 0 0 {name=p34051 lab=_73238_/X }
C {devices/lab_pin.sym} 34740 -33760 0 0 {name=p34052 lab=_73360_/X }
C {devices/lab_pin.sym} 34900 -33820 0 1 {name=p34053 lab=_73361_/X }
C {sky130_stdcells/a211o_4.sym} 34820 -33820 0 0 {name=X_73361_ }
C {devices/lab_pin.sym} 34730 -33670 0 0 {name=p34054 lab=_85346_/CLK }
C {devices/lab_pin.sym} 34730 -33650 0 0 {name=p34055 lab=_85347_/D }
C {devices/lab_pin.sym} 34910 -33670 0 1 {name=p34056 lab=_85347_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -33660 0 0 {name=X_85347_ }
C {devices/lab_pin.sym} 34780 -33530 0 0 {name=p34057 lab=_46616_/A }
C {devices/lab_pin.sym} 34860 -33530 0 1 {name=p34058 lab=_54400_/A }
C {sky130_stdcells/buf_2.sym} 34820 -33530 0 0 {name=X_51739_ }
C {devices/lab_pin.sym} 34760 -33440 0 0 {name=p34059 lab=_71867_/A }
C {devices/lab_pin.sym} 34760 -33400 0 0 {name=p34060 lab=_70573_/B }
C {devices/lab_pin.sym} 34760 -33360 0 0 {name=p34061 lab=_70568_/C }
C {devices/lab_pin.sym} 34760 -33320 0 0 {name=p34062 lab=_70568_/D }
C {devices/lab_pin.sym} 34880 -33380 0 1 {name=p34063 lab=_70573_/Y }
C {sky130_stdcells/nor4_4.sym} 34820 -33380 0 0 {name=X_70573_ }
C {devices/lab_pin.sym} 34730 -33230 0 0 {name=p34064 lab=_82557_/CLK }
C {devices/lab_pin.sym} 34730 -33210 0 0 {name=p34065 lab=_82559_/D }
C {devices/lab_pin.sym} 34910 -33230 0 1 {name=p34066 lab=_82559_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -33220 0 0 {name=X_82559_ }
C {devices/lab_pin.sym} 34780 -33090 0 0 {name=p34067 lab=_64525_/C }
C {devices/lab_pin.sym} 34860 -33090 0 1 {name=p34068 lab=_58296_/A }
C {sky130_stdcells/buf_2.sym} 34820 -33090 0 0 {name=X_58295_ }
C {devices/lab_pin.sym} 34780 -32970 0 0 {name=p34069 lab=_75100_/A }
C {devices/lab_pin.sym} 34860 -32970 0 1 {name=p34070 lab=_75100_/Y }
C {sky130_stdcells/inv_2.sym} 34820 -32970 0 0 {name=X_75100_ }
C {devices/lab_pin.sym} 34740 -32880 0 0 {name=p34071 lab=_83266_/Q }
C {devices/lab_pin.sym} 34740 -32840 0 0 {name=p34072 lab=_72250_/X }
C {devices/lab_pin.sym} 34740 -32800 0 0 {name=p34073 lab=_72304_/X }
C {devices/lab_pin.sym} 34740 -32760 0 0 {name=p34074 lab=_72311_/X }
C {devices/lab_pin.sym} 34900 -32820 0 1 {name=p34075 lab=_72312_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 34820 -32820 0 0 {name=X_72312_ }
C {devices/lab_pin.sym} 34780 -32670 0 0 {name=p34076 lab=_62544_/A }
C {devices/lab_pin.sym} 34860 -32670 0 1 {name=p34077 lab=_61607_/B }
C {sky130_stdcells/buf_2.sym} 34820 -32670 0 0 {name=X_45260_ }
C {devices/lab_pin.sym} 34740 -32580 0 0 {name=p34078 lab=_57243_/X }
C {devices/lab_pin.sym} 34740 -32540 0 0 {name=p34079 lab=_56589_/X }
C {devices/lab_pin.sym} 34740 -32500 0 0 {name=p34080 lab=_85052_/Q }
C {devices/lab_pin.sym} 34740 -32460 0 0 {name=p34081 lab=_57245_/X }
C {devices/lab_pin.sym} 34900 -32520 0 1 {name=p34082 lab=_85052_/D }
C {sky130_stdcells/a2bb2o_4.sym} 34820 -32520 0 0 {name=X_57246_ }
C {devices/lab_pin.sym} 34740 -32390 0 0 {name=p34083 lab=_76071_/Y }
C {devices/lab_pin.sym} 34740 -32350 0 0 {name=p34084 lab=_76078_/Y }
C {devices/lab_pin.sym} 34740 -32310 0 0 {name=p34085 lab=_76079_/Y }
C {devices/lab_pin.sym} 34900 -32350 0 1 {name=p34086 lab=_76080_/X }
C {sky130_stdcells/o21a_4.sym} 34820 -32350 0 0 {name=X_76080_ }
C {devices/lab_pin.sym} 34730 -32210 0 0 {name=p34087 lab=_87553_/CLK }
C {devices/lab_pin.sym} 34730 -32190 0 0 {name=p34088 lab=_42027_/Y }
C {devices/lab_pin.sym} 34910 -32210 0 1 {name=p34089 lab=_73196_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -32200 0 0 {name=X_88066_ }
C {devices/lab_pin.sym} 34780 -32070 0 0 {name=p34090 lab=_41993_/A }
C {devices/lab_pin.sym} 34860 -32070 0 1 {name=p34091 lab=_42472_/X }
C {sky130_stdcells/buf_2.sym} 34820 -32070 0 0 {name=X_42472_ }
C {devices/lab_pin.sym} 34780 -31950 0 0 {name=p34092 lab=_54321_/A }
C {devices/lab_pin.sym} 34860 -31950 0 1 {name=p34093 lab=_54486_/A }
C {sky130_stdcells/buf_2.sym} 34820 -31950 0 0 {name=X_54458_ }
C {devices/lab_pin.sym} 34740 -31850 0 0 {name=p34094 lab=_73277_/X }
C {devices/lab_pin.sym} 34740 -31810 0 0 {name=p34095 lab=_73281_/Y }
C {devices/lab_pin.sym} 34740 -31770 0 0 {name=p34096 lab=_73291_/X }
C {devices/lab_pin.sym} 34900 -31810 0 1 {name=p34097 lab=_73292_/X }
C {sky130_stdcells/a21o_4.sym} 34820 -31810 0 0 {name=X_73292_ }
C {devices/lab_pin.sym} 34730 -31670 0 0 {name=p34098 lab=_85248_/CLK }
C {devices/lab_pin.sym} 34730 -31650 0 0 {name=p34099 lab=_85278_/D }
C {devices/lab_pin.sym} 34910 -31670 0 1 {name=p34100 lab=_85278_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -31660 0 0 {name=X_85278_ }
C {devices/lab_pin.sym} 34760 -31550 0 0 {name=p34101 lab=_45950_/A }
C {devices/lab_pin.sym} 34760 -31510 0 0 {name=p34102 lab=_44204_/Y }
C {devices/lab_pin.sym} 34760 -31470 0 0 {name=p34103 lab=_44210_/X }
C {devices/lab_pin.sym} 34880 -31510 0 1 {name=p34104 lab=_44211_/Y }
C {sky130_stdcells/nor3_4.sym} 34820 -31510 0 0 {name=X_44211_ }
C {devices/lab_pin.sym} 34780 -31370 0 0 {name=p34105 lab=_75047_/B }
C {devices/lab_pin.sym} 34860 -31370 0 1 {name=p34106 lab=_75031_/Y }
C {sky130_stdcells/inv_2.sym} 34820 -31370 0 0 {name=X_75031_ }
C {devices/lab_pin.sym} 34740 -31270 0 0 {name=p34107 lab=_41421_/X }
C {devices/lab_pin.sym} 34740 -31230 0 0 {name=p34108 lab=_82888_/Q }
C {devices/lab_pin.sym} 34740 -31190 0 0 {name=p34109 lab=_41422_/X }
C {devices/lab_pin.sym} 34900 -31230 0 1 {name=p34110 lab=_41423_/X }
C {sky130_stdcells/o21a_4.sym} 34820 -31230 0 0 {name=X_41423_ }
C {devices/lab_pin.sym} 34730 -31090 0 0 {name=p34111 lab=_87011_/CLK }
C {devices/lab_pin.sym} 34730 -31070 0 0 {name=p34112 lab=_87017_/D }
C {devices/lab_pin.sym} 34910 -31090 0 1 {name=p34113 lab=_87017_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -31080 0 0 {name=X_87017_ }
C {devices/lab_pin.sym} 34780 -30950 0 0 {name=p34114 lab=_53357_/A }
C {devices/lab_pin.sym} 34860 -30950 0 1 {name=p34115 lab=_53410_/C }
C {sky130_stdcells/buf_2.sym} 34820 -30950 0 0 {name=X_53409_ }
C {devices/lab_pin.sym} 34740 -30850 0 0 {name=p34116 lab=_72228_/X }
C {devices/lab_pin.sym} 34740 -30810 0 0 {name=p34117 lab=_85975_/Q }
C {devices/lab_pin.sym} 34740 -30770 0 0 {name=p34118 lab=_72242_/X }
C {devices/lab_pin.sym} 34900 -30810 0 1 {name=p34119 lab=_72243_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -30810 0 0 {name=X_72243_ }
C {devices/lab_pin.sym} 34730 -30670 0 0 {name=p34120 lab=_85315_/CLK }
C {devices/lab_pin.sym} 34730 -30650 0 0 {name=p34121 lab=_84229_/D }
C {devices/lab_pin.sym} 34910 -30670 0 1 {name=p34122 lab=_79836_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -30660 0 0 {name=X_84229_ }
C {devices/lab_pin.sym} 34740 -30550 0 0 {name=p34123 lab=_85198_/Q }
C {devices/lab_pin.sym} 34740 -30510 0 0 {name=p34124 lab=_45176_/X }
C {devices/lab_pin.sym} 34740 -30470 0 0 {name=p34125 lab=_45190_/X }
C {devices/lab_pin.sym} 34900 -30510 0 1 {name=p34126 lab=_45191_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -30510 0 0 {name=X_45191_ }
C {devices/lab_pin.sym} 34740 -30410 0 0 {name=p34127 lab=_56801_/X }
C {devices/lab_pin.sym} 34740 -30370 0 0 {name=p34128 lab=_56738_/X }
C {devices/lab_pin.sym} 34740 -30330 0 0 {name=p34129 lab=_56821_/X }
C {devices/lab_pin.sym} 34740 -30290 0 0 {name=p34130 lab=_57156_/X }
C {devices/lab_pin.sym} 34740 -30260 0 0 {name=p34131 lab=_45957_/A }
C {devices/lab_pin.sym} 34900 -30330 0 1 {name=p34132 lab=_57177_/Y }
C {sky130_stdcells/a41oi_4.sym} 34820 -30330 0 0 {name=X_57177_ }
C {devices/lab_pin.sym} 34740 -30190 0 0 {name=p34133 lab=_85451_/Q }
C {devices/lab_pin.sym} 34740 -30150 0 0 {name=p34134 lab=_54376_/X }
C {devices/lab_pin.sym} 34740 -30110 0 0 {name=p34135 lab=_54388_/Y }
C {devices/lab_pin.sym} 34900 -30150 0 1 {name=p34136 lab=_54389_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -30150 0 0 {name=X_54389_ }
C {devices/lab_pin.sym} 34760 -30040 0 0 {name=p34137 lab=_56117_/B }
C {devices/lab_pin.sym} 34760 -30000 0 0 {name=p34138 lab=_56143_/B }
C {devices/lab_pin.sym} 34760 -29960 0 0 {name=p34139 lab=_55773_/D }
C {devices/lab_pin.sym} 34760 -29920 0 0 {name=p34140 lab=_55801_/B }
C {devices/lab_pin.sym} 34880 -29980 0 1 {name=p34141 lab=_56128_/Y }
C {sky130_stdcells/nand4_4.sym} 34820 -29980 0 0 {name=X_56128_ }
C {devices/lab_pin.sym} 34780 -29830 0 0 {name=p34142 lab=_44004_/Y }
C {devices/lab_pin.sym} 34860 -29830 0 1 {name=p34143 lab=_44142_/X }
C {sky130_stdcells/buf_2.sym} 34820 -29830 0 0 {name=X_44142_ }
C {devices/lab_pin.sym} 34760 -29720 0 0 {name=p34144 lab=_41159_/A }
C {devices/lab_pin.sym} 34760 -29680 0 0 {name=p34145 lab=_82900_/Q }
C {devices/lab_pin.sym} 34880 -29700 0 1 {name=p34146 lab=_41354_/X }
C {sky130_stdcells/or2_4.sym} 34820 -29700 0 0 {name=X_41354_ }
C {devices/lab_pin.sym} 34760 -29580 0 0 {name=p34147 lab=_72220_/A }
C {devices/lab_pin.sym} 34760 -29540 0 0 {name=p34148 lab=_72174_/B }
C {devices/lab_pin.sym} 34880 -29560 0 1 {name=p34149 lab=_72174_/Y }
C {sky130_stdcells/nor2_4.sym} 34820 -29560 0 0 {name=X_72174_ }
C {devices/lab_pin.sym} 34760 -29450 0 0 {name=p34150 lab=_71112_/X }
C {devices/lab_pin.sym} 34760 -29410 0 0 {name=p34151 lab=_71080_/B }
C {devices/lab_pin.sym} 34760 -29370 0 0 {name=p34152 lab=_71119_/C }
C {devices/lab_pin.sym} 34880 -29410 0 1 {name=p34153 lab=_71125_/Y }
C {sky130_stdcells/nand3_4.sym} 34820 -29410 0 0 {name=X_71125_ }
C {devices/lab_pin.sym} 34760 -29280 0 0 {name=p34154 lab=_48908_/A }
C {devices/lab_pin.sym} 34760 -29240 0 0 {name=p34155 lab=_71989_/B }
C {devices/lab_pin.sym} 34880 -29260 0 1 {name=p34156 lab=_48950_/X }
C {sky130_stdcells/and2_4.sym} 34820 -29260 0 0 {name=X_48950_ }
C {devices/lab_pin.sym} 34780 -29130 0 0 {name=p34157 lab=_86755_/Q }
C {devices/lab_pin.sym} 34860 -29130 0 1 {name=p34158 lab=_55129_/A }
C {sky130_stdcells/inv_2.sym} 34820 -29130 0 0 {name=X_44073_ }
C {devices/lab_pin.sym} 34760 -29020 0 0 {name=p34159 lab=_74310_/C }
C {devices/lab_pin.sym} 34760 -28980 0 0 {name=p34160 lab=_55928_/A }
C {devices/lab_pin.sym} 34880 -29000 0 1 {name=p34161 lab=_56059_/Y }
C {sky130_stdcells/xnor2_4.sym} 34820 -29000 0 0 {name=X_56059_ }
C {devices/lab_pin.sym} 34740 -28890 0 0 {name=p34162 lab=_79767_/Y }
C {devices/lab_pin.sym} 34740 -28850 0 0 {name=p34163 lab=_79750_/Y }
C {devices/lab_pin.sym} 34740 -28810 0 0 {name=p34164 lab=_79769_/X }
C {devices/lab_pin.sym} 34900 -28850 0 1 {name=p34165 lab=_79770_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -28850 0 0 {name=X_79770_ }
C {devices/lab_pin.sym} 34740 -28740 0 0 {name=p34166 lab=_41282_/X }
C {devices/lab_pin.sym} 34740 -28700 0 0 {name=p34167 lab=_41283_/X }
C {devices/lab_pin.sym} 34740 -28660 0 0 {name=p34168 lab=_69129_/B }
C {devices/lab_pin.sym} 34740 -28620 0 0 {name=p34169 lab=_41284_/X }
C {devices/lab_pin.sym} 34900 -28680 0 1 {name=p34170 lab=_88244_/D }
C {sky130_stdcells/a2bb2o_4.sym} 34820 -28680 0 0 {name=X_41285_ }
C {devices/lab_pin.sym} 34760 -28540 0 0 {name=p34171 lab=_84534_/Q }
C {devices/lab_pin.sym} 34760 -28500 0 0 {name=p34172 lab=_62498_/C }
C {devices/lab_pin.sym} 34880 -28520 0 1 {name=p34173 lab=_76982_/X }
C {sky130_stdcells/xor2_4.sym} 34820 -28520 0 0 {name=X_76982_ }
C {devices/lab_pin.sym} 34760 -28400 0 0 {name=p34174 lab=_47912_/A }
C {devices/lab_pin.sym} 34760 -28360 0 0 {name=p34175 lab=_50264_/B }
C {devices/lab_pin.sym} 34880 -28380 0 1 {name=p34176 lab=_47901_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -28380 0 0 {name=X_47901_ }
C {devices/lab_pin.sym} 34780 -28250 0 0 {name=p34177 lab=_43024_/A }
C {devices/lab_pin.sym} 34860 -28250 0 1 {name=p34178 lab=_43127_/A }
C {sky130_stdcells/buf_2.sym} 34820 -28250 0 0 {name=X_43024_ }
C {devices/lab_pin.sym} 34760 -28140 0 0 {name=p34179 lab=_78721_/A }
C {devices/lab_pin.sym} 34760 -28100 0 0 {name=p34180 lab=_78721_/B }
C {devices/lab_pin.sym} 34880 -28120 0 1 {name=p34181 lab=_78725_/A }
C {sky130_stdcells/nand2_4.sym} 34820 -28120 0 0 {name=X_78721_ }
C {devices/lab_pin.sym} 34740 -28010 0 0 {name=p34182 lab=_48901_/B }
C {devices/lab_pin.sym} 34740 -27970 0 0 {name=p34183 lab=_71047_/X }
C {devices/lab_pin.sym} 34740 -27930 0 0 {name=p34184 lab=_71055_/Y }
C {devices/lab_pin.sym} 34900 -27970 0 1 {name=p34185 lab=_71056_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -27970 0 0 {name=X_71056_ }
C {devices/lab_pin.sym} 34760 -27840 0 0 {name=p34186 lab=_75933_/A }
C {devices/lab_pin.sym} 34760 -27800 0 0 {name=p34187 lab=_75933_/B }
C {devices/lab_pin.sym} 34880 -27820 0 1 {name=p34188 lab=_75933_/Y }
C {sky130_stdcells/nor2_4.sym} 34820 -27820 0 0 {name=X_75933_ }
C {devices/lab_pin.sym} 34730 -27690 0 0 {name=p34189 lab=_87473_/CLK }
C {devices/lab_pin.sym} 34730 -27670 0 0 {name=p34190 lab=_87919_/D }
C {devices/lab_pin.sym} 34910 -27690 0 1 {name=p34191 lab=_87919_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -27680 0 0 {name=X_87919_ }
C {devices/lab_pin.sym} 34780 -27550 0 0 {name=p34192 lab=_48471_/A }
C {devices/lab_pin.sym} 34860 -27550 0 1 {name=p34193 lab=_48881_/X }
C {sky130_stdcells/buf_2.sym} 34820 -27550 0 0 {name=X_48881_ }
C {devices/lab_pin.sym} 34740 -27460 0 0 {name=p34194 lab=_69520_/X }
C {devices/lab_pin.sym} 34740 -27420 0 0 {name=p34195 lab=_69668_/Y }
C {devices/lab_pin.sym} 34740 -27380 0 0 {name=p34196 lab=_69984_/X }
C {devices/lab_pin.sym} 34740 -27340 0 0 {name=p34197 lab=_70006_/Y }
C {devices/lab_pin.sym} 34900 -27400 0 1 {name=p34198 lab=_70007_/X }
C {sky130_stdcells/a211o_4.sym} 34820 -27400 0 0 {name=X_70007_ }
C {devices/lab_pin.sym} 34780 -27250 0 0 {name=p34199 lab=_47832_/A }
C {devices/lab_pin.sym} 34860 -27250 0 1 {name=p34200 lab=_47832_/X }
C {sky130_stdcells/buf_2.sym} 34820 -27250 0 0 {name=X_47832_ }
C {devices/lab_pin.sym} 34740 -27160 0 0 {name=p34201 lab=_80433_/A }
C {devices/lab_pin.sym} 34740 -27120 0 0 {name=p34202 lab=_59339_/X }
C {devices/lab_pin.sym} 34740 -27080 0 0 {name=p34203 lab=_59688_/X }
C {devices/lab_pin.sym} 34740 -27040 0 0 {name=p34204 lab=_59817_/Y }
C {devices/lab_pin.sym} 34900 -27100 0 1 {name=p34205 lab=_84695_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 34820 -27100 0 0 {name=X_59818_ }
C {devices/lab_pin.sym} 34780 -26950 0 0 {name=p34206 lab=_78651_/X }
C {devices/lab_pin.sym} 34860 -26950 0 1 {name=p34207 lab=_78652_/Y }
C {sky130_stdcells/inv_2.sym} 34820 -26950 0 0 {name=X_78652_ }
C {devices/lab_pin.sym} 34760 -26850 0 0 {name=p34208 lab=_75864_/A }
C {devices/lab_pin.sym} 34760 -26810 0 0 {name=p34209 lab=_81024_/Q }
C {devices/lab_pin.sym} 34760 -26770 0 0 {name=p34210 lab=_75862_/Y }
C {devices/lab_pin.sym} 34880 -26810 0 1 {name=p34211 lab=_75865_/A }
C {sky130_stdcells/nand3_4.sym} 34820 -26810 0 0 {name=X_75864_ }
C {devices/lab_pin.sym} 34760 -26690 0 0 {name=p34212 lab=_77603_/A }
C {devices/lab_pin.sym} 34760 -26650 0 0 {name=p34213 lab=_77600_/Y }
C {devices/lab_pin.sym} 34760 -26610 0 0 {name=p34214 lab=_77603_/C }
C {devices/lab_pin.sym} 34880 -26650 0 1 {name=p34215 lab=_77603_/X }
C {sky130_stdcells/or3_4.sym} 34820 -26650 0 0 {name=X_77603_ }
C {devices/lab_pin.sym} 34780 -26510 0 0 {name=p34216 lab=_46227_/A }
C {devices/lab_pin.sym} 34860 -26510 0 1 {name=p34217 lab=_80667_/D }
C {sky130_stdcells/inv_2.sym} 34820 -26510 0 0 {name=X_74815_ }
C {devices/lab_pin.sym} 34780 -26390 0 0 {name=p34218 lab=_47762_/Y }
C {devices/lab_pin.sym} 34860 -26390 0 1 {name=p34219 lab=_53232_/B }
C {sky130_stdcells/buf_2.sym} 34820 -26390 0 0 {name=X_47763_ }
C {devices/lab_pin.sym} 34780 -26270 0 0 {name=p34220 lab=_59629_/A }
C {devices/lab_pin.sym} 34860 -26270 0 1 {name=p34221 lab=_59755_/A }
C {sky130_stdcells/buf_2.sym} 34820 -26270 0 0 {name=X_59749_ }
C {devices/lab_pin.sym} 34740 -26170 0 0 {name=p34222 lab=_78569_/A }
C {devices/lab_pin.sym} 34740 -26130 0 0 {name=p34223 lab=_78569_/B }
C {devices/lab_pin.sym} 34740 -26090 0 0 {name=p34224 lab=_78568_/A }
C {devices/lab_pin.sym} 34900 -26130 0 1 {name=p34225 lab=_78591_/A }
C {sky130_stdcells/o21a_4.sym} 34820 -26130 0 0 {name=X_78583_ }
C {devices/lab_pin.sym} 34780 -25990 0 0 {name=p34226 lab=_44975_/A }
C {devices/lab_pin.sym} 34860 -25990 0 1 {name=p34227 lab=_44975_/X }
C {sky130_stdcells/buf_2.sym} 34820 -25990 0 0 {name=X_44975_ }
C {devices/lab_pin.sym} 34780 -25870 0 0 {name=p34228 lab=_80923_/Q }
C {devices/lab_pin.sym} 34860 -25870 0 1 {name=p34229 lab=_75802_/B }
C {sky130_stdcells/inv_2.sym} 34820 -25870 0 0 {name=X_75795_ }
C {devices/lab_pin.sym} 34760 -25760 0 0 {name=p34230 lab=_49502_/A }
C {devices/lab_pin.sym} 34760 -25720 0 0 {name=p34231 lab=_51026_/B }
C {devices/lab_pin.sym} 34880 -25740 0 1 {name=p34232 lab=_49502_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -25740 0 0 {name=X_49502_ }
C {devices/lab_pin.sym} 34780 -25610 0 0 {name=p34233 lab=_46667_/A }
C {devices/lab_pin.sym} 34860 -25610 0 1 {name=p34234 lab=_46717_/C }
C {sky130_stdcells/buf_2.sym} 34820 -25610 0 0 {name=X_46714_ }
C {devices/lab_pin.sym} 34780 -25490 0 0 {name=p34235 lab=_77533_/Y }
C {devices/lab_pin.sym} 34860 -25490 0 1 {name=p34236 lab=_77537_/B }
C {sky130_stdcells/inv_2.sym} 34820 -25490 0 0 {name=X_77534_ }
C {devices/lab_pin.sym} 34780 -25370 0 0 {name=p34237 lab=_43926_/A }
C {devices/lab_pin.sym} 34860 -25370 0 1 {name=p34238 lab=_87196_/D }
C {sky130_stdcells/inv_2.sym} 34820 -25370 0 0 {name=X_43926_ }
C {devices/lab_pin.sym} 34760 -25280 0 0 {name=p34239 lab=_62711_/A }
C {devices/lab_pin.sym} 34760 -25240 0 0 {name=p34240 lab=_84832_/Q }
C {devices/lab_pin.sym} 34760 -25200 0 0 {name=p34241 lab=_62737_/X }
C {devices/lab_pin.sym} 34760 -25160 0 0 {name=p34242 lab=_62738_/D }
C {devices/lab_pin.sym} 34880 -25220 0 1 {name=p34243 lab=_62760_/X }
C {sky130_stdcells/and4_4.sym} 34820 -25220 0 0 {name=X_62760_ }
C {devices/lab_pin.sym} 34780 -25070 0 0 {name=p34244 lab=_70730_/X }
C {devices/lab_pin.sym} 34860 -25070 0 1 {name=p34245 lab=_74797_/C }
C {sky130_stdcells/buf_2.sym} 34820 -25070 0 0 {name=X_74746_ }
C {devices/lab_pin.sym} 34740 -24970 0 0 {name=p34246 lab=_83313_/Q }
C {devices/lab_pin.sym} 34740 -24930 0 0 {name=p34247 lab=_57615_/X }
C {devices/lab_pin.sym} 34740 -24890 0 0 {name=p34248 lab=_71957_/Y }
C {devices/lab_pin.sym} 34900 -24930 0 1 {name=p34249 lab=_71958_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -24930 0 0 {name=X_71958_ }
C {devices/lab_pin.sym} 34780 -24790 0 0 {name=p34250 lab=_47694_/A }
C {devices/lab_pin.sym} 34860 -24790 0 1 {name=p34251 lab=_54885_/B }
C {sky130_stdcells/inv_2.sym} 34820 -24790 0 0 {name=X_47694_ }
C {devices/lab_pin.sym} 34780 -24670 0 0 {name=p34252 lab=_49569_/A }
C {devices/lab_pin.sym} 34860 -24670 0 1 {name=p34253 lab=_49434_/A }
C {sky130_stdcells/buf_2.sym} 34820 -24670 0 0 {name=X_49433_ }
C {devices/lab_pin.sym} 34780 -24550 0 0 {name=p34254 lab=_59635_/Y }
C {devices/lab_pin.sym} 34860 -24550 0 1 {name=p34255 lab=_61711_/X }
C {sky130_stdcells/buf_2.sym} 34820 -24550 0 0 {name=X_61711_ }
C {devices/lab_pin.sym} 34780 -24430 0 0 {name=p34256 lab=_70909_/A }
C {devices/lab_pin.sym} 34860 -24430 0 1 {name=p34257 lab=_70909_/X }
C {sky130_stdcells/buf_2.sym} 34820 -24430 0 0 {name=X_70909_ }
C {devices/lab_pin.sym} 34780 -24310 0 0 {name=p34258 lab=_82974_/Q }
C {devices/lab_pin.sym} 34860 -24310 0 1 {name=p34259 lab=_54286_/D }
C {sky130_stdcells/inv_2.sym} 34820 -24310 0 0 {name=X_46645_ }
C {devices/lab_pin.sym} 34760 -24200 0 0 {name=p34260 lab=_77458_/X }
C {devices/lab_pin.sym} 34760 -24160 0 0 {name=p34261 lab=_77465_/B }
C {devices/lab_pin.sym} 34880 -24180 0 1 {name=p34262 lab=_82194_/D }
C {sky130_stdcells/xor2_4.sym} 34820 -24180 0 0 {name=X_77465_ }
C {devices/lab_pin.sym} 34740 -24090 0 0 {name=p34263 lab=_43846_/X }
C {devices/lab_pin.sym} 34740 -24050 0 0 {name=p34264 lab=_43854_/X }
C {devices/lab_pin.sym} 34740 -24010 0 0 {name=p34265 lab=_41220_/X }
C {devices/lab_pin.sym} 34740 -23970 0 0 {name=p34266 lab=_87231_/Q }
C {devices/lab_pin.sym} 34740 -23930 0 0 {name=p34267 lab=_43847_/X }
C {devices/lab_pin.sym} 34900 -24010 0 1 {name=p34268 lab=_43858_/A }
C {sky130_stdcells/o32ai_4.sym} 34820 -24010 0 0 {name=X_43857_ }
C {devices/lab_pin.sym} 34740 -23890 0 0 {name=p34269 lab=_58228_/X }
C {devices/lab_pin.sym} 34740 -23850 0 0 {name=p34270 lab=_62689_/X }
C {devices/lab_pin.sym} 34740 -23810 0 0 {name=p34271 lab=_60205_/X }
C {devices/lab_pin.sym} 34740 -23770 0 0 {name=p34272 lab=_60263_/C }
C {devices/lab_pin.sym} 34740 -23740 0 0 {name=p34273 lab=_62690_/X }
C {devices/lab_pin.sym} 34900 -23810 0 1 {name=p34274 lab=_62691_/Y }
C {sky130_stdcells/a41oi_4.sym} 34820 -23810 0 0 {name=X_62691_ }
C {devices/lab_pin.sym} 34740 -23670 0 0 {name=p34275 lab=_74675_/X }
C {devices/lab_pin.sym} 34740 -23630 0 0 {name=p34276 lab=_56798_/A }
C {devices/lab_pin.sym} 34740 -23590 0 0 {name=p34277 lab=_74676_/Y }
C {devices/lab_pin.sym} 34900 -23630 0 1 {name=p34278 lab=_74678_/A }
C {sky130_stdcells/o21ai_4.sym} 34820 -23630 0 0 {name=X_74677_ }
C {devices/lab_pin.sym} 34760 -23520 0 0 {name=p34279 lab=_71867_/A }
C {devices/lab_pin.sym} 34760 -23480 0 0 {name=p34280 lab=_71783_/A }
C {devices/lab_pin.sym} 34760 -23440 0 0 {name=p34281 lab=_71783_/C }
C {devices/lab_pin.sym} 34760 -23400 0 0 {name=p34282 lab=_71319_/B }
C {devices/lab_pin.sym} 34880 -23460 0 1 {name=p34283 lab=_71889_/Y }
C {sky130_stdcells/nor4_4.sym} 34820 -23460 0 0 {name=X_71889_ }
C {devices/lab_pin.sym} 34740 -23330 0 0 {name=p34284 lab=_79201_/Y }
C {devices/lab_pin.sym} 34740 -23290 0 0 {name=p34285 lab=_79202_/Y }
C {devices/lab_pin.sym} 34740 -23250 0 0 {name=p34286 lab=_79203_/A }
C {devices/lab_pin.sym} 34900 -23290 0 1 {name=p34287 lab=_79205_/C }
C {sky130_stdcells/a21o_4.sym} 34820 -23290 0 0 {name=X_79204_ }
C {devices/lab_pin.sym} 34780 -23150 0 0 {name=p34288 lab=_64267_/A }
C {devices/lab_pin.sym} 34860 -23150 0 1 {name=p34289 lab=_64511_/B }
C {sky130_stdcells/buf_2.sym} 34820 -23150 0 0 {name=X_64430_ }
C {devices/lab_pin.sym} 34740 -23050 0 0 {name=p34290 lab=_76412_/X }
C {devices/lab_pin.sym} 34740 -23010 0 0 {name=p34291 lab=_76417_/C }
C {devices/lab_pin.sym} 34740 -22970 0 0 {name=p34292 lab=_76415_/Y }
C {devices/lab_pin.sym} 34900 -23010 0 1 {name=p34293 lab=_76418_/A }
C {sky130_stdcells/a21o_4.sym} 34820 -23010 0 0 {name=X_76416_ }
C {devices/lab_pin.sym} 34740 -22910 0 0 {name=p34294 lab=_42795_/X }
C {devices/lab_pin.sym} 34740 -22870 0 0 {name=p34295 lab=_42796_/X }
C {devices/lab_pin.sym} 34740 -22830 0 0 {name=p34296 lab=_41408_/X }
C {devices/lab_pin.sym} 34740 -22790 0 0 {name=p34297 lab=_67889_/B }
C {devices/lab_pin.sym} 34740 -22750 0 0 {name=p34298 lab=_42805_/X }
C {devices/lab_pin.sym} 34900 -22830 0 1 {name=p34299 lab=_42808_/Y }
C {sky130_stdcells/o32ai_4.sym} 34820 -22830 0 0 {name=X_42808_ }
C {devices/lab_pin.sym} 34760 -22700 0 0 {name=p34300 lab=_49374_/A }
C {devices/lab_pin.sym} 34760 -22660 0 0 {name=p34301 lab=_49364_/B }
C {devices/lab_pin.sym} 34760 -22620 0 0 {name=p34302 lab=_49380_/C }
C {devices/lab_pin.sym} 34760 -22580 0 0 {name=p34303 lab=_52580_/D }
C {devices/lab_pin.sym} 34880 -22640 0 1 {name=p34304 lab=_49364_/X }
C {sky130_stdcells/and4_4.sym} 34820 -22640 0 0 {name=X_49364_ }
C {devices/lab_pin.sym} 34780 -22490 0 0 {name=p34305 lab=_61642_/A }
C {devices/lab_pin.sym} 34860 -22490 0 1 {name=p34306 lab=_61642_/Y }
C {sky130_stdcells/inv_2.sym} 34820 -22490 0 0 {name=X_61642_ }
C {devices/lab_pin.sym} 34780 -22370 0 0 {name=p34307 lab=_44189_/X }
C {devices/lab_pin.sym} 34860 -22370 0 1 {name=p34308 lab=_73701_/B }
C {sky130_stdcells/buf_2.sym} 34820 -22370 0 0 {name=X_73628_ }
C {devices/lab_pin.sym} 34780 -22250 0 0 {name=p34309 lab=_46399_/A }
C {devices/lab_pin.sym} 34860 -22250 0 1 {name=p34310 lab=_46576_/X }
C {sky130_stdcells/buf_2.sym} 34820 -22250 0 0 {name=X_46576_ }
C {devices/lab_pin.sym} 34760 -22140 0 0 {name=p34311 lab=_77396_/A }
C {devices/lab_pin.sym} 34760 -22100 0 0 {name=p34312 lab=_77396_/B }
C {devices/lab_pin.sym} 34880 -22120 0 1 {name=p34313 lab=_77396_/Y }
C {sky130_stdcells/nor2_4.sym} 34820 -22120 0 0 {name=X_77396_ }
C {devices/lab_pin.sym} 34740 -22020 0 0 {name=p34314 lab=_41028_/X }
C {devices/lab_pin.sym} 34740 -21980 0 0 {name=p34315 lab=_43770_/X }
C {devices/lab_pin.sym} 34740 -21940 0 0 {name=p34316 lab=_69358_/B }
C {devices/lab_pin.sym} 34740 -21900 0 0 {name=p34317 lab=_43772_/X }
C {devices/lab_pin.sym} 34900 -21960 0 1 {name=p34318 lab=_43788_/X }
C {sky130_stdcells/a2bb2o_4.sym} 34820 -21960 0 0 {name=X_43788_ }
C {devices/lab_pin.sym} 34760 -21820 0 0 {name=p34319 lab=_48264_/X }
C {devices/lab_pin.sym} 34760 -21780 0 0 {name=p34320 lab=_50358_/B }
C {devices/lab_pin.sym} 34880 -21800 0 1 {name=p34321 lab=_48315_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -21800 0 0 {name=X_48315_ }
C {devices/lab_pin.sym} 34760 -21680 0 0 {name=p34322 lab=_79135_/A }
C {devices/lab_pin.sym} 34760 -21640 0 0 {name=p34323 lab=_79135_/B }
C {devices/lab_pin.sym} 34880 -21660 0 1 {name=p34324 lab=_79135_/X }
C {sky130_stdcells/xor2_4.sym} 34820 -21660 0 0 {name=X_79135_ }
C {devices/lab_pin.sym} 34760 -21540 0 0 {name=p34325 lab=_45527_/A }
C {devices/lab_pin.sym} 34760 -21500 0 0 {name=p34326 lab=_45381_/B }
C {devices/lab_pin.sym} 34880 -21520 0 1 {name=p34327 lab=_45527_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -21520 0 0 {name=X_45527_ }
C {devices/lab_pin.sym} 34780 -21390 0 0 {name=p34328 lab=_64361_/A }
C {devices/lab_pin.sym} 34860 -21390 0 1 {name=p34329 lab=_64363_/A }
C {sky130_stdcells/buf_2.sym} 34820 -21390 0 0 {name=X_64361_ }
C {devices/lab_pin.sym} 34780 -21270 0 0 {name=p34330 lab=_76347_/A }
C {devices/lab_pin.sym} 34860 -21270 0 1 {name=p34331 lab=_76348_/C }
C {sky130_stdcells/inv_2.sym} 34820 -21270 0 0 {name=X_76347_ }
C {devices/lab_pin.sym} 34780 -21150 0 0 {name=p34332 lab=_42720_/X }
C {devices/lab_pin.sym} 34860 -21150 0 1 {name=p34333 lab=_42739_/X }
C {sky130_stdcells/buf_2.sym} 34820 -21150 0 0 {name=X_42739_ }
C {devices/lab_pin.sym} 34760 -21040 0 0 {name=p34334 lab=_49287_/A }
C {devices/lab_pin.sym} 34760 -21000 0 0 {name=p34335 lab=_51324_/B }
C {devices/lab_pin.sym} 34880 -21020 0 1 {name=p34336 lab=_49295_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -21020 0 0 {name=X_49295_ }
C {devices/lab_pin.sym} 34760 -20900 0 0 {name=p34337 lab=_73556_/X }
C {devices/lab_pin.sym} 34760 -20860 0 0 {name=p34338 lab=_73558_/Y }
C {devices/lab_pin.sym} 34880 -20880 0 1 {name=p34339 lab=_73559_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -20880 0 0 {name=X_73559_ }
C {devices/lab_pin.sym} 34760 -20780 0 0 {name=p34340 lab=_58452_/A }
C {devices/lab_pin.sym} 34760 -20740 0 0 {name=p34341 lab=_61563_/B }
C {devices/lab_pin.sym} 34760 -20700 0 0 {name=p34342 lab=_61563_/C }
C {devices/lab_pin.sym} 34760 -20660 0 0 {name=p34343 lab=_61563_/D }
C {devices/lab_pin.sym} 34880 -20720 0 1 {name=p34344 lab=_61574_/A }
C {sky130_stdcells/nand4_4.sym} 34820 -20720 0 0 {name=X_61573_ }
C {devices/lab_pin.sym} 34780 -20570 0 0 {name=p34345 lab=_64898_/A }
C {devices/lab_pin.sym} 34860 -20570 0 1 {name=p34346 lab=_66226_/A }
C {sky130_stdcells/buf_2.sym} 34820 -20570 0 0 {name=X_66100_ }
C {devices/lab_pin.sym} 34760 -20480 0 0 {name=p34347 lab=_60454_/A }
C {devices/lab_pin.sym} 34760 -20440 0 0 {name=p34348 lab=_63312_/B }
C {devices/lab_pin.sym} 34760 -20400 0 0 {name=p34349 lab=_63312_/C }
C {devices/lab_pin.sym} 34760 -20360 0 0 {name=p34350 lab=_63237_/X }
C {devices/lab_pin.sym} 34880 -20420 0 1 {name=p34351 lab=_63312_/X }
C {sky130_stdcells/and4_4.sym} 34820 -20420 0 0 {name=X_63312_ }
C {devices/lab_pin.sym} 34780 -20270 0 0 {name=p34352 lab=_47965_/B }
C {devices/lab_pin.sym} 34860 -20270 0 1 {name=p34353 lab=_53520_/B }
C {sky130_stdcells/buf_2.sym} 34820 -20270 0 0 {name=X_48246_ }
C {devices/lab_pin.sym} 34740 -20170 0 0 {name=p34354 lab=_60488_/B }
C {devices/lab_pin.sym} 34740 -20130 0 0 {name=p34355 lab=_60476_/D }
C {devices/lab_pin.sym} 34740 -20090 0 0 {name=p34356 lab=_60445_/A }
C {devices/lab_pin.sym} 34900 -20130 0 1 {name=p34357 lab=_60524_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -20130 0 0 {name=X_60524_ }
C {devices/lab_pin.sym} 34740 -20020 0 0 {name=p34358 lab=_87934_/Q }
C {devices/lab_pin.sym} 34740 -19980 0 0 {name=p34359 lab=_67056_/X }
C {devices/lab_pin.sym} 34740 -19940 0 0 {name=p34360 lab=_67032_/X }
C {devices/lab_pin.sym} 34740 -19900 0 0 {name=p34361 lab=_67079_/X }
C {devices/lab_pin.sym} 34900 -19960 0 1 {name=p34362 lab=_67080_/X }
C {sky130_stdcells/a211o_4.sym} 34820 -19960 0 0 {name=X_67080_ }
C {devices/lab_pin.sym} 34760 -19840 0 0 {name=p34363 lab=_79027_/A }
C {devices/lab_pin.sym} 34760 -19800 0 0 {name=p34364 lab=_79042_/A }
C {devices/lab_pin.sym} 34760 -19760 0 0 {name=p34365 lab=_79034_/A }
C {devices/lab_pin.sym} 34760 -19720 0 0 {name=p34366 lab=_79057_/C }
C {devices/lab_pin.sym} 34880 -19780 0 1 {name=p34367 lab=_79066_/X }
C {sky130_stdcells/and4_4.sym} 34820 -19780 0 0 {name=X_79066_ }
C {devices/lab_pin.sym} 34740 -19660 0 0 {name=p34368 lab=_45455_/Y }
C {devices/lab_pin.sym} 34740 -19620 0 0 {name=p34369 lab=_45439_/X }
C {devices/lab_pin.sym} 34740 -19580 0 0 {name=p34370 lab=_45390_/X }
C {devices/lab_pin.sym} 34740 -19540 0 0 {name=p34371 lab=_45457_/Y }
C {devices/lab_pin.sym} 34900 -19600 0 1 {name=p34372 lab=_45458_/X }
C {sky130_stdcells/a211o_4.sym} 34820 -19600 0 0 {name=X_45458_ }
C {devices/lab_pin.sym} 34760 -19460 0 0 {name=p34373 lab=_64292_/A }
C {devices/lab_pin.sym} 34760 -19420 0 0 {name=p34374 lab=_64301_/B }
C {devices/lab_pin.sym} 34880 -19440 0 1 {name=p34375 lab=_64292_/Y }
C {sky130_stdcells/nor2_4.sym} 34820 -19440 0 0 {name=X_64292_ }
C {devices/lab_pin.sym} 34760 -19320 0 0 {name=p34376 lab=_81258_/Q }
C {devices/lab_pin.sym} 34760 -19280 0 0 {name=p34377 lab=_81514_/D }
C {devices/lab_pin.sym} 34880 -19300 0 1 {name=p34378 lab=_76278_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -19300 0 0 {name=X_76278_ }
C {devices/lab_pin.sym} 34760 -19190 0 0 {name=p34379 lab=_65553_/X }
C {devices/lab_pin.sym} 34760 -19150 0 0 {name=p34380 lab=_66062_/B }
C {devices/lab_pin.sym} 34760 -19110 0 0 {name=p34381 lab=_65556_/C }
C {devices/lab_pin.sym} 34880 -19150 0 1 {name=p34382 lab=_66031_/Y }
C {sky130_stdcells/nand3_4.sym} 34820 -19150 0 0 {name=X_66031_ }
C {devices/lab_pin.sym} 34760 -19020 0 0 {name=p34383 lab=_78018_/A }
C {devices/lab_pin.sym} 34760 -18980 0 0 {name=p34384 lab=_78018_/B }
C {devices/lab_pin.sym} 34880 -19000 0 1 {name=p34385 lab=_78017_/X }
C {sky130_stdcells/xor2_4.sym} 34820 -19000 0 0 {name=X_78017_ }
C {devices/lab_pin.sym} 34740 -18910 0 0 {name=p34386 lab=_44404_/X }
C {devices/lab_pin.sym} 34740 -18870 0 0 {name=p34387 lab=_44405_/X }
C {devices/lab_pin.sym} 34740 -18830 0 0 {name=p34388 lab=_41520_/X }
C {devices/lab_pin.sym} 34740 -18790 0 0 {name=p34389 lab=_87123_/Q }
C {devices/lab_pin.sym} 34740 -18750 0 0 {name=p34390 lab=_44406_/X }
C {devices/lab_pin.sym} 34900 -18830 0 1 {name=p34391 lab=_44410_/A }
C {sky130_stdcells/o32ai_4.sym} 34820 -18830 0 0 {name=X_44409_ }
C {devices/lab_pin.sym} 34740 -18710 0 0 {name=p34392 lab=_63236_/Y }
C {devices/lab_pin.sym} 34740 -18670 0 0 {name=p34393 lab=_63238_/X }
C {devices/lab_pin.sym} 34740 -18630 0 0 {name=p34394 lab=_63239_/X }
C {devices/lab_pin.sym} 34740 -18590 0 0 {name=p34395 lab=_63241_/X }
C {devices/lab_pin.sym} 34740 -18550 0 0 {name=p34396 lab=_63242_/X }
C {devices/lab_pin.sym} 34900 -18630 0 1 {name=p34397 lab=_63243_/Y }
C {sky130_stdcells/o41ai_4.sym} 34820 -18630 0 0 {name=X_63243_ }
C {devices/lab_pin.sym} 34740 -18490 0 0 {name=p34398 lab=_75225_/Y }
C {devices/lab_pin.sym} 34740 -18450 0 0 {name=p34399 lab=_75227_/Y }
C {devices/lab_pin.sym} 34740 -18410 0 0 {name=p34400 lab=_75224_/Y }
C {devices/lab_pin.sym} 34900 -18450 0 1 {name=p34401 lab=_75230_/B }
C {sky130_stdcells/o21ai_4.sym} 34820 -18450 0 0 {name=X_75229_ }
C {devices/lab_pin.sym} 34780 -18310 0 0 {name=p34402 lab=_49173_/A }
C {devices/lab_pin.sym} 34860 -18310 0 1 {name=p34403 lab=_48184_/A }
C {sky130_stdcells/buf_2.sym} 34820 -18310 0 0 {name=X_48177_ }
C {devices/lab_pin.sym} 34740 -18230 0 0 {name=p34404 lab=_60572_/A }
C {devices/lab_pin.sym} 34740 -18190 0 0 {name=p34405 lab=_60572_/B }
C {devices/lab_pin.sym} 34740 -18150 0 0 {name=p34406 lab=_60572_/C }
C {devices/lab_pin.sym} 34740 -18110 0 0 {name=p34407 lab=_60476_/D }
C {devices/lab_pin.sym} 34740 -18070 0 0 {name=p34408 lab=_60562_/B }
C {devices/lab_pin.sym} 34900 -18150 0 1 {name=p34409 lab=_60455_/Y }
C {sky130_stdcells/a32oi_4.sym} 34820 -18150 0 0 {name=X_60455_ }
C {devices/lab_pin.sym} 34780 -17990 0 0 {name=p34410 lab=_45389_/A }
C {devices/lab_pin.sym} 34860 -17990 0 1 {name=p34411 lab=_45389_/X }
C {sky130_stdcells/buf_2.sym} 34820 -17990 0 0 {name=X_45389_ }
C {devices/lab_pin.sym} 34780 -17870 0 0 {name=p34412 lab=_47128_/A }
C {devices/lab_pin.sym} 34860 -17870 0 1 {name=p34413 lab=_47128_/X }
C {sky130_stdcells/buf_2.sym} 34820 -17870 0 0 {name=X_47128_ }
C {devices/lab_pin.sym} 34740 -17770 0 0 {name=p34414 lab=_79363_/A }
C {devices/lab_pin.sym} 34740 -17730 0 0 {name=p34415 lab=_63130_/X }
C {devices/lab_pin.sym} 34740 -17690 0 0 {name=p34416 lab=_63173_/Y }
C {devices/lab_pin.sym} 34900 -17730 0 1 {name=p34417 lab=_84347_/D }
C {sky130_stdcells/a21o_4.sym} 34820 -17730 0 0 {name=X_63174_ }
C {devices/lab_pin.sym} 34760 -17600 0 0 {name=p34418 lab=_60386_/A }
C {devices/lab_pin.sym} 34760 -17560 0 0 {name=p34419 lab=_60418_/D }
C {devices/lab_pin.sym} 34880 -17580 0 1 {name=p34420 lab=_60387_/C }
C {sky130_stdcells/and2_4.sym} 34820 -17580 0 0 {name=X_60386_ }
C {devices/lab_pin.sym} 34740 -17470 0 0 {name=p34421 lab=_59858_/A }
C {devices/lab_pin.sym} 34740 -17430 0 0 {name=p34422 lab=_61637_/X }
C {devices/lab_pin.sym} 34740 -17390 0 0 {name=p34423 lab=_62124_/X }
C {devices/lab_pin.sym} 34900 -17430 0 1 {name=p34424 lab=_62125_/X }
C {sky130_stdcells/a21o_4.sym} 34820 -17430 0 0 {name=X_62125_ }
C {devices/lab_pin.sym} 34760 -17320 0 0 {name=p34425 lab=_47067_/A }
C {devices/lab_pin.sym} 34760 -17280 0 0 {name=p34426 lab=_47039_/B }
C {devices/lab_pin.sym} 34760 -17240 0 0 {name=p34427 lab=_47048_/C }
C {devices/lab_pin.sym} 34760 -17200 0 0 {name=p34428 lab=_52831_/D }
C {devices/lab_pin.sym} 34880 -17260 0 1 {name=p34429 lab=_47059_/X }
C {sky130_stdcells/and4_4.sym} 34820 -17260 0 0 {name=X_47059_ }
C {devices/lab_pin.sym} 34780 -17110 0 0 {name=p34430 lab=_67388_/X }
C {devices/lab_pin.sym} 34860 -17110 0 1 {name=p34431 lab=_68089_/A }
C {sky130_stdcells/buf_2.sym} 34820 -17110 0 0 {name=X_67982_ }
C {devices/lab_pin.sym} 34740 -17010 0 0 {name=p34432 lab=_79957_/A }
C {devices/lab_pin.sym} 34740 -16970 0 0 {name=p34433 lab=_79957_/B }
C {devices/lab_pin.sym} 34740 -16930 0 0 {name=p34434 lab=_79957_/C }
C {devices/lab_pin.sym} 34900 -16970 0 1 {name=p34435 lab=_79968_/Y }
C {sky130_stdcells/a21boi_4.sym} 34820 -16970 0 0 {name=X_79968_ }
C {devices/lab_pin.sym} 34780 -16830 0 0 {name=p34436 lab=_44148_/A }
C {devices/lab_pin.sym} 34860 -16830 0 1 {name=p34437 lab=_69766_/A }
C {sky130_stdcells/buf_2.sym} 34820 -16830 0 0 {name=X_69721_ }
C {devices/lab_pin.sym} 34740 -16730 0 0 {name=p34438 lab=_50066_/Y }
C {devices/lab_pin.sym} 34740 -16690 0 0 {name=p34439 lab=_50068_/X }
C {devices/lab_pin.sym} 34740 -16650 0 0 {name=p34440 lab=_50069_/X }
C {devices/lab_pin.sym} 34900 -16690 0 1 {name=p34441 lab=_50070_/Y }
C {sky130_stdcells/a21oi_4.sym} 34820 -16690 0 0 {name=X_50070_ }
C {devices/lab_pin.sym} 34740 -16580 0 0 {name=p34442 lab=_87120_/Q }
C {devices/lab_pin.sym} 34740 -16540 0 0 {name=p34443 lab=_66833_/X }
C {devices/lab_pin.sym} 34740 -16500 0 0 {name=p34444 lab=_66834_/X }
C {devices/lab_pin.sym} 34740 -16460 0 0 {name=p34445 lab=_66932_/X }
C {devices/lab_pin.sym} 34900 -16520 0 1 {name=p34446 lab=_66933_/X }
C {sky130_stdcells/a211o_4.sym} 34820 -16520 0 0 {name=X_66933_ }
C {devices/lab_pin.sym} 34740 -16390 0 0 {name=p34447 lab=_59858_/A }
C {devices/lab_pin.sym} 34740 -16350 0 0 {name=p34448 lab=_61580_/X }
C {devices/lab_pin.sym} 34740 -16310 0 0 {name=p34449 lab=_62055_/X }
C {devices/lab_pin.sym} 34900 -16350 0 1 {name=p34450 lab=_62056_/X }
C {sky130_stdcells/a21o_4.sym} 34820 -16350 0 0 {name=X_62056_ }
C {devices/lab_pin.sym} 34760 -16220 0 0 {name=p34451 lab=_78919_/A }
C {devices/lab_pin.sym} 34760 -16180 0 0 {name=p34452 lab=_78918_/Y }
C {devices/lab_pin.sym} 34880 -16200 0 1 {name=p34453 lab=_78920_/B }
C {sky130_stdcells/xor2_4.sym} 34820 -16200 0 0 {name=X_78919_ }
C {devices/lab_pin.sym} 34760 -16080 0 0 {name=p34454 lab=_79899_/A }
C {devices/lab_pin.sym} 34760 -16040 0 0 {name=p34455 lab=_79898_/Y }
C {devices/lab_pin.sym} 34880 -16060 0 1 {name=p34456 lab=_80264_/A }
C {sky130_stdcells/nand2_4.sym} 34820 -16060 0 0 {name=X_79899_ }
C {devices/lab_pin.sym} 34760 -15940 0 0 {name=p34457 lab=_59875_/A }
C {devices/lab_pin.sym} 34760 -15900 0 0 {name=p34458 lab=_63765_/A }
C {devices/lab_pin.sym} 34880 -15920 0 1 {name=p34459 lab=_61008_/A }
C {sky130_stdcells/nor2_4.sym} 34820 -15920 0 0 {name=X_61007_ }
C {devices/lab_pin.sym} 34730 -15790 0 0 {name=p34460 lab=_82234_/CLK }
C {devices/lab_pin.sym} 34730 -15770 0 0 {name=p34461 lab=_77819_/Y }
C {devices/lab_pin.sym} 34910 -15790 0 1 {name=p34462 lab=_81930_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -15780 0 0 {name=X_81930_ }
C {devices/lab_pin.sym} 34760 -15660 0 0 {name=p34463 lab=_69680_/A }
C {devices/lab_pin.sym} 34760 -15620 0 0 {name=p34464 lab=_88333_/Q }
C {devices/lab_pin.sym} 34880 -15640 0 1 {name=p34465 lab=_69652_/X }
C {sky130_stdcells/and2_4.sym} 34820 -15640 0 0 {name=X_69652_ }
C {devices/lab_pin.sym} 34760 -15520 0 0 {name=p34466 lab=_66840_/X }
C {devices/lab_pin.sym} 34760 -15480 0 0 {name=p34467 lab=_86826_/Q }
C {devices/lab_pin.sym} 34880 -15500 0 1 {name=p34468 lab=_66864_/X }
C {sky130_stdcells/and2_4.sym} 34820 -15500 0 0 {name=X_66864_ }
C {devices/lab_pin.sym} 34780 -15370 0 0 {name=p34469 lab=_69357_/A }
C {devices/lab_pin.sym} 34860 -15370 0 1 {name=p34470 lab=_68604_/A }
C {sky130_stdcells/buf_2.sym} 34820 -15370 0 0 {name=X_68603_ }
C {devices/lab_pin.sym} 34740 -15270 0 0 {name=p34471 lab=_65789_/X }
C {devices/lab_pin.sym} 34740 -15230 0 0 {name=p34472 lab=_65255_/Y }
C {devices/lab_pin.sym} 34740 -15190 0 0 {name=p34473 lab=_65814_/Y }
C {devices/lab_pin.sym} 34900 -15230 0 1 {name=p34474 lab=_65815_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -15230 0 0 {name=X_65815_ }
C {devices/lab_pin.sym} 34730 -15090 0 0 {name=p34475 lab=_80708_/CLK }
C {devices/lab_pin.sym} 34730 -15070 0 0 {name=p34476 lab=_81861_/D }
C {devices/lab_pin.sym} 34910 -15090 0 1 {name=p34477 lab=_81861_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -15080 0 0 {name=X_81861_ }
C {devices/lab_pin.sym} 34760 -14960 0 0 {name=p34478 lab=_68934_/X }
C {devices/lab_pin.sym} 34760 -14920 0 0 {name=p34479 lab=_69583_/B }
C {devices/lab_pin.sym} 34880 -14940 0 1 {name=p34480 lab=_69583_/Y }
C {sky130_stdcells/nor2_4.sym} 34820 -14940 0 0 {name=X_69583_ }
C {devices/lab_pin.sym} 34760 -14820 0 0 {name=p34481 lab=_66795_/A }
C {devices/lab_pin.sym} 34760 -14780 0 0 {name=p34482 lab=_66795_/B }
C {devices/lab_pin.sym} 34880 -14800 0 1 {name=p34483 lab=_66795_/X }
C {sky130_stdcells/and2_4.sym} 34820 -14800 0 0 {name=X_66795_ }
C {devices/lab_pin.sym} 34730 -14670 0 0 {name=p34484 lab=_86145_/CLK }
C {devices/lab_pin.sym} 34730 -14650 0 0 {name=p34485 lab=_83600_/D }
C {devices/lab_pin.sym} 34910 -14670 0 1 {name=p34486 lab=_83600_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -14660 0 0 {name=X_83600_ }
C {devices/lab_pin.sym} 34730 -14530 0 0 {name=p34487 lab=_81134_/CLK }
C {devices/lab_pin.sym} 34730 -14510 0 0 {name=p34488 lab=_83956_/Q }
C {devices/lab_pin.sym} 34910 -14530 0 1 {name=p34489 lab=_75806_/B }
C {sky130_stdcells/dfxtp_4.sym} 34820 -14520 0 0 {name=X_80812_ }
C {devices/lab_pin.sym} 34780 -14390 0 0 {name=p34490 lab=_69014_/A }
C {devices/lab_pin.sym} 34860 -14390 0 1 {name=p34491 lab=_68560_/A }
C {sky130_stdcells/buf_2.sym} 34820 -14390 0 0 {name=X_68534_ }
C {devices/lab_pin.sym} 34740 -14290 0 0 {name=p34492 lab=_53757_/Y }
C {devices/lab_pin.sym} 34740 -14250 0 0 {name=p34493 lab=_53747_/X }
C {devices/lab_pin.sym} 34740 -14210 0 0 {name=p34494 lab=_53759_/X }
C {devices/lab_pin.sym} 34900 -14250 0 1 {name=p34495 lab=_53760_/Y }
C {sky130_stdcells/a21oi_4.sym} 34820 -14250 0 0 {name=X_53760_ }
C {devices/lab_pin.sym} 34740 -14130 0 0 {name=p34496 lab=_65742_/Y }
C {devices/lab_pin.sym} 34740 -14090 0 0 {name=p34497 lab=_65681_/X }
C {devices/lab_pin.sym} 34740 -14050 0 0 {name=p34498 lab=_65745_/Y }
C {devices/lab_pin.sym} 34900 -14090 0 1 {name=p34499 lab=_65746_/X }
C {sky130_stdcells/a21o_4.sym} 34820 -14090 0 0 {name=X_65746_ }
C {devices/lab_pin.sym} 34730 -13950 0 0 {name=p34500 lab=_84583_/CLK }
C {devices/lab_pin.sym} 34730 -13930 0 0 {name=p34501 lab=_60728_/X }
C {devices/lab_pin.sym} 34910 -13950 0 1 {name=p34502 lab=_84580_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -13940 0 0 {name=X_84580_ }
C {devices/lab_pin.sym} 34740 -13830 0 0 {name=p34503 lab=_86097_/Q }
C {devices/lab_pin.sym} 34740 -13790 0 0 {name=p34504 lab=_50965_/X }
C {devices/lab_pin.sym} 34740 -13750 0 0 {name=p34505 lab=_50971_/Y }
C {devices/lab_pin.sym} 34900 -13790 0 1 {name=p34506 lab=_50972_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -13790 0 0 {name=X_50972_ }
C {devices/lab_pin.sym} 34760 -13680 0 0 {name=p34507 lab=_61652_/B }
C {devices/lab_pin.sym} 34760 -13640 0 0 {name=p34508 lab=_62936_/X }
C {devices/lab_pin.sym} 34760 -13600 0 0 {name=p34509 lab=_62982_/C }
C {devices/lab_pin.sym} 34760 -13560 0 0 {name=p34510 lab=_62908_/X }
C {devices/lab_pin.sym} 34880 -13620 0 1 {name=p34511 lab=_62958_/Y }
C {sky130_stdcells/nand4_4.sym} 34820 -13620 0 0 {name=X_62958_ }
C {devices/lab_pin.sym} 34730 -13470 0 0 {name=p34512 lab=_86807_/CLK }
C {devices/lab_pin.sym} 34730 -13450 0 0 {name=p34513 lab=_75955_/X }
C {devices/lab_pin.sym} 34910 -13470 0 1 {name=p34514 lab=_48373_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -13460 0 0 {name=X_81792_ }
C {devices/lab_pin.sym} 34780 -13330 0 0 {name=p34515 lab=_52684_/A }
C {devices/lab_pin.sym} 34860 -13330 0 1 {name=p34516 lab=_52711_/X }
C {sky130_stdcells/buf_2.sym} 34820 -13330 0 0 {name=X_52711_ }
C {devices/lab_pin.sym} 34730 -13210 0 0 {name=p34517 lab=_86203_/CLK }
C {devices/lab_pin.sym} 34730 -13190 0 0 {name=p34518 lab=_71336_/Y }
C {devices/lab_pin.sym} 34910 -13210 0 1 {name=p34519 lab=_83531_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -13200 0 0 {name=X_83531_ }
C {devices/lab_pin.sym} 34780 -13070 0 0 {name=p34520 lab=_58322_/A }
C {devices/lab_pin.sym} 34860 -13070 0 1 {name=p34521 lab=_61909_/X }
C {sky130_stdcells/buf_2.sym} 34820 -13070 0 0 {name=X_61909_ }
C {devices/lab_pin.sym} 34730 -12950 0 0 {name=p34522 lab=_80961_/CLK }
C {devices/lab_pin.sym} 34730 -12930 0 0 {name=p34523 lab=_80743_/D }
C {devices/lab_pin.sym} 34910 -12950 0 1 {name=p34524 lab=_75062_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -12940 0 0 {name=X_80743_ }
C {devices/lab_pin.sym} 34760 -12820 0 0 {name=p34525 lab=_64615_/A }
C {devices/lab_pin.sym} 34760 -12780 0 0 {name=p34526 lab=_68465_/B }
C {devices/lab_pin.sym} 34880 -12800 0 1 {name=p34527 lab=_68465_/Y }
C {sky130_stdcells/nor2_4.sym} 34820 -12800 0 0 {name=X_68465_ }
C {devices/lab_pin.sym} 34780 -12670 0 0 {name=p34528 lab=_53733_/A }
C {devices/lab_pin.sym} 34860 -12670 0 1 {name=p34529 lab=_53720_/B }
C {sky130_stdcells/buf_2.sym} 34820 -12670 0 0 {name=X_53691_ }
C {devices/lab_pin.sym} 34780 -12550 0 0 {name=p34530 lab=_65984_/A }
C {devices/lab_pin.sym} 34860 -12550 0 1 {name=p34531 lab=_65828_/B }
C {sky130_stdcells/buf_2.sym} 34820 -12550 0 0 {name=X_65677_ }
C {devices/lab_pin.sym} 34760 -12460 0 0 {name=p34532 lab=_61570_/B }
C {devices/lab_pin.sym} 34760 -12420 0 0 {name=p34533 lab=_62858_/X }
C {devices/lab_pin.sym} 34760 -12380 0 0 {name=p34534 lab=_62859_/X }
C {devices/lab_pin.sym} 34760 -12340 0 0 {name=p34535 lab=_62889_/D }
C {devices/lab_pin.sym} 34880 -12400 0 1 {name=p34536 lab=_62889_/Y }
C {sky130_stdcells/nand4_4.sym} 34820 -12400 0 0 {name=X_62889_ }
C {devices/lab_pin.sym} 34760 -12270 0 0 {name=p34537 lab=_55683_/A }
C {devices/lab_pin.sym} 34760 -12230 0 0 {name=p34538 lab=_55429_/Y }
C {devices/lab_pin.sym} 34760 -12190 0 0 {name=p34539 lab=_55373_/Y }
C {devices/lab_pin.sym} 34880 -12230 0 1 {name=p34540 lab=_55430_/Y }
C {sky130_stdcells/nand3_4.sym} 34820 -12230 0 0 {name=X_55430_ }
C {devices/lab_pin.sym} 34740 -12120 0 0 {name=p34541 lab=_87920_/Q }
C {devices/lab_pin.sym} 34740 -12080 0 0 {name=p34542 lab=_67414_/X }
C {devices/lab_pin.sym} 34740 -12040 0 0 {name=p34543 lab=_67391_/X }
C {devices/lab_pin.sym} 34740 -12000 0 0 {name=p34544 lab=_67415_/X }
C {devices/lab_pin.sym} 34900 -12060 0 1 {name=p34545 lab=_67416_/X }
C {sky130_stdcells/a211o_4.sym} 34820 -12060 0 0 {name=X_67416_ }
C {devices/lab_pin.sym} 34730 -11910 0 0 {name=p34546 lab=_83613_/CLK }
C {devices/lab_pin.sym} 34730 -11890 0 0 {name=p34547 lab=_86250_/D }
C {devices/lab_pin.sym} 34910 -11910 0 1 {name=p34548 lab=_86250_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -11900 0 0 {name=X_86250_ }
C {devices/lab_pin.sym} 34740 -11790 0 0 {name=p34549 lab=_85781_/Q }
C {devices/lab_pin.sym} 34740 -11750 0 0 {name=p34550 lab=_52629_/X }
C {devices/lab_pin.sym} 34740 -11710 0 0 {name=p34551 lab=_52641_/Y }
C {devices/lab_pin.sym} 34900 -11750 0 1 {name=p34552 lab=_52642_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -11750 0 0 {name=X_52642_ }
C {devices/lab_pin.sym} 34740 -11640 0 0 {name=p34553 lab=_64589_/X }
C {devices/lab_pin.sym} 34740 -11600 0 0 {name=p34554 lab=_85568_/Q }
C {devices/lab_pin.sym} 34740 -11560 0 0 {name=p34555 lab=_64591_/X }
C {devices/lab_pin.sym} 34740 -11520 0 0 {name=p34556 lab=_64627_/X }
C {devices/lab_pin.sym} 34900 -11580 0 1 {name=p34557 lab=_64628_/X }
C {sky130_stdcells/a211o_4.sym} 34820 -11580 0 0 {name=X_64628_ }
C {devices/lab_pin.sym} 34730 -11430 0 0 {name=p34558 lab=_83464_/CLK }
C {devices/lab_pin.sym} 34730 -11410 0 0 {name=p34559 lab=_83462_/D }
C {devices/lab_pin.sym} 34910 -11430 0 1 {name=p34560 lab=_83462_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -11420 0 0 {name=X_83462_ }
C {devices/lab_pin.sym} 34730 -11290 0 0 {name=p34561 lab=_81104_/CLK }
C {devices/lab_pin.sym} 34730 -11270 0 0 {name=p34562 lab=_80674_/D }
C {devices/lab_pin.sym} 34910 -11290 0 1 {name=p34563 lab=_75086_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -11280 0 0 {name=X_80674_ }
C {devices/lab_pin.sym} 34780 -11150 0 0 {name=p34564 lab=_69651_/A }
C {devices/lab_pin.sym} 34860 -11150 0 1 {name=p34565 lab=_69877_/A }
C {sky130_stdcells/buf_2.sym} 34820 -11150 0 0 {name=X_68396_ }
C {devices/lab_pin.sym} 34730 -11030 0 0 {name=p34566 lab=_85297_/CLK }
C {devices/lab_pin.sym} 34730 -11010 0 0 {name=p34567 lab=_85201_/D }
C {devices/lab_pin.sym} 34910 -11030 0 1 {name=p34568 lab=_85201_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -11020 0 0 {name=X_85201_ }
C {devices/lab_pin.sym} 34730 -10890 0 0 {name=p34569 lab=_82248_/CLK }
C {devices/lab_pin.sym} 34730 -10870 0 0 {name=p34570 lab=_82445_/Q }
C {devices/lab_pin.sym} 34910 -10890 0 1 {name=p34571 lab=_78458_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -10880 0 0 {name=X_82413_ }
C {devices/lab_pin.sym} 34760 -10760 0 0 {name=p34572 lab=_56689_/A }
C {devices/lab_pin.sym} 34760 -10720 0 0 {name=p34573 lab=_55360_/X }
C {devices/lab_pin.sym} 34880 -10740 0 1 {name=p34574 lab=_55443_/A }
C {sky130_stdcells/nand2_4.sym} 34820 -10740 0 0 {name=X_55361_ }
C {devices/lab_pin.sym} 34730 -10610 0 0 {name=p34575 lab=_86499_/CLK }
C {devices/lab_pin.sym} 34730 -10590 0 0 {name=p34576 lab=_86181_/D }
C {devices/lab_pin.sym} 34910 -10610 0 1 {name=p34577 lab=_86181_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -10600 0 0 {name=X_86181_ }
C {devices/lab_pin.sym} 34740 -10490 0 0 {name=p34578 lab=_67343_/X }
C {devices/lab_pin.sym} 34740 -10450 0 0 {name=p34579 lab=_67346_/X }
C {devices/lab_pin.sym} 34740 -10410 0 0 {name=p34580 lab=_67322_/X }
C {devices/lab_pin.sym} 34900 -10450 0 1 {name=p34581 lab=_67347_/X }
C {sky130_stdcells/a21o_4.sym} 34820 -10450 0 0 {name=X_67347_ }
C {sky130_stdcells/decap_3.sym} 34820 -10280 0 0 {name=XPHY_506 }
C {devices/lab_pin.sym} 34760 -10150 0 0 {name=p34582 lab=_51396_/A }
C {devices/lab_pin.sym} 34760 -10110 0 0 {name=p34583 lab=_52573_/B }
C {devices/lab_pin.sym} 34760 -10070 0 0 {name=p34584 lab=_50918_/A }
C {devices/lab_pin.sym} 34880 -10110 0 1 {name=p34585 lab=_52573_/X }
C {sky130_stdcells/and3_4.sym} 34820 -10110 0 0 {name=X_52573_ }
C {devices/lab_pin.sym} 34760 -9990 0 0 {name=p34586 lab=_64689_/A }
C {devices/lab_pin.sym} 34760 -9950 0 0 {name=p34587 lab=_64741_/B }
C {devices/lab_pin.sym} 34760 -9910 0 0 {name=p34588 lab=_79529_/B }
C {devices/lab_pin.sym} 34880 -9950 0 1 {name=p34589 lab=_64559_/Y }
C {sky130_stdcells/nor3_4.sym} 34820 -9950 0 0 {name=X_64559_ }
C {devices/lab_pin.sym} 34730 -9810 0 0 {name=p34590 lab=_85505_/CLK }
C {devices/lab_pin.sym} 34730 -9790 0 0 {name=p34591 lab=_71742_/Y }
C {devices/lab_pin.sym} 34910 -9810 0 1 {name=p34592 lab=_83393_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -9800 0 0 {name=X_83393_ }
C {sky130_stdcells/decap_3.sym} 34820 -9640 0 0 {name=XPHY_517 }
C {sky130_stdcells/decap_3.sym} 34820 -9460 0 0 {name=XPHY_528 }
C {devices/lab_pin.sym} 34740 -9340 0 0 {name=p34593 lab=_57097_/X }
C {devices/lab_pin.sym} 34740 -9300 0 0 {name=p34594 lab=_56571_/X }
C {devices/lab_pin.sym} 34740 -9260 0 0 {name=p34595 lab=_45408_/A }
C {devices/lab_pin.sym} 34740 -9220 0 0 {name=p34596 lab=_57099_/X }
C {devices/lab_pin.sym} 34900 -9280 0 1 {name=p34597 lab=_57100_/X }
C {sky130_stdcells/a2bb2o_4.sym} 34820 -9280 0 0 {name=X_57100_ }
C {devices/lab_pin.sym} 34760 -9160 0 0 {name=p34598 lab=_54312_/A }
C {devices/lab_pin.sym} 34760 -9120 0 0 {name=p34599 lab=_54325_/B }
C {devices/lab_pin.sym} 34760 -9080 0 0 {name=p34600 lab=_54312_/C }
C {devices/lab_pin.sym} 34760 -9040 0 0 {name=p34601 lab=_54312_/D }
C {devices/lab_pin.sym} 34880 -9100 0 1 {name=p34602 lab=_54312_/X }
C {sky130_stdcells/and4_4.sym} 34820 -9100 0 0 {name=X_54312_ }
C {sky130_stdcells/decap_3.sym} 34820 -8920 0 0 {name=XPHY_539 }
C {devices/lab_pin.sym} 34730 -8770 0 0 {name=p34603 lab=_85067_/CLK }
C {devices/lab_pin.sym} 34730 -8750 0 0 {name=p34604 lab=_56799_/Y }
C {devices/lab_pin.sym} 34910 -8770 0 1 {name=p34605 lab=_85132_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -8760 0 0 {name=X_85132_ }
C {devices/lab_pin.sym} 34760 -8640 0 0 {name=p34606 lab=_51514_/A }
C {devices/lab_pin.sym} 34760 -8600 0 0 {name=p34607 lab=_53050_/B }
C {devices/lab_pin.sym} 34880 -8620 0 1 {name=p34608 lab=_51524_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -8620 0 0 {name=X_51524_ }
C {devices/lab_pin.sym} 34780 -8490 0 0 {name=p34609 lab=_58080_/A }
C {devices/lab_pin.sym} 34860 -8490 0 1 {name=p34610 lab=_58576_/A }
C {sky130_stdcells/buf_2.sym} 34820 -8490 0 0 {name=X_58080_ }
C {devices/lab_pin.sym} 34730 -8370 0 0 {name=p34611 lab=_82558_/CLK }
C {devices/lab_pin.sym} 34730 -8350 0 0 {name=p34612 lab=_77094_/X }
C {devices/lab_pin.sym} 34910 -8370 0 1 {name=p34613 lab=_48094_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -8360 0 0 {name=X_82344_ }
C {devices/lab_pin.sym} 34740 -8250 0 0 {name=p34614 lab=_55265_/Y }
C {devices/lab_pin.sym} 34740 -8210 0 0 {name=p34615 lab=_55289_/X }
C {devices/lab_pin.sym} 34740 -8170 0 0 {name=p34616 lab=_55291_/Y }
C {devices/lab_pin.sym} 34900 -8210 0 1 {name=p34617 lab=_55292_/X }
C {sky130_stdcells/o21a_4.sym} 34820 -8210 0 0 {name=X_55292_ }
C {devices/lab_pin.sym} 34780 -8070 0 0 {name=p34618 lab=_67039_/X }
C {devices/lab_pin.sym} 34860 -8070 0 1 {name=p34619 lab=_67278_/X }
C {sky130_stdcells/buf_2.sym} 34820 -8070 0 0 {name=X_67278_ }
C {devices/lab_pin.sym} 34780 -7950 0 0 {name=p34620 lab=_57031_/A }
C {devices/lab_pin.sym} 34860 -7950 0 1 {name=p34621 lab=_57031_/Y }
C {sky130_stdcells/inv_2.sym} 34820 -7950 0 0 {name=X_57031_ }
C {devices/lab_pin.sym} 34780 -7830 0 0 {name=p34622 lab=_68660_/X }
C {devices/lab_pin.sym} 34860 -7830 0 1 {name=p34623 lab=_69017_/X }
C {sky130_stdcells/buf_2.sym} 34820 -7830 0 0 {name=X_69017_ }
C {devices/lab_pin.sym} 34760 -7720 0 0 {name=p34624 lab=_54230_/A }
C {devices/lab_pin.sym} 34760 -7680 0 0 {name=p34625 lab=_53076_/B }
C {devices/lab_pin.sym} 34880 -7700 0 1 {name=p34626 lab=_54243_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -7700 0 0 {name=X_54243_ }
C {devices/lab_pin.sym} 34760 -7590 0 0 {name=p34627 lab=_65767_/X }
C {devices/lab_pin.sym} 34760 -7550 0 0 {name=p34628 lab=_66135_/B }
C {devices/lab_pin.sym} 34760 -7510 0 0 {name=p34629 lab=_65770_/X }
C {devices/lab_pin.sym} 34880 -7550 0 1 {name=p34630 lab=_66229_/Y }
C {sky130_stdcells/nand3_4.sym} 34820 -7550 0 0 {name=X_66229_ }
C {devices/lab_pin.sym} 34730 -7410 0 0 {name=p34631 lab=_85128_/CLK }
C {devices/lab_pin.sym} 34730 -7390 0 0 {name=p34632 lab=_57207_/X }
C {devices/lab_pin.sym} 34910 -7410 0 1 {name=p34633 lab=_85063_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -7400 0 0 {name=X_85063_ }
C {devices/lab_pin.sym} 34740 -7290 0 0 {name=p34634 lab=_86007_/Q }
C {devices/lab_pin.sym} 34740 -7250 0 0 {name=p34635 lab=_51429_/X }
C {devices/lab_pin.sym} 34740 -7210 0 0 {name=p34636 lab=_51454_/Y }
C {devices/lab_pin.sym} 34900 -7250 0 1 {name=p34637 lab=_51455_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -7250 0 0 {name=X_51455_ }
C {devices/lab_pin.sym} 34730 -7110 0 0 {name=p34638 lab=_82103_/CLK }
C {devices/lab_pin.sym} 34730 -7090 0 0 {name=p34639 lab=_77013_/B }
C {devices/lab_pin.sym} 34910 -7110 0 1 {name=p34640 lab=_82275_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -7100 0 0 {name=X_82275_ }
C {devices/lab_pin.sym} 34730 -6970 0 0 {name=p34641 lab=_84014_/CLK }
C {devices/lab_pin.sym} 34730 -6950 0 0 {name=p34642 lab=_68199_/X }
C {devices/lab_pin.sym} 34910 -6970 0 1 {name=p34643 lab=_84014_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -6960 0 0 {name=X_84014_ }
C {devices/lab_pin.sym} 34740 -6850 0 0 {name=p34644 lab=_86207_/Q }
C {devices/lab_pin.sym} 34740 -6810 0 0 {name=p34645 lab=_50403_/X }
C {devices/lab_pin.sym} 34740 -6770 0 0 {name=p34646 lab=_50405_/Y }
C {devices/lab_pin.sym} 34900 -6810 0 1 {name=p34647 lab=_50406_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -6810 0 0 {name=X_50406_ }
C {devices/lab_pin.sym} 34730 -6670 0 0 {name=p34648 lab=_81224_/CLK }
C {devices/lab_pin.sym} 34730 -6650 0 0 {name=p34649 lab=_81034_/Q }
C {devices/lab_pin.sym} 34910 -6670 0 1 {name=p34650 lab=_47747_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -6660 0 0 {name=X_81226_ }
C {devices/lab_pin.sym} 34740 -6550 0 0 {name=p34651 lab=_54170_/Y }
C {devices/lab_pin.sym} 34740 -6510 0 0 {name=p34652 lab=_54171_/X }
C {devices/lab_pin.sym} 34740 -6470 0 0 {name=p34653 lab=_54173_/X }
C {devices/lab_pin.sym} 34900 -6510 0 1 {name=p34654 lab=_85491_/D }
C {sky130_stdcells/a21oi_4.sym} 34820 -6510 0 0 {name=X_54174_ }
C {devices/lab_pin.sym} 34780 -6370 0 0 {name=p34655 lab=_48808_/A }
C {devices/lab_pin.sym} 34860 -6370 0 1 {name=p34656 lab=_51789_/A }
C {sky130_stdcells/buf_2.sym} 34820 -6370 0 0 {name=X_51386_ }
C {devices/lab_pin.sym} 34760 -6280 0 0 {name=p34657 lab=_53133_/A }
C {devices/lab_pin.sym} 34760 -6240 0 0 {name=p34658 lab=_53133_/B }
C {devices/lab_pin.sym} 34760 -6200 0 0 {name=p34659 lab=_53133_/C }
C {devices/lab_pin.sym} 34760 -6160 0 0 {name=p34660 lab=_53125_/D }
C {devices/lab_pin.sym} 34880 -6220 0 1 {name=p34661 lab=_53125_/X }
C {sky130_stdcells/and4_4.sym} 34820 -6220 0 0 {name=X_53125_ }
C {devices/lab_pin.sym} 34780 -6070 0 0 {name=p34662 lab=_50537_/A }
C {devices/lab_pin.sym} 34860 -6070 0 1 {name=p34663 lab=_50510_/A }
C {sky130_stdcells/buf_2.sym} 34820 -6070 0 0 {name=X_50337_ }
C {devices/lab_pin.sym} 34780 -5950 0 0 {name=p34664 lab=clkbuf_9_331_0_CLK/X }
C {devices/lab_pin.sym} 34860 -5950 0 1 {name=p34665 lab=_88128_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 34820 -5950 0 0 {name=Xclkbuf_10_663_0_CLK }
C {devices/lab_pin.sym} 34730 -5830 0 0 {name=p34666 lab=_81179_/CLK }
C {devices/lab_pin.sym} 34730 -5810 0 0 {name=p34667 lab=_74868_/B }
C {devices/lab_pin.sym} 34910 -5830 0 1 {name=p34668 lab=_40530_/B }
C {sky130_stdcells/dfxtp_4.sym} 34820 -5820 0 0 {name=X_81157_ }
C {devices/lab_pin.sym} 34780 -5690 0 0 {name=p34669 lab=_58982_/A }
C {devices/lab_pin.sym} 34860 -5690 0 1 {name=p34670 lab=_58982_/X }
C {sky130_stdcells/buf_2.sym} 34820 -5690 0 0 {name=X_58982_ }
C {devices/lab_pin.sym} 34760 -5580 0 0 {name=p34671 lab=_80101_/X }
C {devices/lab_pin.sym} 34760 -5540 0 0 {name=p34672 lab=_80108_/B }
C {devices/lab_pin.sym} 34880 -5560 0 1 {name=p34673 lab=_80108_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -5560 0 0 {name=X_80108_ }
C {devices/lab_pin.sym} 34740 -5460 0 0 {name=p34674 lab=_57922_/Y }
C {devices/lab_pin.sym} 34740 -5420 0 0 {name=p34675 lab=_57758_/X }
C {devices/lab_pin.sym} 34740 -5380 0 0 {name=p34676 lab=_57929_/X }
C {devices/lab_pin.sym} 34740 -5340 0 0 {name=p34677 lab=_57932_/X }
C {devices/lab_pin.sym} 34900 -5400 0 1 {name=p34678 lab=_57933_/Y }
C {sky130_stdcells/a22oi_4.sym} 34820 -5400 0 0 {name=X_57933_ }
C {devices/lab_pin.sym} 34780 -5250 0 0 {name=p34679 lab=_41069_/Y }
C {devices/lab_pin.sym} 34860 -5250 0 1 {name=p34680 lab=_41070_/X }
C {sky130_stdcells/buf_2.sym} 34820 -5250 0 0 {name=X_41070_ }
C {devices/lab_pin.sym} 34780 -5130 0 0 {name=p34681 lab=_53111_/A }
C {devices/lab_pin.sym} 34860 -5130 0 1 {name=p34682 lab=_53056_/X }
C {sky130_stdcells/buf_2.sym} 34820 -5130 0 0 {name=X_53056_ }
C {devices/lab_pin.sym} 34740 -5040 0 0 {name=p34683 lab=_73438_/A }
C {devices/lab_pin.sym} 34740 -5000 0 0 {name=p34684 lab=_68463_/X }
C {devices/lab_pin.sym} 34740 -4960 0 0 {name=p34685 lab=_69478_/X }
C {devices/lab_pin.sym} 34740 -4920 0 0 {name=p34686 lab=_69918_/Y }
C {devices/lab_pin.sym} 34900 -4980 0 1 {name=p34687 lab=_69919_/X }
C {sky130_stdcells/a211o_4.sym} 34820 -4980 0 0 {name=X_69919_ }
C {devices/lab_pin.sym} 34760 -4840 0 0 {name=p34688 lab=_50240_/A }
C {devices/lab_pin.sym} 34760 -4800 0 0 {name=p34689 lab=_50268_/B }
C {devices/lab_pin.sym} 34880 -4820 0 1 {name=p34690 lab=_50268_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -4820 0 0 {name=X_50268_ }
C {devices/lab_pin.sym} 34730 -4690 0 0 {name=p34691 lab=_84802_/CLK }
C {devices/lab_pin.sym} 34730 -4670 0 0 {name=p34692 lab=_51685_/Y }
C {devices/lab_pin.sym} 34910 -4690 0 1 {name=p34693 lab=_85965_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -4680 0 0 {name=X_85965_ }
C {devices/lab_pin.sym} 34780 -4550 0 0 {name=p34694 lab=clkbuf_8_77_0_CLK/X }
C {devices/lab_pin.sym} 34860 -4550 0 1 {name=p34695 lab=clkbuf_9_154_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 34820 -4550 0 0 {name=Xclkbuf_9_154_0_CLK }
C {devices/lab_pin.sym} 34730 -4430 0 0 {name=p34696 lab=_80681_/CLK }
C {devices/lab_pin.sym} 34730 -4410 0 0 {name=p34697 lab=_81120_/Q }
C {devices/lab_pin.sym} 34910 -4430 0 1 {name=p34698 lab=_75541_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -4420 0 0 {name=X_81088_ }
C {devices/lab_pin.sym} 34780 -4290 0 0 {name=p34699 lab=clkbuf_8_40_0_CLK/X }
C {devices/lab_pin.sym} 34860 -4290 0 1 {name=p34700 lab=clkbuf_9_81_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 34820 -4290 0 0 {name=Xclkbuf_9_81_0_CLK }
C {devices/lab_pin.sym} 34760 -4180 0 0 {name=p34701 lab=_51982_/X }
C {devices/lab_pin.sym} 34760 -4140 0 0 {name=p34702 lab=_48257_/B }
C {devices/lab_pin.sym} 34880 -4160 0 1 {name=p34703 lab=_52007_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -4160 0 0 {name=X_52007_ }
C {devices/lab_pin.sym} 34730 -4030 0 0 {name=p34704 lab=_87221_/CLK }
C {devices/lab_pin.sym} 34730 -4010 0 0 {name=p34705 lab=_42814_/X }
C {devices/lab_pin.sym} 34910 -4030 0 1 {name=p34706 lab=_67972_/B }
C {sky130_stdcells/dfxtp_4.sym} 34820 -4020 0 0 {name=X_87704_ }
C {devices/lab_pin.sym} 34740 -3920 0 0 {name=p34707 lab=_72806_/X }
C {devices/lab_pin.sym} 34740 -3880 0 0 {name=p34708 lab=_86203_/Q }
C {devices/lab_pin.sym} 34740 -3840 0 0 {name=p34709 lab=_72746_/X }
C {devices/lab_pin.sym} 34740 -3800 0 0 {name=p34710 lab=_72929_/X }
C {devices/lab_pin.sym} 34900 -3860 0 1 {name=p34711 lab=_72930_/X }
C {sky130_stdcells/a211o_4.sym} 34820 -3860 0 0 {name=X_72930_ }
C {devices/lab_pin.sym} 34730 -3710 0 0 {name=p34712 lab=_84915_/CLK }
C {devices/lab_pin.sym} 34730 -3690 0 0 {name=p34713 lab=_58169_/X }
C {devices/lab_pin.sym} 34910 -3710 0 1 {name=p34714 lab=_58166_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -3700 0 0 {name=X_84916_ }
C {devices/lab_pin.sym} 34760 -3580 0 0 {name=p34715 lab=_84933_/Q }
C {devices/lab_pin.sym} 34760 -3540 0 0 {name=p34716 lab=_84181_/Q }
C {devices/lab_pin.sym} 34880 -3560 0 1 {name=p34717 lab=_80039_/X }
C {sky130_stdcells/xor2_4.sym} 34820 -3560 0 0 {name=X_80039_ }
C {devices/lab_pin.sym} 34740 -3450 0 0 {name=p34718 lab=_57861_/Y }
C {devices/lab_pin.sym} 34740 -3410 0 0 {name=p34719 lab=_57863_/Y }
C {devices/lab_pin.sym} 34740 -3370 0 0 {name=p34720 lab=_57829_/X }
C {devices/lab_pin.sym} 34900 -3410 0 1 {name=p34721 lab=_57864_/X }
C {sky130_stdcells/a21o_4.sym} 34820 -3410 0 0 {name=X_57864_ }
C {devices/lab_pin.sym} 34760 -3280 0 0 {name=p34722 lab=_50187_/X }
C {devices/lab_pin.sym} 34760 -3240 0 0 {name=p34723 lab=_50712_/B }
C {devices/lab_pin.sym} 34880 -3260 0 1 {name=p34724 lab=_50199_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -3260 0 0 {name=X_50199_ }
C {devices/lab_pin.sym} 34730 -3130 0 0 {name=p34725 lab=_86210_/CLK }
C {devices/lab_pin.sym} 34730 -3110 0 0 {name=p34726 lab=_85896_/D }
C {devices/lab_pin.sym} 34910 -3130 0 1 {name=p34727 lab=_85896_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -3120 0 0 {name=X_85896_ }
C {devices/lab_pin.sym} 34780 -2990 0 0 {name=p34728 lab=_59603_/A }
C {devices/lab_pin.sym} 34860 -2990 0 1 {name=p34729 lab=_72569_/C }
C {sky130_stdcells/buf_2.sym} 34820 -2990 0 0 {name=X_59603_ }
C {devices/lab_pin.sym} 34780 -2870 0 0 {name=p34730 lab=clkbuf_9_339_0_CLK/X }
C {devices/lab_pin.sym} 34860 -2870 0 1 {name=p34731 lab=_87898_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 34820 -2870 0 0 {name=Xclkbuf_10_678_0_CLK }
C {devices/lab_pin.sym} 34740 -2770 0 0 {name=p34732 lab=_56725_/B }
C {devices/lab_pin.sym} 34740 -2730 0 0 {name=p34733 lab=_56806_/Y }
C {devices/lab_pin.sym} 34740 -2690 0 0 {name=p34734 lab=_56814_/Y }
C {devices/lab_pin.sym} 34900 -2730 0 1 {name=p34735 lab=_85131_/D }
C {sky130_stdcells/o21ai_4.sym} 34820 -2730 0 0 {name=X_56815_ }
C {devices/lab_pin.sym} 34730 -2590 0 0 {name=p34736 lab=_87995_/CLK }
C {devices/lab_pin.sym} 34730 -2570 0 0 {name=p34737 lab=_87635_/D }
C {devices/lab_pin.sym} 34910 -2590 0 1 {name=p34738 lab=_66567_/B }
C {sky130_stdcells/dfxtp_4.sym} 34820 -2580 0 0 {name=X_87635_ }
C {devices/lab_pin.sym} 34780 -2450 0 0 {name=p34739 lab=_73067_/A }
C {devices/lab_pin.sym} 34860 -2450 0 1 {name=p34740 lab=_72861_/X }
C {sky130_stdcells/buf_2.sym} 34820 -2450 0 0 {name=X_72861_ }
C {devices/lab_pin.sym} 34730 -2330 0 0 {name=p34741 lab=_83457_/CLK }
C {devices/lab_pin.sym} 34730 -2310 0 0 {name=p34742 lab=_84847_/D }
C {devices/lab_pin.sym} 34910 -2330 0 1 {name=p34743 lab=_84847_/Q }
C {sky130_stdcells/dfxtp_4.sym} 34820 -2320 0 0 {name=X_84847_ }
C {devices/lab_pin.sym} 34780 -2190 0 0 {name=p34744 lab=_72417_/A }
C {devices/lab_pin.sym} 34860 -2190 0 1 {name=p34745 lab=_57795_/X }
C {sky130_stdcells/buf_2.sym} 34820 -2190 0 0 {name=X_57795_ }
C {devices/lab_pin.sym} 34780 -2070 0 0 {name=p34746 lab=_74600_/A }
C {devices/lab_pin.sym} 34860 -2070 0 1 {name=p34747 lab=_74600_/X }
C {sky130_stdcells/buf_2.sym} 34820 -2070 0 0 {name=X_74600_ }
C {devices/lab_pin.sym} 34740 -1970 0 0 {name=p34748 lab=_71805_/X }
C {devices/lab_pin.sym} 34740 -1930 0 0 {name=p34749 lab=_83367_/Q }
C {devices/lab_pin.sym} 34740 -1890 0 0 {name=p34750 lab=_71811_/X }
C {devices/lab_pin.sym} 34900 -1930 0 1 {name=p34751 lab=_83367_/D }
C {sky130_stdcells/a21o_4.sym} 34820 -1930 0 0 {name=X_71812_ }
C {devices/lab_pin.sym} 34760 -1810 0 0 {name=p34752 lab=_59546_/A }
C {devices/lab_pin.sym} 34760 -1770 0 0 {name=p34753 lab=_59563_/A }
C {devices/lab_pin.sym} 34760 -1730 0 0 {name=p34754 lab=_59519_/C }
C {devices/lab_pin.sym} 34880 -1770 0 1 {name=p34755 lab=_59535_/A }
C {sky130_stdcells/nand3_4.sym} 34820 -1770 0 0 {name=X_59534_ }
C {devices/lab_pin.sym} 34780 -1630 0 0 {name=p34756 lab=clkbuf_8_84_0_CLK/X }
C {devices/lab_pin.sym} 34860 -1630 0 1 {name=p34757 lab=clkbuf_9_169_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 34820 -1630 0 0 {name=Xclkbuf_9_169_0_CLK }
C {devices/lab_pin.sym} 34780 -1510 0 0 {name=p34758 lab=_44760_/A }
C {devices/lab_pin.sym} 34860 -1510 0 1 {name=p34759 lab=_86969_/D }
C {sky130_stdcells/inv_2.sym} 34820 -1510 0 0 {name=X_44760_ }
C {devices/lab_pin.sym} 34760 -1400 0 0 {name=p34760 lab=_56725_/Y }
C {devices/lab_pin.sym} 34760 -1360 0 0 {name=p34761 lab=_56745_/X }
C {devices/lab_pin.sym} 34880 -1380 0 1 {name=p34762 lab=_85135_/D }
C {sky130_stdcells/nand2_4.sym} 34820 -1380 0 0 {name=X_56746_ }
C {devices/lab_pin.sym} 34760 -1260 0 0 {name=p34763 lab=_75579_/Y }
C {devices/lab_pin.sym} 34760 -1220 0 0 {name=p34764 lab=_80819_/Q }
C {devices/lab_pin.sym} 34880 -1240 0 1 {name=p34765 lab=_75580_/Y }
C {sky130_stdcells/nand2_4.sym} 34820 -1240 0 0 {name=X_75580_ }
C {devices/lab_pin.sym} 34730 -1110 0 0 {name=p34766 lab=_87824_/CLK }
C {devices/lab_pin.sym} 34730 -1090 0 0 {name=p34767 lab=_87566_/D }
C {devices/lab_pin.sym} 34910 -1110 0 1 {name=p34768 lab=_43126_/A }
C {sky130_stdcells/dfxtp_4.sym} 34820 -1100 0 0 {name=X_87566_ }
C {devices/lab_pin.sym} 34780 -970 0 0 {name=p34769 lab=_41972_/A }
C {devices/lab_pin.sym} 34860 -970 0 1 {name=p34770 lab=_41972_/Y }
C {sky130_stdcells/inv_2.sym} 34820 -970 0 0 {name=X_41972_ }
C {devices/lab_pin.sym} 34740 -870 0 0 {name=p34771 lab=_85534_/Q }
C {devices/lab_pin.sym} 34740 -830 0 0 {name=p34772 lab=_53955_/X }
C {devices/lab_pin.sym} 34740 -790 0 0 {name=p34773 lab=_53957_/Y }
C {devices/lab_pin.sym} 34900 -830 0 1 {name=p34774 lab=_53958_/Y }
C {sky130_stdcells/o21ai_4.sym} 34820 -830 0 0 {name=X_53958_ }
C {devices/lab_pin.sym} 34740 -710 0 0 {name=p34775 lab=_72790_/X }
C {devices/lab_pin.sym} 34740 -670 0 0 {name=p34776 lab=_72791_/Y }
C {devices/lab_pin.sym} 34740 -630 0 0 {name=p34777 lab=_72766_/X }
C {devices/lab_pin.sym} 34900 -670 0 1 {name=p34778 lab=_72792_/Y }
C {sky130_stdcells/a21oi_4.sym} 34820 -670 0 0 {name=X_72792_ }
C {devices/lab_pin.sym} 35650 -42150 0 0 {name=p34779 lab=_84778_/CLK }
C {devices/lab_pin.sym} 35650 -42130 0 0 {name=p34780 lab=_58995_/Y }
C {devices/lab_pin.sym} 35830 -42150 0 1 {name=p34781 lab=_62186_/A }
C {sky130_stdcells/dfxtp_4.sym} 35740 -42140 0 0 {name=X_84778_ }
C {devices/lab_pin.sym} 35700 -42010 0 0 {name=p34782 lab=clkbuf_9_97_0_CLK/A }
C {devices/lab_pin.sym} 35780 -42010 0 1 {name=p34783 lab=clkbuf_9_96_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 35740 -42010 0 0 {name=Xclkbuf_9_96_0_CLK }
C {devices/lab_pin.sym} 35660 -41920 0 0 {name=p34784 lab=_40848_/X }
C {devices/lab_pin.sym} 35660 -41880 0 0 {name=p34785 lab=_43698_/X }
C {devices/lab_pin.sym} 35660 -41840 0 0 {name=p34786 lab=_69780_/B }
C {devices/lab_pin.sym} 35660 -41800 0 0 {name=p34787 lab=_43700_/X }
C {devices/lab_pin.sym} 35820 -41860 0 1 {name=p34788 lab=_43712_/A }
C {sky130_stdcells/a2bb2o_4.sym} 35740 -41860 0 0 {name=X_43711_ }
C {devices/lab_pin.sym} 35680 -41740 0 0 {name=p34789 lab=_74531_/A }
C {devices/lab_pin.sym} 35680 -41700 0 0 {name=p34790 lab=_74531_/B }
C {devices/lab_pin.sym} 35680 -41660 0 0 {name=p34791 lab=_74531_/C }
C {devices/lab_pin.sym} 35680 -41620 0 0 {name=p34792 lab=_74531_/D }
C {devices/lab_pin.sym} 35800 -41680 0 1 {name=p34793 lab=_74531_/Y }
C {sky130_stdcells/nand4_4.sym} 35740 -41680 0 0 {name=X_74531_ }
C {devices/lab_pin.sym} 35650 -41530 0 0 {name=p34794 lab=_85581_/CLK }
C {devices/lab_pin.sym} 35650 -41510 0 0 {name=p34795 lab=_86517_/D }
C {devices/lab_pin.sym} 35830 -41530 0 1 {name=p34796 lab=_73096_/B }
C {sky130_stdcells/dfxtp_4.sym} 35740 -41520 0 0 {name=X_86517_ }
C {devices/lab_pin.sym} 35680 -41400 0 0 {name=p34797 lab=_40923_/A }
C {devices/lab_pin.sym} 35680 -41360 0 0 {name=p34798 lab=_40842_/X }
C {devices/lab_pin.sym} 35800 -41380 0 1 {name=p34799 lab=_40923_/X }
C {sky130_stdcells/or2_4.sym} 35740 -41380 0 0 {name=X_40923_ }
C {devices/lab_pin.sym} 35660 -41270 0 0 {name=p34800 lab=_52906_/Y }
C {devices/lab_pin.sym} 35660 -41230 0 0 {name=p34801 lab=_52892_/X }
C {devices/lab_pin.sym} 35660 -41190 0 0 {name=p34802 lab=_52908_/X }
C {devices/lab_pin.sym} 35820 -41230 0 1 {name=p34803 lab=_85733_/D }
C {sky130_stdcells/a21oi_4.sym} 35740 -41230 0 0 {name=X_52909_ }
C {devices/lab_pin.sym} 35700 -41090 0 0 {name=p34804 lab=_71026_/A }
C {devices/lab_pin.sym} 35780 -41090 0 1 {name=p34805 lab=_71744_/C }
C {sky130_stdcells/buf_2.sym} 35740 -41090 0 0 {name=X_71743_ }
C {devices/lab_pin.sym} 35680 -40980 0 0 {name=p34806 lab=_59463_/Y }
C {devices/lab_pin.sym} 35680 -40940 0 0 {name=p34807 lab=_59478_/B }
C {devices/lab_pin.sym} 35800 -40960 0 1 {name=p34808 lab=_59465_/Y }
C {sky130_stdcells/nand2_4.sym} 35740 -40960 0 0 {name=X_59465_ }
C {devices/lab_pin.sym} 35650 -40830 0 0 {name=p34809 lab=_85379_/CLK }
C {devices/lab_pin.sym} 35650 -40810 0 0 {name=p34810 lab=_70671_/X }
C {devices/lab_pin.sym} 35830 -40830 0 1 {name=p34811 lab=_83729_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -40820 0 0 {name=X_83729_ }
C {devices/lab_pin.sym} 35700 -40690 0 0 {name=p34812 lab=clkbuf_9_300_0_CLK/X }
C {devices/lab_pin.sym} 35780 -40690 0 1 {name=p34813 lab=_81985_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 35740 -40690 0 0 {name=Xclkbuf_10_601_0_CLK }
C {devices/lab_pin.sym} 35700 -40570 0 0 {name=p34814 lab=_44691_/A }
C {devices/lab_pin.sym} 35780 -40570 0 1 {name=p34815 lab=_44691_/Y }
C {sky130_stdcells/inv_2.sym} 35740 -40570 0 0 {name=X_44691_ }
C {devices/lab_pin.sym} 35680 -40460 0 0 {name=p34816 lab=_56700_/C }
C {devices/lab_pin.sym} 35680 -40420 0 0 {name=p34817 lab=_56676_/Y }
C {devices/lab_pin.sym} 35800 -40440 0 1 {name=p34818 lab=_56679_/B }
C {sky130_stdcells/nor2_4.sym} 35740 -40440 0 0 {name=X_56677_ }
C {devices/lab_pin.sym} 35650 -40310 0 0 {name=p34819 lab=_88012_/CLK }
C {devices/lab_pin.sym} 35650 -40290 0 0 {name=p34820 lab=_43289_/X }
C {devices/lab_pin.sym} 35830 -40310 0 1 {name=p34821 lab=_87497_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -40300 0 0 {name=X_87497_ }
C {devices/lab_pin.sym} 35660 -40190 0 0 {name=p34822 lab=_53887_/Y }
C {devices/lab_pin.sym} 35660 -40150 0 0 {name=p34823 lab=_53829_/X }
C {devices/lab_pin.sym} 35660 -40110 0 0 {name=p34824 lab=_53888_/X }
C {devices/lab_pin.sym} 35820 -40150 0 1 {name=p34825 lab=_85548_/D }
C {sky130_stdcells/a21oi_4.sym} 35740 -40150 0 0 {name=X_53889_ }
C {devices/lab_pin.sym} 35700 -40010 0 0 {name=p34826 lab=_46279_/A }
C {devices/lab_pin.sym} 35780 -40010 0 1 {name=p34827 lab=_46430_/X }
C {sky130_stdcells/buf_2.sym} 35740 -40010 0 0 {name=X_46430_ }
C {devices/lab_pin.sym} 35660 -39910 0 0 {name=p34828 lab=_58406_/X }
C {devices/lab_pin.sym} 35660 -39870 0 0 {name=p34829 lab=_83366_/Q }
C {devices/lab_pin.sym} 35660 -39830 0 0 {name=p34830 lab=_58415_/Y }
C {devices/lab_pin.sym} 35820 -39870 0 1 {name=p34831 lab=_84854_/D }
C {sky130_stdcells/o21a_4.sym} 35740 -39870 0 0 {name=X_58416_ }
C {devices/lab_pin.sym} 35700 -39730 0 0 {name=p34832 lab=_77250_/A }
C {devices/lab_pin.sym} 35780 -39730 0 1 {name=p34833 lab=_77252_/A }
C {sky130_stdcells/inv_2.sym} 35740 -39730 0 0 {name=X_77250_ }
C {devices/lab_pin.sym} 35680 -39620 0 0 {name=p34834 lab=_44070_/B }
C {devices/lab_pin.sym} 35680 -39580 0 0 {name=p34835 lab=_55628_/B }
C {devices/lab_pin.sym} 35800 -39600 0 1 {name=p34836 lab=_55628_/Y }
C {sky130_stdcells/nor2_4.sym} 35740 -39600 0 0 {name=X_55628_ }
C {devices/lab_pin.sym} 35660 -39500 0 0 {name=p34837 lab=_40682_/A }
C {devices/lab_pin.sym} 35660 -39460 0 0 {name=p34838 lab=_43634_/X }
C {devices/lab_pin.sym} 35660 -39420 0 0 {name=p34839 lab=_43641_/Y }
C {devices/lab_pin.sym} 35660 -39380 0 0 {name=p34840 lab=_43636_/X }
C {devices/lab_pin.sym} 35820 -39440 0 1 {name=p34841 lab=_43642_/X }
C {sky130_stdcells/a2bb2o_4.sym} 35740 -39440 0 0 {name=X_43642_ }
C {devices/lab_pin.sym} 35660 -39310 0 0 {name=p34842 lab=_83061_/Q }
C {devices/lab_pin.sym} 35660 -39270 0 0 {name=p34843 lab=_74441_/X }
C {devices/lab_pin.sym} 35660 -39230 0 0 {name=p34844 lab=_74461_/Y }
C {devices/lab_pin.sym} 35820 -39270 0 1 {name=p34845 lab=_74462_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -39270 0 0 {name=X_74462_ }
C {devices/lab_pin.sym} 35650 -39130 0 0 {name=p34846 lab=_85554_/CLK }
C {devices/lab_pin.sym} 35650 -39110 0 0 {name=p34847 lab=_49062_/Y }
C {devices/lab_pin.sym} 35830 -39130 0 1 {name=p34848 lab=_65066_/B }
C {sky130_stdcells/dfxtp_4.sym} 35740 -39120 0 0 {name=X_86448_ }
C {devices/lab_pin.sym} 35700 -38990 0 0 {name=p34849 lab=_40853_/X }
C {devices/lab_pin.sym} 35780 -38990 0 1 {name=p34850 lab=_40854_/X }
C {sky130_stdcells/buf_2.sym} 35740 -38990 0 0 {name=X_40854_ }
C {devices/lab_pin.sym} 35680 -38890 0 0 {name=p34851 lab=_71680_/A }
C {devices/lab_pin.sym} 35680 -38850 0 0 {name=p34852 lab=_71671_/X }
C {devices/lab_pin.sym} 35680 -38810 0 0 {name=p34853 lab=_71297_/X }
C {devices/lab_pin.sym} 35800 -38850 0 1 {name=p34854 lab=_71674_/Y }
C {sky130_stdcells/nand3_4.sym} 35740 -38850 0 0 {name=X_71674_ }
C {devices/lab_pin.sym} 35700 -38710 0 0 {name=p34855 lab=_63127_/A }
C {devices/lab_pin.sym} 35780 -38710 0 1 {name=p34856 lab=_59399_/A }
C {sky130_stdcells/buf_2.sym} 35740 -38710 0 0 {name=X_59396_ }
C {devices/lab_pin.sym} 35680 -38600 0 0 {name=p34857 lab=_76200_/A }
C {devices/lab_pin.sym} 35680 -38560 0 0 {name=p34858 lab=_76200_/B }
C {devices/lab_pin.sym} 35800 -38580 0 1 {name=p34859 lab=_76201_/Y }
C {sky130_stdcells/nand2_4.sym} 35740 -38580 0 0 {name=X_76201_ }
C {devices/lab_pin.sym} 35660 -38470 0 0 {name=p34860 lab=_73411_/X }
C {devices/lab_pin.sym} 35660 -38430 0 0 {name=p34861 lab=_73412_/Y }
C {devices/lab_pin.sym} 35660 -38390 0 0 {name=p34862 lab=_73367_/X }
C {devices/lab_pin.sym} 35820 -38430 0 1 {name=p34863 lab=_73413_/Y }
C {sky130_stdcells/a21oi_4.sym} 35740 -38430 0 0 {name=X_73413_ }
C {devices/lab_pin.sym} 35700 -38290 0 0 {name=p34864 lab=_46361_/A }
C {devices/lab_pin.sym} 35780 -38290 0 1 {name=p34865 lab=_52468_/B }
C {sky130_stdcells/buf_2.sym} 35740 -38290 0 0 {name=X_46361_ }
C {devices/lab_pin.sym} 35680 -38180 0 0 {name=p34866 lab=_70423_/X }
C {devices/lab_pin.sym} 35680 -38140 0 0 {name=p34867 lab=_71162_/B }
C {devices/lab_pin.sym} 35800 -38160 0 1 {name=p34868 lab=_70625_/Y }
C {sky130_stdcells/nor2_4.sym} 35740 -38160 0 0 {name=X_70625_ }
C {devices/lab_pin.sym} 35700 -38030 0 0 {name=p34869 lab=_63295_/A }
C {devices/lab_pin.sym} 35780 -38030 0 1 {name=p34870 lab=_58348_/A }
C {sky130_stdcells/buf_2.sym} 35740 -38030 0 0 {name=X_58347_ }
C {devices/lab_pin.sym} 35680 -37920 0 0 {name=p34871 lab=_77184_/A }
C {devices/lab_pin.sym} 35680 -37880 0 0 {name=p34872 lab=_77181_/B }
C {devices/lab_pin.sym} 35800 -37900 0 1 {name=p34873 lab=_77182_/B }
C {sky130_stdcells/xor2_4.sym} 35740 -37900 0 0 {name=X_77181_ }
C {devices/lab_pin.sym} 35660 -37800 0 0 {name=p34874 lab=_40524_/X }
C {devices/lab_pin.sym} 35660 -37760 0 0 {name=p34875 lab=_43560_/X }
C {devices/lab_pin.sym} 35660 -37720 0 0 {name=p34876 lab=_87353_/Q }
C {devices/lab_pin.sym} 35660 -37680 0 0 {name=p34877 lab=_43561_/X }
C {devices/lab_pin.sym} 35820 -37740 0 1 {name=p34878 lab=_87353_/D }
C {sky130_stdcells/a2bb2o_4.sym} 35740 -37740 0 0 {name=X_43573_ }
C {devices/lab_pin.sym} 35660 -37620 0 0 {name=p34879 lab=_85115_/Q }
C {devices/lab_pin.sym} 35660 -37580 0 0 {name=p34880 lab=_55522_/X }
C {devices/lab_pin.sym} 35660 -37540 0 0 {name=p34881 lab=_55506_/X }
C {devices/lab_pin.sym} 35660 -37500 0 0 {name=p34882 lab=_55558_/Y }
C {devices/lab_pin.sym} 35820 -37560 0 1 {name=p34883 lab=_55559_/X }
C {sky130_stdcells/a211o_4.sym} 35740 -37560 0 0 {name=X_55559_ }
C {devices/lab_pin.sym} 35680 -37420 0 0 {name=p34884 lab=_74408_/A }
C {devices/lab_pin.sym} 35680 -37380 0 0 {name=p34885 lab=_53647_/B }
C {devices/lab_pin.sym} 35800 -37400 0 1 {name=p34886 lab=_74393_/Y }
C {sky130_stdcells/nand2_4.sym} 35740 -37400 0 0 {name=X_74393_ }
C {devices/lab_pin.sym} 35650 -37270 0 0 {name=p34887 lab=_86381_/CLK }
C {devices/lab_pin.sym} 35650 -37250 0 0 {name=p34888 lab=_86379_/D }
C {devices/lab_pin.sym} 35830 -37270 0 1 {name=p34889 lab=_86379_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -37260 0 0 {name=X_86379_ }
C {devices/lab_pin.sym} 35680 -37140 0 0 {name=p34890 lab=_82877_/Q }
C {devices/lab_pin.sym} 35680 -37100 0 0 {name=p34891 lab=_40847_/B }
C {devices/lab_pin.sym} 35800 -37120 0 1 {name=p34892 lab=_40785_/X }
C {sky130_stdcells/or2_4.sym} 35740 -37120 0 0 {name=X_40785_ }
C {devices/lab_pin.sym} 35680 -37010 0 0 {name=p34893 lab=_50360_/A }
C {devices/lab_pin.sym} 35680 -36970 0 0 {name=p34894 lab=_48099_/X }
C {devices/lab_pin.sym} 35680 -36930 0 0 {name=p34895 lab=_48723_/C }
C {devices/lab_pin.sym} 35800 -36970 0 1 {name=p34896 lab=_48100_/X }
C {sky130_stdcells/and3_4.sym} 35740 -36970 0 0 {name=X_48100_ }
C {devices/lab_pin.sym} 35660 -36850 0 0 {name=p34897 lab=_55702_/B }
C {devices/lab_pin.sym} 35660 -36810 0 0 {name=p34898 lab=_45281_/X }
C {devices/lab_pin.sym} 35660 -36770 0 0 {name=p34899 lab=_45311_/X }
C {devices/lab_pin.sym} 35820 -36810 0 1 {name=p34900 lab=_45312_/X }
C {sky130_stdcells/o21a_4.sym} 35740 -36810 0 0 {name=X_45312_ }
C {devices/lab_pin.sym} 35680 -36680 0 0 {name=p34901 lab=_81726_/D }
C {devices/lab_pin.sym} 35680 -36640 0 0 {name=p34902 lab=_76133_/B }
C {devices/lab_pin.sym} 35800 -36660 0 1 {name=p34903 lab=_76132_/X }
C {sky130_stdcells/or2_4.sym} 35740 -36660 0 0 {name=X_76132_ }
C {devices/lab_pin.sym} 35650 -36530 0 0 {name=p34904 lab=_88376_/CLK }
C {devices/lab_pin.sym} 35650 -36510 0 0 {name=p34905 lab=_88118_/D }
C {devices/lab_pin.sym} 35830 -36530 0 1 {name=p34906 lab=_88118_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -36520 0 0 {name=X_88118_ }
C {devices/lab_pin.sym} 35700 -36390 0 0 {name=p34907 lab=_42524_/A }
C {devices/lab_pin.sym} 35780 -36390 0 1 {name=p34908 lab=_87835_/D }
C {sky130_stdcells/inv_2.sym} 35740 -36390 0 0 {name=X_42524_ }
C {devices/lab_pin.sym} 35680 -36280 0 0 {name=p34909 lab=_49080_/A }
C {devices/lab_pin.sym} 35680 -36240 0 0 {name=p34910 lab=_53879_/B }
C {devices/lab_pin.sym} 35800 -36260 0 1 {name=p34911 lab=_49080_/X }
C {sky130_stdcells/and2_4.sym} 35740 -36260 0 0 {name=X_49080_ }
C {devices/lab_pin.sym} 35700 -36130 0 0 {name=p34912 lab=clkbuf_9_308_0_CLK/X }
C {devices/lab_pin.sym} 35780 -36130 0 1 {name=p34913 lab=_81154_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 35740 -36130 0 0 {name=Xclkbuf_10_616_0_CLK }
C {devices/lab_pin.sym} 35700 -36010 0 0 {name=p34914 lab=_73343_/X }
C {devices/lab_pin.sym} 35780 -36010 0 1 {name=p34915 lab=_73344_/X }
C {sky130_stdcells/buf_2.sym} 35740 -36010 0 0 {name=X_73344_ }
C {devices/lab_pin.sym} 35700 -35890 0 0 {name=p34916 lab=_46719_/A }
C {devices/lab_pin.sym} 35780 -35890 0 1 {name=p34917 lab=_46292_/X }
C {sky130_stdcells/buf_2.sym} 35740 -35890 0 0 {name=X_46292_ }
C {devices/lab_pin.sym} 35660 -35790 0 0 {name=p34918 lab=_70533_/X }
C {devices/lab_pin.sym} 35660 -35750 0 0 {name=p34919 lab=_83750_/Q }
C {devices/lab_pin.sym} 35660 -35710 0 0 {name=p34920 lab=_70555_/Y }
C {devices/lab_pin.sym} 35820 -35750 0 1 {name=p34921 lab=_70556_/X }
C {sky130_stdcells/a21o_4.sym} 35740 -35750 0 0 {name=X_70556_ }
C {devices/lab_pin.sym} 35660 -35630 0 0 {name=p34922 lab=_58271_/X }
C {devices/lab_pin.sym} 35660 -35590 0 0 {name=p34923 lab=_83442_/Q }
C {devices/lab_pin.sym} 35660 -35550 0 0 {name=p34924 lab=_58277_/Y }
C {devices/lab_pin.sym} 35820 -35590 0 1 {name=p34925 lab=_84890_/D }
C {sky130_stdcells/o21a_4.sym} 35740 -35590 0 0 {name=X_58278_ }
C {devices/lab_pin.sym} 35700 -35450 0 0 {name=p34926 lab=_53552_/B }
C {devices/lab_pin.sym} 35780 -35450 0 1 {name=p34927 lab=_50328_/B }
C {sky130_stdcells/buf_2.sym} 35740 -35450 0 0 {name=X_48031_ }
C {devices/lab_pin.sym} 35700 -35330 0 0 {name=p34928 lab=_45883_/B }
C {devices/lab_pin.sym} 35780 -35330 0 1 {name=p34929 lab=_72710_/A }
C {sky130_stdcells/buf_2.sym} 35740 -35330 0 0 {name=X_57229_ }
C {devices/lab_pin.sym} 35660 -35230 0 0 {name=p34930 lab=_85291_/Q }
C {devices/lab_pin.sym} 35660 -35190 0 0 {name=p34931 lab=_45194_/X }
C {devices/lab_pin.sym} 35660 -35150 0 0 {name=p34932 lab=_45229_/X }
C {devices/lab_pin.sym} 35820 -35190 0 1 {name=p34933 lab=_45243_/X }
C {sky130_stdcells/o21a_4.sym} 35740 -35190 0 0 {name=X_45243_ }
C {devices/lab_pin.sym} 35680 -35070 0 0 {name=p34934 lab=_76063_/A }
C {devices/lab_pin.sym} 35680 -35030 0 0 {name=p34935 lab=_76063_/B }
C {devices/lab_pin.sym} 35680 -34990 0 0 {name=p34936 lab=_76063_/C }
C {devices/lab_pin.sym} 35800 -35030 0 1 {name=p34937 lab=_76064_/B }
C {sky130_stdcells/and3_4.sym} 35740 -35030 0 0 {name=X_76063_ }
C {devices/lab_pin.sym} 35650 -34890 0 0 {name=p34938 lab=_88056_/CLK }
C {devices/lab_pin.sym} 35650 -34870 0 0 {name=p34939 lab=_88049_/D }
C {devices/lab_pin.sym} 35830 -34890 0 1 {name=p34940 lab=_88049_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -34880 0 0 {name=X_88049_ }
C {devices/lab_pin.sym} 35700 -34750 0 0 {name=p34941 lab=clkbuf_8_53_0_CLK/X }
C {devices/lab_pin.sym} 35780 -34750 0 1 {name=p34942 lab=clkbuf_9_107_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 35740 -34750 0 0 {name=Xclkbuf_9_107_0_CLK }
C {devices/lab_pin.sym} 35700 -34630 0 0 {name=p34943 lab=_42454_/Y }
C {devices/lab_pin.sym} 35780 -34630 0 1 {name=p34944 lab=_87859_/D }
C {sky130_stdcells/inv_2.sym} 35740 -34630 0 0 {name=X_42455_ }
C {devices/lab_pin.sym} 35680 -34520 0 0 {name=p34945 lab=_73275_/A }
C {devices/lab_pin.sym} 35680 -34480 0 0 {name=p34946 lab=_73228_/B }
C {devices/lab_pin.sym} 35800 -34500 0 1 {name=p34947 lab=_73275_/Y }
C {sky130_stdcells/nor2_4.sym} 35740 -34500 0 0 {name=X_73275_ }
C {devices/lab_pin.sym} 35660 -34390 0 0 {name=p34948 lab=_70466_/Y }
C {devices/lab_pin.sym} 35660 -34350 0 0 {name=p34949 lab=_83763_/Q }
C {devices/lab_pin.sym} 35660 -34310 0 0 {name=p34950 lab=_70486_/X }
C {devices/lab_pin.sym} 35820 -34350 0 1 {name=p34951 lab=_83763_/D }
C {sky130_stdcells/a21o_4.sym} 35740 -34350 0 0 {name=X_70487_ }
C {devices/lab_pin.sym} 35700 -34210 0 0 {name=p34952 lab=clkbuf_9_35_0_CLK/A }
C {devices/lab_pin.sym} 35780 -34210 0 1 {name=p34953 lab=clkbuf_9_34_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 35740 -34210 0 0 {name=Xclkbuf_9_34_0_CLK }
C {devices/lab_pin.sym} 35680 -34100 0 0 {name=p34954 lab=_80953_/Q }
C {devices/lab_pin.sym} 35680 -34060 0 0 {name=p34955 lab=_75014_/B }
C {devices/lab_pin.sym} 35800 -34080 0 1 {name=p34956 lab=_75014_/X }
C {sky130_stdcells/xor2_4.sym} 35740 -34080 0 0 {name=X_75014_ }
C {devices/lab_pin.sym} 35680 -33960 0 0 {name=p34957 lab=_41406_/A }
C {devices/lab_pin.sym} 35680 -33920 0 0 {name=p34958 lab=_41379_/X }
C {devices/lab_pin.sym} 35800 -33940 0 1 {name=p34959 lab=_41406_/X }
C {sky130_stdcells/or2_4.sym} 35740 -33940 0 0 {name=X_41406_ }
C {devices/lab_pin.sym} 35700 -33810 0 0 {name=p34960 lab=_60239_/X }
C {devices/lab_pin.sym} 35780 -33810 0 1 {name=p34961 lab=_60241_/A }
C {sky130_stdcells/inv_2.sym} 35740 -33810 0 0 {name=X_60240_ }
C {devices/lab_pin.sym} 35660 -33710 0 0 {name=p34962 lab=_72180_/X }
C {devices/lab_pin.sym} 35660 -33670 0 0 {name=p34963 lab=_85336_/Q }
C {devices/lab_pin.sym} 35660 -33630 0 0 {name=p34964 lab=_72225_/X }
C {devices/lab_pin.sym} 35820 -33670 0 1 {name=p34965 lab=_72226_/X }
C {sky130_stdcells/o21a_4.sym} 35740 -33670 0 0 {name=X_72226_ }
C {devices/lab_pin.sym} 35660 -33550 0 0 {name=p34966 lab=_55821_/B }
C {devices/lab_pin.sym} 35660 -33510 0 0 {name=p34967 lab=_45131_/X }
C {devices/lab_pin.sym} 35660 -33470 0 0 {name=p34968 lab=_45161_/X }
C {devices/lab_pin.sym} 35820 -33510 0 1 {name=p34969 lab=_45174_/X }
C {sky130_stdcells/o21a_4.sym} 35740 -33510 0 0 {name=X_45174_ }
C {devices/lab_pin.sym} 35700 -33370 0 0 {name=p34970 lab=_42386_/A }
C {devices/lab_pin.sym} 35780 -33370 0 1 {name=p34971 lab=_87889_/D }
C {sky130_stdcells/inv_2.sym} 35740 -33370 0 0 {name=X_42386_ }
C {devices/lab_pin.sym} 35700 -33250 0 0 {name=p34972 lab=_72814_/A }
C {devices/lab_pin.sym} 35780 -33250 0 1 {name=p34973 lab=_73352_/A }
C {sky130_stdcells/buf_2.sym} 35740 -33250 0 0 {name=X_44125_ }
C {devices/lab_pin.sym} 35680 -33140 0 0 {name=p34974 lab=_79829_/B }
C {devices/lab_pin.sym} 35680 -33100 0 0 {name=p34975 lab=_79822_/B }
C {devices/lab_pin.sym} 35800 -33120 0 1 {name=p34976 lab=_79822_/Y }
C {sky130_stdcells/xnor2_4.sym} 35740 -33120 0 0 {name=X_79822_ }
C {devices/lab_pin.sym} 35700 -32990 0 0 {name=p34977 lab=_41336_/X }
C {devices/lab_pin.sym} 35780 -32990 0 1 {name=p34978 lab=_41337_/X }
C {sky130_stdcells/buf_2.sym} 35740 -32990 0 0 {name=X_41337_ }
C {devices/lab_pin.sym} 35680 -32880 0 0 {name=p34979 lab=_60171_/A }
C {devices/lab_pin.sym} 35680 -32840 0 0 {name=p34980 lab=_60171_/B }
C {devices/lab_pin.sym} 35800 -32860 0 1 {name=p34981 lab=_60172_/A }
C {sky130_stdcells/and2_4.sym} 35740 -32860 0 0 {name=X_60171_ }
C {devices/lab_pin.sym} 35660 -32750 0 0 {name=p34982 lab=_72155_/X }
C {devices/lab_pin.sym} 35660 -32710 0 0 {name=p34983 lab=_85694_/Q }
C {devices/lab_pin.sym} 35660 -32670 0 0 {name=p34984 lab=_72156_/X }
C {devices/lab_pin.sym} 35820 -32710 0 1 {name=p34985 lab=_72157_/X }
C {sky130_stdcells/o21a_4.sym} 35740 -32710 0 0 {name=X_72157_ }
C {devices/lab_pin.sym} 35660 -32590 0 0 {name=p34986 lab=_86287_/Q }
C {devices/lab_pin.sym} 35660 -32550 0 0 {name=p34987 lab=_49960_/X }
C {devices/lab_pin.sym} 35660 -32510 0 0 {name=p34988 lab=_49981_/Y }
C {devices/lab_pin.sym} 35820 -32550 0 1 {name=p34989 lab=_49982_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -32550 0 0 {name=X_49982_ }
C {devices/lab_pin.sym} 35680 -32430 0 0 {name=p34990 lab=_71101_/X }
C {devices/lab_pin.sym} 35680 -32390 0 0 {name=p34991 lab=_71230_/B }
C {devices/lab_pin.sym} 35680 -32350 0 0 {name=p34992 lab=_70890_/D }
C {devices/lab_pin.sym} 35800 -32390 0 1 {name=p34993 lab=_71108_/Y }
C {sky130_stdcells/nand3_4.sym} 35740 -32390 0 0 {name=X_71108_ }
C {devices/lab_pin.sym} 35660 -32270 0 0 {name=p34994 lab=_64759_/B }
C {devices/lab_pin.sym} 35660 -32230 0 0 {name=p34995 lab=_48896_/X }
C {devices/lab_pin.sym} 35660 -32190 0 0 {name=p34996 lab=_48932_/Y }
C {devices/lab_pin.sym} 35820 -32230 0 1 {name=p34997 lab=_48933_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -32230 0 0 {name=X_48933_ }
C {devices/lab_pin.sym} 35700 -32090 0 0 {name=p34998 lab=_55125_/A }
C {devices/lab_pin.sym} 35780 -32090 0 1 {name=p34999 lab=_55152_/A }
C {sky130_stdcells/buf_2.sym} 35740 -32090 0 0 {name=X_44056_ }
C {devices/lab_pin.sym} 35660 -31990 0 0 {name=p35000 lab=_79741_/X }
C {devices/lab_pin.sym} 35660 -31950 0 0 {name=p35001 lab=_79742_/X }
C {devices/lab_pin.sym} 35660 -31910 0 0 {name=p35002 lab=_79752_/Y }
C {devices/lab_pin.sym} 35820 -31950 0 1 {name=p35003 lab=_79757_/A }
C {sky130_stdcells/a21boi_4.sym} 35740 -31950 0 0 {name=X_79753_ }
C {devices/lab_pin.sym} 35700 -31810 0 0 {name=p35004 lab=_41267_/Y }
C {devices/lab_pin.sym} 35780 -31810 0 1 {name=p35005 lab=_41268_/X }
C {sky130_stdcells/buf_2.sym} 35740 -31810 0 0 {name=X_41268_ }
C {devices/lab_pin.sym} 35680 -31700 0 0 {name=p35006 lab=_72075_/A }
C {devices/lab_pin.sym} 35680 -31660 0 0 {name=p35007 lab=_50183_/B }
C {devices/lab_pin.sym} 35800 -31680 0 1 {name=p35008 lab=_72088_/Y }
C {sky130_stdcells/nand2_4.sym} 35740 -31680 0 0 {name=X_72088_ }
C {devices/lab_pin.sym} 35700 -31550 0 0 {name=p35009 lab=_76965_/A }
C {devices/lab_pin.sym} 35780 -31550 0 1 {name=p35010 lab=_76965_/Y }
C {sky130_stdcells/inv_2.sym} 35740 -31550 0 0 {name=X_76965_ }
C {devices/lab_pin.sym} 35700 -31430 0 0 {name=p35011 lab=clkbuf_9_49_0_CLK/A }
C {devices/lab_pin.sym} 35780 -31430 0 1 {name=p35012 lab=clkbuf_9_49_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 35740 -31430 0 0 {name=Xclkbuf_9_49_0_CLK }
C {devices/lab_pin.sym} 35700 -31310 0 0 {name=p35013 lab=_43006_/Y }
C {devices/lab_pin.sym} 35780 -31310 0 1 {name=p35014 lab=_87607_/D }
C {sky130_stdcells/inv_2.sym} 35740 -31310 0 0 {name=X_43007_ }
C {devices/lab_pin.sym} 35660 -31210 0 0 {name=p35015 lab=_78685_/A }
C {devices/lab_pin.sym} 35660 -31170 0 0 {name=p35016 lab=_78702_/Y }
C {devices/lab_pin.sym} 35660 -31130 0 0 {name=p35017 lab=_78703_/Y }
C {devices/lab_pin.sym} 35820 -31170 0 1 {name=p35018 lab=_78742_/B }
C {sky130_stdcells/a21bo_4.sym} 35740 -31170 0 0 {name=X_78704_ }
C {devices/lab_pin.sym} 35680 -31050 0 0 {name=p35019 lab=_63960_/A }
C {devices/lab_pin.sym} 35680 -31010 0 0 {name=p35020 lab=_63960_/B }
C {devices/lab_pin.sym} 35680 -30970 0 0 {name=p35021 lab=_80133_/B }
C {devices/lab_pin.sym} 35800 -31010 0 1 {name=p35022 lab=_63930_/Y }
C {sky130_stdcells/nor3_4.sym} 35740 -31010 0 0 {name=X_63930_ }
C {devices/lab_pin.sym} 35680 -30900 0 0 {name=p35023 lab=_71183_/A }
C {devices/lab_pin.sym} 35680 -30860 0 0 {name=p35024 lab=_71030_/B }
C {devices/lab_pin.sym} 35680 -30820 0 0 {name=p35025 lab=_71030_/C }
C {devices/lab_pin.sym} 35680 -30780 0 0 {name=p35026 lab=_71039_/D }
C {devices/lab_pin.sym} 35800 -30840 0 1 {name=p35027 lab=_71039_/Y }
C {sky130_stdcells/nand4_4.sym} 35740 -30840 0 0 {name=X_71039_ }
C {devices/lab_pin.sym} 35680 -30700 0 0 {name=p35028 lab=_61174_/C }
C {devices/lab_pin.sym} 35680 -30660 0 0 {name=p35029 lab=_84386_/Q }
C {devices/lab_pin.sym} 35800 -30680 0 1 {name=p35030 lab=_75916_/X }
C {sky130_stdcells/xor2_4.sym} 35740 -30680 0 0 {name=X_75916_ }
C {devices/lab_pin.sym} 35660 -30570 0 0 {name=p35031 lab=_86468_/Q }
C {devices/lab_pin.sym} 35660 -30530 0 0 {name=p35032 lab=_48861_/X }
C {devices/lab_pin.sym} 35660 -30490 0 0 {name=p35033 lab=_48863_/Y }
C {devices/lab_pin.sym} 35820 -30530 0 1 {name=p35034 lab=_48864_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -30530 0 0 {name=X_48864_ }
C {devices/lab_pin.sym} 35660 -30420 0 0 {name=p35035 lab=_79660_/A }
C {devices/lab_pin.sym} 35660 -30380 0 0 {name=p35036 lab=_79659_/Y }
C {devices/lab_pin.sym} 35660 -30340 0 0 {name=p35037 lab=_79669_/X }
C {devices/lab_pin.sym} 35660 -30300 0 0 {name=p35038 lab=_79672_/Y }
C {devices/lab_pin.sym} 35820 -30360 0 1 {name=p35039 lab=_79684_/X }
C {sky130_stdcells/o22a_4.sym} 35740 -30360 0 0 {name=X_79684_ }
C {devices/lab_pin.sym} 35700 -30210 0 0 {name=p35040 lab=_41198_/Y }
C {devices/lab_pin.sym} 35780 -30210 0 1 {name=p35041 lab=_41199_/X }
C {sky130_stdcells/buf_2.sym} 35740 -30210 0 0 {name=X_41199_ }
C {devices/lab_pin.sym} 35680 -30100 0 0 {name=p35042 lab=_76894_/Y }
C {devices/lab_pin.sym} 35680 -30060 0 0 {name=p35043 lab=_76895_/Y }
C {devices/lab_pin.sym} 35800 -30080 0 1 {name=p35044 lab=_76899_/A }
C {sky130_stdcells/nor2_4.sym} 35740 -30080 0 0 {name=X_76896_ }
C {devices/lab_pin.sym} 35700 -29950 0 0 {name=p35045 lab=clkbuf_3_6_0_CLK/A }
C {devices/lab_pin.sym} 35780 -29950 0 1 {name=p35046 lab=clkbuf_3_7_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 35740 -29950 0 0 {name=Xclkbuf_3_7_0_CLK }
C {devices/lab_pin.sym} 35680 -29860 0 0 {name=p35047 lab=_49374_/A }
C {devices/lab_pin.sym} 35680 -29820 0 0 {name=p35048 lab=_49364_/B }
C {devices/lab_pin.sym} 35680 -29780 0 0 {name=p35049 lab=_50886_/C }
C {devices/lab_pin.sym} 35680 -29740 0 0 {name=p35050 lab=_53257_/D }
C {devices/lab_pin.sym} 35800 -29800 0 1 {name=p35051 lab=_47815_/X }
C {sky130_stdcells/and4_4.sym} 35740 -29800 0 0 {name=X_47815_ }
C {devices/lab_pin.sym} 35700 -29650 0 0 {name=p35052 lab=_78634_/X }
C {devices/lab_pin.sym} 35780 -29650 0 1 {name=p35053 lab=_78637_/B }
C {sky130_stdcells/inv_2.sym} 35740 -29650 0 0 {name=X_78635_ }
C {devices/lab_pin.sym} 35680 -29560 0 0 {name=p35054 lab=_61419_/X }
C {devices/lab_pin.sym} 35680 -29520 0 0 {name=p35055 lab=_63877_/B }
C {devices/lab_pin.sym} 35680 -29480 0 0 {name=p35056 lab=_63814_/C }
C {devices/lab_pin.sym} 35680 -29440 0 0 {name=p35057 lab=_63877_/D }
C {devices/lab_pin.sym} 35800 -29500 0 1 {name=p35058 lab=_63861_/Y }
C {sky130_stdcells/nand4_4.sym} 35740 -29500 0 0 {name=X_63861_ }
C {devices/lab_pin.sym} 35700 -29350 0 0 {name=p35059 lab=_81023_/Q }
C {devices/lab_pin.sym} 35780 -29350 0 1 {name=p35060 lab=_75848_/B }
C {sky130_stdcells/inv_2.sym} 35740 -29350 0 0 {name=X_75847_ }
C {devices/lab_pin.sym} 35700 -29230 0 0 {name=p35061 lab=_52139_/A }
C {devices/lab_pin.sym} 35780 -29230 0 1 {name=p35062 lab=_48833_/A }
C {sky130_stdcells/buf_2.sym} 35740 -29230 0 0 {name=X_48795_ }
C {devices/lab_pin.sym} 35680 -29130 0 0 {name=p35063 lab=_64908_/X }
C {devices/lab_pin.sym} 35680 -29090 0 0 {name=p35064 lab=_65647_/B }
C {devices/lab_pin.sym} 35680 -29050 0 0 {name=p35065 lab=_64910_/X }
C {devices/lab_pin.sym} 35800 -29090 0 1 {name=p35066 lab=_65600_/Y }
C {sky130_stdcells/nand3_4.sym} 35740 -29090 0 0 {name=X_65600_ }
C {devices/lab_pin.sym} 35680 -28970 0 0 {name=p35067 lab=_62773_/X }
C {devices/lab_pin.sym} 35680 -28930 0 0 {name=p35068 lab=_62812_/B }
C {devices/lab_pin.sym} 35680 -28890 0 0 {name=p35069 lab=_61939_/X }
C {devices/lab_pin.sym} 35800 -28930 0 1 {name=p35070 lab=_62812_/Y }
C {sky130_stdcells/nand3_4.sym} 35740 -28930 0 0 {name=X_62812_ }
C {devices/lab_pin.sym} 35700 -28790 0 0 {name=p35071 lab=_47792_/A }
C {devices/lab_pin.sym} 35780 -28790 0 1 {name=p35072 lab=_47777_/B }
C {sky130_stdcells/buf_2.sym} 35740 -28790 0 0 {name=X_47746_ }
C {devices/lab_pin.sym} 35660 -28690 0 0 {name=p35073 lab=_66568_/X }
C {devices/lab_pin.sym} 35660 -28650 0 0 {name=p35074 lab=_66578_/X }
C {devices/lab_pin.sym} 35660 -28610 0 0 {name=p35075 lab=_66579_/X }
C {devices/lab_pin.sym} 35820 -28650 0 1 {name=p35076 lab=_66580_/X }
C {sky130_stdcells/a21o_4.sym} 35740 -28650 0 0 {name=X_66580_ }
C {devices/lab_pin.sym} 35680 -28520 0 0 {name=p35077 lab=_78566_/A }
C {devices/lab_pin.sym} 35680 -28480 0 0 {name=p35078 lab=_82720_/Q }
C {devices/lab_pin.sym} 35800 -28500 0 1 {name=p35079 lab=_78569_/B }
C {sky130_stdcells/nor2_4.sym} 35740 -28500 0 0 {name=X_78566_ }
C {devices/lab_pin.sym} 35700 -28370 0 0 {name=p35080 lab=_45389_/A }
C {devices/lab_pin.sym} 35780 -28370 0 1 {name=p35081 lab=_45720_/A }
C {sky130_stdcells/buf_2.sym} 35740 -28370 0 0 {name=X_44958_ }
C {devices/lab_pin.sym} 35700 -28250 0 0 {name=p35082 lab=_64012_/A }
C {devices/lab_pin.sym} 35780 -28250 0 1 {name=p35083 lab=_63793_/D }
C {sky130_stdcells/buf_2.sym} 35740 -28250 0 0 {name=X_63792_ }
C {devices/lab_pin.sym} 35700 -28130 0 0 {name=p35084 lab=_75778_/A }
C {devices/lab_pin.sym} 35780 -28130 0 1 {name=p35085 lab=_75778_/Y }
C {sky130_stdcells/inv_2.sym} 35740 -28130 0 0 {name=X_75778_ }
C {devices/lab_pin.sym} 35680 -28030 0 0 {name=p35086 lab=_65559_/A }
C {devices/lab_pin.sym} 35680 -27990 0 0 {name=p35087 lab=_65546_/B }
C {devices/lab_pin.sym} 35680 -27950 0 0 {name=p35088 lab=_65531_/C }
C {devices/lab_pin.sym} 35800 -27990 0 1 {name=p35089 lab=_65531_/X }
C {sky130_stdcells/and3_4.sym} 35740 -27990 0 0 {name=X_65531_ }
C {devices/lab_pin.sym} 35700 -27850 0 0 {name=p35090 lab=_77517_/A }
C {devices/lab_pin.sym} 35780 -27850 0 1 {name=p35091 lab=_77519_/A }
C {sky130_stdcells/inv_2.sym} 35740 -27850 0 0 {name=X_77517_ }
C {devices/lab_pin.sym} 35660 -27760 0 0 {name=p35092 lab=_41361_/X }
C {devices/lab_pin.sym} 35660 -27720 0 0 {name=p35093 lab=_43907_/X }
C {devices/lab_pin.sym} 35660 -27680 0 0 {name=p35094 lab=_67667_/B }
C {devices/lab_pin.sym} 35660 -27640 0 0 {name=p35095 lab=_43908_/X }
C {devices/lab_pin.sym} 35820 -27700 0 1 {name=p35096 lab=_43909_/X }
C {sky130_stdcells/a2bb2o_4.sym} 35740 -27700 0 0 {name=X_43909_ }
C {devices/lab_pin.sym} 35680 -27580 0 0 {name=p35097 lab=_61419_/X }
C {devices/lab_pin.sym} 35680 -27540 0 0 {name=p35098 lab=_62743_/B }
C {devices/lab_pin.sym} 35680 -27500 0 0 {name=p35099 lab=_62742_/X }
C {devices/lab_pin.sym} 35680 -27460 0 0 {name=p35100 lab=_62729_/D }
C {devices/lab_pin.sym} 35800 -27520 0 1 {name=p35101 lab=_62743_/Y }
C {sky130_stdcells/nand4_4.sym} 35740 -27520 0 0 {name=X_62743_ }
C {devices/lab_pin.sym} 35680 -27400 0 0 {name=p35102 lab=_74729_/A }
C {devices/lab_pin.sym} 35680 -27360 0 0 {name=p35103 lab=_74796_/B }
C {devices/lab_pin.sym} 35680 -27320 0 0 {name=p35104 lab=_74796_/C }
C {devices/lab_pin.sym} 35680 -27280 0 0 {name=p35105 lab=_71016_/A }
C {devices/lab_pin.sym} 35800 -27340 0 1 {name=p35106 lab=_74729_/Y }
C {sky130_stdcells/nand4_4.sym} 35740 -27340 0 0 {name=X_74729_ }
C {devices/lab_pin.sym} 35660 -27210 0 0 {name=p35107 lab=_47671_/Y }
C {devices/lab_pin.sym} 35660 -27170 0 0 {name=p35108 lab=_47651_/X }
C {devices/lab_pin.sym} 35660 -27130 0 0 {name=p35109 lab=_47676_/X }
C {devices/lab_pin.sym} 35820 -27170 0 1 {name=p35110 lab=_47677_/Y }
C {sky130_stdcells/a21oi_4.sym} 35740 -27170 0 0 {name=X_47677_ }
C {devices/lab_pin.sym} 35660 -27050 0 0 {name=p35111 lab=_78460_/A }
C {devices/lab_pin.sym} 35660 -27010 0 0 {name=p35112 lab=_78463_/A }
C {devices/lab_pin.sym} 35660 -26970 0 0 {name=p35113 lab=_78473_/X }
C {devices/lab_pin.sym} 35820 -27010 0 1 {name=p35114 lab=_78497_/X }
C {sky130_stdcells/a21o_4.sym} 35740 -27010 0 0 {name=X_78497_ }
C {devices/lab_pin.sym} 35700 -26870 0 0 {name=p35115 lab=_44889_/A }
C {devices/lab_pin.sym} 35780 -26870 0 1 {name=p35116 lab=_44889_/X }
C {sky130_stdcells/buf_2.sym} 35740 -26870 0 0 {name=X_44889_ }
C {devices/lab_pin.sym} 35700 -26750 0 0 {name=p35117 lab=_49416_/A }
C {devices/lab_pin.sym} 35780 -26750 0 1 {name=p35118 lab=_49444_/A }
C {sky130_stdcells/buf_2.sym} 35740 -26750 0 0 {name=X_49416_ }
C {devices/lab_pin.sym} 35660 -26650 0 0 {name=p35119 lab=_84001_/Q }
C {devices/lab_pin.sym} 35660 -26610 0 0 {name=p35120 lab=_68238_/X }
C {devices/lab_pin.sym} 35660 -26570 0 0 {name=p35121 lab=_68249_/X }
C {devices/lab_pin.sym} 35820 -26610 0 1 {name=p35122 lab=_68250_/X }
C {sky130_stdcells/a21bo_4.sym} 35740 -26610 0 0 {name=X_68250_ }
C {devices/lab_pin.sym} 35700 -26470 0 0 {name=p35123 lab=_74509_/B }
C {devices/lab_pin.sym} 35780 -26470 0 1 {name=p35124 lab=_46670_/A }
C {sky130_stdcells/buf_2.sym} 35740 -26470 0 0 {name=X_46628_ }
C {devices/lab_pin.sym} 35680 -26370 0 0 {name=p35125 lab=_64655_/X }
C {devices/lab_pin.sym} 35680 -26330 0 0 {name=p35126 lab=_65340_/X }
C {devices/lab_pin.sym} 35680 -26290 0 0 {name=p35127 lab=_64659_/X }
C {devices/lab_pin.sym} 35800 -26330 0 1 {name=p35128 lab=_65462_/Y }
C {sky130_stdcells/nand3_4.sym} 35740 -26330 0 0 {name=X_65462_ }
C {devices/lab_pin.sym} 35660 -26210 0 0 {name=p35129 lab=_77444_/Y }
C {devices/lab_pin.sym} 35660 -26170 0 0 {name=p35130 lab=_77446_/Y }
C {devices/lab_pin.sym} 35660 -26130 0 0 {name=p35131 lab=_77447_/A }
C {devices/lab_pin.sym} 35820 -26170 0 1 {name=p35132 lab=_77448_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -26170 0 0 {name=X_77448_ }
C {devices/lab_pin.sym} 35660 -26050 0 0 {name=p35133 lab=_62670_/X }
C {devices/lab_pin.sym} 35660 -26010 0 0 {name=p35134 lab=_62652_/X }
C {devices/lab_pin.sym} 35660 -25970 0 0 {name=p35135 lab=_62673_/Y }
C {devices/lab_pin.sym} 35820 -26010 0 1 {name=p35136 lab=_62674_/Y }
C {sky130_stdcells/a21oi_4.sym} 35740 -26010 0 0 {name=X_62674_ }
C {devices/lab_pin.sym} 35680 -25880 0 0 {name=p35137 lab=_67250_/A }
C {devices/lab_pin.sym} 35680 -25840 0 0 {name=p35138 lab=_67201_/B }
C {devices/lab_pin.sym} 35800 -25860 0 1 {name=p35139 lab=_67201_/X }
C {sky130_stdcells/and2_4.sym} 35740 -25860 0 0 {name=X_67201_ }
C {devices/lab_pin.sym} 35680 -25750 0 0 {name=p35140 lab=_64380_/X }
C {devices/lab_pin.sym} 35680 -25710 0 0 {name=p35141 lab=_84864_/Q }
C {devices/lab_pin.sym} 35680 -25670 0 0 {name=p35142 lab=_64381_/X }
C {devices/lab_pin.sym} 35800 -25710 0 1 {name=p35143 lab=_64413_/Y }
C {sky130_stdcells/nand3_4.sym} 35740 -25710 0 0 {name=X_64413_ }
C {devices/lab_pin.sym} 35660 -25590 0 0 {name=p35144 lab=_49345_/Y }
C {devices/lab_pin.sym} 35660 -25550 0 0 {name=p35145 lab=_49326_/X }
C {devices/lab_pin.sym} 35660 -25510 0 0 {name=p35146 lab=_49346_/Y }
C {devices/lab_pin.sym} 35820 -25550 0 1 {name=p35147 lab=_86405_/D }
C {sky130_stdcells/a21boi_4.sym} 35740 -25550 0 0 {name=X_49347_ }
C {devices/lab_pin.sym} 35660 -25430 0 0 {name=p35148 lab=_61623_/X }
C {devices/lab_pin.sym} 35660 -25390 0 0 {name=p35149 lab=_61576_/X }
C {devices/lab_pin.sym} 35660 -25350 0 0 {name=p35150 lab=_61624_/Y }
C {devices/lab_pin.sym} 35820 -25390 0 1 {name=p35151 lab=_61625_/Y }
C {sky130_stdcells/a21oi_4.sym} 35740 -25390 0 0 {name=X_61625_ }
C {devices/lab_pin.sym} 35660 -25270 0 0 {name=p35152 lab=_67135_/X }
C {devices/lab_pin.sym} 35660 -25230 0 0 {name=p35153 lab=_67137_/X }
C {devices/lab_pin.sym} 35660 -25190 0 0 {name=p35154 lab=_68169_/X }
C {devices/lab_pin.sym} 35820 -25230 0 1 {name=p35155 lab=_68181_/Y }
C {sky130_stdcells/a21oi_4.sym} 35740 -25230 0 0 {name=X_68181_ }
C {devices/lab_pin.sym} 35660 -25110 0 0 {name=p35156 lab=_46525_/X }
C {devices/lab_pin.sym} 35660 -25070 0 0 {name=p35157 lab=_49161_/A }
C {devices/lab_pin.sym} 35660 -25030 0 0 {name=p35158 lab=_46558_/X }
C {devices/lab_pin.sym} 35820 -25070 0 1 {name=p35159 lab=_51376_/B }
C {sky130_stdcells/o21ai_4.sym} 35740 -25070 0 0 {name=X_46559_ }
C {devices/lab_pin.sym} 35660 -24960 0 0 {name=p35160 lab=_65342_/X }
C {devices/lab_pin.sym} 35660 -24920 0 0 {name=p35161 lab=_83283_/Q }
C {devices/lab_pin.sym} 35660 -24880 0 0 {name=p35162 lab=_65391_/X }
C {devices/lab_pin.sym} 35660 -24840 0 0 {name=p35163 lab=_65392_/X }
C {devices/lab_pin.sym} 35820 -24900 0 1 {name=p35164 lab=_65393_/X }
C {sky130_stdcells/a211o_4.sym} 35740 -24900 0 0 {name=X_65393_ }
C {devices/lab_pin.sym} 35680 -24760 0 0 {name=p35165 lab=_77380_/A }
C {devices/lab_pin.sym} 35680 -24720 0 0 {name=p35166 lab=_82093_/D }
C {devices/lab_pin.sym} 35800 -24740 0 1 {name=p35167 lab=_77382_/B }
C {sky130_stdcells/nor2_4.sym} 35740 -24740 0 0 {name=X_77379_ }
C {devices/lab_pin.sym} 35660 -24640 0 0 {name=p35168 lab=_87868_/Q }
C {devices/lab_pin.sym} 35660 -24600 0 0 {name=p35169 lab=_67056_/X }
C {devices/lab_pin.sym} 35660 -24560 0 0 {name=p35170 lab=_67032_/X }
C {devices/lab_pin.sym} 35660 -24520 0 0 {name=p35171 lab=_67131_/X }
C {devices/lab_pin.sym} 35820 -24580 0 1 {name=p35172 lab=_67132_/X }
C {sky130_stdcells/a211o_4.sym} 35740 -24580 0 0 {name=X_67132_ }
C {devices/lab_pin.sym} 35700 -24430 0 0 {name=p35173 lab=_78997_/B }
C {devices/lab_pin.sym} 35780 -24430 0 1 {name=p35174 lab=_82519_/D }
C {sky130_stdcells/inv_2.sym} 35740 -24430 0 0 {name=X_79118_ }
C {devices/lab_pin.sym} 35700 -24310 0 0 {name=p35175 lab=_64285_/A }
C {devices/lab_pin.sym} 35780 -24310 0 1 {name=p35176 lab=_64344_/X }
C {sky130_stdcells/buf_2.sym} 35740 -24310 0 0 {name=X_64344_ }
C {devices/lab_pin.sym} 35660 -24210 0 0 {name=p35177 lab=_61554_/X }
C {devices/lab_pin.sym} 35660 -24170 0 0 {name=p35178 lab=_61517_/X }
C {devices/lab_pin.sym} 35660 -24130 0 0 {name=p35179 lab=_61555_/Y }
C {devices/lab_pin.sym} 35820 -24170 0 1 {name=p35180 lab=_61556_/Y }
C {sky130_stdcells/a21oi_4.sym} 35740 -24170 0 0 {name=X_61556_ }
C {devices/lab_pin.sym} 35660 -24050 0 0 {name=p35181 lab=_49276_/Y }
C {devices/lab_pin.sym} 35660 -24010 0 0 {name=p35182 lab=_49271_/X }
C {devices/lab_pin.sym} 35660 -23970 0 0 {name=p35183 lab=_49277_/Y }
C {devices/lab_pin.sym} 35820 -24010 0 1 {name=p35184 lab=_86419_/D }
C {sky130_stdcells/a21boi_4.sym} 35740 -24010 0 0 {name=X_49278_ }
C {devices/lab_pin.sym} 35680 -23880 0 0 {name=p35185 lab=_84755_/Q }
C {devices/lab_pin.sym} 35680 -23840 0 0 {name=p35186 lab=_80397_/B }
C {devices/lab_pin.sym} 35800 -23860 0 1 {name=p35187 lab=_80390_/X }
C {sky130_stdcells/xor2_4.sym} 35740 -23860 0 0 {name=X_80390_ }
C {devices/lab_pin.sym} 35700 -23730 0 0 {name=p35188 lab=_63247_/A }
C {devices/lab_pin.sym} 35780 -23730 0 1 {name=p35189 lab=_60508_/A }
C {sky130_stdcells/buf_2.sym} 35740 -23730 0 0 {name=X_60507_ }
C {devices/lab_pin.sym} 35680 -23620 0 0 {name=p35190 lab=_48229_/A }
C {devices/lab_pin.sym} 35680 -23580 0 0 {name=p35191 lab=_53504_/B }
C {devices/lab_pin.sym} 35800 -23600 0 1 {name=p35192 lab=_48229_/Y }
C {sky130_stdcells/nand2_4.sym} 35740 -23600 0 0 {name=X_48229_ }
C {devices/lab_pin.sym} 35700 -23470 0 0 {name=p35193 lab=_67062_/X }
C {devices/lab_pin.sym} 35780 -23470 0 1 {name=p35194 lab=_67087_/A }
C {sky130_stdcells/buf_2.sym} 35740 -23470 0 0 {name=X_67063_ }
C {devices/lab_pin.sym} 35700 -23350 0 0 {name=p35195 lab=_79049_/A }
C {devices/lab_pin.sym} 35780 -23350 0 1 {name=p35196 lab=_79057_/B }
C {sky130_stdcells/inv_2.sym} 35740 -23350 0 0 {name=X_79049_ }
C {devices/lab_pin.sym} 35680 -23250 0 0 {name=p35197 lab=_64275_/A }
C {devices/lab_pin.sym} 35680 -23210 0 0 {name=p35198 lab=_64275_/B }
C {devices/lab_pin.sym} 35680 -23170 0 0 {name=p35199 lab=_64274_/X }
C {devices/lab_pin.sym} 35800 -23210 0 1 {name=p35200 lab=_64275_/X }
C {sky130_stdcells/and3_4.sym} 35740 -23210 0 0 {name=X_64275_ }
C {devices/lab_pin.sym} 35680 -23090 0 0 {name=p35201 lab=_61518_/A }
C {devices/lab_pin.sym} 35680 -23050 0 0 {name=p35202 lab=_61518_/B }
C {devices/lab_pin.sym} 35680 -23010 0 0 {name=p35203 lab=_84477_/Q }
C {devices/lab_pin.sym} 35800 -23050 0 1 {name=p35204 lab=_61487_/Y }
C {sky130_stdcells/nor3_4.sym} 35740 -23050 0 0 {name=X_61487_ }
C {devices/lab_pin.sym} 35680 -22930 0 0 {name=p35205 lab=_66010_/X }
C {devices/lab_pin.sym} 35680 -22890 0 0 {name=p35206 lab=_65967_/B }
C {devices/lab_pin.sym} 35680 -22850 0 0 {name=p35207 lab=_66013_/X }
C {devices/lab_pin.sym} 35800 -22890 0 1 {name=p35208 lab=_66014_/Y }
C {sky130_stdcells/nand3_4.sym} 35740 -22890 0 0 {name=X_66014_ }
C {devices/lab_pin.sym} 35680 -22760 0 0 {name=p35209 lab=_51240_/A }
C {devices/lab_pin.sym} 35680 -22720 0 0 {name=p35210 lab=_49212_/B }
C {devices/lab_pin.sym} 35800 -22740 0 1 {name=p35211 lab=_51240_/Y }
C {sky130_stdcells/nand2_4.sym} 35740 -22740 0 0 {name=X_51240_ }
C {devices/lab_pin.sym} 35680 -22640 0 0 {name=p35212 lab=_63203_/X }
C {devices/lab_pin.sym} 35680 -22600 0 0 {name=p35213 lab=_84838_/Q }
C {devices/lab_pin.sym} 35680 -22560 0 0 {name=p35214 lab=_63204_/X }
C {devices/lab_pin.sym} 35680 -22520 0 0 {name=p35215 lab=_63239_/D }
C {devices/lab_pin.sym} 35800 -22580 0 1 {name=p35216 lab=_63226_/X }
C {sky130_stdcells/and4_4.sym} 35740 -22580 0 0 {name=X_63226_ }
C {devices/lab_pin.sym} 35650 -22430 0 0 {name=p35217 lab=_81507_/CLK }
C {devices/lab_pin.sym} 35650 -22410 0 0 {name=p35218 lab=_82060_/D }
C {devices/lab_pin.sym} 35830 -22430 0 1 {name=p35219 lab=_77813_/A }
C {sky130_stdcells/dfxtp_4.sym} 35740 -22420 0 0 {name=X_82060_ }
C {devices/lab_pin.sym} 35700 -22290 0 0 {name=p35220 lab=_60438_/A }
C {devices/lab_pin.sym} 35780 -22290 0 1 {name=p35221 lab=_60583_/A }
C {sky130_stdcells/buf_2.sym} 35740 -22290 0 0 {name=X_60438_ }
C {devices/lab_pin.sym} 35650 -22170 0 0 {name=p35222 lab=_84223_/CLK }
C {devices/lab_pin.sym} 35650 -22150 0 0 {name=p35223 lab=_84219_/Q }
C {devices/lab_pin.sym} 35830 -22170 0 1 {name=p35224 lab=_81011_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -22160 0 0 {name=X_81011_ }
C {devices/lab_pin.sym} 35680 -22060 0 0 {name=p35225 lab=_51177_/A }
C {devices/lab_pin.sym} 35680 -22020 0 0 {name=p35226 lab=_51160_/B }
C {devices/lab_pin.sym} 35680 -21980 0 0 {name=p35227 lab=_51192_/C }
C {devices/lab_pin.sym} 35680 -21940 0 0 {name=p35228 lab=_52861_/D }
C {devices/lab_pin.sym} 35800 -22000 0 1 {name=p35229 lab=_51171_/X }
C {sky130_stdcells/and4_4.sym} 35740 -22000 0 0 {name=X_51171_ }
C {devices/lab_pin.sym} 35700 -21850 0 0 {name=p35230 lab=_60469_/X }
C {devices/lab_pin.sym} 35780 -21850 0 1 {name=p35231 lab=_63157_/X }
C {sky130_stdcells/buf_2.sym} 35740 -21850 0 0 {name=X_63157_ }
C {devices/lab_pin.sym} 35660 -21760 0 0 {name=p35232 lab=_79553_/A }
C {devices/lab_pin.sym} 35660 -21720 0 0 {name=p35233 lab=_60132_/X }
C {devices/lab_pin.sym} 35660 -21680 0 0 {name=p35234 lab=_60331_/D }
C {devices/lab_pin.sym} 35660 -21640 0 0 {name=p35235 lab=_60247_/Y }
C {devices/lab_pin.sym} 35820 -21700 0 1 {name=p35236 lab=_60369_/X }
C {sky130_stdcells/a2bb2o_4.sym} 35740 -21700 0 0 {name=X_60369_ }
C {devices/lab_pin.sym} 35680 -21560 0 0 {name=p35237 lab=_50106_/A }
C {devices/lab_pin.sym} 35680 -21520 0 0 {name=p35238 lab=_72025_/B }
C {devices/lab_pin.sym} 35800 -21540 0 1 {name=p35239 lab=_50122_/X }
C {sky130_stdcells/and2_4.sym} 35740 -21540 0 0 {name=X_50122_ }
C {devices/lab_pin.sym} 35680 -21440 0 0 {name=p35240 lab=_61949_/A }
C {devices/lab_pin.sym} 35680 -21400 0 0 {name=p35241 lab=_62170_/B }
C {devices/lab_pin.sym} 35680 -21360 0 0 {name=p35242 lab=_62158_/C }
C {devices/lab_pin.sym} 35680 -21320 0 0 {name=p35243 lab=_63292_/B }
C {devices/lab_pin.sym} 35800 -21380 0 1 {name=p35244 lab=_62108_/X }
C {sky130_stdcells/and4_4.sym} 35740 -21380 0 0 {name=X_62108_ }
C {devices/lab_pin.sym} 35660 -21260 0 0 {name=p35245 lab=_87385_/Q }
C {devices/lab_pin.sym} 35660 -21220 0 0 {name=p35246 lab=_67868_/X }
C {devices/lab_pin.sym} 35660 -21180 0 0 {name=p35247 lab=_67938_/X }
C {devices/lab_pin.sym} 35660 -21140 0 0 {name=p35248 lab=_67964_/X }
C {devices/lab_pin.sym} 35820 -21200 0 1 {name=p35249 lab=_67965_/X }
C {sky130_stdcells/a211o_4.sym} 35740 -21200 0 0 {name=X_67965_ }
C {devices/lab_pin.sym} 35680 -21080 0 0 {name=p35250 lab=_63088_/A }
C {devices/lab_pin.sym} 35680 -21040 0 0 {name=p35251 lab=_64295_/C }
C {devices/lab_pin.sym} 35680 -21000 0 0 {name=p35252 lab=_63087_/X }
C {devices/lab_pin.sym} 35680 -20960 0 0 {name=p35253 lab=_63077_/D }
C {devices/lab_pin.sym} 35800 -21020 0 1 {name=p35254 lab=_63088_/X }
C {sky130_stdcells/and4_4.sym} 35740 -21020 0 0 {name=X_63088_ }
C {devices/lab_pin.sym} 35660 -20900 0 0 {name=p35255 lab=_73024_/A }
C {devices/lab_pin.sym} 35660 -20860 0 0 {name=p35256 lab=_66608_/X }
C {devices/lab_pin.sym} 35660 -20820 0 0 {name=p35257 lab=_57800_/A }
C {devices/lab_pin.sym} 35660 -20780 0 0 {name=p35258 lab=_69703_/X }
C {devices/lab_pin.sym} 35820 -20840 0 1 {name=p35259 lab=_69704_/X }
C {sky130_stdcells/a211o_4.sym} 35740 -20840 0 0 {name=X_69704_ }
C {devices/lab_pin.sym} 35660 -20710 0 0 {name=p35260 lab=_86273_/Q }
C {devices/lab_pin.sym} 35660 -20670 0 0 {name=p35261 lab=_48861_/X }
C {devices/lab_pin.sym} 35660 -20630 0 0 {name=p35262 lab=_50052_/Y }
C {devices/lab_pin.sym} 35820 -20670 0 1 {name=p35263 lab=_50053_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -20670 0 0 {name=X_50053_ }
C {devices/lab_pin.sym} 35680 -20540 0 0 {name=p35264 lab=_54919_/X }
C {devices/lab_pin.sym} 35680 -20500 0 0 {name=p35265 lab=_47771_/Y }
C {devices/lab_pin.sym} 35800 -20520 0 1 {name=p35266 lab=_54930_/Y }
C {sky130_stdcells/nand2_4.sym} 35740 -20520 0 0 {name=X_54930_ }
C {devices/lab_pin.sym} 35680 -20400 0 0 {name=p35267 lab=_66840_/X }
C {devices/lab_pin.sym} 35680 -20360 0 0 {name=p35268 lab=_86824_/Q }
C {devices/lab_pin.sym} 35800 -20380 0 1 {name=p35269 lab=_66916_/X }
C {sky130_stdcells/and2_4.sym} 35740 -20380 0 0 {name=X_66916_ }
C {devices/lab_pin.sym} 35700 -20250 0 0 {name=p35270 lab=_83245_/Q }
C {devices/lab_pin.sym} 35780 -20250 0 1 {name=p35271 lab=_63611_/A }
C {sky130_stdcells/inv_2.sym} 35740 -20250 0 0 {name=X_62039_ }
C {devices/lab_pin.sym} 35650 -20130 0 0 {name=p35272 lab=_85751_/CLK }
C {devices/lab_pin.sym} 35650 -20110 0 0 {name=p35273 lab=_52812_/Y }
C {devices/lab_pin.sym} 35830 -20130 0 1 {name=p35274 lab=_85750_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -20120 0 0 {name=X_85750_ }
C {devices/lab_pin.sym} 35650 -19990 0 0 {name=p35275 lab=_82774_/CLK }
C {devices/lab_pin.sym} 35650 -19970 0 0 {name=p35276 lab=_82770_/Q }
C {devices/lab_pin.sym} 35830 -19990 0 1 {name=p35277 lab=_46762_/A }
C {sky130_stdcells/dfxtp_4.sym} 35740 -19980 0 0 {name=X_82962_ }
C {devices/lab_pin.sym} 35660 -19880 0 0 {name=p35278 lab=_86952_/Q }
C {devices/lab_pin.sym} 35660 -19840 0 0 {name=p35279 lab=_67825_/X }
C {devices/lab_pin.sym} 35660 -19800 0 0 {name=p35280 lab=_67872_/X }
C {devices/lab_pin.sym} 35660 -19760 0 0 {name=p35281 lab=_67895_/X }
C {devices/lab_pin.sym} 35820 -19820 0 1 {name=p35282 lab=_67896_/X }
C {sky130_stdcells/a211o_4.sym} 35740 -19820 0 0 {name=X_67896_ }
C {devices/lab_pin.sym} 35650 -19670 0 0 {name=p35283 lab=_84713_/CLK }
C {devices/lab_pin.sym} 35650 -19650 0 0 {name=p35284 lab=_59786_/Y }
C {devices/lab_pin.sym} 35830 -19670 0 1 {name=p35285 lab=_80497_/A }
C {sky130_stdcells/dfxtp_4.sym} 35740 -19660 0 0 {name=X_84701_ }
C {devices/lab_pin.sym} 35650 -19530 0 0 {name=p35286 lab=_82005_/CLK }
C {devices/lab_pin.sym} 35650 -19510 0 0 {name=p35287 lab=_81913_/D }
C {devices/lab_pin.sym} 35830 -19530 0 1 {name=p35288 lab=_81913_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -19520 0 0 {name=X_81913_ }
C {devices/lab_pin.sym} 35680 -19400 0 0 {name=p35289 lab=_68360_/X }
C {devices/lab_pin.sym} 35680 -19360 0 0 {name=p35290 lab=_42555_/Y }
C {devices/lab_pin.sym} 35800 -19380 0 1 {name=p35291 lab=_69635_/Y }
C {sky130_stdcells/nor2_4.sym} 35740 -19380 0 0 {name=X_69635_ }
C {devices/lab_pin.sym} 35700 -19250 0 0 {name=p35292 lab=_54807_/A }
C {devices/lab_pin.sym} 35780 -19250 0 1 {name=p35293 lab=_54883_/A }
C {sky130_stdcells/buf_2.sym} 35740 -19250 0 0 {name=X_54861_ }
C {devices/lab_pin.sym} 35660 -19150 0 0 {name=p35294 lab=_66844_/X }
C {devices/lab_pin.sym} 35660 -19110 0 0 {name=p35295 lab=_66846_/X }
C {devices/lab_pin.sym} 35660 -19070 0 0 {name=p35296 lab=_66706_/X }
C {devices/lab_pin.sym} 35820 -19110 0 1 {name=p35297 lab=_66847_/Y }
C {sky130_stdcells/a21oi_4.sym} 35740 -19110 0 0 {name=X_66847_ }
C {devices/lab_pin.sym} 35650 -18970 0 0 {name=p35298 lab=_84797_/CLK }
C {devices/lab_pin.sym} 35650 -18950 0 0 {name=p35299 lab=_85681_/D }
C {devices/lab_pin.sym} 35830 -18970 0 1 {name=p35300 lab=_85681_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -18960 0 0 {name=X_85681_ }
C {devices/lab_pin.sym} 35650 -18830 0 0 {name=p35301 lab=_82906_/CLK }
C {devices/lab_pin.sym} 35650 -18810 0 0 {name=p35302 lab=_78160_/B }
C {devices/lab_pin.sym} 35830 -18830 0 1 {name=p35303 lab=_82893_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -18820 0 0 {name=X_82893_ }
C {devices/lab_pin.sym} 35700 -18690 0 0 {name=p35304 lab=_56600_/A }
C {devices/lab_pin.sym} 35780 -18690 0 1 {name=p35305 lab=_56600_/X }
C {sky130_stdcells/buf_2.sym} 35740 -18690 0 0 {name=X_56600_ }
C {devices/lab_pin.sym} 35650 -18570 0 0 {name=p35306 lab=_82317_/CLK }
C {devices/lab_pin.sym} 35650 -18550 0 0 {name=p35307 lab=_43440_/X }
C {devices/lab_pin.sym} 35830 -18570 0 1 {name=p35308 lab=_87420_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -18560 0 0 {name=X_87420_ }
C {devices/lab_pin.sym} 35680 -18440 0 0 {name=p35309 lab=_53791_/A }
C {devices/lab_pin.sym} 35680 -18400 0 0 {name=p35310 lab=_71987_/B }
C {devices/lab_pin.sym} 35800 -18420 0 1 {name=p35311 lab=_53812_/Y }
C {sky130_stdcells/nand2_4.sym} 35740 -18420 0 0 {name=X_53812_ }
C {devices/lab_pin.sym} 35650 -18290 0 0 {name=p35312 lab=_84620_/CLK }
C {devices/lab_pin.sym} 35650 -18270 0 0 {name=p35313 lab=_60326_/X }
C {devices/lab_pin.sym} 35830 -18290 0 1 {name=p35314 lab=_79700_/A }
C {sky130_stdcells/dfxtp_4.sym} 35740 -18280 0 0 {name=X_84632_ }
C {devices/lab_pin.sym} 35700 -18150 0 0 {name=p35315 lab=_46653_/A }
C {devices/lab_pin.sym} 35780 -18150 0 1 {name=p35316 lab=_72009_/A }
C {sky130_stdcells/buf_2.sym} 35740 -18150 0 0 {name=X_57580_ }
C {devices/lab_pin.sym} 35660 -18060 0 0 {name=p35317 lab=_87571_/Q }
C {devices/lab_pin.sym} 35660 -18020 0 0 {name=p35318 lab=_69506_/X }
C {devices/lab_pin.sym} 35660 -17980 0 0 {name=p35319 lab=_66349_/X }
C {devices/lab_pin.sym} 35660 -17940 0 0 {name=p35320 lab=_69565_/X }
C {devices/lab_pin.sym} 35820 -18000 0 1 {name=p35321 lab=_69566_/X }
C {sky130_stdcells/a211o_4.sym} 35740 -18000 0 0 {name=X_69566_ }
C {devices/lab_pin.sym} 35650 -17850 0 0 {name=p35322 lab=_81094_/CLK }
C {devices/lab_pin.sym} 35650 -17830 0 0 {name=p35323 lab=_81876_/Q }
C {devices/lab_pin.sym} 35830 -17850 0 1 {name=p35324 lab=_77488_/A }
C {sky130_stdcells/dfxtp_4.sym} 35740 -17840 0 0 {name=X_81844_ }
C {devices/lab_pin.sym} 35700 -17710 0 0 {name=p35325 lab=_51340_/A }
C {devices/lab_pin.sym} 35780 -17710 0 1 {name=p35326 lab=_54900_/A }
C {sky130_stdcells/buf_2.sym} 35740 -17710 0 0 {name=X_54792_ }
C {devices/lab_pin.sym} 35660 -17620 0 0 {name=p35327 lab=_88395_/Q }
C {devices/lab_pin.sym} 35660 -17580 0 0 {name=p35328 lab=_66751_/X }
C {devices/lab_pin.sym} 35660 -17540 0 0 {name=p35329 lab=_66682_/X }
C {devices/lab_pin.sym} 35660 -17500 0 0 {name=p35330 lab=_66777_/X }
C {devices/lab_pin.sym} 35820 -17560 0 1 {name=p35331 lab=_66778_/X }
C {sky130_stdcells/a211o_4.sym} 35740 -17560 0 0 {name=X_66778_ }
C {devices/lab_pin.sym} 35680 -17430 0 0 {name=p35332 lab=_56533_/A }
C {devices/lab_pin.sym} 35680 -17390 0 0 {name=p35333 lab=_56533_/B }
C {devices/lab_pin.sym} 35680 -17350 0 0 {name=p35334 lab=_85160_/Q }
C {devices/lab_pin.sym} 35800 -17390 0 1 {name=p35335 lab=_56531_/Y }
C {sky130_stdcells/nand3_4.sym} 35740 -17390 0 0 {name=X_56531_ }
C {devices/lab_pin.sym} 35700 -17250 0 0 {name=p35336 lab=_68517_/A }
C {devices/lab_pin.sym} 35780 -17250 0 1 {name=p35337 lab=_68517_/X }
C {sky130_stdcells/buf_2.sym} 35740 -17250 0 0 {name=X_68517_ }
C {devices/lab_pin.sym} 35650 -17130 0 0 {name=p35338 lab=_86814_/CLK }
C {devices/lab_pin.sym} 35650 -17110 0 0 {name=p35339 lab=_87351_/D }
C {devices/lab_pin.sym} 35830 -17130 0 1 {name=p35340 lab=_87351_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -17120 0 0 {name=X_87351_ }
C {devices/lab_pin.sym} 35680 -17010 0 0 {name=p35341 lab=_48841_/A }
C {devices/lab_pin.sym} 35680 -16970 0 0 {name=p35342 lab=_53748_/B }
C {devices/lab_pin.sym} 35680 -16930 0 0 {name=p35343 lab=_53748_/C }
C {devices/lab_pin.sym} 35800 -16970 0 1 {name=p35344 lab=_53743_/X }
C {sky130_stdcells/and3_4.sym} 35740 -16970 0 0 {name=X_53743_ }
C {devices/lab_pin.sym} 35660 -16850 0 0 {name=p35345 lab=_65726_/Y }
C {devices/lab_pin.sym} 35660 -16810 0 0 {name=p35346 lab=_65681_/X }
C {devices/lab_pin.sym} 35660 -16770 0 0 {name=p35347 lab=_65728_/Y }
C {devices/lab_pin.sym} 35820 -16810 0 1 {name=p35348 lab=_84182_/D }
C {sky130_stdcells/a21o_4.sym} 35740 -16810 0 0 {name=X_65729_ }
C {devices/lab_pin.sym} 35650 -16670 0 0 {name=p35349 lab=_84454_/CLK }
C {devices/lab_pin.sym} 35650 -16650 0 0 {name=p35350 lab=_60803_/Y }
C {devices/lab_pin.sym} 35830 -16670 0 1 {name=p35351 lab=_84563_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -16660 0 0 {name=X_84563_ }
C {devices/lab_pin.sym} 35680 -16540 0 0 {name=p35352 lab=_50938_/X }
C {devices/lab_pin.sym} 35680 -16500 0 0 {name=p35353 lab=_46740_/X }
C {devices/lab_pin.sym} 35800 -16520 0 1 {name=p35354 lab=_50955_/Y }
C {sky130_stdcells/nand2_4.sym} 35740 -16520 0 0 {name=X_50955_ }
C {devices/lab_pin.sym} 35650 -16390 0 0 {name=p35355 lab=_84014_/CLK }
C {devices/lab_pin.sym} 35650 -16370 0 0 {name=p35356 lab=_76069_/X }
C {devices/lab_pin.sym} 35830 -16390 0 1 {name=p35357 lab=_81775_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -16380 0 0 {name=X_81775_ }
C {devices/lab_pin.sym} 35680 -16260 0 0 {name=p35358 lab=_69322_/A }
C {devices/lab_pin.sym} 35680 -16220 0 0 {name=p35359 lab=_88281_/Q }
C {devices/lab_pin.sym} 35800 -16240 0 1 {name=p35360 lab=_69497_/X }
C {sky130_stdcells/and2_4.sym} 35740 -16240 0 0 {name=X_69497_ }
C {devices/lab_pin.sym} 35650 -16110 0 0 {name=p35361 lab=_86303_/CLK }
C {devices/lab_pin.sym} 35650 -16090 0 0 {name=p35362 lab=_49905_/Y }
C {devices/lab_pin.sym} 35830 -16110 0 1 {name=p35363 lab=_72160_/B }
C {sky130_stdcells/dfxtp_4.sym} 35740 -16100 0 0 {name=X_86302_ }
C {devices/lab_pin.sym} 35660 -15990 0 0 {name=p35364 lab=_59177_/X }
C {devices/lab_pin.sym} 35660 -15950 0 0 {name=p35365 lab=_86061_/Q }
C {devices/lab_pin.sym} 35660 -15910 0 0 {name=p35366 lab=_59249_/X }
C {devices/lab_pin.sym} 35820 -15950 0 1 {name=p35367 lab=_59250_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -15950 0 0 {name=X_59250_ }
C {devices/lab_pin.sym} 35650 -15810 0 0 {name=p35368 lab=_83514_/CLK }
C {devices/lab_pin.sym} 35650 -15790 0 0 {name=p35369 lab=_71394_/X }
C {devices/lab_pin.sym} 35830 -15810 0 1 {name=p35370 lab=_83514_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -15800 0 0 {name=X_83514_ }
C {devices/lab_pin.sym} 35700 -15670 0 0 {name=p35371 lab=_56528_/A }
C {devices/lab_pin.sym} 35780 -15670 0 1 {name=p35372 lab=_56462_/X }
C {sky130_stdcells/buf_2.sym} 35740 -15670 0 0 {name=X_56462_ }
C {devices/lab_pin.sym} 35650 -15550 0 0 {name=p35373 lab=_80676_/CLK }
C {devices/lab_pin.sym} 35650 -15530 0 0 {name=p35374 lab=_75912_/X }
C {devices/lab_pin.sym} 35830 -15550 0 1 {name=p35375 lab=_80694_/D }
C {sky130_stdcells/dfxtp_4.sym} 35740 -15540 0 0 {name=X_80726_ }
C {devices/lab_pin.sym} 35680 -15420 0 0 {name=p35376 lab=_68403_/A }
C {devices/lab_pin.sym} 35680 -15380 0 0 {name=p35377 lab=_87760_/Q }
C {devices/lab_pin.sym} 35800 -15400 0 1 {name=p35378 lab=_68448_/X }
C {sky130_stdcells/and2_4.sym} 35740 -15400 0 0 {name=X_68448_ }
C {devices/lab_pin.sym} 35650 -15270 0 0 {name=p35379 lab=_88084_/CLK }
C {devices/lab_pin.sym} 35650 -15250 0 0 {name=p35380 lab=_87282_/D }
C {devices/lab_pin.sym} 35830 -15270 0 1 {name=p35381 lab=_87282_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -15260 0 0 {name=X_87282_ }
C {devices/lab_pin.sym} 35680 -15140 0 0 {name=p35382 lab=_53662_/X }
C {devices/lab_pin.sym} 35680 -15100 0 0 {name=p35383 lab=_73073_/A }
C {devices/lab_pin.sym} 35800 -15120 0 1 {name=p35384 lab=_53674_/Y }
C {sky130_stdcells/nand2_4.sym} 35740 -15120 0 0 {name=X_53674_ }
C {devices/lab_pin.sym} 35650 -14990 0 0 {name=p35385 lab=_84623_/CLK }
C {devices/lab_pin.sym} 35650 -14970 0 0 {name=p35386 lab=_61266_/X }
C {devices/lab_pin.sym} 35830 -14990 0 1 {name=p35387 lab=_61265_/C }
C {sky130_stdcells/dfxtp_4.sym} 35740 -14980 0 0 {name=X_84494_ }
C {devices/lab_pin.sym} 35680 -14880 0 0 {name=p35388 lab=_50257_/X }
C {devices/lab_pin.sym} 35680 -14840 0 0 {name=p35389 lab=_50045_/X }
C {devices/lab_pin.sym} 35680 -14800 0 0 {name=p35390 lab=_50886_/C }
C {devices/lab_pin.sym} 35680 -14760 0 0 {name=p35391 lab=_52580_/D }
C {devices/lab_pin.sym} 35800 -14820 0 1 {name=p35392 lab=_50886_/X }
C {sky130_stdcells/and4_4.sym} 35740 -14820 0 0 {name=X_50886_ }
C {devices/lab_pin.sym} 35700 -14670 0 0 {name=p35393 lab=_58201_/A }
C {devices/lab_pin.sym} 35780 -14670 0 1 {name=p35394 lab=_58201_/X }
C {sky130_stdcells/buf_2.sym} 35740 -14670 0 0 {name=X_58201_ }
C {devices/lab_pin.sym} 35680 -14570 0 0 {name=p35395 lab=_55399_/X }
C {devices/lab_pin.sym} 35680 -14530 0 0 {name=p35396 lab=_55412_/Y }
C {devices/lab_pin.sym} 35680 -14490 0 0 {name=p35397 lab=_55409_/Y }
C {devices/lab_pin.sym} 35800 -14530 0 1 {name=p35398 lab=_55414_/B }
C {sky130_stdcells/nand3_4.sym} 35740 -14530 0 0 {name=X_55413_ }
C {devices/lab_pin.sym} 35650 -14390 0 0 {name=p35399 lab=_86235_/CLK }
C {devices/lab_pin.sym} 35650 -14370 0 0 {name=p35400 lab=_50276_/Y }
C {devices/lab_pin.sym} 35830 -14390 0 1 {name=p35401 lab=_86233_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -14380 0 0 {name=X_86233_ }
C {devices/lab_pin.sym} 35660 -14270 0 0 {name=p35402 lab=_85784_/Q }
C {devices/lab_pin.sym} 35660 -14230 0 0 {name=p35403 lab=_52601_/X }
C {devices/lab_pin.sym} 35660 -14190 0 0 {name=p35404 lab=_52624_/Y }
C {devices/lab_pin.sym} 35820 -14230 0 1 {name=p35405 lab=_52625_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -14230 0 0 {name=X_52625_ }
C {devices/lab_pin.sym} 35660 -14120 0 0 {name=p35406 lab=_84763_/Q }
C {devices/lab_pin.sym} 35660 -14080 0 0 {name=p35407 lab=_59129_/X }
C {devices/lab_pin.sym} 35660 -14040 0 0 {name=p35408 lab=_59174_/X }
C {devices/lab_pin.sym} 35660 -14000 0 0 {name=p35409 lab=_59180_/X }
C {devices/lab_pin.sym} 35820 -14060 0 1 {name=p35410 lab=_84763_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 35740 -14060 0 0 {name=X_59181_ }
C {devices/lab_pin.sym} 35650 -13910 0 0 {name=p35411 lab=_83763_/CLK }
C {devices/lab_pin.sym} 35650 -13890 0 0 {name=p35412 lab=_83445_/D }
C {devices/lab_pin.sym} 35830 -13910 0 1 {name=p35413 lab=_83445_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -13900 0 0 {name=X_83445_ }
C {devices/lab_pin.sym} 35660 -13790 0 0 {name=p35414 lab=_56035_/X }
C {devices/lab_pin.sym} 35660 -13750 0 0 {name=p35415 lab=_56378_/X }
C {devices/lab_pin.sym} 35660 -13710 0 0 {name=p35416 lab=_56392_/Y }
C {devices/lab_pin.sym} 35820 -13750 0 1 {name=p35417 lab=_85211_/D }
C {sky130_stdcells/o21ai_4.sym} 35740 -13750 0 0 {name=X_56393_ }
C {devices/lab_pin.sym} 35650 -13610 0 0 {name=p35418 lab=_80657_/CLK }
C {devices/lab_pin.sym} 35650 -13590 0 0 {name=p35419 lab=_74833_/Y }
C {devices/lab_pin.sym} 35830 -13610 0 1 {name=p35420 lab=_46114_/A }
C {sky130_stdcells/dfxtp_4.sym} 35740 -13600 0 0 {name=X_80657_ }
C {devices/lab_pin.sym} 35700 -13470 0 0 {name=p35421 lab=_69088_/A }
C {devices/lab_pin.sym} 35780 -13470 0 1 {name=p35422 lab=_68379_/X }
C {sky130_stdcells/buf_2.sym} 35740 -13470 0 0 {name=X_68379_ }
C {sky130_stdcells/decap_3.sym} 35740 -13320 0 0 {name=XPHY_303 }
C {sky130_stdcells/decap_3.sym} 35740 -13140 0 0 {name=XPHY_314 }
C {devices/lab_pin.sym} 35680 -13000 0 0 {name=p35423 lab=_58132_/A }
C {devices/lab_pin.sym} 35680 -12960 0 0 {name=p35424 lab=_58649_/B }
C {devices/lab_pin.sym} 35800 -12980 0 1 {name=p35425 lab=_58132_/Y }
C {sky130_stdcells/nor2_4.sym} 35740 -12980 0 0 {name=X_58132_ }
C {devices/lab_pin.sym} 35700 -12850 0 0 {name=p35426 lab=_70609_/A }
C {devices/lab_pin.sym} 35780 -12850 0 1 {name=p35427 lab=_70410_/Y }
C {sky130_stdcells/inv_2.sym} 35740 -12850 0 0 {name=X_70410_ }
C {sky130_stdcells/decap_3.sym} 35740 -12700 0 0 {name=XPHY_325 }
C {devices/lab_pin.sym} 35660 -12580 0 0 {name=p35428 lab=_85105_/Q }
C {devices/lab_pin.sym} 35660 -12540 0 0 {name=p35429 lab=_55342_/X }
C {devices/lab_pin.sym} 35660 -12500 0 0 {name=p35430 lab=_44046_/X }
C {devices/lab_pin.sym} 35660 -12460 0 0 {name=p35431 lab=_55343_/X }
C {devices/lab_pin.sym} 35820 -12520 0 1 {name=p35432 lab=_55344_/X }
C {sky130_stdcells/a211o_4.sym} 35740 -12520 0 0 {name=X_55344_ }
C {devices/lab_pin.sym} 35650 -12370 0 0 {name=p35433 lab=_85557_/CLK }
C {devices/lab_pin.sym} 35650 -12350 0 0 {name=p35434 lab=_50631_/Y }
C {devices/lab_pin.sym} 35830 -12370 0 1 {name=p35435 lab=_86164_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -12360 0 0 {name=X_86164_ }
C {devices/lab_pin.sym} 35700 -12230 0 0 {name=p35436 lab=_40569_/Y }
C {devices/lab_pin.sym} 35780 -12230 0 1 {name=p35437 lab=_88371_/D }
C {sky130_stdcells/inv_2.sym} 35740 -12230 0 0 {name=X_40570_ }
C {sky130_stdcells/decap_3.sym} 35740 -12080 0 0 {name=XPHY_336 }
C {devices/lab_pin.sym} 35660 -11950 0 0 {name=p35438 lab=_65298_/B }
C {devices/lab_pin.sym} 35660 -11910 0 0 {name=p35439 lab=_52549_/X }
C {devices/lab_pin.sym} 35660 -11870 0 0 {name=p35440 lab=_52555_/Y }
C {devices/lab_pin.sym} 35820 -11910 0 1 {name=p35441 lab=_52556_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -11910 0 0 {name=X_52556_ }
C {devices/lab_pin.sym} 35660 -11790 0 0 {name=p35442 lab=_71372_/Y }
C {devices/lab_pin.sym} 35660 -11750 0 0 {name=p35443 lab=_83516_/Q }
C {devices/lab_pin.sym} 35660 -11710 0 0 {name=p35444 lab=_71389_/Y }
C {devices/lab_pin.sym} 35820 -11750 0 1 {name=p35445 lab=_83516_/D }
C {sky130_stdcells/a21o_4.sym} 35740 -11750 0 0 {name=X_71390_ }
C {devices/lab_pin.sym} 35650 -11610 0 0 {name=p35446 lab=_83756_/CLK }
C {devices/lab_pin.sym} 35650 -11590 0 0 {name=p35447 lab=_83376_/D }
C {devices/lab_pin.sym} 35830 -11610 0 1 {name=p35448 lab=_83376_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -11600 0 0 {name=X_83376_ }
C {devices/lab_pin.sym} 35680 -11480 0 0 {name=p35449 lab=_80588_/A }
C {devices/lab_pin.sym} 35680 -11440 0 0 {name=p35450 lab=_80588_/B }
C {devices/lab_pin.sym} 35800 -11460 0 1 {name=p35451 lab=_80589_/B }
C {sky130_stdcells/xor2_4.sym} 35740 -11460 0 0 {name=X_80588_ }
C {sky130_stdcells/decap_3.sym} 35740 -11300 0 0 {name=XPHY_347 }
C {sky130_stdcells/decap_3.sym} 35740 -11120 0 0 {name=XPHY_358 }
C {devices/lab_pin.sym} 35650 -10970 0 0 {name=p35452 lab=_85089_/CLK }
C {devices/lab_pin.sym} 35650 -10950 0 0 {name=p35453 lab=_85115_/D }
C {devices/lab_pin.sym} 35830 -10970 0 1 {name=p35454 lab=_85115_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -10960 0 0 {name=X_85115_ }
C {sky130_stdcells/decap_3.sym} 35740 -10800 0 0 {name=XPHY_369 }
C {devices/lab_pin.sym} 35680 -10660 0 0 {name=p35455 lab=_51491_/A }
C {devices/lab_pin.sym} 35680 -10620 0 0 {name=p35456 lab=_53033_/B }
C {devices/lab_pin.sym} 35800 -10640 0 1 {name=p35457 lab=_51507_/Y }
C {sky130_stdcells/nand2_4.sym} 35740 -10640 0 0 {name=X_51507_ }
C {devices/lab_pin.sym} 35660 -10530 0 0 {name=p35458 lab=_58030_/X }
C {devices/lab_pin.sym} 35660 -10490 0 0 {name=p35459 lab=_85480_/Q }
C {devices/lab_pin.sym} 35660 -10450 0 0 {name=p35460 lab=_58062_/X }
C {devices/lab_pin.sym} 35820 -10490 0 1 {name=p35461 lab=_58063_/X }
C {sky130_stdcells/o21a_4.sym} 35740 -10490 0 0 {name=X_58063_ }
C {devices/lab_pin.sym} 35660 -10370 0 0 {name=p35462 lab=_70337_/X }
C {devices/lab_pin.sym} 35660 -10330 0 0 {name=p35463 lab=_74786_/A }
C {devices/lab_pin.sym} 35660 -10290 0 0 {name=p35464 lab=_70340_/X }
C {devices/lab_pin.sym} 35820 -10330 0 1 {name=p35465 lab=_83791_/D }
C {sky130_stdcells/a21o_4.sym} 35740 -10330 0 0 {name=X_70341_ }
C {devices/lab_pin.sym} 35650 -10190 0 0 {name=p35466 lab=_82327_/CLK }
C {devices/lab_pin.sym} 35650 -10170 0 0 {name=p35467 lab=_77152_/B }
C {devices/lab_pin.sym} 35830 -10190 0 1 {name=p35468 lab=_82327_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -10180 0 0 {name=X_82327_ }
C {devices/lab_pin.sym} 35660 -10070 0 0 {name=p35469 lab=_55285_/A }
C {devices/lab_pin.sym} 35660 -10030 0 0 {name=p35470 lab=_55274_/X }
C {devices/lab_pin.sym} 35660 -9990 0 0 {name=p35471 lab=_83318_/Q }
C {devices/lab_pin.sym} 35820 -10030 0 1 {name=p35472 lab=_55287_/A }
C {sky130_stdcells/a21o_4.sym} 35740 -10030 0 0 {name=X_55275_ }
C {devices/lab_pin.sym} 35650 -9890 0 0 {name=p35473 lab=_85778_/CLK }
C {devices/lab_pin.sym} 35650 -9870 0 0 {name=p35474 lab=_86095_/D }
C {devices/lab_pin.sym} 35830 -9890 0 1 {name=p35475 lab=_86095_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -9880 0 0 {name=X_86095_ }
C {devices/lab_pin.sym} 35700 -9750 0 0 {name=p35476 lab=_52319_/A }
C {devices/lab_pin.sym} 35780 -9750 0 1 {name=p35477 lab=_52487_/X }
C {sky130_stdcells/buf_2.sym} 35740 -9750 0 0 {name=X_52487_ }
C {devices/lab_pin.sym} 35680 -9640 0 0 {name=p35478 lab=_85101_/Q }
C {devices/lab_pin.sym} 35680 -9600 0 0 {name=p35479 lab=_56997_/X }
C {devices/lab_pin.sym} 35800 -9620 0 1 {name=p35480 lab=_57014_/Y }
C {sky130_stdcells/nor2_4.sym} 35740 -9620 0 0 {name=X_57014_ }
C {devices/lab_pin.sym} 35660 -9530 0 0 {name=p35481 lab=_42231_/X }
C {devices/lab_pin.sym} 35660 -9490 0 0 {name=p35482 lab=_42226_/X }
C {devices/lab_pin.sym} 35660 -9450 0 0 {name=p35483 lab=_41408_/X }
C {devices/lab_pin.sym} 35660 -9410 0 0 {name=p35484 lab=_87964_/Q }
C {devices/lab_pin.sym} 35660 -9370 0 0 {name=p35485 lab=_42228_/X }
C {devices/lab_pin.sym} 35820 -9450 0 1 {name=p35486 lab=_42241_/A }
C {sky130_stdcells/o32ai_4.sym} 35740 -9450 0 0 {name=X_42240_ }
C {devices/lab_pin.sym} 35700 -9290 0 0 {name=p35487 lab=_54253_/A }
C {devices/lab_pin.sym} 35780 -9290 0 1 {name=p35488 lab=_54226_/X }
C {sky130_stdcells/buf_2.sym} 35740 -9290 0 0 {name=X_54226_ }
C {devices/lab_pin.sym} 35660 -9190 0 0 {name=p35489 lab=_88328_/Q }
C {devices/lab_pin.sym} 35660 -9150 0 0 {name=p35490 lab=_73059_/X }
C {devices/lab_pin.sym} 35660 -9110 0 0 {name=p35491 lab=_73007_/X }
C {devices/lab_pin.sym} 35820 -9150 0 1 {name=p35492 lab=_73060_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -9150 0 0 {name=X_73060_ }
C {devices/lab_pin.sym} 35650 -9010 0 0 {name=p35493 lab=_85050_/CLK }
C {devices/lab_pin.sym} 35650 -8990 0 0 {name=p35494 lab=_57259_/X }
C {devices/lab_pin.sym} 35830 -9010 0 1 {name=p35495 lab=_45567_/A }
C {sky130_stdcells/dfxtp_4.sym} 35740 -9000 0 0 {name=X_85046_ }
C {devices/lab_pin.sym} 35680 -8900 0 0 {name=p35496 lab=_51456_/A }
C {devices/lab_pin.sym} 35680 -8860 0 0 {name=p35497 lab=_51421_/X }
C {devices/lab_pin.sym} 35680 -8820 0 0 {name=p35498 lab=_51438_/C }
C {devices/lab_pin.sym} 35680 -8780 0 0 {name=p35499 lab=_52967_/D }
C {devices/lab_pin.sym} 35800 -8840 0 1 {name=p35500 lab=_51438_/X }
C {sky130_stdcells/and4_4.sym} 35740 -8840 0 0 {name=X_51438_ }
C {devices/lab_pin.sym} 35700 -8690 0 0 {name=p35501 lab=_83815_/Q }
C {devices/lab_pin.sym} 35780 -8690 0 1 {name=p35502 lab=_74788_/A }
C {sky130_stdcells/inv_2.sym} 35740 -8690 0 0 {name=X_70272_ }
C {devices/lab_pin.sym} 35650 -8570 0 0 {name=p35503 lab=_82436_/CLK }
C {devices/lab_pin.sym} 35650 -8550 0 0 {name=p35504 lab=_80471_/X }
C {devices/lab_pin.sym} 35830 -8570 0 1 {name=p35505 lab=_82258_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -8560 0 0 {name=X_82258_ }
C {devices/lab_pin.sym} 35660 -8450 0 0 {name=p35506 lab=_72008_/Y }
C {devices/lab_pin.sym} 35660 -8410 0 0 {name=p35507 lab=_72009_/X }
C {devices/lab_pin.sym} 35660 -8370 0 0 {name=p35508 lab=_72010_/Y }
C {devices/lab_pin.sym} 35820 -8410 0 1 {name=p35509 lab=_72011_/Y }
C {sky130_stdcells/a21boi_4.sym} 35740 -8410 0 0 {name=X_72011_ }
C {devices/lab_pin.sym} 35650 -8270 0 0 {name=p35510 lab=_81996_/CLK }
C {devices/lab_pin.sym} 35650 -8250 0 0 {name=p35511 lab=_75066_/X }
C {devices/lab_pin.sym} 35830 -8270 0 1 {name=p35512 lab=_48967_/A }
C {sky130_stdcells/dfxtp_4.sym} 35740 -8260 0 0 {name=X_81209_ }
C {devices/lab_pin.sym} 35660 -8170 0 0 {name=p35513 lab=_42154_/X }
C {devices/lab_pin.sym} 35660 -8130 0 0 {name=p35514 lab=_42169_/X }
C {devices/lab_pin.sym} 35660 -8090 0 0 {name=p35515 lab=_41220_/X }
C {devices/lab_pin.sym} 35660 -8050 0 0 {name=p35516 lab=_87999_/Q }
C {devices/lab_pin.sym} 35660 -8010 0 0 {name=p35517 lab=_42170_/X }
C {devices/lab_pin.sym} 35820 -8090 0 1 {name=p35518 lab=_42172_/A }
C {sky130_stdcells/o32ai_4.sym} 35740 -8090 0 0 {name=X_42171_ }
C {devices/lab_pin.sym} 35660 -7950 0 0 {name=p35519 lab=_54154_/Y }
C {devices/lab_pin.sym} 35660 -7910 0 0 {name=p35520 lab=_54144_/X }
C {devices/lab_pin.sym} 35660 -7870 0 0 {name=p35521 lab=_54156_/X }
C {devices/lab_pin.sym} 35820 -7910 0 1 {name=p35522 lab=_85494_/D }
C {sky130_stdcells/a21oi_4.sym} 35740 -7910 0 0 {name=X_54157_ }
C {devices/lab_pin.sym} 35660 -7790 0 0 {name=p35523 lab=_51365_/Y }
C {devices/lab_pin.sym} 35660 -7750 0 0 {name=p35524 lab=_51366_/X }
C {devices/lab_pin.sym} 35660 -7710 0 0 {name=p35525 lab=_51368_/X }
C {devices/lab_pin.sym} 35820 -7750 0 1 {name=p35526 lab=_86024_/D }
C {sky130_stdcells/a21oi_4.sym} 35740 -7750 0 0 {name=X_51369_ }
C {devices/lab_pin.sym} 35650 -7610 0 0 {name=p35527 lab=_84945_/CLK }
C {devices/lab_pin.sym} 35650 -7590 0 0 {name=p35528 lab=_82189_/D }
C {devices/lab_pin.sym} 35830 -7610 0 1 {name=p35529 lab=_82189_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -7600 0 0 {name=X_82189_ }
C {devices/lab_pin.sym} 35660 -7500 0 0 {name=p35530 lab=_41121_/X }
C {devices/lab_pin.sym} 35660 -7460 0 0 {name=p35531 lab=_41109_/X }
C {devices/lab_pin.sym} 35660 -7420 0 0 {name=p35532 lab=_88274_/Q }
C {devices/lab_pin.sym} 35660 -7380 0 0 {name=p35533 lab=_41110_/X }
C {devices/lab_pin.sym} 35820 -7440 0 1 {name=p35534 lab=_41122_/X }
C {sky130_stdcells/a2bb2o_4.sym} 35740 -7440 0 0 {name=X_41122_ }
C {devices/lab_pin.sym} 35660 -7310 0 0 {name=p35535 lab=_53106_/Y }
C {devices/lab_pin.sym} 35660 -7270 0 0 {name=p35536 lab=_53082_/X }
C {devices/lab_pin.sym} 35660 -7230 0 0 {name=p35537 lab=_53107_/X }
C {devices/lab_pin.sym} 35820 -7270 0 1 {name=p35538 lab=_85696_/D }
C {sky130_stdcells/a21oi_4.sym} 35740 -7270 0 0 {name=X_53108_ }
C {devices/lab_pin.sym} 35660 -7150 0 0 {name=p35539 lab=_58891_/X }
C {devices/lab_pin.sym} 35660 -7110 0 0 {name=p35540 lab=_86082_/Q }
C {devices/lab_pin.sym} 35660 -7070 0 0 {name=p35541 lab=_58964_/X }
C {devices/lab_pin.sym} 35820 -7110 0 1 {name=p35542 lab=_58965_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -7110 0 0 {name=X_58965_ }
C {devices/lab_pin.sym} 35660 -6990 0 0 {name=p35543 lab=_54086_/Y }
C {devices/lab_pin.sym} 35660 -6950 0 0 {name=p35544 lab=_53472_/X }
C {devices/lab_pin.sym} 35660 -6910 0 0 {name=p35545 lab=_54087_/Y }
C {devices/lab_pin.sym} 35820 -6950 0 1 {name=p35546 lab=_54088_/Y }
C {sky130_stdcells/a21boi_4.sym} 35740 -6950 0 0 {name=X_54088_ }
C {devices/lab_pin.sym} 35650 -6810 0 0 {name=p35547 lab=_88363_/CLK }
C {devices/lab_pin.sym} 35650 -6790 0 0 {name=p35548 lab=_44696_/Y }
C {devices/lab_pin.sym} 35830 -6810 0 1 {name=p35549 lab=_86997_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -6800 0 0 {name=X_86997_ }
C {devices/lab_pin.sym} 35700 -6670 0 0 {name=p35550 lab=_72905_/A }
C {devices/lab_pin.sym} 35780 -6670 0 1 {name=p35551 lab=_45930_/X }
C {sky130_stdcells/buf_2.sym} 35740 -6670 0 0 {name=X_45930_ }
C {devices/lab_pin.sym} 35660 -6570 0 0 {name=p35552 lab=_40991_/X }
C {devices/lab_pin.sym} 35660 -6530 0 0 {name=p35553 lab=_41223_/A }
C {devices/lab_pin.sym} 35660 -6490 0 0 {name=p35554 lab=_41052_/X }
C {devices/lab_pin.sym} 35820 -6530 0 1 {name=p35555 lab=_41053_/X }
C {sky130_stdcells/o21a_4.sym} 35740 -6530 0 0 {name=X_41053_ }
C {devices/lab_pin.sym} 35700 -6390 0 0 {name=p35556 lab=_52630_/A }
C {devices/lab_pin.sym} 35780 -6390 0 1 {name=p35557 lab=_53147_/A }
C {sky130_stdcells/buf_2.sym} 35740 -6390 0 0 {name=X_53039_ }
C {devices/lab_pin.sym} 35660 -6290 0 0 {name=p35558 lab=_72476_/B }
C {devices/lab_pin.sym} 35660 -6250 0 0 {name=p35559 lab=_86004_/Q }
C {devices/lab_pin.sym} 35660 -6210 0 0 {name=p35560 lab=_57915_/X }
C {devices/lab_pin.sym} 35820 -6250 0 1 {name=p35561 lab=_57916_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -6250 0 0 {name=X_57916_ }
C {devices/lab_pin.sym} 35660 -6130 0 0 {name=p35562 lab=_76738_/Y }
C {devices/lab_pin.sym} 35660 -6090 0 0 {name=p35563 lab=_76742_/Y }
C {devices/lab_pin.sym} 35660 -6050 0 0 {name=p35564 lab=_76744_/A }
C {devices/lab_pin.sym} 35820 -6090 0 1 {name=p35565 lab=_76750_/Y }
C {sky130_stdcells/a21boi_4.sym} 35740 -6090 0 0 {name=X_76750_ }
C {devices/lab_pin.sym} 35700 -5950 0 0 {name=p35566 lab=_73343_/X }
C {devices/lab_pin.sym} 35780 -5950 0 1 {name=p35567 lab=_73962_/X }
C {sky130_stdcells/buf_2.sym} 35740 -5950 0 0 {name=X_73962_ }
C {devices/lab_pin.sym} 35650 -5830 0 0 {name=p35568 lab=_82394_/CLK }
C {devices/lab_pin.sym} 35650 -5810 0 0 {name=p35569 lab=_85948_/D }
C {devices/lab_pin.sym} 35830 -5830 0 1 {name=p35570 lab=_85948_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -5820 0 0 {name=X_85948_ }
C {devices/lab_pin.sym} 35680 -5700 0 0 {name=p35571 lab=_58872_/A }
C {devices/lab_pin.sym} 35680 -5660 0 0 {name=p35572 lab=_58896_/B }
C {devices/lab_pin.sym} 35800 -5680 0 1 {name=p35573 lab=_58896_/Y }
C {sky130_stdcells/nor2_4.sym} 35740 -5680 0 0 {name=X_58896_ }
C {devices/lab_pin.sym} 35660 -5580 0 0 {name=p35574 lab=_75689_/A }
C {devices/lab_pin.sym} 35660 -5540 0 0 {name=p35575 lab=_75688_/Y }
C {devices/lab_pin.sym} 35660 -5500 0 0 {name=p35576 lab=_80910_/Q }
C {devices/lab_pin.sym} 35660 -5460 0 0 {name=p35577 lab=_80782_/D }
C {devices/lab_pin.sym} 35820 -5520 0 1 {name=p35578 lab=_75701_/X }
C {sky130_stdcells/a2bb2o_4.sym} 35740 -5520 0 0 {name=X_75701_ }
C {devices/lab_pin.sym} 35660 -5390 0 0 {name=p35579 lab=_72907_/X }
C {devices/lab_pin.sym} 35660 -5350 0 0 {name=p35580 lab=_72912_/X }
C {devices/lab_pin.sym} 35660 -5310 0 0 {name=p35581 lab=_72877_/X }
C {devices/lab_pin.sym} 35820 -5350 0 1 {name=p35582 lab=_72916_/A }
C {sky130_stdcells/a21o_4.sym} 35740 -5350 0 0 {name=X_72913_ }
C {devices/lab_pin.sym} 35700 -5210 0 0 {name=p35583 lab=_45861_/A }
C {devices/lab_pin.sym} 35780 -5210 0 1 {name=p35584 lab=_74702_/B }
C {sky130_stdcells/inv_2.sym} 35740 -5210 0 0 {name=X_45861_ }
C {devices/lab_pin.sym} 35660 -5130 0 0 {name=p35585 lab=_57801_/X }
C {devices/lab_pin.sym} 35660 -5090 0 0 {name=p35586 lab=_57843_/Y }
C {devices/lab_pin.sym} 35660 -5050 0 0 {name=p35587 lab=_57846_/Y }
C {devices/lab_pin.sym} 35660 -5010 0 0 {name=p35588 lab=_57822_/X }
C {devices/lab_pin.sym} 35660 -4970 0 0 {name=p35589 lab=_57809_/X }
C {devices/lab_pin.sym} 35820 -5050 0 1 {name=p35590 lab=_57847_/X }
C {sky130_stdcells/o32a_4.sym} 35740 -5050 0 0 {name=X_57847_ }
C {devices/lab_pin.sym} 35680 -4900 0 0 {name=p35591 lab=_76678_/X }
C {devices/lab_pin.sym} 35680 -4860 0 0 {name=p35592 lab=_76680_/Y }
C {devices/lab_pin.sym} 35800 -4880 0 1 {name=p35593 lab=_81445_/D }
C {sky130_stdcells/xor2_4.sym} 35740 -4880 0 0 {name=X_76681_ }
C {devices/lab_pin.sym} 35660 -4780 0 0 {name=p35594 lab=_68727_/Y }
C {devices/lab_pin.sym} 35660 -4740 0 0 {name=p35595 lab=_73891_/X }
C {devices/lab_pin.sym} 35660 -4700 0 0 {name=p35596 lab=_73819_/X }
C {devices/lab_pin.sym} 35660 -4660 0 0 {name=p35597 lab=_73892_/Y }
C {devices/lab_pin.sym} 35820 -4720 0 1 {name=p35598 lab=_73893_/X }
C {sky130_stdcells/a211o_4.sym} 35740 -4720 0 0 {name=X_73893_ }
C {devices/lab_pin.sym} 35650 -4570 0 0 {name=p35599 lab=_85879_/CLK }
C {devices/lab_pin.sym} 35650 -4550 0 0 {name=p35600 lab=_85879_/D }
C {devices/lab_pin.sym} 35830 -4570 0 1 {name=p35601 lab=_73040_/B }
C {sky130_stdcells/dfxtp_4.sym} 35740 -4560 0 0 {name=X_85879_ }
C {devices/lab_pin.sym} 35660 -4450 0 0 {name=p35602 lab=_86617_/Q }
C {devices/lab_pin.sym} 35660 -4410 0 0 {name=p35603 lab=_47570_/X }
C {devices/lab_pin.sym} 35660 -4370 0 0 {name=p35604 lab=_47599_/Y }
C {devices/lab_pin.sym} 35820 -4410 0 1 {name=p35605 lab=_47600_/Y }
C {sky130_stdcells/o21ai_4.sym} 35740 -4410 0 0 {name=X_47600_ }
C {devices/lab_pin.sym} 35660 -4290 0 0 {name=p35606 lab=_78405_/Y }
C {devices/lab_pin.sym} 35660 -4250 0 0 {name=p35607 lab=_78402_/Y }
C {devices/lab_pin.sym} 35660 -4210 0 0 {name=p35608 lab=_78408_/C }
C {devices/lab_pin.sym} 35820 -4250 0 1 {name=p35609 lab=_78420_/X }
C {sky130_stdcells/o21a_4.sym} 35740 -4250 0 0 {name=X_78420_ }
C {devices/lab_pin.sym} 35660 -4140 0 0 {name=p35610 lab=_41642_/Y }
C {devices/lab_pin.sym} 35660 -4100 0 0 {name=p35611 lab=_43939_/X }
C {devices/lab_pin.sym} 35660 -4060 0 0 {name=p35612 lab=_67381_/B }
C {devices/lab_pin.sym} 35660 -4020 0 0 {name=p35613 lab=_43941_/X }
C {devices/lab_pin.sym} 35820 -4080 0 1 {name=p35614 lab=_86941_/D }
C {sky130_stdcells/a2bb2o_4.sym} 35740 -4080 0 0 {name=X_44812_ }
C {devices/lab_pin.sym} 35680 -3940 0 0 {name=p35615 lab=_75632_/A }
C {devices/lab_pin.sym} 35680 -3900 0 0 {name=p35616 lab=_75632_/B }
C {devices/lab_pin.sym} 35800 -3920 0 1 {name=p35617 lab=_75633_/B }
C {sky130_stdcells/nor2_4.sym} 35740 -3920 0 0 {name=X_75632_ }
C {devices/lab_pin.sym} 35650 -3790 0 0 {name=p35618 lab=_88387_/CLK }
C {devices/lab_pin.sym} 35650 -3770 0 0 {name=p35619 lab=_42987_/Y }
C {devices/lab_pin.sym} 35830 -3790 0 1 {name=p35620 lab=_87618_/Q }
C {sky130_stdcells/dfxtp_4.sym} 35740 -3780 0 0 {name=X_87618_ }
C {devices/lab_pin.sym} 35660 -3670 0 0 {name=p35621 lab=_48574_/Y }
C {devices/lab_pin.sym} 35660 -3630 0 0 {name=p35622 lab=_48517_/X }
C {devices/lab_pin.sym} 35660 -3590 0 0 {name=p35623 lab=_48579_/X }
C {devices/lab_pin.sym} 35820 -3630 0 1 {name=p35624 lab=_48580_/Y }
C {sky130_stdcells/a21oi_4.sym} 35740 -3630 0 0 {name=X_48580_ }
C {devices/lab_pin.sym} 35660 -3520 0 0 {name=p35625 lab=_72755_/X }
