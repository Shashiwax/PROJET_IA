C {devices/lab_pin.sym} 146220 -33490 0 1 {name=p144945 lab=_52155_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -33490 0 0 {name=X_52155_ }
C {devices/lab_pin.sym} 146050 -33350 0 0 {name=p144946 lab=_88104_/CLK }
C {devices/lab_pin.sym} 146050 -33330 0 0 {name=p144947 lab=_42476_/Y }
C {devices/lab_pin.sym} 146230 -33350 0 1 {name=p144948 lab=_42475_/A }
C {sky130_stdcells/dfxtp_4.sym} 146140 -33340 0 0 {name=X_87852_ }
C {devices/lab_pin.sym} 146080 -33220 0 0 {name=p144949 lab=_80187_/A }
C {devices/lab_pin.sym} 146080 -33180 0 0 {name=p144950 lab=_80186_/X }
C {devices/lab_pin.sym} 146200 -33200 0 1 {name=p144951 lab=_80187_/Y }
C {sky130_stdcells/xnor2_4.sym} 146140 -33200 0 0 {name=X_80187_ }
C {devices/lab_pin.sym} 146060 -33090 0 0 {name=p144952 lab=_68497_/X }
C {devices/lab_pin.sym} 146060 -33050 0 0 {name=p144953 lab=_68499_/X }
C {devices/lab_pin.sym} 146060 -33010 0 0 {name=p144954 lab=_69925_/X }
C {devices/lab_pin.sym} 146220 -33050 0 1 {name=p144955 lab=_69998_/Y }
C {sky130_stdcells/a21oi_4.sym} 146140 -33050 0 0 {name=X_69998_ }
C {devices/lab_pin.sym} 146060 -32930 0 0 {name=p144956 lab=_51104_/Y }
C {devices/lab_pin.sym} 146060 -32890 0 0 {name=p144957 lab=_51093_/X }
C {devices/lab_pin.sym} 146060 -32850 0 0 {name=p144958 lab=_51105_/X }
C {devices/lab_pin.sym} 146220 -32890 0 1 {name=p144959 lab=_51106_/Y }
C {sky130_stdcells/a21oi_4.sym} 146140 -32890 0 0 {name=X_51106_ }
C {devices/lab_pin.sym} 146050 -32750 0 0 {name=p144960 lab=_87073_/CLK }
C {devices/lab_pin.sym} 146050 -32730 0 0 {name=p144961 lab=_46034_/Y }
C {devices/lab_pin.sym} 146230 -32750 0 1 {name=p144962 lab=_86803_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -32740 0 0 {name=X_86803_ }
C {devices/lab_pin.sym} 146100 -32610 0 0 {name=p144963 lab=_59751_/A }
C {devices/lab_pin.sym} 146180 -32610 0 1 {name=p144964 lab=_60312_/C }
C {sky130_stdcells/buf_2.sym} 146140 -32610 0 0 {name=X_59751_ }
C {devices/lab_pin.sym} 146100 -32490 0 0 {name=p144965 lab=clkbuf_8_104_0_CLK/X }
C {devices/lab_pin.sym} 146180 -32490 0 1 {name=p144966 lab=clkbuf_9_209_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 146140 -32490 0 0 {name=Xclkbuf_9_209_0_CLK }
C {devices/lab_pin.sym} 146060 -32390 0 0 {name=p144967 lab=_66334_/B }
C {devices/lab_pin.sym} 146060 -32350 0 0 {name=p144968 lab=_52075_/X }
C {devices/lab_pin.sym} 146060 -32310 0 0 {name=p144969 lab=_52085_/Y }
C {devices/lab_pin.sym} 146220 -32350 0 1 {name=p144970 lab=_52086_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -32350 0 0 {name=X_52086_ }
C {devices/lab_pin.sym} 146060 -32240 0 0 {name=p144971 lab=_56949_/X }
C {devices/lab_pin.sym} 146060 -32200 0 0 {name=p144972 lab=_56630_/X }
C {devices/lab_pin.sym} 146060 -32160 0 0 {name=p144973 lab=_45572_/A }
C {devices/lab_pin.sym} 146060 -32120 0 0 {name=p144974 lab=_56947_/X }
C {devices/lab_pin.sym} 146220 -32180 0 1 {name=p144975 lab=_85110_/D }
C {sky130_stdcells/a2bb2o_4.sym} 146140 -32180 0 0 {name=X_56963_ }
C {devices/lab_pin.sym} 146080 -32040 0 0 {name=p144976 lab=_68994_/A }
C {devices/lab_pin.sym} 146080 -32000 0 0 {name=p144977 lab=_88252_/Q }
C {devices/lab_pin.sym} 146200 -32020 0 1 {name=p144978 lab=_68949_/X }
C {sky130_stdcells/and2_4.sym} 146140 -32020 0 0 {name=X_68949_ }
C {devices/lab_pin.sym} 146050 -31890 0 0 {name=p144979 lab=_87544_/CLK }
C {devices/lab_pin.sym} 146050 -31870 0 0 {name=p144980 lab=_42660_/Y }
C {devices/lab_pin.sym} 146230 -31890 0 1 {name=p144981 lab=_87783_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -31880 0 0 {name=X_87783_ }
C {devices/lab_pin.sym} 146050 -31750 0 0 {name=p144982 lab=_85005_/CLK }
C {devices/lab_pin.sym} 146050 -31730 0 0 {name=p144983 lab=_57485_/X }
C {devices/lab_pin.sym} 146230 -31750 0 1 {name=p144984 lab=_55219_/B }
C {sky130_stdcells/dfxtp_4.sym} 146140 -31740 0 0 {name=X_84995_ }
C {devices/lab_pin.sym} 146060 -31650 0 0 {name=p144985 lab=_58696_/X }
C {devices/lab_pin.sym} 146060 -31610 0 0 {name=p144986 lab=_58699_/Y }
C {devices/lab_pin.sym} 146060 -31570 0 0 {name=p144987 lab=_58700_/Y }
C {devices/lab_pin.sym} 146060 -31530 0 0 {name=p144988 lab=_58603_/X }
C {devices/lab_pin.sym} 146060 -31490 0 0 {name=p144989 lab=_58701_/X }
C {devices/lab_pin.sym} 146220 -31570 0 1 {name=p144990 lab=_58702_/X }
C {sky130_stdcells/o32a_4.sym} 146140 -31570 0 0 {name=X_58702_ }
C {devices/lab_pin.sym} 146080 -31420 0 0 {name=p144991 lab=_51022_/A }
C {devices/lab_pin.sym} 146080 -31380 0 0 {name=p144992 lab=_51037_/B }
C {devices/lab_pin.sym} 146200 -31400 0 1 {name=p144993 lab=_51037_/Y }
C {sky130_stdcells/nand2_4.sym} 146140 -31400 0 0 {name=X_51037_ }
C {devices/lab_pin.sym} 146060 -31300 0 0 {name=p144994 lab=_83033_/Q }
C {devices/lab_pin.sym} 146060 -31260 0 0 {name=p144995 lab=_55617_/X }
C {devices/lab_pin.sym} 146060 -31220 0 0 {name=p144996 lab=_44099_/X }
C {devices/lab_pin.sym} 146060 -31180 0 0 {name=p144997 lab=_55913_/X }
C {devices/lab_pin.sym} 146220 -31240 0 1 {name=p144998 lab=_55914_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -31240 0 0 {name=X_55914_ }
C {devices/lab_pin.sym} 146050 -31090 0 0 {name=p144999 lab=_86414_/CLK }
C {devices/lab_pin.sym} 146050 -31070 0 0 {name=p145000 lab=_86734_/D }
C {devices/lab_pin.sym} 146230 -31090 0 1 {name=p145001 lab=_86734_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -31080 0 0 {name=X_86734_ }
C {devices/lab_pin.sym} 146080 -30970 0 0 {name=p145002 lab=_48884_/A }
C {devices/lab_pin.sym} 146080 -30930 0 0 {name=p145003 lab=_71959_/X }
C {devices/lab_pin.sym} 146080 -30890 0 0 {name=p145004 lab=_71960_/C }
C {devices/lab_pin.sym} 146200 -30930 0 1 {name=p145005 lab=_71960_/X }
C {sky130_stdcells/and3_4.sym} 146140 -30930 0 0 {name=X_71960_ }
C {devices/lab_pin.sym} 146050 -30790 0 0 {name=p145006 lab=_83973_/CLK }
C {devices/lab_pin.sym} 146050 -30770 0 0 {name=p145007 lab=_83946_/D }
C {devices/lab_pin.sym} 146230 -30790 0 1 {name=p145008 lab=_80802_/D }
C {sky130_stdcells/dfxtp_4.sym} 146140 -30780 0 0 {name=X_83946_ }
C {devices/lab_pin.sym} 146080 -30670 0 0 {name=p145009 lab=_59836_/D }
C {devices/lab_pin.sym} 146080 -30630 0 0 {name=p145010 lab=_59664_/C }
C {devices/lab_pin.sym} 146080 -30590 0 0 {name=p145011 lab=_59664_/A }
C {devices/lab_pin.sym} 146200 -30630 0 1 {name=p145012 lab=_59683_/A }
C {sky130_stdcells/nor3_4.sym} 146140 -30630 0 0 {name=X_59682_ }
C {devices/lab_pin.sym} 146100 -30490 0 0 {name=p145013 lab=_56849_/X }
C {devices/lab_pin.sym} 146180 -30490 0 1 {name=p145014 lab=_56894_/Y }
C {sky130_stdcells/inv_2.sym} 146140 -30490 0 0 {name=X_56894_ }
C {devices/lab_pin.sym} 146100 -30370 0 0 {name=p145015 lab=_70925_/A }
C {devices/lab_pin.sym} 146180 -30370 0 1 {name=p145016 lab=_70914_/C }
C {sky130_stdcells/buf_2.sym} 146140 -30370 0 0 {name=X_70911_ }
C {devices/lab_pin.sym} 146080 -30260 0 0 {name=p145017 lab=_58659_/A }
C {devices/lab_pin.sym} 146080 -30220 0 0 {name=p145018 lab=_58633_/B }
C {devices/lab_pin.sym} 146200 -30240 0 1 {name=p145019 lab=_58633_/Y }
C {sky130_stdcells/nor2_4.sym} 146140 -30240 0 0 {name=X_58633_ }
C {devices/lab_pin.sym} 146080 -30140 0 0 {name=p145020 lab=_56088_/A }
C {devices/lab_pin.sym} 146080 -30100 0 0 {name=p145021 lab=_55845_/B }
C {devices/lab_pin.sym} 146080 -30060 0 0 {name=p145022 lab=_55842_/X }
C {devices/lab_pin.sym} 146080 -30020 0 0 {name=p145023 lab=_55844_/X }
C {devices/lab_pin.sym} 146200 -30080 0 1 {name=p145024 lab=_56083_/C }
C {sky130_stdcells/and4_4.sym} 146140 -30080 0 0 {name=X_55845_ }
C {devices/lab_pin.sym} 146050 -29930 0 0 {name=p145025 lab=_86665_/CLK }
C {devices/lab_pin.sym} 146050 -29910 0 0 {name=p145026 lab=_47156_/Y }
C {devices/lab_pin.sym} 146230 -29930 0 1 {name=p145027 lab=_86665_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -29920 0 0 {name=X_86665_ }
C {devices/lab_pin.sym} 146080 -29800 0 0 {name=p145028 lab=_70530_/Y }
C {devices/lab_pin.sym} 146080 -29760 0 0 {name=p145029 lab=_71137_/B }
C {devices/lab_pin.sym} 146200 -29780 0 1 {name=p145030 lab=_71891_/Y }
C {sky130_stdcells/nor2_4.sym} 146140 -29780 0 0 {name=X_71891_ }
C {devices/lab_pin.sym} 146050 -29650 0 0 {name=p145031 lab=_82557_/CLK }
C {devices/lab_pin.sym} 146050 -29630 0 0 {name=p145032 lab=_69997_/X }
C {devices/lab_pin.sym} 146230 -29650 0 1 {name=p145033 lab=_82557_/D }
C {sky130_stdcells/dfxtp_4.sym} 146140 -29640 0 0 {name=X_83877_ }
C {devices/lab_pin.sym} 146060 -29540 0 0 {name=p145034 lab=_41416_/X }
C {devices/lab_pin.sym} 146060 -29500 0 0 {name=p145035 lab=_42802_/X }
C {devices/lab_pin.sym} 146060 -29460 0 0 {name=p145036 lab=_67901_/B }
C {devices/lab_pin.sym} 146060 -29420 0 0 {name=p145037 lab=_42803_/X }
C {devices/lab_pin.sym} 146220 -29480 0 1 {name=p145038 lab=_42810_/X }
C {sky130_stdcells/a2bb2o_4.sym} 146140 -29480 0 0 {name=X_42810_ }
C {devices/lab_pin.sym} 146060 -29360 0 0 {name=p145039 lab=_43032_/Y }
C {devices/lab_pin.sym} 146060 -29320 0 0 {name=p145040 lab=_73627_/X }
C {devices/lab_pin.sym} 146060 -29280 0 0 {name=p145041 lab=_73464_/X }
C {devices/lab_pin.sym} 146060 -29240 0 0 {name=p145042 lab=_73629_/Y }
C {devices/lab_pin.sym} 146220 -29300 0 1 {name=p145043 lab=_73630_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -29300 0 0 {name=X_73630_ }
C {devices/lab_pin.sym} 146050 -29150 0 0 {name=p145044 lab=_86576_/CLK }
C {devices/lab_pin.sym} 146050 -29130 0 0 {name=p145045 lab=_85616_/D }
C {devices/lab_pin.sym} 146230 -29150 0 1 {name=p145046 lab=_85616_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -29140 0 0 {name=X_85616_ }
C {devices/lab_pin.sym} 146060 -29030 0 0 {name=p145047 lab=_51765_/B }
C {devices/lab_pin.sym} 146060 -28990 0 0 {name=p145048 lab=_70831_/X }
C {devices/lab_pin.sym} 146060 -28950 0 0 {name=p145049 lab=_70841_/Y }
C {devices/lab_pin.sym} 146220 -28990 0 1 {name=p145050 lab=_70842_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -28990 0 0 {name=X_70842_ }
C {devices/lab_pin.sym} 146080 -28860 0 0 {name=p145051 lab=_58576_/A }
C {devices/lab_pin.sym} 146080 -28820 0 0 {name=p145052 lab=_86401_/Q }
C {devices/lab_pin.sym} 146200 -28840 0 1 {name=p145053 lab=_58564_/Y }
C {sky130_stdcells/nor2_4.sym} 146140 -28840 0 0 {name=X_58564_ }
C {devices/lab_pin.sym} 146050 -28710 0 0 {name=p145054 lab=_82828_/CLK }
C {devices/lab_pin.sym} 146050 -28690 0 0 {name=p145055 lab=_82828_/D }
C {devices/lab_pin.sym} 146230 -28710 0 1 {name=p145056 lab=_82828_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -28700 0 0 {name=X_82828_ }
C {devices/lab_pin.sym} 146080 -28580 0 0 {name=p145057 lab=_55794_/A }
C {devices/lab_pin.sym} 146080 -28540 0 0 {name=p145058 lab=_85162_/Q }
C {devices/lab_pin.sym} 146200 -28560 0 1 {name=p145059 lab=_55776_/X }
C {sky130_stdcells/and2_4.sym} 146140 -28560 0 0 {name=X_55776_ }
C {devices/lab_pin.sym} 146100 -28430 0 0 {name=p145060 lab=_43774_/A }
C {devices/lab_pin.sym} 146180 -28430 0 1 {name=p145061 lab=_43790_/X }
C {sky130_stdcells/buf_2.sym} 146140 -28430 0 0 {name=X_43790_ }
C {devices/lab_pin.sym} 146050 -28310 0 0 {name=p145062 lab=_85955_/CLK }
C {devices/lab_pin.sym} 146050 -28290 0 0 {name=p145063 lab=_86596_/D }
C {devices/lab_pin.sym} 146230 -28310 0 1 {name=p145064 lab=_86596_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -28300 0 0 {name=X_86596_ }
C {devices/lab_pin.sym} 146100 -28170 0 0 {name=p145065 lab=_53069_/A }
C {devices/lab_pin.sym} 146180 -28170 0 1 {name=p145066 lab=_52997_/B }
C {sky130_stdcells/buf_2.sym} 146140 -28170 0 0 {name=X_52988_ }
C {devices/lab_pin.sym} 146100 -28050 0 0 {name=p145067 lab=_46399_/A }
C {devices/lab_pin.sym} 146180 -28050 0 1 {name=p145068 lab=_57515_/X }
C {sky130_stdcells/buf_2.sym} 146140 -28050 0 0 {name=X_57515_ }
C {devices/lab_pin.sym} 146050 -27930 0 0 {name=p145069 lab=_88327_/CLK }
C {devices/lab_pin.sym} 146050 -27910 0 0 {name=p145070 lab=_88335_/D }
C {devices/lab_pin.sym} 146230 -27930 0 1 {name=p145071 lab=_69627_/B }
C {sky130_stdcells/dfxtp_4.sym} 146140 -27920 0 0 {name=X_88335_ }
C {devices/lab_pin.sym} 146080 -27820 0 0 {name=p145072 lab=_54748_/A }
C {devices/lab_pin.sym} 146080 -27780 0 0 {name=p145073 lab=_54734_/B }
C {devices/lab_pin.sym} 146080 -27740 0 0 {name=p145074 lab=_54748_/C }
C {devices/lab_pin.sym} 146080 -27700 0 0 {name=p145075 lab=_47417_/A }
C {devices/lab_pin.sym} 146200 -27760 0 1 {name=p145076 lab=_54727_/X }
C {sky130_stdcells/and4_4.sym} 146140 -27760 0 0 {name=X_54727_ }
C {devices/lab_pin.sym} 146060 -27650 0 0 {name=p145077 lab=_42739_/X }
C {devices/lab_pin.sym} 146060 -27610 0 0 {name=p145078 lab=_42740_/X }
C {devices/lab_pin.sym} 146060 -27570 0 0 {name=p145079 lab=_41225_/X }
C {devices/lab_pin.sym} 146060 -27530 0 0 {name=p145080 lab=_68896_/B }
C {devices/lab_pin.sym} 146060 -27490 0 0 {name=p145081 lab=_42732_/X }
C {devices/lab_pin.sym} 146220 -27570 0 1 {name=p145082 lab=_42741_/Y }
C {sky130_stdcells/o32ai_4.sym} 146140 -27570 0 0 {name=X_42741_ }
C {devices/lab_pin.sym} 146080 -27420 0 0 {name=p145083 lab=_73583_/A }
C {devices/lab_pin.sym} 146080 -27380 0 0 {name=p145084 lab=_73561_/B }
C {devices/lab_pin.sym} 146200 -27400 0 1 {name=p145085 lab=_73561_/X }
C {sky130_stdcells/and2_4.sym} 146140 -27400 0 0 {name=X_73561_ }
C {devices/lab_pin.sym} 146050 -27270 0 0 {name=p145086 lab=_85547_/CLK }
C {devices/lab_pin.sym} 146050 -27250 0 0 {name=p145087 lab=_53894_/Y }
C {devices/lab_pin.sym} 146230 -27270 0 1 {name=p145088 lab=_85547_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -27260 0 0 {name=X_85547_ }
C {devices/lab_pin.sym} 146080 -27140 0 0 {name=p145089 lab=_53259_/A }
C {devices/lab_pin.sym} 146080 -27100 0 0 {name=p145090 lab=_50232_/B }
C {devices/lab_pin.sym} 146200 -27120 0 1 {name=p145091 lab=_51939_/Y }
C {sky130_stdcells/nand2_4.sym} 146140 -27120 0 0 {name=X_51939_ }
C {devices/lab_pin.sym} 146050 -26990 0 0 {name=p145092 lab=_82961_/CLK }
C {devices/lab_pin.sym} 146050 -26970 0 0 {name=p145093 lab=_82759_/D }
C {devices/lab_pin.sym} 146230 -26990 0 1 {name=p145094 lab=_82759_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -26980 0 0 {name=X_82759_ }
C {devices/lab_pin.sym} 146100 -26850 0 0 {name=p145095 lab=_70773_/A }
C {devices/lab_pin.sym} 146180 -26850 0 1 {name=p145096 lab=_70862_/A }
C {sky130_stdcells/buf_2.sym} 146140 -26850 0 0 {name=X_70773_ }
C {devices/lab_pin.sym} 146080 -26740 0 0 {name=p145097 lab=_58495_/A }
C {devices/lab_pin.sym} 146080 -26700 0 0 {name=p145098 lab=_58502_/B }
C {devices/lab_pin.sym} 146200 -26720 0 1 {name=p145099 lab=_58495_/Y }
C {sky130_stdcells/nor2_4.sym} 146140 -26720 0 0 {name=X_58495_ }
C {devices/lab_pin.sym} 146100 -26590 0 0 {name=p145100 lab=clkbuf_4_9_0_CLK/A }
C {devices/lab_pin.sym} 146180 -26590 0 1 {name=p145101 lab=clkbuf_4_9_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 146140 -26590 0 0 {name=Xclkbuf_4_9_0_CLK }
C {devices/lab_pin.sym} 146080 -26480 0 0 {name=p145102 lab=_80690_/Q }
C {devices/lab_pin.sym} 146080 -26440 0 0 {name=p145103 lab=_80990_/Q }
C {devices/lab_pin.sym} 146200 -26460 0 1 {name=p145104 lab=_75301_/B }
C {sky130_stdcells/xor2_4.sym} 146140 -26460 0 0 {name=X_75300_ }
C {devices/lab_pin.sym} 146060 -26370 0 0 {name=p145105 lab=_72506_/Y }
C {devices/lab_pin.sym} 146060 -26330 0 0 {name=p145106 lab=_72510_/Y }
C {devices/lab_pin.sym} 146060 -26290 0 0 {name=p145107 lab=_59654_/X }
C {devices/lab_pin.sym} 146060 -26250 0 0 {name=p145108 lab=_61281_/C }
C {devices/lab_pin.sym} 146060 -26220 0 0 {name=p145109 lab=_72511_/Y }
C {devices/lab_pin.sym} 146220 -26290 0 1 {name=p145110 lab=_72512_/X }
C {sky130_stdcells/a41o_4.sym} 146140 -26290 0 0 {name=X_72512_ }
C {devices/lab_pin.sym} 146080 -26140 0 0 {name=p145111 lab=_45460_/A }
C {devices/lab_pin.sym} 146080 -26100 0 0 {name=p145112 lab=_45397_/X }
C {devices/lab_pin.sym} 146200 -26120 0 1 {name=p145113 lab=_45460_/Y }
C {sky130_stdcells/nor2_4.sym} 146140 -26120 0 0 {name=X_45460_ }
C {devices/lab_pin.sym} 146060 -26010 0 0 {name=p145114 lab=_57440_/X }
C {devices/lab_pin.sym} 146060 -25970 0 0 {name=p145115 lab=_57444_/X }
C {devices/lab_pin.sym} 146060 -25930 0 0 {name=p145116 lab=_57445_/Y }
C {devices/lab_pin.sym} 146220 -25970 0 1 {name=p145117 lab=_57447_/A }
C {sky130_stdcells/o21ai_4.sym} 146140 -25970 0 0 {name=X_57446_ }
C {devices/lab_pin.sym} 146060 -25850 0 0 {name=p145118 lab=_76276_/X }
C {devices/lab_pin.sym} 146060 -25810 0 0 {name=p145119 lab=_76282_/C }
C {devices/lab_pin.sym} 146060 -25770 0 0 {name=p145120 lab=_76281_/A }
C {devices/lab_pin.sym} 146220 -25810 0 1 {name=p145121 lab=_76293_/A }
C {sky130_stdcells/a21boi_4.sym} 146140 -25810 0 0 {name=X_76280_ }
C {devices/lab_pin.sym} 146050 -25670 0 0 {name=p145122 lab=_88268_/CLK }
C {devices/lab_pin.sym} 146050 -25650 0 0 {name=p145123 lab=_88266_/D }
C {devices/lab_pin.sym} 146230 -25670 0 1 {name=p145124 lab=_68607_/B }
C {sky130_stdcells/dfxtp_4.sym} 146140 -25660 0 0 {name=X_88266_ }
C {devices/lab_pin.sym} 146100 -25530 0 0 {name=p145125 lab=_42672_/A }
C {devices/lab_pin.sym} 146180 -25530 0 1 {name=p145126 lab=_42672_/Y }
C {sky130_stdcells/inv_2.sym} 146140 -25530 0 0 {name=X_42672_ }
C {devices/lab_pin.sym} 146080 -25440 0 0 {name=p145127 lab=_54667_/A }
C {devices/lab_pin.sym} 146080 -25400 0 0 {name=p145128 lab=_54674_/B }
C {devices/lab_pin.sym} 146080 -25360 0 0 {name=p145129 lab=_54644_/X }
C {devices/lab_pin.sym} 146080 -25320 0 0 {name=p145130 lab=_47294_/A }
C {devices/lab_pin.sym} 146200 -25380 0 1 {name=p145131 lab=_54658_/X }
C {sky130_stdcells/and4_4.sym} 146140 -25380 0 0 {name=X_54658_ }
C {devices/lab_pin.sym} 146060 -25250 0 0 {name=p145132 lab=_88310_/Q }
C {devices/lab_pin.sym} 146060 -25210 0 0 {name=p145133 lab=_73153_/X }
C {devices/lab_pin.sym} 146060 -25170 0 0 {name=p145134 lab=_72901_/X }
C {devices/lab_pin.sym} 146220 -25210 0 1 {name=p145135 lab=_73492_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -25210 0 0 {name=X_73492_ }
C {devices/lab_pin.sym} 146050 -25070 0 0 {name=p145136 lab=_84926_/CLK }
C {devices/lab_pin.sym} 146050 -25050 0 0 {name=p145137 lab=_85478_/D }
C {devices/lab_pin.sym} 146230 -25070 0 1 {name=p145138 lab=_85478_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -25060 0 0 {name=X_85478_ }
C {devices/lab_pin.sym} 146060 -24960 0 0 {name=p145139 lab=_41525_/X }
C {devices/lab_pin.sym} 146060 -24920 0 0 {name=p145140 lab=_44394_/X }
C {devices/lab_pin.sym} 146060 -24880 0 0 {name=p145141 lab=_87122_/Q }
C {devices/lab_pin.sym} 146060 -24840 0 0 {name=p145142 lab=_44395_/X }
C {devices/lab_pin.sym} 146220 -24900 0 1 {name=p145143 lab=_87122_/D }
C {sky130_stdcells/a2bb2o_4.sym} 146140 -24900 0 0 {name=X_44411_ }
C {devices/lab_pin.sym} 146100 -24750 0 0 {name=p145144 lab=_75230_/X }
C {devices/lab_pin.sym} 146180 -24750 0 1 {name=p145145 lab=_75245_/A }
C {sky130_stdcells/buf_2.sym} 146140 -24750 0 0 {name=X_75231_ }
C {devices/lab_pin.sym} 146100 -24630 0 0 {name=p145146 lab=_41623_/A }
C {devices/lab_pin.sym} 146180 -24630 0 1 {name=p145147 lab=_41623_/Y }
C {sky130_stdcells/inv_2.sym} 146140 -24630 0 0 {name=X_41623_ }
C {devices/lab_pin.sym} 146050 -24510 0 0 {name=p145148 lab=_87408_/CLK }
C {devices/lab_pin.sym} 146050 -24490 0 0 {name=p145149 lab=_87217_/D }
C {devices/lab_pin.sym} 146230 -24510 0 1 {name=p145150 lab=_67395_/B }
C {sky130_stdcells/dfxtp_4.sym} 146140 -24500 0 0 {name=X_87217_ }
C {devices/lab_pin.sym} 146060 -24390 0 0 {name=p145151 lab=_53607_/Y }
C {devices/lab_pin.sym} 146060 -24350 0 0 {name=p145152 lab=_53603_/X }
C {devices/lab_pin.sym} 146060 -24310 0 0 {name=p145153 lab=_53608_/Y }
C {devices/lab_pin.sym} 146220 -24350 0 1 {name=p145154 lab=_85603_/D }
C {sky130_stdcells/a21boi_4.sym} 146140 -24350 0 0 {name=X_53609_ }
C {devices/lab_pin.sym} 146060 -24230 0 0 {name=p145155 lab=_72440_/Y }
C {devices/lab_pin.sym} 146060 -24190 0 0 {name=p145156 lab=_72442_/Y }
C {devices/lab_pin.sym} 146060 -24150 0 0 {name=p145157 lab=_57779_/X }
C {devices/lab_pin.sym} 146220 -24190 0 1 {name=p145158 lab=_72443_/X }
C {sky130_stdcells/a21o_4.sym} 146140 -24190 0 0 {name=X_72443_ }
C {devices/lab_pin.sym} 146050 -24050 0 0 {name=p145159 lab=_84430_/CLK }
C {devices/lab_pin.sym} 146050 -24030 0 0 {name=p145160 lab=_62156_/Y }
C {devices/lab_pin.sym} 146230 -24050 0 1 {name=p145161 lab=_78052_/B }
C {sky130_stdcells/dfxtp_4.sym} 146140 -24040 0 0 {name=X_84429_ }
C {devices/lab_pin.sym} 146080 -23920 0 0 {name=p145162 lab=_85121_/Q }
C {devices/lab_pin.sym} 146080 -23880 0 0 {name=p145163 lab=_44892_/X }
C {devices/lab_pin.sym} 146200 -23900 0 1 {name=p145164 lab=_45391_/Y }
C {sky130_stdcells/nor2_4.sym} 146140 -23900 0 0 {name=X_45391_ }
C {devices/lab_pin.sym} 146100 -23770 0 0 {name=p145165 lab=_57376_/X }
C {devices/lab_pin.sym} 146180 -23770 0 1 {name=p145166 lab=_57377_/X }
C {sky130_stdcells/buf_2.sym} 146140 -23770 0 0 {name=X_57377_ }
C {devices/lab_pin.sym} 146050 -23650 0 0 {name=p145167 lab=_87686_/CLK }
C {devices/lab_pin.sym} 146050 -23630 0 0 {name=p145168 lab=_88197_/D }
C {devices/lab_pin.sym} 146230 -23650 0 1 {name=p145169 lab=_88197_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -23640 0 0 {name=X_88197_ }
C {devices/lab_pin.sym} 146100 -23510 0 0 {name=p145170 lab=_54481_/A }
C {devices/lab_pin.sym} 146180 -23510 0 1 {name=p145171 lab=_54589_/X }
C {sky130_stdcells/buf_2.sym} 146140 -23510 0 0 {name=X_54589_ }
C {devices/lab_pin.sym} 146100 -23390 0 0 {name=p145172 lab=_58698_/A }
C {devices/lab_pin.sym} 146180 -23390 0 1 {name=p145173 lab=_59117_/A }
C {sky130_stdcells/buf_2.sym} 146140 -23390 0 0 {name=X_59116_ }
C {devices/lab_pin.sym} 146100 -23270 0 0 {name=p145174 lab=_47130_/A }
C {devices/lab_pin.sym} 146180 -23270 0 1 {name=p145175 lab=_47133_/B }
C {sky130_stdcells/buf_2.sym} 146140 -23270 0 0 {name=X_47130_ }
C {devices/lab_pin.sym} 146100 -23150 0 0 {name=p145176 lab=_44341_/Y }
C {devices/lab_pin.sym} 146180 -23150 0 1 {name=p145177 lab=_44342_/Y }
C {sky130_stdcells/inv_2.sym} 146140 -23150 0 0 {name=X_44342_ }
C {devices/lab_pin.sym} 146080 -23050 0 0 {name=p145178 lab=_56332_/A }
C {devices/lab_pin.sym} 146080 -23010 0 0 {name=p145179 lab=_56335_/B }
C {devices/lab_pin.sym} 146080 -22970 0 0 {name=p145180 lab=_55846_/B }
C {devices/lab_pin.sym} 146200 -23010 0 1 {name=p145181 lab=_56328_/Y }
C {sky130_stdcells/nand3_4.sym} 146140 -23010 0 0 {name=X_56328_ }
C {devices/lab_pin.sym} 146050 -22870 0 0 {name=p145182 lab=_88158_/CLK }
C {devices/lab_pin.sym} 146050 -22850 0 0 {name=p145183 lab=_87148_/D }
C {devices/lab_pin.sym} 146230 -22870 0 1 {name=p145184 lab=_87148_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -22860 0 0 {name=X_87148_ }
C {devices/lab_pin.sym} 146080 -22740 0 0 {name=p145185 lab=_75162_/A }
C {devices/lab_pin.sym} 146080 -22700 0 0 {name=p145186 lab=_75162_/B }
C {devices/lab_pin.sym} 146200 -22720 0 1 {name=p145187 lab=_75162_/X }
C {sky130_stdcells/and2_4.sym} 146140 -22720 0 0 {name=X_75162_ }
C {devices/lab_pin.sym} 146080 -22600 0 0 {name=p145188 lab=_81167_/Q }
C {devices/lab_pin.sym} 146080 -22560 0 0 {name=p145189 lab=_41584_/B }
C {devices/lab_pin.sym} 146200 -22580 0 1 {name=p145190 lab=_41554_/X }
C {sky130_stdcells/or2_4.sym} 146140 -22580 0 0 {name=X_41554_ }
C {devices/lab_pin.sym} 146060 -22470 0 0 {name=p145191 lab=_72361_/X }
C {devices/lab_pin.sym} 146060 -22430 0 0 {name=p145192 lab=_85676_/Q }
C {devices/lab_pin.sym} 146060 -22390 0 0 {name=p145193 lab=_72362_/X }
C {devices/lab_pin.sym} 146220 -22430 0 1 {name=p145194 lab=_72374_/X }
C {sky130_stdcells/o21a_4.sym} 146140 -22430 0 0 {name=X_72374_ }
C {devices/lab_pin.sym} 146060 -22320 0 0 {name=p145195 lab=_73566_/X }
C {devices/lab_pin.sym} 146060 -22280 0 0 {name=p145196 lab=_84970_/Q }
C {devices/lab_pin.sym} 146060 -22240 0 0 {name=p145197 lab=_74087_/X }
C {devices/lab_pin.sym} 146060 -22200 0 0 {name=p145198 lab=_74112_/X }
C {devices/lab_pin.sym} 146220 -22260 0 1 {name=p145199 lab=_74114_/B }
C {sky130_stdcells/a211o_4.sym} 146140 -22260 0 0 {name=X_74113_ }
C {devices/lab_pin.sym} 146080 -22120 0 0 {name=p145200 lab=_40416_/A }
C {devices/lab_pin.sym} 146080 -22080 0 0 {name=p145201 lab=_81162_/Q }
C {devices/lab_pin.sym} 146200 -22100 0 1 {name=p145202 lab=_40505_/X }
C {sky130_stdcells/or2_4.sym} 146140 -22100 0 0 {name=X_40505_ }
C {devices/lab_pin.sym} 146100 -21970 0 0 {name=p145203 lab=_83042_/Q }
C {devices/lab_pin.sym} 146180 -21970 0 1 {name=p145204 lab=_53345_/B }
C {sky130_stdcells/inv_2.sym} 146140 -21970 0 0 {name=X_47061_ }
C {devices/lab_pin.sym} 146060 -21890 0 0 {name=p145205 lab=_59027_/X }
C {devices/lab_pin.sym} 146060 -21850 0 0 {name=p145206 lab=_59044_/Y }
C {devices/lab_pin.sym} 146060 -21810 0 0 {name=p145207 lab=_59045_/Y }
C {devices/lab_pin.sym} 146060 -21770 0 0 {name=p145208 lab=_59046_/X }
C {devices/lab_pin.sym} 146060 -21730 0 0 {name=p145209 lab=_59031_/X }
C {devices/lab_pin.sym} 146220 -21810 0 1 {name=p145210 lab=_59047_/X }
C {sky130_stdcells/o32a_4.sym} 146140 -21810 0 0 {name=X_59047_ }
C {devices/lab_pin.sym} 146100 -21650 0 0 {name=p145211 lab=_71337_/A }
C {devices/lab_pin.sym} 146180 -21650 0 1 {name=p145212 lab=_71335_/A }
C {sky130_stdcells/buf_2.sym} 146140 -21650 0 0 {name=X_71325_ }
C {devices/lab_pin.sym} 146080 -21540 0 0 {name=p145213 lab=_72739_/A }
C {devices/lab_pin.sym} 146080 -21500 0 0 {name=p145214 lab=_44272_/X }
C {devices/lab_pin.sym} 146200 -21520 0 1 {name=p145215 lab=_44273_/Y }
C {sky130_stdcells/nor2_4.sym} 146140 -21520 0 0 {name=X_44273_ }
C {devices/lab_pin.sym} 146080 -21410 0 0 {name=p145216 lab=_56263_/A }
C {devices/lab_pin.sym} 146080 -21370 0 0 {name=p145217 lab=_56263_/B }
C {devices/lab_pin.sym} 146080 -21330 0 0 {name=p145218 lab=_85256_/Q }
C {devices/lab_pin.sym} 146200 -21370 0 1 {name=p145219 lab=_56259_/Y }
C {sky130_stdcells/nand3_4.sym} 146140 -21370 0 0 {name=X_56259_ }
C {devices/lab_pin.sym} 146080 -21240 0 0 {name=p145220 lab=_60136_/C }
C {devices/lab_pin.sym} 146080 -21200 0 0 {name=p145221 lab=_84271_/Q }
C {devices/lab_pin.sym} 146200 -21220 0 1 {name=p145222 lab=_79973_/A }
C {sky130_stdcells/xor2_4.sym} 146140 -21220 0 0 {name=X_79970_ }
C {devices/lab_pin.sym} 146100 -21090 0 0 {name=p145223 lab=_75092_/X }
C {devices/lab_pin.sym} 146180 -21090 0 1 {name=p145224 lab=_81027_/D }
C {sky130_stdcells/buf_2.sym} 146140 -21090 0 0 {name=X_75093_ }
C {devices/lab_pin.sym} 146100 -20970 0 0 {name=p145225 lab=_41484_/Y }
C {devices/lab_pin.sym} 146180 -20970 0 1 {name=p145226 lab=_41485_/X }
C {sky130_stdcells/buf_2.sym} 146140 -20970 0 0 {name=X_41485_ }
C {devices/lab_pin.sym} 146050 -20850 0 0 {name=p145227 lab=_88006_/CLK }
C {devices/lab_pin.sym} 146050 -20830 0 0 {name=p145228 lab=_44500_/Y }
C {devices/lab_pin.sym} 146230 -20850 0 1 {name=p145229 lab=_87079_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -20840 0 0 {name=X_87079_ }
C {devices/lab_pin.sym} 146060 -20740 0 0 {name=p145230 lab=_40506_/Y }
C {devices/lab_pin.sym} 146060 -20700 0 0 {name=p145231 lab=_46007_/X }
C {devices/lab_pin.sym} 146060 -20660 0 0 {name=p145232 lab=_67133_/B }
C {devices/lab_pin.sym} 146060 -20620 0 0 {name=p145233 lab=_46008_/X }
C {devices/lab_pin.sym} 146220 -20680 0 1 {name=p145234 lab=_86815_/D }
C {sky130_stdcells/a2bb2o_4.sym} 146140 -20680 0 0 {name=X_46012_ }
C {devices/lab_pin.sym} 146060 -20560 0 0 {name=p145235 lab=_40982_/X }
C {devices/lab_pin.sym} 146060 -20520 0 0 {name=p145236 lab=_43216_/X }
C {devices/lab_pin.sym} 146060 -20480 0 0 {name=p145237 lab=_87530_/Q }
C {devices/lab_pin.sym} 146060 -20440 0 0 {name=p145238 lab=_43218_/X }
C {devices/lab_pin.sym} 146220 -20500 0 1 {name=p145239 lab=_43224_/X }
C {sky130_stdcells/a2bb2o_4.sym} 146140 -20500 0 0 {name=X_43224_ }
C {devices/lab_pin.sym} 146060 -20380 0 0 {name=p145240 lab=_73907_/X }
C {devices/lab_pin.sym} 146060 -20340 0 0 {name=p145241 lab=_84973_/Q }
C {devices/lab_pin.sym} 146060 -20300 0 0 {name=p145242 lab=_74021_/X }
C {devices/lab_pin.sym} 146060 -20260 0 0 {name=p145243 lab=_74043_/X }
C {devices/lab_pin.sym} 146220 -20320 0 1 {name=p145244 lab=_74045_/B }
C {sky130_stdcells/a211o_4.sym} 146140 -20320 0 0 {name=X_74044_ }
C {devices/lab_pin.sym} 146100 -20170 0 0 {name=p145245 lab=_78921_/A }
C {devices/lab_pin.sym} 146180 -20170 0 1 {name=p145246 lab=_78921_/Y }
C {sky130_stdcells/inv_2.sym} 146140 -20170 0 0 {name=X_78921_ }
C {devices/lab_pin.sym} 146100 -20050 0 0 {name=p145247 lab=_40686_/A }
C {devices/lab_pin.sym} 146180 -20050 0 1 {name=p145248 lab=_44733_/A }
C {sky130_stdcells/buf_2.sym} 146140 -20050 0 0 {name=X_40436_ }
C {devices/lab_pin.sym} 146080 -19950 0 0 {name=p145249 lab=_71258_/A }
C {devices/lab_pin.sym} 146080 -19910 0 0 {name=p145250 lab=_71256_/B }
C {devices/lab_pin.sym} 146080 -19870 0 0 {name=p145251 lab=_71141_/B }
C {devices/lab_pin.sym} 146200 -19910 0 1 {name=p145252 lab=_71256_/Y }
C {sky130_stdcells/nand3_4.sym} 146140 -19910 0 0 {name=X_71256_ }
C {devices/lab_pin.sym} 146080 -19800 0 0 {name=p145253 lab=_70214_/A }
C {devices/lab_pin.sym} 146080 -19760 0 0 {name=p145254 lab=_70214_/B }
C {devices/lab_pin.sym} 146080 -19720 0 0 {name=p145255 lab=_83197_/Q }
C {devices/lab_pin.sym} 146080 -19680 0 0 {name=p145256 lab=_70204_/X }
C {devices/lab_pin.sym} 146200 -19740 0 1 {name=p145257 lab=_70207_/X }
C {sky130_stdcells/and4_4.sym} 146140 -19740 0 0 {name=X_70207_ }
C {devices/lab_pin.sym} 146060 -19630 0 0 {name=p145258 lab=_43146_/X }
C {devices/lab_pin.sym} 146060 -19590 0 0 {name=p145259 lab=_43149_/X }
C {devices/lab_pin.sym} 146060 -19550 0 0 {name=p145260 lab=_40849_/X }
C {devices/lab_pin.sym} 146060 -19510 0 0 {name=p145261 lab=_87555_/Q }
C {devices/lab_pin.sym} 146060 -19470 0 0 {name=p145262 lab=_43154_/X }
C {devices/lab_pin.sym} 146220 -19550 0 1 {name=p145263 lab=_43156_/A }
C {sky130_stdcells/o32ai_4.sym} 146140 -19550 0 0 {name=X_43155_ }
C {devices/lab_pin.sym} 146080 -19400 0 0 {name=p145264 lab=_82840_/Q }
C {devices/lab_pin.sym} 146080 -19360 0 0 {name=p145265 lab=_82552_/Q }
C {devices/lab_pin.sym} 146200 -19380 0 1 {name=p145266 lab=_78852_/X }
C {sky130_stdcells/xor2_4.sym} 146140 -19380 0 0 {name=X_78852_ }
C {devices/lab_pin.sym} 146100 -19250 0 0 {name=p145267 lab=_40629_/A }
C {devices/lab_pin.sym} 146180 -19250 0 1 {name=p145268 lab=_40420_/A }
C {sky130_stdcells/buf_2.sym} 146140 -19250 0 0 {name=X_40367_ }
C {devices/lab_pin.sym} 146080 -19160 0 0 {name=p145269 lab=_70491_/Y }
C {devices/lab_pin.sym} 146080 -19120 0 0 {name=p145270 lab=_70827_/C }
C {devices/lab_pin.sym} 146080 -19080 0 0 {name=p145271 lab=_70696_/B }
C {devices/lab_pin.sym} 146080 -19040 0 0 {name=p145272 lab=_70578_/A }
C {devices/lab_pin.sym} 146200 -19100 0 1 {name=p145273 lab=_71191_/A }
C {sky130_stdcells/nand4_4.sym} 146140 -19100 0 0 {name=X_71187_ }
C {devices/lab_pin.sym} 146060 -18990 0 0 {name=p145274 lab=_42099_/X }
C {devices/lab_pin.sym} 146060 -18950 0 0 {name=p145275 lab=_42094_/X }
C {devices/lab_pin.sym} 146060 -18910 0 0 {name=p145276 lab=_41036_/X }
C {devices/lab_pin.sym} 146060 -18870 0 0 {name=p145277 lab=_88033_/Q }
C {devices/lab_pin.sym} 146060 -18830 0 0 {name=p145278 lab=_42096_/X }
C {devices/lab_pin.sym} 146220 -18910 0 1 {name=p145279 lab=_42106_/Y }
C {sky130_stdcells/o32ai_4.sym} 146140 -18910 0 0 {name=X_42106_ }
C {devices/lab_pin.sym} 146060 -18770 0 0 {name=p145280 lab=_77798_/Y }
C {devices/lab_pin.sym} 146060 -18730 0 0 {name=p145281 lab=_77766_/Y }
C {devices/lab_pin.sym} 146060 -18690 0 0 {name=p145282 lab=_77802_/Y }
C {devices/lab_pin.sym} 146220 -18730 0 1 {name=p145283 lab=_77817_/A }
C {sky130_stdcells/o21ai_4.sym} 146140 -18730 0 0 {name=X_77803_ }
C {devices/lab_pin.sym} 146060 -18620 0 0 {name=p145284 lab=_83529_/Q }
C {devices/lab_pin.sym} 146060 -18580 0 0 {name=p145285 lab=_83177_/Q }
C {devices/lab_pin.sym} 146060 -18540 0 0 {name=p145286 lab=_83520_/Q }
C {devices/lab_pin.sym} 146060 -18500 0 0 {name=p145287 lab=_83168_/Q }
C {devices/lab_pin.sym} 146220 -18560 0 1 {name=p145288 lab=_70139_/D }
C {sky130_stdcells/a22oi_4.sym} 146140 -18560 0 0 {name=X_70138_ }
C {devices/lab_pin.sym} 146080 -18420 0 0 {name=p145289 lab=_47963_/A }
C {devices/lab_pin.sym} 146080 -18380 0 0 {name=p145290 lab=_47963_/B }
C {devices/lab_pin.sym} 146200 -18400 0 1 {name=p145291 lab=_47963_/X }
C {sky130_stdcells/or2_4.sym} 146140 -18400 0 0 {name=X_47963_ }
C {devices/lab_pin.sym} 146100 -18270 0 0 {name=p145292 lab=_59943_/X }
C {devices/lab_pin.sym} 146180 -18270 0 1 {name=p145293 lab=_59950_/C }
C {sky130_stdcells/buf_2.sym} 146140 -18270 0 0 {name=X_59949_ }
C {devices/lab_pin.sym} 146100 -18150 0 0 {name=p145294 lab=_43189_/A }
C {devices/lab_pin.sym} 146180 -18150 0 1 {name=p145295 lab=_43086_/X }
C {sky130_stdcells/buf_2.sym} 146140 -18150 0 0 {name=X_43086_ }
C {devices/lab_pin.sym} 146080 -18040 0 0 {name=p145296 lab=_78783_/A }
C {devices/lab_pin.sym} 146080 -18000 0 0 {name=p145297 lab=_78782_/Y }
C {devices/lab_pin.sym} 146200 -18020 0 1 {name=p145298 lab=_78784_/A }
C {sky130_stdcells/nand2_4.sym} 146140 -18020 0 0 {name=X_78783_ }
C {devices/lab_pin.sym} 146100 -17890 0 0 {name=p145299 lab=clkbuf_9_511_0_CLK/X }
C {devices/lab_pin.sym} 146180 -17890 0 1 {name=p145300 lab=_86505_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 146140 -17890 0 0 {name=Xclkbuf_10_1022_0_CLK }
C {devices/lab_pin.sym} 146080 -17780 0 0 {name=p145301 lab=_76005_/A }
C {devices/lab_pin.sym} 146080 -17740 0 0 {name=p145302 lab=_75994_/Y }
C {devices/lab_pin.sym} 146200 -17760 0 1 {name=p145303 lab=_81740_/D }
C {sky130_stdcells/xor2_4.sym} 146140 -17760 0 0 {name=X_75995_ }
C {devices/lab_pin.sym} 146060 -17650 0 0 {name=p145304 lab=_49700_/Y }
C {devices/lab_pin.sym} 146060 -17610 0 0 {name=p145305 lab=_49677_/X }
C {devices/lab_pin.sym} 146060 -17570 0 0 {name=p145306 lab=_49701_/X }
C {devices/lab_pin.sym} 146220 -17610 0 1 {name=p145307 lab=_49702_/Y }
C {sky130_stdcells/a21oi_4.sym} 146140 -17610 0 0 {name=X_49702_ }
C {devices/lab_pin.sym} 146060 -17490 0 0 {name=p145308 lab=_86690_/Q }
C {devices/lab_pin.sym} 146060 -17450 0 0 {name=p145309 lab=_46908_/X }
C {devices/lab_pin.sym} 146060 -17410 0 0 {name=p145310 lab=_46913_/Y }
C {devices/lab_pin.sym} 146220 -17450 0 1 {name=p145311 lab=_46914_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -17450 0 0 {name=X_46914_ }
C {devices/lab_pin.sym} 146100 -17310 0 0 {name=p145312 lab=_42000_/A }
C {devices/lab_pin.sym} 146180 -17310 0 1 {name=p145313 lab=_42037_/X }
C {sky130_stdcells/buf_2.sym} 146140 -17310 0 0 {name=X_42037_ }
C {devices/lab_pin.sym} 146100 -17190 0 0 {name=p145314 lab=_77737_/B }
C {devices/lab_pin.sym} 146180 -17190 0 1 {name=p145315 lab=_77734_/Y }
C {sky130_stdcells/inv_2.sym} 146140 -17190 0 0 {name=X_77734_ }
C {devices/lab_pin.sym} 146060 -17090 0 0 {name=p145316 lab=_74937_/Y }
C {devices/lab_pin.sym} 146060 -17050 0 0 {name=p145317 lab=_74944_/Y }
C {devices/lab_pin.sym} 146060 -17010 0 0 {name=p145318 lab=_74945_/Y }
C {devices/lab_pin.sym} 146220 -17050 0 1 {name=p145319 lab=_74946_/X }
C {sky130_stdcells/o21a_4.sym} 146140 -17050 0 0 {name=X_74946_ }
C {devices/lab_pin.sym} 146060 -16950 0 0 {name=p145320 lab=_62956_/Y }
C {devices/lab_pin.sym} 146060 -16910 0 0 {name=p145321 lab=_62886_/X }
C {devices/lab_pin.sym} 146060 -16870 0 0 {name=p145322 lab=_62957_/Y }
C {devices/lab_pin.sym} 146060 -16830 0 0 {name=p145323 lab=_62958_/Y }
C {devices/lab_pin.sym} 146060 -16800 0 0 {name=p145324 lab=_62959_/X }
C {devices/lab_pin.sym} 146220 -16870 0 1 {name=p145325 lab=_62960_/X }
C {sky130_stdcells/a41o_4.sym} 146140 -16870 0 0 {name=X_62960_ }
C {devices/lab_pin.sym} 146060 -16740 0 0 {name=p145326 lab=_68940_/Y }
C {devices/lab_pin.sym} 146060 -16700 0 0 {name=p145327 lab=_68823_/X }
C {devices/lab_pin.sym} 146060 -16660 0 0 {name=p145328 lab=_70056_/X }
C {devices/lab_pin.sym} 146060 -16620 0 0 {name=p145329 lab=_70068_/Y }
C {devices/lab_pin.sym} 146220 -16680 0 1 {name=p145330 lab=_70069_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -16680 0 0 {name=X_70069_ }
C {devices/lab_pin.sym} 146060 -16550 0 0 {name=p145331 lab=_46578_/X }
C {devices/lab_pin.sym} 146060 -16510 0 0 {name=p145332 lab=_82940_/Q }
C {devices/lab_pin.sym} 146060 -16470 0 0 {name=p145333 lab=_47893_/X }
C {devices/lab_pin.sym} 146220 -16510 0 1 {name=p145334 lab=_47895_/B }
C {sky130_stdcells/o21ai_4.sym} 146140 -16510 0 0 {name=X_47894_ }
C {devices/lab_pin.sym} 146100 -16370 0 0 {name=p145335 lab=_49580_/A }
C {devices/lab_pin.sym} 146180 -16370 0 1 {name=p145336 lab=_49638_/A }
C {sky130_stdcells/buf_2.sym} 146140 -16370 0 0 {name=X_49633_ }
C {devices/lab_pin.sym} 146080 -16280 0 0 {name=p145337 lab=_61879_/A }
C {devices/lab_pin.sym} 146080 -16240 0 0 {name=p145338 lab=_61907_/Y }
C {devices/lab_pin.sym} 146080 -16200 0 0 {name=p145339 lab=_61908_/Y }
C {devices/lab_pin.sym} 146080 -16160 0 0 {name=p145340 lab=_61910_/Y }
C {devices/lab_pin.sym} 146200 -16220 0 1 {name=p145341 lab=_61911_/Y }
C {sky130_stdcells/nand4_4.sym} 146140 -16220 0 0 {name=X_61911_ }
C {devices/lab_pin.sym} 146100 -16070 0 0 {name=p145342 lab=_46845_/A }
C {devices/lab_pin.sym} 146180 -16070 0 1 {name=p145343 lab=_46845_/X }
C {sky130_stdcells/buf_2.sym} 146140 -16070 0 0 {name=X_46845_ }
C {devices/lab_pin.sym} 146080 -15960 0 0 {name=p145344 lab=_77665_/A }
C {devices/lab_pin.sym} 146080 -15920 0 0 {name=p145345 lab=_77625_/X }
C {devices/lab_pin.sym} 146200 -15940 0 1 {name=p145346 lab=_77665_/X }
C {sky130_stdcells/or2_4.sym} 146140 -15940 0 0 {name=X_77665_ }
C {devices/lab_pin.sym} 146080 -15840 0 0 {name=p145347 lab=_62847_/X }
C {devices/lab_pin.sym} 146080 -15800 0 0 {name=p145348 lab=_63244_/A }
C {devices/lab_pin.sym} 146080 -15760 0 0 {name=p145349 lab=_62911_/C }
C {devices/lab_pin.sym} 146080 -15720 0 0 {name=p145350 lab=_62967_/D }
C {devices/lab_pin.sym} 146200 -15780 0 1 {name=p145351 lab=_62891_/X }
C {sky130_stdcells/and4_4.sym} 146140 -15780 0 0 {name=X_62891_ }
C {devices/lab_pin.sym} 146060 -15650 0 0 {name=p145352 lab=_74872_/Y }
C {devices/lab_pin.sym} 146060 -15610 0 0 {name=p145353 lab=_74897_/A }
C {devices/lab_pin.sym} 146060 -15570 0 0 {name=p145354 lab=_74876_/Y }
C {devices/lab_pin.sym} 146220 -15610 0 1 {name=p145355 lab=_74878_/B }
C {sky130_stdcells/a21boi_4.sym} 146140 -15610 0 0 {name=X_74877_ }
C {devices/lab_pin.sym} 146080 -15480 0 0 {name=p145356 lab=_84807_/Q }
C {devices/lab_pin.sym} 146080 -15440 0 0 {name=p145357 lab=_66420_/C }
C {devices/lab_pin.sym} 146200 -15460 0 1 {name=p145358 lab=_79404_/X }
C {sky130_stdcells/xor2_4.sym} 146140 -15460 0 0 {name=X_79404_ }
C {devices/lab_pin.sym} 146060 -15350 0 0 {name=p145359 lab=_64625_/X }
C {devices/lab_pin.sym} 146060 -15310 0 0 {name=p145360 lab=_64628_/X }
C {devices/lab_pin.sym} 146060 -15270 0 0 {name=p145361 lab=_64629_/X }
C {devices/lab_pin.sym} 146220 -15310 0 1 {name=p145362 lab=_64630_/X }
C {sky130_stdcells/a21o_4.sym} 146140 -15310 0 0 {name=X_64630_ }
C {devices/lab_pin.sym} 146080 -15180 0 0 {name=p145363 lab=_76615_/Y }
C {devices/lab_pin.sym} 146080 -15140 0 0 {name=p145364 lab=_76616_/B }
C {devices/lab_pin.sym} 146200 -15160 0 1 {name=p145365 lab=_76616_/X }
C {sky130_stdcells/or2_4.sym} 146140 -15160 0 0 {name=X_76616_ }
C {devices/lab_pin.sym} 146060 -15050 0 0 {name=p145366 lab=_86364_/Q }
C {devices/lab_pin.sym} 146060 -15010 0 0 {name=p145367 lab=_49551_/X }
C {devices/lab_pin.sym} 146060 -14970 0 0 {name=p145368 lab=_49563_/Y }
C {devices/lab_pin.sym} 146220 -15010 0 1 {name=p145369 lab=_49564_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -15010 0 0 {name=X_49564_ }
C {devices/lab_pin.sym} 146100 -14870 0 0 {name=p145370 lab=_61842_/A }
C {devices/lab_pin.sym} 146180 -14870 0 1 {name=p145371 lab=_61843_/B }
C {sky130_stdcells/buf_2.sym} 146140 -14870 0 0 {name=X_61842_ }
C {devices/lab_pin.sym} 146060 -14780 0 0 {name=p145372 lab=_73731_/X }
C {devices/lab_pin.sym} 146060 -14740 0 0 {name=p145373 lab=_86230_/Q }
C {devices/lab_pin.sym} 146060 -14700 0 0 {name=p145374 lab=_73804_/X }
C {devices/lab_pin.sym} 146060 -14660 0 0 {name=p145375 lab=_73827_/X }
C {devices/lab_pin.sym} 146220 -14720 0 1 {name=p145376 lab=_73828_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -14720 0 0 {name=X_73828_ }
C {devices/lab_pin.sym} 146080 -14600 0 0 {name=p145377 lab=_46784_/A }
C {devices/lab_pin.sym} 146080 -14560 0 0 {name=p145378 lab=_46784_/B }
C {devices/lab_pin.sym} 146080 -14520 0 0 {name=p145379 lab=_46784_/C }
C {devices/lab_pin.sym} 146080 -14480 0 0 {name=p145380 lab=_46775_/X }
C {devices/lab_pin.sym} 146200 -14540 0 1 {name=p145381 lab=_46776_/X }
C {sky130_stdcells/and4_4.sym} 146140 -14540 0 0 {name=X_46776_ }
C {devices/lab_pin.sym} 146080 -14400 0 0 {name=p145382 lab=_77596_/A }
C {devices/lab_pin.sym} 146080 -14360 0 0 {name=p145383 lab=_77596_/B }
C {devices/lab_pin.sym} 146200 -14380 0 1 {name=p145384 lab=_82202_/D }
C {sky130_stdcells/xor2_4.sym} 146140 -14380 0 0 {name=X_77596_ }
C {devices/lab_pin.sym} 146060 -14280 0 0 {name=p145385 lab=_43986_/Y }
C {devices/lab_pin.sym} 146060 -14240 0 0 {name=p145386 lab=_43954_/X }
C {devices/lab_pin.sym} 146060 -14200 0 0 {name=p145387 lab=_43945_/A }
C {devices/lab_pin.sym} 146060 -14160 0 0 {name=p145388 lab=_43987_/Y }
C {devices/lab_pin.sym} 146220 -14220 0 1 {name=p145389 lab=_43988_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -14220 0 0 {name=X_43988_ }
C {devices/lab_pin.sym} 146080 -14080 0 0 {name=p145390 lab=_48515_/A }
C {devices/lab_pin.sym} 146080 -14040 0 0 {name=p145391 lab=_50466_/B }
C {devices/lab_pin.sym} 146200 -14060 0 1 {name=p145392 lab=_48515_/Y }
C {sky130_stdcells/nand2_4.sym} 146140 -14060 0 0 {name=X_48515_ }
C {devices/lab_pin.sym} 146080 -13940 0 0 {name=p145393 lab=_79336_/B }
C {devices/lab_pin.sym} 146080 -13900 0 0 {name=p145394 lab=_79322_/Y }
C {devices/lab_pin.sym} 146200 -13920 0 1 {name=p145395 lab=_79335_/X }
C {sky130_stdcells/or2_4.sym} 146140 -13920 0 0 {name=X_79335_ }
C {devices/lab_pin.sym} 146100 -13790 0 0 {name=p145396 lab=_45727_/A }
C {devices/lab_pin.sym} 146180 -13790 0 1 {name=p145397 lab=_45728_/A }
C {sky130_stdcells/inv_2.sym} 146140 -13790 0 0 {name=X_45727_ }
C {devices/lab_pin.sym} 146100 -13670 0 0 {name=p145398 lab=_64561_/A }
C {devices/lab_pin.sym} 146180 -13670 0 1 {name=p145399 lab=_64561_/X }
C {sky130_stdcells/buf_2.sym} 146140 -13670 0 0 {name=X_64561_ }
C {devices/lab_pin.sym} 146060 -13570 0 0 {name=p145400 lab=_76516_/Y }
C {devices/lab_pin.sym} 146060 -13530 0 0 {name=p145401 lab=_76543_/X }
C {devices/lab_pin.sym} 146060 -13490 0 0 {name=p145402 lab=_76546_/X }
C {devices/lab_pin.sym} 146220 -13530 0 1 {name=p145403 lab=_76547_/Y }
C {sky130_stdcells/a21boi_4.sym} 146140 -13530 0 0 {name=X_76547_ }
C {devices/lab_pin.sym} 146060 -13420 0 0 {name=p145404 lab=_41768_/X }
C {devices/lab_pin.sym} 146060 -13380 0 0 {name=p145405 lab=_42930_/X }
C {devices/lab_pin.sym} 146060 -13340 0 0 {name=p145406 lab=_87641_/Q }
C {devices/lab_pin.sym} 146060 -13300 0 0 {name=p145407 lab=_42931_/X }
C {devices/lab_pin.sym} 146220 -13360 0 1 {name=p145408 lab=_87641_/D }
C {sky130_stdcells/a2bb2o_4.sym} 146140 -13360 0 0 {name=X_42939_ }
C {devices/lab_pin.sym} 146060 -13230 0 0 {name=p145409 lab=_49492_/Y }
C {devices/lab_pin.sym} 146060 -13190 0 0 {name=p145410 lab=_49487_/X }
C {devices/lab_pin.sym} 146060 -13150 0 0 {name=p145411 lab=_49494_/X }
C {devices/lab_pin.sym} 146220 -13190 0 1 {name=p145412 lab=_86377_/D }
C {sky130_stdcells/a21oi_4.sym} 146140 -13190 0 0 {name=X_49495_ }
C {devices/lab_pin.sym} 146060 -13090 0 0 {name=p145413 lab=_58228_/X }
C {devices/lab_pin.sym} 146060 -13050 0 0 {name=p145414 lab=_61728_/X }
C {devices/lab_pin.sym} 146060 -13010 0 0 {name=p145415 lab=_61756_/X }
C {devices/lab_pin.sym} 146060 -12970 0 0 {name=p145416 lab=_59591_/A }
C {devices/lab_pin.sym} 146060 -12940 0 0 {name=p145417 lab=_61772_/X }
C {devices/lab_pin.sym} 146220 -13010 0 1 {name=p145418 lab=_61773_/X }
C {sky130_stdcells/a41o_4.sym} 146140 -13010 0 0 {name=X_61773_ }
C {devices/lab_pin.sym} 146080 -12860 0 0 {name=p145419 lab=_73711_/A }
C {devices/lab_pin.sym} 146080 -12820 0 0 {name=p145420 lab=_66024_/B }
C {devices/lab_pin.sym} 146200 -12840 0 1 {name=p145421 lab=_73759_/X }
C {sky130_stdcells/and2_4.sym} 146140 -12840 0 0 {name=X_73759_ }
C {devices/lab_pin.sym} 146060 -12730 0 0 {name=p145422 lab=_66297_/X }
C {devices/lab_pin.sym} 146060 -12690 0 0 {name=p145423 lab=_66299_/X }
C {devices/lab_pin.sym} 146060 -12650 0 0 {name=p145424 lab=_66240_/X }
C {devices/lab_pin.sym} 146220 -12690 0 1 {name=p145425 lab=_66300_/X }
C {sky130_stdcells/a21o_4.sym} 146140 -12690 0 0 {name=X_66300_ }
C {devices/lab_pin.sym} 146080 -12570 0 0 {name=p145426 lab=_63512_/A }
C {devices/lab_pin.sym} 146080 -12530 0 0 {name=p145427 lab=_84957_/Q }
C {devices/lab_pin.sym} 146080 -12490 0 0 {name=p145428 lab=_63476_/C }
C {devices/lab_pin.sym} 146200 -12530 0 1 {name=p145429 lab=_63512_/X }
C {sky130_stdcells/and3_4.sym} 146140 -12530 0 0 {name=X_63512_ }
C {devices/lab_pin.sym} 146080 -12400 0 0 {name=p145430 lab=_48469_/A }
C {devices/lab_pin.sym} 146080 -12360 0 0 {name=p145431 lab=_52137_/B }
C {devices/lab_pin.sym} 146200 -12380 0 1 {name=p145432 lab=_48446_/Y }
C {sky130_stdcells/nand2_4.sym} 146140 -12380 0 0 {name=X_48446_ }
C {devices/lab_pin.sym} 146080 -12270 0 0 {name=p145433 lab=_60724_/A }
C {devices/lab_pin.sym} 146080 -12230 0 0 {name=p145434 lab=_60724_/B }
C {devices/lab_pin.sym} 146080 -12190 0 0 {name=p145435 lab=_60624_/X }
C {devices/lab_pin.sym} 146200 -12230 0 1 {name=p145436 lab=_60725_/B }
C {sky130_stdcells/nand3_4.sym} 146140 -12230 0 0 {name=X_60724_ }
C {devices/lab_pin.sym} 146060 -12120 0 0 {name=p145437 lab=_87106_/Q }
C {devices/lab_pin.sym} 146060 -12080 0 0 {name=p145438 lab=_67230_/X }
C {devices/lab_pin.sym} 146060 -12040 0 0 {name=p145439 lab=_67278_/X }
C {devices/lab_pin.sym} 146060 -12000 0 0 {name=p145440 lab=_67279_/X }
C {devices/lab_pin.sym} 146220 -12060 0 1 {name=p145441 lab=_67280_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -12060 0 0 {name=X_67280_ }
C {devices/lab_pin.sym} 146080 -11920 0 0 {name=p145442 lab=_84794_/Q }
C {devices/lab_pin.sym} 146080 -11880 0 0 {name=p145443 lab=_84114_/Q }
C {devices/lab_pin.sym} 146200 -11900 0 1 {name=p145444 lab=_79266_/X }
C {sky130_stdcells/xor2_4.sym} 146140 -11900 0 0 {name=X_79266_ }
C {devices/lab_pin.sym} 146060 -11790 0 0 {name=p145445 lab=_45650_/X }
C {devices/lab_pin.sym} 146060 -11750 0 0 {name=p145446 lab=_45655_/Y }
C {devices/lab_pin.sym} 146060 -11710 0 0 {name=p145447 lab=_45657_/Y }
C {devices/lab_pin.sym} 146220 -11750 0 1 {name=p145448 lab=_45658_/Y }
C {sky130_stdcells/a21oi_4.sym} 146140 -11750 0 0 {name=X_45658_ }
C {devices/lab_pin.sym} 146080 -11620 0 0 {name=p145449 lab=_58348_/A }
C {devices/lab_pin.sym} 146080 -11580 0 0 {name=p145450 lab=_64511_/B }
C {devices/lab_pin.sym} 146200 -11600 0 1 {name=p145451 lab=_64492_/Y }
C {sky130_stdcells/nor2_4.sym} 146140 -11600 0 0 {name=X_64492_ }
C {devices/lab_pin.sym} 146060 -11490 0 0 {name=p145452 lab=_76474_/X }
C {devices/lab_pin.sym} 146060 -11450 0 0 {name=p145453 lab=_76479_/C }
C {devices/lab_pin.sym} 146060 -11410 0 0 {name=p145454 lab=_76479_/B }
C {devices/lab_pin.sym} 146220 -11450 0 1 {name=p145455 lab=_76478_/X }
C {sky130_stdcells/a21o_4.sym} 146140 -11450 0 0 {name=X_76478_ }
C {devices/lab_pin.sym} 146100 -11310 0 0 {name=p145456 lab=_65969_/A }
C {devices/lab_pin.sym} 146180 -11310 0 1 {name=p145457 lab=_66231_/X }
C {sky130_stdcells/buf_2.sym} 146140 -11310 0 0 {name=X_66231_ }
C {devices/lab_pin.sym} 146080 -11200 0 0 {name=p145458 lab=_78214_/Y }
C {devices/lab_pin.sym} 146080 -11160 0 0 {name=p145459 lab=_78217_/B }
C {devices/lab_pin.sym} 146200 -11180 0 1 {name=p145460 lab=_78218_/B }
C {sky130_stdcells/xor2_4.sym} 146140 -11180 0 0 {name=X_78217_ }
C {devices/lab_pin.sym} 146060 -11090 0 0 {name=p145461 lab=_44588_/X }
C {devices/lab_pin.sym} 146060 -11050 0 0 {name=p145462 lab=_44589_/X }
C {devices/lab_pin.sym} 146060 -11010 0 0 {name=p145463 lab=_40959_/A }
C {devices/lab_pin.sym} 146060 -10970 0 0 {name=p145464 lab=_87035_/Q }
C {devices/lab_pin.sym} 146060 -10930 0 0 {name=p145465 lab=_44590_/X }
C {devices/lab_pin.sym} 146220 -11010 0 1 {name=p145466 lab=_44609_/Y }
C {sky130_stdcells/o32ai_4.sym} 146140 -11010 0 0 {name=X_44609_ }
C {devices/lab_pin.sym} 146100 -10850 0 0 {name=p145467 lab=_63443_/A }
C {devices/lab_pin.sym} 146180 -10850 0 1 {name=p145468 lab=_63465_/C }
C {sky130_stdcells/buf_2.sym} 146140 -10850 0 0 {name=X_63443_ }
C {devices/lab_pin.sym} 146060 -10750 0 0 {name=p145469 lab=_75413_/A }
C {devices/lab_pin.sym} 146060 -10710 0 0 {name=p145470 lab=_75413_/B }
C {devices/lab_pin.sym} 146060 -10670 0 0 {name=p145471 lab=_75411_/Y }
C {devices/lab_pin.sym} 146220 -10710 0 1 {name=p145472 lab=_75430_/A }
C {sky130_stdcells/o21a_4.sym} 146140 -10710 0 0 {name=X_75429_ }
C {devices/lab_pin.sym} 146100 -10570 0 0 {name=p145473 lab=_60655_/A }
C {devices/lab_pin.sym} 146180 -10570 0 1 {name=p145474 lab=_60702_/C }
C {sky130_stdcells/buf_2.sym} 146140 -10570 0 0 {name=X_60655_ }
C {devices/lab_pin.sym} 146080 -10470 0 0 {name=p145475 lab=_52103_/A }
C {devices/lab_pin.sym} 146080 -10430 0 0 {name=p145476 lab=_48364_/X }
C {devices/lab_pin.sym} 146080 -10390 0 0 {name=p145477 lab=_48354_/X }
C {devices/lab_pin.sym} 146200 -10430 0 1 {name=p145478 lab=_48377_/X }
C {sky130_stdcells/and3_4.sym} 146140 -10430 0 0 {name=X_48377_ }
C {devices/lab_pin.sym} 146080 -10300 0 0 {name=p145479 lab=_79196_/Y }
C {devices/lab_pin.sym} 146080 -10260 0 0 {name=p145480 lab=_79197_/B }
C {devices/lab_pin.sym} 146200 -10280 0 1 {name=p145481 lab=_79197_/Y }
C {sky130_stdcells/nand2_4.sym} 146140 -10280 0 0 {name=X_79197_ }
C {devices/lab_pin.sym} 146060 -10170 0 0 {name=p145482 lab=_82997_/Q }
C {devices/lab_pin.sym} 146060 -10130 0 0 {name=p145483 lab=_45401_/X }
C {devices/lab_pin.sym} 146060 -10090 0 0 {name=p145484 lab=_45588_/X }
C {devices/lab_pin.sym} 146220 -10130 0 1 {name=p145485 lab=_45589_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -10130 0 0 {name=X_45589_ }
C {devices/lab_pin.sym} 146100 -9990 0 0 {name=p145486 lab=_81814_/Q }
C {devices/lab_pin.sym} 146180 -9990 0 1 {name=p145487 lab=_47329_/A }
C {sky130_stdcells/inv_2.sym} 146140 -9990 0 0 {name=X_47328_ }
C {devices/lab_pin.sym} 146060 -9890 0 0 {name=p145488 lab=_66068_/X }
C {devices/lab_pin.sym} 146060 -9850 0 0 {name=p145489 lab=_65694_/Y }
C {devices/lab_pin.sym} 146060 -9810 0 0 {name=p145490 lab=_66161_/Y }
C {devices/lab_pin.sym} 146220 -9850 0 1 {name=p145491 lab=_66162_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -9850 0 0 {name=X_66162_ }
C {devices/lab_pin.sym} 146080 -9720 0 0 {name=p145492 lab=_82571_/Q }
C {devices/lab_pin.sym} 146080 -9680 0 0 {name=p145493 lab=_82483_/Q }
C {devices/lab_pin.sym} 146200 -9700 0 1 {name=p145494 lab=_78148_/Y }
C {sky130_stdcells/nor2_4.sym} 146140 -9700 0 0 {name=X_78148_ }
C {devices/lab_pin.sym} 146080 -9580 0 0 {name=p145495 lab=_63374_/A }
C {devices/lab_pin.sym} 146080 -9540 0 0 {name=p145496 lab=_61744_/X }
C {devices/lab_pin.sym} 146200 -9560 0 1 {name=p145497 lab=_63374_/X }
C {sky130_stdcells/and2_4.sym} 146140 -9560 0 0 {name=X_63374_ }
C {devices/lab_pin.sym} 146080 -9460 0 0 {name=p145498 lab=_60586_/A }
C {devices/lab_pin.sym} 146080 -9420 0 0 {name=p145499 lab=_60413_/X }
C {devices/lab_pin.sym} 146080 -9380 0 0 {name=p145500 lab=_60435_/C }
C {devices/lab_pin.sym} 146080 -9340 0 0 {name=p145501 lab=_60586_/D }
C {devices/lab_pin.sym} 146200 -9400 0 1 {name=p145502 lab=_60586_/X }
C {sky130_stdcells/and4_4.sym} 146140 -9400 0 0 {name=X_60586_ }
C {devices/lab_pin.sym} 146080 -9270 0 0 {name=p145503 lab=_65196_/A }
C {devices/lab_pin.sym} 146080 -9230 0 0 {name=p145504 lab=_65268_/B }
C {devices/lab_pin.sym} 146080 -9190 0 0 {name=p145505 lab=_84214_/Q }
C {devices/lab_pin.sym} 146200 -9230 0 1 {name=p145506 lab=_65113_/X }
C {sky130_stdcells/and3_4.sym} 146140 -9230 0 0 {name=X_65113_ }
C {devices/lab_pin.sym} 146060 -9130 0 0 {name=p145507 lab=_61417_/B }
C {devices/lab_pin.sym} 146060 -9090 0 0 {name=p145508 lab=_62278_/X }
C {devices/lab_pin.sym} 146060 -9050 0 0 {name=p145509 lab=_60027_/A }
C {devices/lab_pin.sym} 146060 -9010 0 0 {name=p145510 lab=_62323_/X }
C {devices/lab_pin.sym} 146060 -8980 0 0 {name=p145511 lab=_62324_/X }
C {devices/lab_pin.sym} 146220 -9050 0 1 {name=p145512 lab=_62325_/X }
C {sky130_stdcells/a41o_4.sym} 146140 -9050 0 0 {name=X_62325_ }
C {devices/lab_pin.sym} 146100 -8890 0 0 {name=p145513 lab=_47259_/A }
C {devices/lab_pin.sym} 146180 -8890 0 1 {name=p145514 lab=_47260_/A }
C {sky130_stdcells/inv_2.sym} 146140 -8890 0 0 {name=X_47259_ }
C {devices/lab_pin.sym} 146060 -8790 0 0 {name=p145515 lab=_66090_/Y }
C {devices/lab_pin.sym} 146060 -8750 0 0 {name=p145516 lab=_66065_/X }
C {devices/lab_pin.sym} 146060 -8710 0 0 {name=p145517 lab=_66092_/Y }
C {devices/lab_pin.sym} 146220 -8750 0 1 {name=p145518 lab=_66093_/X }
C {sky130_stdcells/a21o_4.sym} 146140 -8750 0 0 {name=X_66093_ }
C {devices/lab_pin.sym} 146080 -8620 0 0 {name=p145519 lab=_84584_/Q }
C {devices/lab_pin.sym} 146080 -8580 0 0 {name=p145520 lab=_78079_/B }
C {devices/lab_pin.sym} 146200 -8600 0 1 {name=p145521 lab=_78079_/X }
C {sky130_stdcells/xor2_4.sym} 146140 -8600 0 0 {name=X_78079_ }
C {devices/lab_pin.sym} 146080 -8480 0 0 {name=p145522 lab=_84940_/Q }
C {devices/lab_pin.sym} 146080 -8440 0 0 {name=p145523 lab=_84188_/Q }
C {devices/lab_pin.sym} 146200 -8460 0 1 {name=p145524 lab=_80121_/A }
C {sky130_stdcells/xor2_4.sym} 146140 -8460 0 0 {name=X_80110_ }
C {devices/lab_pin.sym} 146100 -8330 0 0 {name=p145525 lab=_65044_/A }
C {devices/lab_pin.sym} 146180 -8330 0 1 {name=p145526 lab=_65045_/A }
C {sky130_stdcells/buf_2.sym} 146140 -8330 0 0 {name=X_65044_ }
C {devices/lab_pin.sym} 146060 -8240 0 0 {name=p145527 lab=_73440_/A }
C {devices/lab_pin.sym} 146060 -8200 0 0 {name=p145528 lab=_68467_/X }
C {devices/lab_pin.sym} 146060 -8160 0 0 {name=p145529 lab=_68385_/X }
C {devices/lab_pin.sym} 146060 -8120 0 0 {name=p145530 lab=_69920_/Y }
C {devices/lab_pin.sym} 146220 -8180 0 1 {name=p145531 lab=_69921_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -8180 0 0 {name=X_69921_ }
C {devices/lab_pin.sym} 146080 -8050 0 0 {name=p145532 lab=_50270_/A }
C {devices/lab_pin.sym} 146080 -8010 0 0 {name=p145533 lab=_74509_/C }
C {devices/lab_pin.sym} 146080 -7970 0 0 {name=p145534 lab=_50247_/X }
C {devices/lab_pin.sym} 146200 -8010 0 1 {name=p145535 lab=_50270_/X }
C {sky130_stdcells/and3_4.sym} 146140 -8010 0 0 {name=X_50270_ }
C {devices/lab_pin.sym} 146080 -7900 0 0 {name=p145536 lab=_62194_/A }
C {devices/lab_pin.sym} 146080 -7860 0 0 {name=p145537 lab=_58228_/X }
C {devices/lab_pin.sym} 146080 -7820 0 0 {name=p145538 lab=_62244_/C }
C {devices/lab_pin.sym} 146080 -7780 0 0 {name=p145539 lab=_62244_/D }
C {devices/lab_pin.sym} 146200 -7840 0 1 {name=p145540 lab=_62256_/X }
C {sky130_stdcells/and4_4.sym} 146140 -7840 0 0 {name=X_62256_ }
C {devices/lab_pin.sym} 146050 -7690 0 0 {name=p145541 lab=_83905_/CLK }
C {devices/lab_pin.sym} 146050 -7670 0 0 {name=p145542 lab=_81090_/D }
C {devices/lab_pin.sym} 146230 -7690 0 1 {name=p145543 lab=_81090_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -7680 0 0 {name=X_81090_ }
C {devices/lab_pin.sym} 146100 -7550 0 0 {name=p145544 lab=_64223_/C }
C {devices/lab_pin.sym} 146180 -7550 0 1 {name=p145545 lab=_61207_/X }
C {sky130_stdcells/buf_2.sym} 146140 -7550 0 0 {name=X_61207_ }
C {devices/lab_pin.sym} 146080 -7440 0 0 {name=p145546 lab=_80039_/X }
C {devices/lab_pin.sym} 146080 -7400 0 0 {name=p145547 lab=_80046_/B }
C {devices/lab_pin.sym} 146200 -7420 0 1 {name=p145548 lab=_80041_/Y }
C {sky130_stdcells/xnor2_4.sym} 146140 -7420 0 0 {name=X_80041_ }
C {devices/lab_pin.sym} 146060 -7310 0 0 {name=p145549 lab=_69849_/X }
C {devices/lab_pin.sym} 146060 -7270 0 0 {name=p145550 lab=_69851_/X }
C {devices/lab_pin.sym} 146060 -7230 0 0 {name=p145551 lab=_69570_/X }
C {devices/lab_pin.sym} 146220 -7270 0 1 {name=p145552 lab=_69852_/X }
C {sky130_stdcells/a21o_4.sym} 146140 -7270 0 0 {name=X_69852_ }
C {devices/lab_pin.sym} 146080 -7160 0 0 {name=p145553 lab=_62186_/X }
C {devices/lab_pin.sym} 146080 -7120 0 0 {name=p145554 lab=_59761_/A }
C {devices/lab_pin.sym} 146080 -7080 0 0 {name=p145555 lab=_62187_/C }
C {devices/lab_pin.sym} 146080 -7040 0 0 {name=p145556 lab=_59761_/B }
C {devices/lab_pin.sym} 146200 -7100 0 1 {name=p145557 lab=_62187_/Y }
C {sky130_stdcells/nand4_4.sym} 146140 -7100 0 0 {name=X_62187_ }
C {devices/lab_pin.sym} 146100 -6950 0 0 {name=p145558 lab=clkbuf_8_90_0_CLK/X }
C {devices/lab_pin.sym} 146180 -6950 0 1 {name=p145559 lab=clkbuf_9_180_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 146140 -6950 0 0 {name=Xclkbuf_9_180_0_CLK }
C {devices/lab_pin.sym} 146060 -6860 0 0 {name=p145560 lab=_73963_/A }
C {devices/lab_pin.sym} 146060 -6820 0 0 {name=p145561 lab=_68778_/X }
C {devices/lab_pin.sym} 146060 -6780 0 0 {name=p145562 lab=_68800_/X }
C {devices/lab_pin.sym} 146060 -6740 0 0 {name=p145563 lab=_68802_/Y }
C {devices/lab_pin.sym} 146220 -6800 0 1 {name=p145564 lab=_68803_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -6800 0 0 {name=X_68803_ }
C {devices/lab_pin.sym} 146080 -6670 0 0 {name=p145565 lab=_61165_/A }
C {devices/lab_pin.sym} 146080 -6630 0 0 {name=p145566 lab=_61138_/B }
C {devices/lab_pin.sym} 146080 -6590 0 0 {name=p145567 lab=_84518_/Q }
C {devices/lab_pin.sym} 146200 -6630 0 1 {name=p145568 lab=_61138_/Y }
C {sky130_stdcells/nor3_4.sym} 146140 -6630 0 0 {name=X_61138_ }
C {devices/lab_pin.sym} 146080 -6500 0 0 {name=p145569 lab=_69770_/A }
C {devices/lab_pin.sym} 146080 -6460 0 0 {name=p145570 lab=_88323_/Q }
C {devices/lab_pin.sym} 146200 -6480 0 1 {name=p145571 lab=_69783_/X }
C {sky130_stdcells/and2_4.sym} 146140 -6480 0 0 {name=X_69783_ }
C {devices/lab_pin.sym} 146080 -6360 0 0 {name=p145572 lab=_66972_/X }
C {devices/lab_pin.sym} 146080 -6320 0 0 {name=p145573 lab=_66995_/B }
C {devices/lab_pin.sym} 146200 -6340 0 1 {name=p145574 lab=_66995_/X }
C {sky130_stdcells/and2_4.sym} 146140 -6340 0 0 {name=X_66995_ }
C {devices/lab_pin.sym} 146050 -6210 0 0 {name=p145575 lab=_83819_/CLK }
C {devices/lab_pin.sym} 146050 -6190 0 0 {name=p145576 lab=_70316_/X }
C {devices/lab_pin.sym} 146230 -6210 0 1 {name=p145577 lab=_74794_/B }
C {sky130_stdcells/dfxtp_4.sym} 146140 -6200 0 0 {name=X_83800_ }
C {devices/lab_pin.sym} 146060 -6090 0 0 {name=p145578 lab=_68729_/X }
C {devices/lab_pin.sym} 146060 -6050 0 0 {name=p145579 lab=_68733_/X }
C {devices/lab_pin.sym} 146060 -6010 0 0 {name=p145580 lab=_68684_/X }
C {devices/lab_pin.sym} 146220 -6050 0 1 {name=p145581 lab=_68734_/X }
C {sky130_stdcells/a21o_4.sym} 146140 -6050 0 0 {name=X_68734_ }
C {devices/lab_pin.sym} 146060 -5930 0 0 {name=p145582 lab=_53958_/Y }
C {devices/lab_pin.sym} 146060 -5890 0 0 {name=p145583 lab=_53948_/X }
C {devices/lab_pin.sym} 146060 -5850 0 0 {name=p145584 lab=_53959_/Y }
C {devices/lab_pin.sym} 146220 -5890 0 1 {name=p145585 lab=_85534_/D }
C {sky130_stdcells/a21boi_4.sym} 146140 -5890 0 0 {name=X_53960_ }
C {devices/lab_pin.sym} 146060 -5780 0 0 {name=p145586 lab=_64714_/X }
C {devices/lab_pin.sym} 146060 -5740 0 0 {name=p145587 lab=_86238_/Q }
C {devices/lab_pin.sym} 146060 -5700 0 0 {name=p145588 lab=_65904_/X }
C {devices/lab_pin.sym} 146060 -5660 0 0 {name=p145589 lab=_65945_/X }
C {devices/lab_pin.sym} 146220 -5720 0 1 {name=p145590 lab=_65946_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -5720 0 0 {name=X_65946_ }
C {devices/lab_pin.sym} 146060 -5610 0 0 {name=p145591 lab=_57686_/A }
C {devices/lab_pin.sym} 146060 -5570 0 0 {name=p145592 lab=_59598_/A }
C {devices/lab_pin.sym} 146060 -5530 0 0 {name=p145593 lab=_44003_/A }
C {devices/lab_pin.sym} 146060 -5490 0 0 {name=p145594 lab=_60232_/Y }
C {devices/lab_pin.sym} 146060 -5450 0 0 {name=p145595 lab=_59551_/A }
C {devices/lab_pin.sym} 146220 -5530 0 1 {name=p145596 lab=_61070_/C }
C {sky130_stdcells/o41a_4.sym} 146140 -5530 0 0 {name=X_61069_ }
C {devices/lab_pin.sym} 146050 -5370 0 0 {name=p145597 lab=_83464_/CLK }
C {devices/lab_pin.sym} 146050 -5350 0 0 {name=p145598 lab=_84780_/D }
C {devices/lab_pin.sym} 146230 -5370 0 1 {name=p145599 lab=_58987_/A }
C {sky130_stdcells/dfxtp_4.sym} 146140 -5360 0 0 {name=X_84780_ }
C {devices/lab_pin.sym} 146050 -5230 0 0 {name=p145600 lab=_81989_/CLK }
C {devices/lab_pin.sym} 146050 -5210 0 0 {name=p145601 lab=_81992_/D }
C {devices/lab_pin.sym} 146230 -5230 0 1 {name=p145602 lab=_81992_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -5220 0 0 {name=X_81992_ }
C {devices/lab_pin.sym} 146060 -5110 0 0 {name=p145603 lab=_85732_/Q }
C {devices/lab_pin.sym} 146060 -5070 0 0 {name=p145604 lab=_52902_/X }
C {devices/lab_pin.sym} 146060 -5030 0 0 {name=p145605 lab=_52910_/Y }
C {devices/lab_pin.sym} 146220 -5070 0 1 {name=p145606 lab=_52911_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -5070 0 0 {name=X_52911_ }
C {devices/lab_pin.sym} 146050 -4930 0 0 {name=p145607 lab=_84930_/CLK }
C {devices/lab_pin.sym} 146050 -4910 0 0 {name=p145608 lab=_83731_/D }
C {devices/lab_pin.sym} 146230 -4930 0 1 {name=p145609 lab=_83731_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -4920 0 0 {name=X_83731_ }
C {devices/lab_pin.sym} 146050 -4790 0 0 {name=p145610 lab=_81195_/CLK }
C {devices/lab_pin.sym} 146050 -4770 0 0 {name=p145611 lab=_80943_/D }
C {devices/lab_pin.sym} 146230 -4790 0 1 {name=p145612 lab=_74940_/A }
C {sky130_stdcells/dfxtp_4.sym} 146140 -4780 0 0 {name=X_80943_ }
C {devices/lab_pin.sym} 146100 -4650 0 0 {name=p145613 lab=_64636_/A }
C {devices/lab_pin.sym} 146180 -4650 0 1 {name=p145614 lab=_69146_/A }
C {sky130_stdcells/buf_2.sym} 146140 -4650 0 0 {name=X_68665_ }
C {devices/lab_pin.sym} 146060 -4550 0 0 {name=p145615 lab=_85547_/Q }
C {devices/lab_pin.sym} 146060 -4510 0 0 {name=p145616 lab=_53869_/X }
C {devices/lab_pin.sym} 146060 -4470 0 0 {name=p145617 lab=_53890_/Y }
C {devices/lab_pin.sym} 146220 -4510 0 1 {name=p145618 lab=_53891_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -4510 0 0 {name=X_53891_ }
C {devices/lab_pin.sym} 146100 -4370 0 0 {name=p145619 lab=_65877_/A }
C {devices/lab_pin.sym} 146180 -4370 0 1 {name=p145620 lab=_65878_/A }
C {sky130_stdcells/buf_2.sym} 146140 -4370 0 0 {name=X_65877_ }
C {devices/lab_pin.sym} 146100 -4250 0 0 {name=p145621 lab=clkbuf_8_97_0_CLK/X }
C {devices/lab_pin.sym} 146180 -4250 0 1 {name=p145622 lab=clkbuf_9_195_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 146140 -4250 0 0 {name=Xclkbuf_9_195_0_CLK }
C {devices/lab_pin.sym} 146060 -4150 0 0 {name=p145623 lab=_55626_/X }
C {devices/lab_pin.sym} 146060 -4110 0 0 {name=p145624 lab=_55629_/X }
C {devices/lab_pin.sym} 146060 -4070 0 0 {name=p145625 lab=_44118_/B }
C {devices/lab_pin.sym} 146220 -4110 0 1 {name=p145626 lab=_55630_/X }
C {sky130_stdcells/a21o_4.sym} 146140 -4110 0 0 {name=X_55630_ }
C {devices/lab_pin.sym} 146080 -3980 0 0 {name=p145627 lab=_67615_/X }
C {devices/lab_pin.sym} 146080 -3940 0 0 {name=p145628 lab=_67616_/B }
C {devices/lab_pin.sym} 146200 -3960 0 1 {name=p145629 lab=_67616_/X }
C {sky130_stdcells/and2_4.sym} 146140 -3960 0 0 {name=X_67616_ }
C {devices/lab_pin.sym} 146050 -3830 0 0 {name=p145630 lab=_83303_/CLK }
C {devices/lab_pin.sym} 146050 -3810 0 0 {name=p145631 lab=_86450_/D }
C {devices/lab_pin.sym} 146230 -3830 0 1 {name=p145632 lab=_86450_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -3820 0 0 {name=X_86450_ }
C {devices/lab_pin.sym} 146060 -3710 0 0 {name=p145633 lab=_52838_/Y }
C {devices/lab_pin.sym} 146060 -3670 0 0 {name=p145634 lab=_52839_/X }
C {devices/lab_pin.sym} 146060 -3630 0 0 {name=p145635 lab=_52841_/X }
C {devices/lab_pin.sym} 146220 -3670 0 1 {name=p145636 lab=_52842_/Y }
C {sky130_stdcells/a21oi_4.sym} 146140 -3670 0 0 {name=X_52842_ }
C {devices/lab_pin.sym} 146100 -3530 0 0 {name=p145637 lab=_64828_/A }
C {devices/lab_pin.sym} 146180 -3530 0 1 {name=p145638 lab=_64828_/X }
C {sky130_stdcells/buf_2.sym} 146140 -3530 0 0 {name=X_64828_ }
C {devices/lab_pin.sym} 146050 -3410 0 0 {name=p145639 lab=_85447_/CLK }
C {devices/lab_pin.sym} 146050 -3390 0 0 {name=p145640 lab=_70922_/Y }
C {devices/lab_pin.sym} 146230 -3410 0 1 {name=p145641 lab=_83662_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -3400 0 0 {name=X_83662_ }
C {devices/lab_pin.sym} 146050 -3270 0 0 {name=p145642 lab=_80754_/CLK }
C {devices/lab_pin.sym} 146050 -3250 0 0 {name=p145643 lab=_75648_/B }
C {devices/lab_pin.sym} 146230 -3270 0 1 {name=p145644 lab=_80874_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -3260 0 0 {name=X_80874_ }
C {devices/lab_pin.sym} 146060 -3160 0 0 {name=p145645 lab=_86998_/Q }
C {devices/lab_pin.sym} 146060 -3120 0 0 {name=p145646 lab=_68570_/X }
C {devices/lab_pin.sym} 146060 -3080 0 0 {name=p145647 lab=_68571_/X }
C {devices/lab_pin.sym} 146060 -3040 0 0 {name=p145648 lab=_68595_/X }
C {devices/lab_pin.sym} 146220 -3100 0 1 {name=p145649 lab=_68596_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -3100 0 0 {name=X_68596_ }
C {devices/lab_pin.sym} 146050 -2950 0 0 {name=p145650 lab=_83745_/CLK }
C {devices/lab_pin.sym} 146050 -2930 0 0 {name=p145651 lab=_85401_/D }
C {devices/lab_pin.sym} 146230 -2950 0 1 {name=p145652 lab=_85401_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -2940 0 0 {name=X_85401_ }
C {devices/lab_pin.sym} 146050 -2810 0 0 {name=p145653 lab=_82518_/CLK }
C {devices/lab_pin.sym} 146050 -2790 0 0 {name=p145654 lab=_78982_/B }
C {devices/lab_pin.sym} 146230 -2810 0 1 {name=p145655 lab=_82613_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -2800 0 0 {name=X_82613_ }
C {devices/lab_pin.sym} 146060 -2700 0 0 {name=p145656 lab=_85051_/Q }
C {devices/lab_pin.sym} 146060 -2660 0 0 {name=p145657 lab=_55522_/X }
C {devices/lab_pin.sym} 146060 -2620 0 0 {name=p145658 lab=_55523_/X }
C {devices/lab_pin.sym} 146060 -2580 0 0 {name=p145659 lab=_55560_/Y }
C {devices/lab_pin.sym} 146220 -2640 0 1 {name=p145660 lab=_55561_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -2640 0 0 {name=X_55561_ }
C {devices/lab_pin.sym} 146080 -2500 0 0 {name=p145661 lab=_67572_/A }
C {devices/lab_pin.sym} 146080 -2460 0 0 {name=p145662 lab=_87210_/Q }
C {devices/lab_pin.sym} 146200 -2480 0 1 {name=p145663 lab=_67547_/X }
C {sky130_stdcells/and2_4.sym} 146140 -2480 0 0 {name=X_67547_ }
C {devices/lab_pin.sym} 146050 -2350 0 0 {name=p145664 lab=_86381_/CLK }
C {devices/lab_pin.sym} 146050 -2330 0 0 {name=p145665 lab=_86381_/D }
C {devices/lab_pin.sym} 146230 -2350 0 1 {name=p145666 lab=_86381_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -2340 0 0 {name=X_86381_ }
C {devices/lab_pin.sym} 146080 -2220 0 0 {name=p145667 lab=_52773_/A }
C {devices/lab_pin.sym} 146080 -2180 0 0 {name=p145668 lab=_52773_/B }
C {devices/lab_pin.sym} 146200 -2200 0 1 {name=p145669 lab=_52773_/Y }
C {sky130_stdcells/nand2_4.sym} 146140 -2200 0 0 {name=X_52773_ }
C {devices/lab_pin.sym} 146080 -2080 0 0 {name=p145670 lab=_64836_/A }
C {devices/lab_pin.sym} 146080 -2040 0 0 {name=p145671 lab=_64759_/B }
C {devices/lab_pin.sym} 146200 -2060 0 1 {name=p145672 lab=_64759_/X }
C {sky130_stdcells/and2_4.sym} 146140 -2060 0 0 {name=X_64759_ }
C {devices/lab_pin.sym} 146050 -1930 0 0 {name=p145673 lab=_83589_/CLK }
C {devices/lab_pin.sym} 146050 -1910 0 0 {name=p145674 lab=_71142_/Y }
C {devices/lab_pin.sym} 146230 -1930 0 1 {name=p145675 lab=_83593_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -1920 0 0 {name=X_83593_ }
C {devices/lab_pin.sym} 146100 -1790 0 0 {name=p145676 lab=_57299_/Y }
C {devices/lab_pin.sym} 146180 -1790 0 1 {name=p145677 lab=_57300_/Y }
C {sky130_stdcells/inv_2.sym} 146140 -1790 0 0 {name=X_57300_ }
C {devices/lab_pin.sym} 146050 -1670 0 0 {name=p145678 lab=_88376_/CLK }
C {devices/lab_pin.sym} 146050 -1650 0 0 {name=p145679 lab=_88120_/D }
C {devices/lab_pin.sym} 146230 -1670 0 1 {name=p145680 lab=_67218_/B }
C {sky130_stdcells/dfxtp_4.sym} 146140 -1660 0 0 {name=X_88120_ }
C {devices/lab_pin.sym} 146100 -1530 0 0 {name=p145681 lab=_54540_/A }
C {devices/lab_pin.sym} 146180 -1530 0 1 {name=p145682 lab=_54512_/X }
C {sky130_stdcells/buf_2.sym} 146140 -1530 0 0 {name=X_54512_ }
C {devices/lab_pin.sym} 146050 -1410 0 0 {name=p145683 lab=_85332_/CLK }
C {devices/lab_pin.sym} 146050 -1390 0 0 {name=p145684 lab=_85332_/D }
C {devices/lab_pin.sym} 146230 -1410 0 1 {name=p145685 lab=_85332_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -1400 0 0 {name=X_85332_ }
C {devices/lab_pin.sym} 146080 -1280 0 0 {name=p145686 lab=_51717_/A }
C {devices/lab_pin.sym} 146080 -1240 0 0 {name=p145687 lab=_53246_/B }
C {devices/lab_pin.sym} 146200 -1260 0 1 {name=p145688 lab=_51724_/Y }
C {sky130_stdcells/nand2_4.sym} 146140 -1260 0 0 {name=X_51724_ }
C {devices/lab_pin.sym} 146080 -1140 0 0 {name=p145689 lab=_58279_/Y }
C {devices/lab_pin.sym} 146080 -1100 0 0 {name=p145690 lab=_58280_/B }
C {devices/lab_pin.sym} 146200 -1120 0 1 {name=p145691 lab=_58280_/Y }
C {sky130_stdcells/nand2_4.sym} 146140 -1120 0 0 {name=X_58280_ }
C {devices/lab_pin.sym} 146050 -990 0 0 {name=p145692 lab=_83141_/CLK }
C {devices/lab_pin.sym} 146050 -970 0 0 {name=p145693 lab=_82544_/D }
C {devices/lab_pin.sym} 146230 -990 0 1 {name=p145694 lab=_82544_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -980 0 0 {name=X_82544_ }
C {devices/lab_pin.sym} 146100 -850 0 0 {name=p145695 lab=_55342_/X }
C {devices/lab_pin.sym} 146180 -850 0 1 {name=p145696 lab=_55492_/X }
C {sky130_stdcells/buf_2.sym} 146140 -850 0 0 {name=X_55492_ }
C {devices/lab_pin.sym} 146080 -740 0 0 {name=p145697 lab=_67381_/A }
C {devices/lab_pin.sym} 146080 -700 0 0 {name=p145698 lab=_86937_/Q }
C {devices/lab_pin.sym} 146200 -720 0 1 {name=p145699 lab=_67478_/X }
C {sky130_stdcells/and2_4.sym} 146140 -720 0 0 {name=X_67478_ }
C {devices/lab_pin.sym} 147000 -42170 0 0 {name=p145700 lab=_56927_/A }
C {devices/lab_pin.sym} 147000 -42130 0 0 {name=p145701 lab=_57086_/X }
C {devices/lab_pin.sym} 147000 -42090 0 0 {name=p145702 lab=_56927_/C }
C {devices/lab_pin.sym} 147120 -42130 0 1 {name=p145703 lab=_57231_/X }
C {sky130_stdcells/and3_4.sym} 147060 -42130 0 0 {name=X_57231_ }
C {devices/lab_pin.sym} 147020 -41990 0 0 {name=p145704 lab=_69315_/A }
C {devices/lab_pin.sym} 147100 -41990 0 1 {name=p145705 lab=_69217_/X }
C {sky130_stdcells/buf_2.sym} 147060 -41990 0 0 {name=X_69217_ }
C {devices/lab_pin.sym} 146970 -41870 0 0 {name=p145706 lab=_88084_/CLK }
C {devices/lab_pin.sym} 146970 -41850 0 0 {name=p145707 lab=_88051_/D }
C {devices/lab_pin.sym} 147150 -41870 0 1 {name=p145708 lab=_88051_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -41860 0 0 {name=X_88051_ }
C {devices/lab_pin.sym} 146980 -41750 0 0 {name=p145709 lab=_85441_/Q }
C {devices/lab_pin.sym} 146980 -41710 0 0 {name=p145710 lab=_54431_/X }
C {devices/lab_pin.sym} 146980 -41670 0 0 {name=p145711 lab=_54442_/Y }
C {devices/lab_pin.sym} 147140 -41710 0 1 {name=p145712 lab=_54443_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -41710 0 0 {name=X_54443_ }
C {devices/lab_pin.sym} 147000 -41590 0 0 {name=p145713 lab=_66389_/A }
C {devices/lab_pin.sym} 147000 -41550 0 0 {name=p145714 lab=_66402_/B }
C {devices/lab_pin.sym} 147000 -41510 0 0 {name=p145715 lab=_66429_/C }
C {devices/lab_pin.sym} 147120 -41550 0 1 {name=p145716 lab=_66429_/Y }
C {sky130_stdcells/nor3_4.sym} 147060 -41550 0 0 {name=X_66429_ }
C {devices/lab_pin.sym} 146970 -41410 0 0 {name=p145717 lab=_85198_/CLK }
C {devices/lab_pin.sym} 146970 -41390 0 0 {name=p145718 lab=_85263_/D }
C {devices/lab_pin.sym} 147150 -41410 0 1 {name=p145719 lab=_85263_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -41400 0 0 {name=X_85263_ }
C {devices/lab_pin.sym} 147020 -41270 0 0 {name=p145720 lab=_50256_/A }
C {devices/lab_pin.sym} 147100 -41270 0 1 {name=p145721 lab=_52620_/A }
C {sky130_stdcells/buf_2.sym} 147060 -41270 0 0 {name=X_51655_ }
C {devices/lab_pin.sym} 146970 -41150 0 0 {name=p145722 lab=_82563_/CLK }
C {devices/lab_pin.sym} 146970 -41130 0 0 {name=p145723 lab=_78444_/X }
C {devices/lab_pin.sym} 147150 -41150 0 1 {name=p145724 lab=_78091_/B }
C {sky130_stdcells/dfxtp_4.sym} 147060 -41140 0 0 {name=X_82475_ }
C {devices/lab_pin.sym} 147020 -41010 0 0 {name=p145725 lab=clkbuf_9_321_0_CLK/X }
C {devices/lab_pin.sym} 147100 -41010 0 1 {name=p145726 lab=_86932_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 147060 -41010 0 0 {name=Xclkbuf_10_642_0_CLK }
C {devices/lab_pin.sym} 146970 -40890 0 0 {name=p145727 lab=_86998_/CLK }
C {devices/lab_pin.sym} 146970 -40870 0 0 {name=p145728 lab=_87002_/D }
C {devices/lab_pin.sym} 147150 -40890 0 1 {name=p145729 lab=_87002_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -40880 0 0 {name=X_87002_ }
C {devices/lab_pin.sym} 146970 -40750 0 0 {name=p145730 lab=_84220_/CLK }
C {devices/lab_pin.sym} 146970 -40730 0 0 {name=p145731 lab=_65114_/X }
C {devices/lab_pin.sym} 147150 -40750 0 1 {name=p145732 lab=_84214_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -40740 0 0 {name=X_84214_ }
C {devices/lab_pin.sym} 146980 -40630 0 0 {name=p145733 lab=_50604_/Y }
C {devices/lab_pin.sym} 146980 -40590 0 0 {name=p145734 lab=_50577_/X }
C {devices/lab_pin.sym} 146980 -40550 0 0 {name=p145735 lab=_50605_/Y }
C {devices/lab_pin.sym} 147140 -40590 0 1 {name=p145736 lab=_86169_/D }
C {sky130_stdcells/a21boi_4.sym} 147060 -40590 0 0 {name=X_50606_ }
C {devices/lab_pin.sym} 147000 -40460 0 0 {name=p145737 lab=_57007_/X }
C {devices/lab_pin.sym} 147000 -40420 0 0 {name=p145738 lab=_57158_/C }
C {devices/lab_pin.sym} 147120 -40440 0 1 {name=p145739 lab=_57162_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -40440 0 0 {name=X_57162_ }
C {devices/lab_pin.sym} 146970 -40310 0 0 {name=p145740 lab=_81461_/CLK }
C {devices/lab_pin.sym} 146970 -40290 0 0 {name=p145741 lab=_81426_/D }
C {devices/lab_pin.sym} 147150 -40310 0 1 {name=p145742 lab=_76042_/B }
C {sky130_stdcells/dfxtp_4.sym} 147060 -40300 0 0 {name=X_81426_ }
C {devices/lab_pin.sym} 146980 -40200 0 0 {name=p145743 lab=_88050_/Q }
C {devices/lab_pin.sym} 146980 -40160 0 0 {name=p145744 lab=_68883_/X }
C {devices/lab_pin.sym} 146980 -40120 0 0 {name=p145745 lab=_68884_/X }
C {devices/lab_pin.sym} 146980 -40080 0 0 {name=p145746 lab=_69147_/X }
C {devices/lab_pin.sym} 147140 -40140 0 1 {name=p145747 lab=_69148_/X }
C {sky130_stdcells/a211o_4.sym} 147060 -40140 0 0 {name=X_69148_ }
C {devices/lab_pin.sym} 146980 -40010 0 0 {name=p145748 lab=_54370_/Y }
C {devices/lab_pin.sym} 146980 -39970 0 0 {name=p145749 lab=_54366_/X }
C {devices/lab_pin.sym} 146980 -39930 0 0 {name=p145750 lab=_54373_/X }
C {devices/lab_pin.sym} 147140 -39970 0 1 {name=p145751 lab=_85454_/D }
C {sky130_stdcells/a21oi_4.sym} 147060 -39970 0 0 {name=X_54374_ }
C {devices/lab_pin.sym} 146970 -39830 0 0 {name=p145752 lab=_80670_/CLK }
C {devices/lab_pin.sym} 146970 -39810 0 0 {name=p145753 lab=_85194_/D }
C {devices/lab_pin.sym} 147150 -39830 0 1 {name=p145754 lab=_85194_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -39820 0 0 {name=X_85194_ }
C {devices/lab_pin.sym} 147020 -39690 0 0 {name=p145755 lab=_52688_/A }
C {devices/lab_pin.sym} 147100 -39690 0 1 {name=p145756 lab=_51694_/A }
C {sky130_stdcells/buf_2.sym} 147060 -39690 0 0 {name=X_51586_ }
C {devices/lab_pin.sym} 147020 -39570 0 0 {name=p145757 lab=clkbuf_8_66_0_CLK/X }
C {devices/lab_pin.sym} 147100 -39570 0 1 {name=p145758 lab=clkbuf_9_133_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 147060 -39570 0 0 {name=Xclkbuf_9_133_0_CLK }
C {devices/lab_pin.sym} 147000 -39460 0 0 {name=p145759 lab=_55811_/X }
C {devices/lab_pin.sym} 147000 -39420 0 0 {name=p145760 lab=_55802_/X }
C {devices/lab_pin.sym} 147120 -39440 0 1 {name=p145761 lab=_56114_/A }
C {sky130_stdcells/xnor2_4.sym} 147060 -39440 0 0 {name=X_56113_ }
C {devices/lab_pin.sym} 147020 -39310 0 0 {name=p145762 lab=clkbuf_9_61_0_CLK/A }
C {devices/lab_pin.sym} 147100 -39310 0 1 {name=p145763 lab=clkbuf_9_60_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 147060 -39310 0 0 {name=Xclkbuf_9_60_0_CLK }
C {devices/lab_pin.sym} 147020 -39190 0 0 {name=p145764 lab=_53352_/A }
C {devices/lab_pin.sym} 147100 -39190 0 1 {name=p145765 lab=_53332_/A }
C {sky130_stdcells/buf_2.sym} 147060 -39190 0 0 {name=X_53325_ }
C {devices/lab_pin.sym} 146970 -39070 0 0 {name=p145766 lab=_84231_/CLK }
C {devices/lab_pin.sym} 146970 -39050 0 0 {name=p145767 lab=_84145_/D }
C {devices/lab_pin.sym} 147150 -39070 0 1 {name=p145768 lab=_84145_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -39060 0 0 {name=X_84145_ }
C {devices/lab_pin.sym} 147020 -38930 0 0 {name=p145769 lab=_50537_/A }
C {devices/lab_pin.sym} 147100 -38930 0 1 {name=p145770 lab=_50538_/A }
C {sky130_stdcells/buf_2.sym} 147060 -38930 0 0 {name=X_50537_ }
C {devices/lab_pin.sym} 146970 -38810 0 0 {name=p145771 lab=_81428_/CLK }
C {devices/lab_pin.sym} 146970 -38790 0 0 {name=p145772 lab=_81357_/D }
C {devices/lab_pin.sym} 147150 -38810 0 1 {name=p145773 lab=_76312_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -38800 0 0 {name=X_81357_ }
C {devices/lab_pin.sym} 146980 -38700 0 0 {name=p145774 lab=_87478_/Q }
C {devices/lab_pin.sym} 146980 -38660 0 0 {name=p145775 lab=_68989_/X }
C {devices/lab_pin.sym} 146980 -38620 0 0 {name=p145776 lab=_69010_/X }
C {devices/lab_pin.sym} 146980 -38580 0 0 {name=p145777 lab=_69078_/X }
C {devices/lab_pin.sym} 147140 -38640 0 1 {name=p145778 lab=_69079_/X }
C {sky130_stdcells/a211o_4.sym} 147060 -38640 0 0 {name=X_69079_ }
C {devices/lab_pin.sym} 146980 -38530 0 0 {name=p145779 lab=_45885_/X }
C {devices/lab_pin.sym} 146980 -38490 0 0 {name=p145780 lab=_45890_/X }
C {devices/lab_pin.sym} 146980 -38450 0 0 {name=p145781 lab=_56935_/X }
C {devices/lab_pin.sym} 146980 -38410 0 0 {name=p145782 lab=_57092_/X }
C {devices/lab_pin.sym} 146980 -38380 0 0 {name=p145783 lab=_44184_/A }
C {devices/lab_pin.sym} 147140 -38450 0 1 {name=p145784 lab=_57093_/Y }
C {sky130_stdcells/a41oi_4.sym} 147060 -38450 0 0 {name=X_57093_ }
C {devices/lab_pin.sym} 147000 -38310 0 0 {name=p145785 lab=_71101_/X }
C {devices/lab_pin.sym} 147000 -38270 0 0 {name=p145786 lab=_71064_/B }
C {devices/lab_pin.sym} 147000 -38230 0 0 {name=p145787 lab=_70890_/D }
C {devices/lab_pin.sym} 147120 -38270 0 1 {name=p145788 lab=_71110_/Y }
C {sky130_stdcells/nand3_4.sym} 147060 -38270 0 0 {name=X_71110_ }
C {devices/lab_pin.sym} 147020 -38130 0 0 {name=p145789 lab=_56043_/X }
C {devices/lab_pin.sym} 147100 -38130 0 1 {name=p145790 lab=_56044_/X }
C {sky130_stdcells/buf_2.sym} 147060 -38130 0 0 {name=X_56044_ }
C {devices/lab_pin.sym} 147000 -38020 0 0 {name=p145791 lab=_80308_/A }
C {devices/lab_pin.sym} 147000 -37980 0 0 {name=p145792 lab=_80308_/B }
C {devices/lab_pin.sym} 147120 -38000 0 1 {name=p145793 lab=_80308_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -38000 0 0 {name=X_80308_ }
C {devices/lab_pin.sym} 147000 -37880 0 0 {name=p145794 lab=_41096_/B }
C {devices/lab_pin.sym} 147000 -37840 0 0 {name=p145795 lab=_41280_/B }
C {devices/lab_pin.sym} 147120 -37860 0 1 {name=p145796 lab=_41270_/X }
C {sky130_stdcells/or2_4.sym} 147060 -37860 0 0 {name=X_41270_ }
C {devices/lab_pin.sym} 146980 -37750 0 0 {name=p145797 lab=_85667_/Q }
C {devices/lab_pin.sym} 146980 -37710 0 0 {name=p145798 lab=_51929_/X }
C {devices/lab_pin.sym} 146980 -37670 0 0 {name=p145799 lab=_53255_/Y }
C {devices/lab_pin.sym} 147140 -37710 0 1 {name=p145800 lab=_53256_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -37710 0 0 {name=X_53256_ }
C {devices/lab_pin.sym} 147020 -37570 0 0 {name=p145801 lab=clkbuf_9_328_0_CLK/X }
C {devices/lab_pin.sym} 147100 -37570 0 1 {name=p145802 lab=_87417_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 147060 -37570 0 0 {name=Xclkbuf_10_657_0_CLK }
C {devices/lab_pin.sym} 147020 -37450 0 0 {name=p145803 lab=_71985_/A }
C {devices/lab_pin.sym} 147100 -37450 0 1 {name=p145804 lab=_72090_/X }
C {sky130_stdcells/buf_2.sym} 147060 -37450 0 0 {name=X_72090_ }
C {devices/lab_pin.sym} 146970 -37330 0 0 {name=p145805 lab=_84074_/CLK }
C {devices/lab_pin.sym} 146970 -37310 0 0 {name=p145806 lab=_84076_/D }
C {devices/lab_pin.sym} 147150 -37330 0 1 {name=p145807 lab=_80900_/D }
C {sky130_stdcells/dfxtp_4.sym} 147060 -37320 0 0 {name=X_84076_ }
C {devices/lab_pin.sym} 147020 -37190 0 0 {name=p145808 lab=_50510_/A }
C {devices/lab_pin.sym} 147100 -37190 0 1 {name=p145809 lab=_50497_/C }
C {sky130_stdcells/buf_2.sym} 147060 -37190 0 0 {name=X_50468_ }
C {devices/lab_pin.sym} 146970 -37070 0 0 {name=p145810 lab=_81288_/CLK }
C {devices/lab_pin.sym} 146970 -37050 0 0 {name=p145811 lab=_76976_/X }
C {devices/lab_pin.sym} 147150 -37070 0 1 {name=p145812 lab=_81256_/D }
C {sky130_stdcells/dfxtp_4.sym} 147060 -37060 0 0 {name=X_81288_ }
C {devices/lab_pin.sym} 146980 -36950 0 0 {name=p145813 lab=_85868_/Q }
C {devices/lab_pin.sym} 146980 -36910 0 0 {name=p145814 lab=_52184_/X }
C {devices/lab_pin.sym} 146980 -36870 0 0 {name=p145815 lab=_52206_/Y }
C {devices/lab_pin.sym} 147140 -36910 0 1 {name=p145816 lab=_52207_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -36910 0 0 {name=X_52207_ }
C {devices/lab_pin.sym} 147020 -36770 0 0 {name=p145817 lab=_70824_/A }
C {devices/lab_pin.sym} 147100 -36770 0 1 {name=p145818 lab=_71041_/X }
C {sky130_stdcells/buf_2.sym} 147060 -36770 0 0 {name=X_71041_ }
C {devices/lab_pin.sym} 146970 -36650 0 0 {name=p145819 lab=_85177_/CLK }
C {devices/lab_pin.sym} 146970 -36630 0 0 {name=p145820 lab=_74581_/Y }
C {devices/lab_pin.sym} 147150 -36650 0 1 {name=p145821 lab=_45122_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -36640 0 0 {name=X_83027_ }
C {devices/lab_pin.sym} 146970 -36510 0 0 {name=p145822 lab=_87646_/CLK }
C {devices/lab_pin.sym} 146970 -36490 0 0 {name=p145823 lab=_87904_/D }
C {devices/lab_pin.sym} 147150 -36510 0 1 {name=p145824 lab=_87904_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -36500 0 0 {name=X_87904_ }
C {devices/lab_pin.sym} 146980 -36390 0 0 {name=p145825 lab=_80233_/A }
C {devices/lab_pin.sym} 146980 -36350 0 0 {name=p145826 lab=_80232_/X }
C {devices/lab_pin.sym} 146980 -36310 0 0 {name=p145827 lab=_80238_/Y }
C {devices/lab_pin.sym} 147140 -36350 0 1 {name=p145828 lab=_80239_/Y }
C {sky130_stdcells/a21boi_4.sym} 147060 -36350 0 0 {name=X_80239_ }
C {devices/lab_pin.sym} 147000 -36220 0 0 {name=p145829 lab=_53187_/A }
C {devices/lab_pin.sym} 147000 -36180 0 0 {name=p145830 lab=_53187_/B }
C {devices/lab_pin.sym} 147120 -36200 0 1 {name=p145831 lab=_53187_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -36200 0 0 {name=X_53187_ }
C {devices/lab_pin.sym} 147020 -36070 0 0 {name=p145832 lab=clkbuf_8_74_0_CLK/X }
C {devices/lab_pin.sym} 147100 -36070 0 1 {name=p145833 lab=clkbuf_9_148_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 147060 -36070 0 0 {name=Xclkbuf_9_148_0_CLK }
C {devices/lab_pin.sym} 146980 -35970 0 0 {name=p145834 lab=_86208_/Q }
C {devices/lab_pin.sym} 146980 -35930 0 0 {name=p145835 lab=_50333_/X }
C {devices/lab_pin.sym} 146980 -35890 0 0 {name=p145836 lab=_50398_/Y }
C {devices/lab_pin.sym} 147140 -35930 0 1 {name=p145837 lab=_50399_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -35930 0 0 {name=X_50399_ }
C {devices/lab_pin.sym} 147020 -35790 0 0 {name=p145838 lab=clkbuf_8_37_0_CLK/X }
C {devices/lab_pin.sym} 147100 -35790 0 1 {name=p145839 lab=clkbuf_9_75_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 147060 -35790 0 0 {name=Xclkbuf_9_75_0_CLK }
C {devices/lab_pin.sym} 147020 -35670 0 0 {name=p145840 lab=_59802_/X }
C {devices/lab_pin.sym} 147100 -35670 0 1 {name=p145841 lab=_59803_/X }
C {sky130_stdcells/buf_2.sym} 147060 -35670 0 0 {name=X_59803_ }
C {devices/lab_pin.sym} 146980 -35570 0 0 {name=p145842 lab=_85881_/Q }
C {devices/lab_pin.sym} 146980 -35530 0 0 {name=p145843 lab=_52125_/X }
C {devices/lab_pin.sym} 146980 -35490 0 0 {name=p145844 lab=_52137_/Y }
C {devices/lab_pin.sym} 147140 -35530 0 1 {name=p145845 lab=_52138_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -35530 0 0 {name=X_52138_ }
C {devices/lab_pin.sym} 146970 -35390 0 0 {name=p145846 lab=_87288_/CLK }
C {devices/lab_pin.sym} 146970 -35370 0 0 {name=p145847 lab=_87835_/D }
C {devices/lab_pin.sym} 147150 -35390 0 1 {name=p145848 lab=_68955_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -35380 0 0 {name=X_87835_ }
C {devices/lab_pin.sym} 146980 -35280 0 0 {name=p145849 lab=_57980_/Y }
C {devices/lab_pin.sym} 146980 -35240 0 0 {name=p145850 lab=_57981_/X }
C {devices/lab_pin.sym} 146980 -35200 0 0 {name=p145851 lab=_57988_/X }
C {devices/lab_pin.sym} 146980 -35160 0 0 {name=p145852 lab=_57994_/X }
C {devices/lab_pin.sym} 147140 -35220 0 1 {name=p145853 lab=_84934_/D }
C {sky130_stdcells/a22oi_4.sym} 147060 -35220 0 0 {name=X_57995_ }
C {devices/lab_pin.sym} 147000 -35090 0 0 {name=p145854 lab=_70586_/X }
C {devices/lab_pin.sym} 147000 -35050 0 0 {name=p145855 lab=_83832_/Q }
C {devices/lab_pin.sym} 147000 -35010 0 0 {name=p145856 lab=_74753_/X }
C {devices/lab_pin.sym} 147120 -35050 0 1 {name=p145857 lab=_74800_/X }
C {sky130_stdcells/and3_4.sym} 147060 -35050 0 0 {name=X_74800_ }
C {devices/lab_pin.sym} 147020 -34910 0 0 {name=p145858 lab=_45923_/X }
C {devices/lab_pin.sym} 147100 -34910 0 1 {name=p145859 lab=_65515_/A }
C {sky130_stdcells/buf_2.sym} 147060 -34910 0 0 {name=X_59734_ }
C {devices/lab_pin.sym} 146980 -34810 0 0 {name=p145860 lab=_55949_/B }
C {devices/lab_pin.sym} 146980 -34770 0 0 {name=p145861 lab=_44882_/X }
C {devices/lab_pin.sym} 146980 -34730 0 0 {name=p145862 lab=_44959_/X }
C {devices/lab_pin.sym} 147140 -34770 0 1 {name=p145863 lab=_44960_/X }
C {sky130_stdcells/o21a_4.sym} 147060 -34770 0 0 {name=X_44960_ }
C {devices/lab_pin.sym} 146980 -34650 0 0 {name=p145864 lab=_52065_/Y }
C {devices/lab_pin.sym} 146980 -34610 0 0 {name=p145865 lab=_52066_/X }
C {devices/lab_pin.sym} 146980 -34570 0 0 {name=p145866 lab=_52068_/Y }
C {devices/lab_pin.sym} 147140 -34610 0 1 {name=p145867 lab=_85895_/D }
C {sky130_stdcells/a21boi_4.sym} 147060 -34610 0 0 {name=X_52069_ }
C {devices/lab_pin.sym} 146980 -34500 0 0 {name=p145868 lab=_44214_/X }
C {devices/lab_pin.sym} 146980 -34460 0 0 {name=p145869 lab=_56578_/X }
C {devices/lab_pin.sym} 146980 -34420 0 0 {name=p145870 lab=_45440_/A }
C {devices/lab_pin.sym} 146980 -34380 0 0 {name=p145871 lab=_56943_/X }
C {devices/lab_pin.sym} 147140 -34440 0 1 {name=p145872 lab=_85118_/D }
C {sky130_stdcells/a2bb2o_4.sym} 147060 -34440 0 0 {name=X_56946_ }
C {devices/lab_pin.sym} 147000 -34300 0 0 {name=p145873 lab=_75778_/Y }
C {devices/lab_pin.sym} 147000 -34260 0 0 {name=p145874 lab=_75779_/Y }
C {devices/lab_pin.sym} 147120 -34280 0 1 {name=p145875 lab=_75784_/A }
C {sky130_stdcells/xor2_4.sym} 147060 -34280 0 0 {name=X_75780_ }
C {devices/lab_pin.sym} 146970 -34150 0 0 {name=p145876 lab=_87766_/CLK }
C {devices/lab_pin.sym} 146970 -34130 0 0 {name=p145877 lab=_87766_/D }
C {devices/lab_pin.sym} 147150 -34150 0 1 {name=p145878 lab=_69531_/B }
C {sky130_stdcells/dfxtp_4.sym} 147060 -34140 0 0 {name=X_87766_ }
C {devices/lab_pin.sym} 147020 -34010 0 0 {name=p145879 lab=_72880_/A }
C {devices/lab_pin.sym} 147100 -34010 0 1 {name=p145880 lab=_72992_/X }
C {sky130_stdcells/buf_2.sym} 147060 -34010 0 0 {name=X_72992_ }
C {devices/lab_pin.sym} 146970 -33890 0 0 {name=p145881 lab=_86238_/CLK }
C {devices/lab_pin.sym} 146970 -33870 0 0 {name=p145882 lab=_84978_/D }
C {devices/lab_pin.sym} 147150 -33890 0 1 {name=p145883 lab=_84978_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -33880 0 0 {name=X_84978_ }
C {devices/lab_pin.sym} 146980 -33780 0 0 {name=p145884 lab=_41371_/X }
C {devices/lab_pin.sym} 146980 -33740 0 0 {name=p145885 lab=_43907_/X }
C {devices/lab_pin.sym} 146980 -33700 0 0 {name=p145886 lab=_67729_/B }
C {devices/lab_pin.sym} 146980 -33660 0 0 {name=p145887 lab=_43908_/X }
C {devices/lab_pin.sym} 147140 -33720 0 1 {name=p145888 lab=_87203_/D }
C {sky130_stdcells/a2bb2o_4.sym} 147060 -33720 0 0 {name=X_43911_ }
C {devices/lab_pin.sym} 147000 -33590 0 0 {name=p145889 lab=_74731_/A }
C {devices/lab_pin.sym} 147000 -33550 0 0 {name=p145890 lab=_70630_/B }
C {devices/lab_pin.sym} 147000 -33510 0 0 {name=p145891 lab=_71735_/C }
C {devices/lab_pin.sym} 147120 -33550 0 1 {name=p145892 lab=_74731_/X }
C {sky130_stdcells/and3_4.sym} 147060 -33550 0 0 {name=X_74731_ }
C {devices/lab_pin.sym} 146970 -33410 0 0 {name=p145893 lab=_86398_/CLK }
C {devices/lab_pin.sym} 146970 -33390 0 0 {name=p145894 lab=_86717_/D }
C {devices/lab_pin.sym} 147150 -33410 0 1 {name=p145895 lab=_86717_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -33400 0 0 {name=X_86717_ }
C {devices/lab_pin.sym} 147000 -33290 0 0 {name=p145896 lab=_71586_/A }
C {devices/lab_pin.sym} 147000 -33250 0 0 {name=p145897 lab=_71930_/B }
C {devices/lab_pin.sym} 147000 -33210 0 0 {name=p145898 lab=_71598_/C }
C {devices/lab_pin.sym} 147120 -33250 0 1 {name=p145899 lab=_71943_/Y }
C {sky130_stdcells/nor3_4.sym} 147060 -33250 0 0 {name=X_71943_ }
C {devices/lab_pin.sym} 147020 -33110 0 0 {name=p145900 lab=_59665_/A }
C {devices/lab_pin.sym} 147100 -33110 0 1 {name=p145901 lab=_59666_/A }
C {sky130_stdcells/buf_2.sym} 147060 -33110 0 0 {name=X_59665_ }
C {devices/lab_pin.sym} 146970 -32990 0 0 {name=p145902 lab=_83932_/CLK }
C {devices/lab_pin.sym} 146970 -32970 0 0 {name=p145903 lab=_83929_/D }
C {devices/lab_pin.sym} 147150 -32990 0 1 {name=p145904 lab=_81393_/D }
C {sky130_stdcells/dfxtp_4.sym} 147060 -32980 0 0 {name=X_83929_ }
C {devices/lab_pin.sym} 147020 -32850 0 0 {name=p145905 lab=_45387_/A }
C {devices/lab_pin.sym} 147100 -32850 0 1 {name=p145906 lab=_44891_/X }
C {sky130_stdcells/buf_2.sym} 147060 -32850 0 0 {name=X_44891_ }
C {devices/lab_pin.sym} 147020 -32730 0 0 {name=p145907 lab=_56876_/X }
C {devices/lab_pin.sym} 147100 -32730 0 1 {name=p145908 lab=_56877_/X }
C {sky130_stdcells/buf_2.sym} 147060 -32730 0 0 {name=X_56877_ }
C {devices/lab_pin.sym} 146970 -32610 0 0 {name=p145909 lab=_87950_/CLK }
C {devices/lab_pin.sym} 146970 -32590 0 0 {name=p145910 lab=_87697_/D }
C {devices/lab_pin.sym} 147150 -32610 0 1 {name=p145911 lab=_66626_/B }
C {sky130_stdcells/dfxtp_4.sym} 147060 -32600 0 0 {name=X_87697_ }
C {devices/lab_pin.sym} 146980 -32490 0 0 {name=p145912 lab=_58605_/X }
C {devices/lab_pin.sym} 146980 -32450 0 0 {name=p145913 lab=_85949_/Q }
C {devices/lab_pin.sym} 146980 -32410 0 0 {name=p145914 lab=_58568_/X }
C {devices/lab_pin.sym} 147140 -32450 0 1 {name=p145915 lab=_58616_/X }
C {sky130_stdcells/o21a_4.sym} 147060 -32450 0 0 {name=X_58616_ }
C {devices/lab_pin.sym} 147020 -32310 0 0 {name=p145916 lab=_54275_/D }
C {devices/lab_pin.sym} 147100 -32310 0 1 {name=p145917 lab=_51756_/D }
C {sky130_stdcells/buf_2.sym} 147060 -32310 0 0 {name=X_46630_ }
C {devices/lab_pin.sym} 147000 -32200 0 0 {name=p145918 lab=_77442_/X }
C {devices/lab_pin.sym} 147000 -32160 0 0 {name=p145919 lab=_77449_/X }
C {devices/lab_pin.sym} 147120 -32180 0 1 {name=p145920 lab=_77452_/A }
C {sky130_stdcells/xnor2_4.sym} 147060 -32180 0 0 {name=X_77450_ }
C {devices/lab_pin.sym} 147020 -32050 0 0 {name=p145921 lab=_43842_/A }
C {devices/lab_pin.sym} 147100 -32050 0 1 {name=p145922 lab=_43842_/X }
C {sky130_stdcells/buf_2.sym} 147060 -32050 0 0 {name=X_43842_ }
C {devices/lab_pin.sym} 147000 -31950 0 0 {name=p145923 lab=_57416_/A }
C {devices/lab_pin.sym} 147000 -31910 0 0 {name=p145924 lab=_57416_/C }
C {devices/lab_pin.sym} 147000 -31870 0 0 {name=p145925 lab=_74656_/X }
C {devices/lab_pin.sym} 147120 -31910 0 1 {name=p145926 lab=_74662_/Y }
C {sky130_stdcells/nand3_4.sym} 147060 -31910 0 0 {name=X_74662_ }
C {devices/lab_pin.sym} 147000 -31780 0 0 {name=p145927 lab=_55825_/X }
C {devices/lab_pin.sym} 147000 -31740 0 0 {name=p145928 lab=_55827_/X }
C {devices/lab_pin.sym} 147120 -31760 0 1 {name=p145929 lab=_55828_/X }
C {sky130_stdcells/and2_4.sym} 147060 -31760 0 0 {name=X_55828_ }
C {devices/lab_pin.sym} 146970 -31630 0 0 {name=p145930 lab=_86008_/CLK }
C {devices/lab_pin.sym} 146970 -31610 0 0 {name=p145931 lab=_86648_/D }
C {devices/lab_pin.sym} 147150 -31630 0 1 {name=p145932 lab=_86648_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -31620 0 0 {name=X_86648_ }
C {devices/lab_pin.sym} 147000 -31520 0 0 {name=p145933 lab=_70534_/Y }
C {devices/lab_pin.sym} 147000 -31480 0 0 {name=p145934 lab=_71883_/B }
C {devices/lab_pin.sym} 147000 -31440 0 0 {name=p145935 lab=_71873_/X }
C {devices/lab_pin.sym} 147000 -31400 0 0 {name=p145936 lab=_71874_/D }
C {devices/lab_pin.sym} 147120 -31460 0 1 {name=p145937 lab=_71874_/Y }
C {sky130_stdcells/nor4_4.sym} 147060 -31460 0 0 {name=X_71874_ }
C {devices/lab_pin.sym} 147000 -31320 0 0 {name=p145938 lab=_59622_/A }
C {devices/lab_pin.sym} 147000 -31280 0 0 {name=p145939 lab=_60182_/A }
C {devices/lab_pin.sym} 147120 -31300 0 1 {name=p145940 lab=_60174_/C }
C {sky130_stdcells/nor2_4.sym} 147060 -31300 0 0 {name=X_59596_ }
C {devices/lab_pin.sym} 146980 -31190 0 0 {name=p145941 lab=_76396_/X }
C {devices/lab_pin.sym} 146980 -31150 0 0 {name=p145942 lab=_76400_/C }
C {devices/lab_pin.sym} 146980 -31110 0 0 {name=p145943 lab=_76391_/X }
C {devices/lab_pin.sym} 147140 -31150 0 1 {name=p145944 lab=_76401_/X }
C {sky130_stdcells/o21a_4.sym} 147060 -31150 0 0 {name=X_76401_ }
C {devices/lab_pin.sym} 146980 -31030 0 0 {name=p145945 lab=_73608_/X }
C {devices/lab_pin.sym} 146980 -30990 0 0 {name=p145946 lab=_73611_/X }
C {devices/lab_pin.sym} 146980 -30950 0 0 {name=p145947 lab=_73612_/X }
C {devices/lab_pin.sym} 147140 -30990 0 1 {name=p145948 lab=_73618_/A }
C {sky130_stdcells/a21o_4.sym} 147060 -30990 0 0 {name=X_73613_ }
C {devices/lab_pin.sym} 147000 -30860 0 0 {name=p145949 lab=_46531_/A }
C {devices/lab_pin.sym} 147000 -30820 0 0 {name=p145950 lab=_54075_/B }
C {devices/lab_pin.sym} 147120 -30840 0 1 {name=p145951 lab=_46561_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -30840 0 0 {name=X_46561_ }
C {devices/lab_pin.sym} 147000 -30730 0 0 {name=p145952 lab=_71219_/A }
C {devices/lab_pin.sym} 147000 -30690 0 0 {name=p145953 lab=_71066_/B }
C {devices/lab_pin.sym} 147000 -30650 0 0 {name=p145954 lab=_70703_/X }
C {devices/lab_pin.sym} 147120 -30690 0 1 {name=p145955 lab=_70825_/Y }
C {sky130_stdcells/nand3_4.sym} 147060 -30690 0 0 {name=X_70825_ }
C {devices/lab_pin.sym} 147020 -30550 0 0 {name=p145956 lab=_58547_/A }
C {devices/lab_pin.sym} 147100 -30550 0 1 {name=p145957 lab=_58548_/A }
C {sky130_stdcells/buf_2.sym} 147060 -30550 0 0 {name=X_58547_ }
C {devices/lab_pin.sym} 147020 -30430 0 0 {name=p145958 lab=_77381_/A }
C {devices/lab_pin.sym} 147100 -30430 0 1 {name=p145959 lab=_77381_/Y }
C {sky130_stdcells/inv_2.sym} 147060 -30430 0 0 {name=X_77381_ }
C {devices/lab_pin.sym} 146980 -30340 0 0 {name=p145960 lab=_40986_/X }
C {devices/lab_pin.sym} 146980 -30300 0 0 {name=p145961 lab=_43770_/X }
C {devices/lab_pin.sym} 146980 -30260 0 0 {name=p145962 lab=_69274_/B }
C {devices/lab_pin.sym} 146980 -30220 0 0 {name=p145963 lab=_43772_/X }
C {devices/lab_pin.sym} 147140 -30280 0 1 {name=p145964 lab=_43773_/X }
C {sky130_stdcells/a2bb2o_4.sym} 147060 -30280 0 0 {name=X_43773_ }
C {devices/lab_pin.sym} 146980 -30160 0 0 {name=p145965 lab=_56444_/C }
C {devices/lab_pin.sym} 146980 -30120 0 0 {name=p145966 lab=_55177_/A }
C {devices/lab_pin.sym} 146980 -30080 0 0 {name=p145967 lab=_55300_/X }
C {devices/lab_pin.sym} 146980 -30040 0 0 {name=p145968 lab=_55758_/X }
C {devices/lab_pin.sym} 147140 -30100 0 1 {name=p145969 lab=_55759_/X }
C {sky130_stdcells/a211o_4.sym} 147060 -30100 0 0 {name=X_55759_ }
C {devices/lab_pin.sym} 146980 -29970 0 0 {name=p145970 lab=_45182_/A }
C {devices/lab_pin.sym} 146980 -29930 0 0 {name=p145971 lab=_74582_/X }
C {devices/lab_pin.sym} 146980 -29890 0 0 {name=p145972 lab=_74592_/X }
C {devices/lab_pin.sym} 147140 -29930 0 1 {name=p145973 lab=_74593_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -29930 0 0 {name=X_74593_ }
C {devices/lab_pin.sym} 146970 -29790 0 0 {name=p145974 lab=_86578_/CLK }
C {devices/lab_pin.sym} 146970 -29770 0 0 {name=p145975 lab=_47985_/Y }
C {devices/lab_pin.sym} 147150 -29790 0 1 {name=p145976 lab=_73904_/B }
C {sky130_stdcells/dfxtp_4.sym} 147060 -29780 0 0 {name=X_86579_ }
C {devices/lab_pin.sym} 146980 -29670 0 0 {name=p145977 lab=_40504_/X }
C {devices/lab_pin.sym} 146980 -29630 0 0 {name=p145978 lab=_82295_/Q }
C {devices/lab_pin.sym} 146980 -29590 0 0 {name=p145979 lab=_40984_/X }
C {devices/lab_pin.sym} 147140 -29630 0 1 {name=p145980 lab=_40985_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -29630 0 0 {name=X_40985_ }
C {devices/lab_pin.sym} 147000 -29500 0 0 {name=p145981 lab=_48264_/X }
C {devices/lab_pin.sym} 147000 -29460 0 0 {name=p145982 lab=_52047_/B }
C {devices/lab_pin.sym} 147120 -29480 0 1 {name=p145983 lab=_48300_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -29480 0 0 {name=X_48300_ }
C {devices/lab_pin.sym} 147020 -29350 0 0 {name=p145984 lab=clkbuf_8_6_0_CLK/X }
C {devices/lab_pin.sym} 147100 -29350 0 1 {name=p145985 lab=clkbuf_9_13_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 147060 -29350 0 0 {name=Xclkbuf_9_13_0_CLK }
C {devices/lab_pin.sym} 147020 -29230 0 0 {name=p145986 lab=_79053_/A }
C {devices/lab_pin.sym} 147100 -29230 0 1 {name=p145987 lab=_82525_/D }
C {sky130_stdcells/inv_2.sym} 147060 -29230 0 0 {name=X_79120_ }
C {devices/lab_pin.sym} 147020 -29110 0 0 {name=p145988 lab=_63089_/B }
C {devices/lab_pin.sym} 147100 -29110 0 1 {name=p145989 lab=_61421_/A }
C {sky130_stdcells/buf_2.sym} 147060 -29110 0 0 {name=X_45512_ }
C {devices/lab_pin.sym} 147000 -29000 0 0 {name=p145990 lab=_76332_/A }
C {devices/lab_pin.sym} 147000 -28960 0 0 {name=p145991 lab=_81563_/Q }
C {devices/lab_pin.sym} 147120 -28980 0 1 {name=p145992 lab=_76332_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -28980 0 0 {name=X_76332_ }
C {devices/lab_pin.sym} 146980 -28890 0 0 {name=p145993 lab=_42721_/X }
C {devices/lab_pin.sym} 146980 -28850 0 0 {name=p145994 lab=_42723_/X }
C {devices/lab_pin.sym} 146980 -28810 0 0 {name=p145995 lab=_41174_/X }
C {devices/lab_pin.sym} 146980 -28770 0 0 {name=p145996 lab=_87751_/Q }
C {devices/lab_pin.sym} 146980 -28730 0 0 {name=p145997 lab=_42700_/X }
C {devices/lab_pin.sym} 147140 -28810 0 1 {name=p145998 lab=_42725_/A }
C {sky130_stdcells/o32ai_4.sym} 147060 -28810 0 0 {name=X_42724_ }
C {devices/lab_pin.sym} 146970 -28650 0 0 {name=p145999 lab=_87063_/CLK }
C {devices/lab_pin.sym} 146970 -28630 0 0 {name=p146000 lab=_40882_/X }
C {devices/lab_pin.sym} 147150 -28650 0 1 {name=p146001 lab=_88318_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -28640 0 0 {name=X_88318_ }
C {devices/lab_pin.sym} 146980 -28530 0 0 {name=p146002 lab=_86418_/Q }
C {devices/lab_pin.sym} 146980 -28490 0 0 {name=p146003 lab=_49204_/X }
C {devices/lab_pin.sym} 146980 -28450 0 0 {name=p146004 lab=_49279_/Y }
C {devices/lab_pin.sym} 147140 -28490 0 1 {name=p146005 lab=_49280_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -28490 0 0 {name=X_49280_ }
C {devices/lab_pin.sym} 146980 -28370 0 0 {name=p146006 lab=_73532_/X }
C {devices/lab_pin.sym} 146980 -28330 0 0 {name=p146007 lab=_73534_/X }
C {devices/lab_pin.sym} 146980 -28290 0 0 {name=p146008 lab=_73543_/X }
C {devices/lab_pin.sym} 147140 -28330 0 1 {name=p146009 lab=_73544_/X }
C {sky130_stdcells/a21o_4.sym} 147060 -28330 0 0 {name=X_73544_ }
C {devices/lab_pin.sym} 146980 -28210 0 0 {name=p146010 lab=_86732_/Q }
C {devices/lab_pin.sym} 146980 -28170 0 0 {name=p146011 lab=_46474_/X }
C {devices/lab_pin.sym} 146980 -28130 0 0 {name=p146012 lab=_46491_/Y }
C {devices/lab_pin.sym} 147140 -28170 0 1 {name=p146013 lab=_46492_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -28170 0 0 {name=X_46492_ }
C {devices/lab_pin.sym} 146980 -28050 0 0 {name=p146014 lab=_53135_/B }
C {devices/lab_pin.sym} 146980 -28010 0 0 {name=p146015 lab=_70740_/A }
C {devices/lab_pin.sym} 146980 -27970 0 0 {name=p146016 lab=_70755_/Y }
C {devices/lab_pin.sym} 147140 -28010 0 1 {name=p146017 lab=_83706_/D }
C {sky130_stdcells/o21ai_4.sym} 147060 -28010 0 0 {name=X_70756_ }
C {devices/lab_pin.sym} 147000 -27880 0 0 {name=p146018 lab=_58478_/A }
C {devices/lab_pin.sym} 147000 -27840 0 0 {name=p146019 lab=_58474_/B }
C {devices/lab_pin.sym} 147120 -27860 0 1 {name=p146020 lab=_58478_/Y }
C {sky130_stdcells/nor2_4.sym} 147060 -27860 0 0 {name=X_58478_ }
C {devices/lab_pin.sym} 147000 -27740 0 0 {name=p146021 lab=_48190_/A }
C {devices/lab_pin.sym} 147000 -27700 0 0 {name=p146022 lab=_48231_/B }
C {devices/lab_pin.sym} 147120 -27720 0 1 {name=p146023 lab=_48231_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -27720 0 0 {name=X_48231_ }
C {devices/lab_pin.sym} 147000 -27600 0 0 {name=p146024 lab=_82829_/Q }
C {devices/lab_pin.sym} 147000 -27560 0 0 {name=p146025 lab=_79051_/B }
C {devices/lab_pin.sym} 147120 -27580 0 1 {name=p146026 lab=_79053_/A }
C {sky130_stdcells/xnor2_4.sym} 147060 -27580 0 0 {name=X_79051_ }
C {devices/lab_pin.sym} 147020 -27450 0 0 {name=p146027 lab=_45395_/X }
C {devices/lab_pin.sym} 147100 -27450 0 1 {name=p146028 lab=_45443_/X }
C {sky130_stdcells/buf_2.sym} 147060 -27450 0 0 {name=X_45443_ }
C {devices/lab_pin.sym} 147020 -27330 0 0 {name=p146029 lab=_57429_/A }
C {devices/lab_pin.sym} 147100 -27330 0 1 {name=p146030 lab=_85006_/D }
C {sky130_stdcells/inv_2.sym} 147060 -27330 0 0 {name=X_57429_ }
C {devices/lab_pin.sym} 146980 -27230 0 0 {name=p146031 lab=_76248_/Y }
C {devices/lab_pin.sym} 146980 -27190 0 0 {name=p146032 lab=_76245_/Y }
C {devices/lab_pin.sym} 146980 -27150 0 0 {name=p146033 lab=_76251_/C }
C {devices/lab_pin.sym} 147140 -27190 0 1 {name=p146034 lab=_76264_/A }
C {sky130_stdcells/o21a_4.sym} 147060 -27190 0 0 {name=X_76263_ }
C {devices/lab_pin.sym} 146970 -27050 0 0 {name=p146035 lab=_88247_/CLK }
C {devices/lab_pin.sym} 146970 -27030 0 0 {name=p146036 lab=_88249_/D }
C {devices/lab_pin.sym} 147150 -27050 0 1 {name=p146037 lab=_88249_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -27040 0 0 {name=X_88249_ }
C {devices/lab_pin.sym} 146980 -26940 0 0 {name=p146038 lab=_40986_/X }
C {devices/lab_pin.sym} 146980 -26900 0 0 {name=p146039 lab=_42652_/X }
C {devices/lab_pin.sym} 146980 -26860 0 0 {name=p146040 lab=_87785_/Q }
C {devices/lab_pin.sym} 146980 -26820 0 0 {name=p146041 lab=_42653_/X }
C {devices/lab_pin.sym} 147140 -26880 0 1 {name=p146042 lab=_87785_/D }
C {sky130_stdcells/a2bb2o_4.sym} 147060 -26880 0 0 {name=X_42655_ }
C {devices/lab_pin.sym} 146980 -26750 0 0 {name=p146043 lab=_73471_/X }
C {devices/lab_pin.sym} 146980 -26710 0 0 {name=p146044 lab=_73474_/X }
C {devices/lab_pin.sym} 146980 -26670 0 0 {name=p146045 lab=_72949_/X }
C {devices/lab_pin.sym} 147140 -26710 0 1 {name=p146046 lab=_73478_/A }
C {sky130_stdcells/a21o_4.sym} 147060 -26710 0 0 {name=X_73475_ }
C {devices/lab_pin.sym} 146980 -26590 0 0 {name=p146047 lab=_70664_/A }
C {devices/lab_pin.sym} 146980 -26550 0 0 {name=p146048 lab=_47497_/A }
C {devices/lab_pin.sym} 146980 -26510 0 0 {name=p146049 lab=_70686_/Y }
C {devices/lab_pin.sym} 147140 -26550 0 1 {name=p146050 lab=_70687_/X }
C {sky130_stdcells/a21o_4.sym} 147060 -26550 0 0 {name=X_70687_ }
C {devices/lab_pin.sym} 147000 -26420 0 0 {name=p146051 lab=_78002_/A }
C {devices/lab_pin.sym} 147000 -26380 0 0 {name=p146052 lab=_78001_/Y }
C {devices/lab_pin.sym} 147120 -26400 0 1 {name=p146053 lab=_78003_/A }
C {sky130_stdcells/xor2_4.sym} 147060 -26400 0 0 {name=X_78002_ }
C {devices/lab_pin.sym} 147020 -26270 0 0 {name=p146054 lab=clkbuf_8_0_0_CLK/X }
C {devices/lab_pin.sym} 147100 -26270 0 1 {name=p146055 lab=clkbuf_9_1_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 147060 -26270 0 0 {name=Xclkbuf_9_1_0_CLK }
C {devices/lab_pin.sym} 147000 -26160 0 0 {name=p146056 lab=_81068_/Q }
C {devices/lab_pin.sym} 147000 -26120 0 0 {name=p146057 lab=_75214_/B }
C {devices/lab_pin.sym} 147120 -26140 0 1 {name=p146058 lab=_75233_/B }
C {sky130_stdcells/xnor2_4.sym} 147060 -26140 0 0 {name=X_75214_ }
C {devices/lab_pin.sym} 147020 -26010 0 0 {name=p146059 lab=_41605_/X }
C {devices/lab_pin.sym} 147100 -26010 0 1 {name=p146060 lab=_41606_/X }
C {sky130_stdcells/buf_2.sym} 147060 -26010 0 0 {name=X_41606_ }
C {devices/lab_pin.sym} 147020 -25890 0 0 {name=p146061 lab=_48162_/A }
C {devices/lab_pin.sym} 147100 -25890 0 1 {name=p146062 lab=_48186_/A }
C {sky130_stdcells/buf_2.sym} 147060 -25890 0 0 {name=X_48162_ }
C {devices/lab_pin.sym} 147020 -25770 0 0 {name=p146063 lab=_60440_/A }
C {devices/lab_pin.sym} 147100 -25770 0 1 {name=p146064 lab=_60440_/X }
C {sky130_stdcells/buf_2.sym} 147060 -25770 0 0 {name=X_60440_ }
C {devices/lab_pin.sym} 146980 -25680 0 0 {name=p146065 lab=_83256_/Q }
C {devices/lab_pin.sym} 146980 -25640 0 0 {name=p146066 lab=_72381_/X }
C {devices/lab_pin.sym} 146980 -25600 0 0 {name=p146067 lab=_72418_/X }
C {devices/lab_pin.sym} 146980 -25560 0 0 {name=p146068 lab=_72425_/X }
C {devices/lab_pin.sym} 147140 -25620 0 1 {name=p146069 lab=_72426_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 147060 -25620 0 0 {name=X_72426_ }
C {devices/lab_pin.sym} 146980 -25490 0 0 {name=p146070 lab=_56280_/C }
C {devices/lab_pin.sym} 146980 -25450 0 0 {name=p146071 lab=_44880_/X }
C {devices/lab_pin.sym} 146980 -25410 0 0 {name=p146072 lab=_45373_/X }
C {devices/lab_pin.sym} 147140 -25450 0 1 {name=p146073 lab=_45374_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -25450 0 0 {name=X_45374_ }
C {devices/lab_pin.sym} 146980 -25330 0 0 {name=p146074 lab=_76168_/B }
C {devices/lab_pin.sym} 146980 -25290 0 0 {name=p146075 lab=_76179_/Y }
C {devices/lab_pin.sym} 146980 -25250 0 0 {name=p146076 lab=_76181_/A }
C {devices/lab_pin.sym} 147140 -25290 0 1 {name=p146077 lab=_76194_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -25290 0 0 {name=X_76194_ }
C {devices/lab_pin.sym} 147020 -25150 0 0 {name=p146078 lab=_42585_/Y }
C {devices/lab_pin.sym} 147100 -25150 0 1 {name=p146079 lab=_42586_/Y }
C {sky130_stdcells/inv_2.sym} 147060 -25150 0 0 {name=X_42586_ }
C {devices/lab_pin.sym} 147020 -25030 0 0 {name=p146080 lab=clkbuf_9_29_0_CLK/A }
C {devices/lab_pin.sym} 147100 -25030 0 1 {name=p146081 lab=clkbuf_9_28_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 147060 -25030 0 0 {name=Xclkbuf_9_28_0_CLK }
C {devices/lab_pin.sym} 147000 -24940 0 0 {name=p146082 lab=_47113_/A }
C {devices/lab_pin.sym} 147000 -24900 0 0 {name=p146083 lab=_47082_/X }
C {devices/lab_pin.sym} 147000 -24860 0 0 {name=p146084 lab=_47091_/X }
C {devices/lab_pin.sym} 147000 -24820 0 0 {name=p146085 lab=_52861_/D }
C {devices/lab_pin.sym} 147120 -24880 0 1 {name=p146086 lab=_47113_/X }
C {sky130_stdcells/and4_4.sym} 147060 -24880 0 0 {name=X_47113_ }
C {devices/lab_pin.sym} 146980 -24760 0 0 {name=p146087 lab=_41647_/X }
C {devices/lab_pin.sym} 146980 -24720 0 0 {name=p146088 lab=_40543_/X }
C {devices/lab_pin.sym} 146980 -24680 0 0 {name=p146089 lab=_87164_/Q }
C {devices/lab_pin.sym} 146980 -24640 0 0 {name=p146090 lab=_40544_/X }
C {devices/lab_pin.sym} 147140 -24700 0 1 {name=p146091 lab=_87164_/D }
C {sky130_stdcells/a2bb2o_4.sym} 147060 -24700 0 0 {name=X_44325_ }
C {devices/lab_pin.sym} 147000 -24570 0 0 {name=p146092 lab=_75143_/Y }
C {devices/lab_pin.sym} 147000 -24530 0 0 {name=p146093 lab=_75141_/X }
C {devices/lab_pin.sym} 147000 -24490 0 0 {name=p146094 lab=_75145_/C }
C {devices/lab_pin.sym} 147120 -24530 0 1 {name=p146095 lab=_75145_/Y }
C {sky130_stdcells/nand3_4.sym} 147060 -24530 0 0 {name=X_75145_ }
C {devices/lab_pin.sym} 147020 -24390 0 0 {name=p146096 lab=_41235_/X }
C {devices/lab_pin.sym} 147100 -24390 0 1 {name=p146097 lab=_41537_/X }
C {sky130_stdcells/buf_2.sym} 147060 -24390 0 0 {name=X_41537_ }
C {devices/lab_pin.sym} 147020 -24270 0 0 {name=p146098 lab=_72357_/A }
C {devices/lab_pin.sym} 147100 -24270 0 1 {name=p146099 lab=_72357_/Y }
C {sky130_stdcells/inv_2.sym} 147060 -24270 0 0 {name=X_72357_ }
C {devices/lab_pin.sym} 146980 -24170 0 0 {name=p146100 lab=_86568_/Q }
C {devices/lab_pin.sym} 146980 -24130 0 0 {name=p146101 lab=_48049_/X }
C {devices/lab_pin.sym} 146980 -24090 0 0 {name=p146102 lab=_48092_/Y }
C {devices/lab_pin.sym} 147140 -24130 0 1 {name=p146103 lab=_48093_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -24130 0 0 {name=X_48093_ }
C {devices/lab_pin.sym} 147020 -23990 0 0 {name=p146104 lab=_60371_/A }
C {devices/lab_pin.sym} 147100 -23990 0 1 {name=p146105 lab=_60371_/X }
C {sky130_stdcells/buf_2.sym} 147060 -23990 0 0 {name=X_60371_ }
C {devices/lab_pin.sym} 147000 -23900 0 0 {name=p146106 lab=_61629_/B }
C {devices/lab_pin.sym} 147000 -23860 0 0 {name=p146107 lab=_62007_/X }
C {devices/lab_pin.sym} 147000 -23820 0 0 {name=p146108 lab=_62149_/C }
C {devices/lab_pin.sym} 147000 -23780 0 0 {name=p146109 lab=_62008_/X }
C {devices/lab_pin.sym} 147120 -23840 0 1 {name=p146110 lab=_62110_/Y }
C {sky130_stdcells/nand4_4.sym} 147060 -23840 0 0 {name=X_62110_ }
C {devices/lab_pin.sym} 146980 -23710 0 0 {name=p146111 lab=_86676_/Q }
C {devices/lab_pin.sym} 146980 -23670 0 0 {name=p146112 lab=_47004_/X }
C {devices/lab_pin.sym} 146980 -23630 0 0 {name=p146113 lab=_47043_/Y }
C {devices/lab_pin.sym} 147140 -23670 0 1 {name=p146114 lab=_47044_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -23670 0 0 {name=X_47044_ }
C {devices/lab_pin.sym} 147020 -23530 0 0 {name=p146115 lab=_71308_/A }
C {devices/lab_pin.sym} 147100 -23530 0 1 {name=p146116 lab=_71500_/A }
C {sky130_stdcells/buf_2.sym} 147060 -23530 0 0 {name=X_71308_ }
C {devices/lab_pin.sym} 147000 -23420 0 0 {name=p146117 lab=_44256_/A }
C {devices/lab_pin.sym} 147000 -23380 0 0 {name=p146118 lab=_44255_/X }
C {devices/lab_pin.sym} 147120 -23400 0 1 {name=p146119 lab=_87177_/D }
C {sky130_stdcells/nor2_4.sym} 147060 -23400 0 0 {name=X_44256_ }
C {devices/lab_pin.sym} 146980 -23310 0 0 {name=p146120 lab=_63084_/Y }
C {devices/lab_pin.sym} 146980 -23270 0 0 {name=p146121 lab=_63085_/X }
C {devices/lab_pin.sym} 146980 -23230 0 0 {name=p146122 lab=_63088_/X }
C {devices/lab_pin.sym} 146980 -23190 0 0 {name=p146123 lab=_63089_/X }
C {devices/lab_pin.sym} 146980 -23150 0 0 {name=p146124 lab=_63067_/X }
C {devices/lab_pin.sym} 147140 -23230 0 1 {name=p146125 lab=_63090_/Y }
C {sky130_stdcells/o41ai_4.sym} 147060 -23230 0 0 {name=X_63090_ }
C {devices/lab_pin.sym} 147000 -23090 0 0 {name=p146126 lab=_75072_/Y }
C {devices/lab_pin.sym} 147000 -23050 0 0 {name=p146127 lab=_75076_/B }
C {devices/lab_pin.sym} 147000 -23010 0 0 {name=p146128 lab=_75074_/B }
C {devices/lab_pin.sym} 147120 -23050 0 1 {name=p146129 lab=_75076_/Y }
C {sky130_stdcells/nand3_4.sym} 147060 -23050 0 0 {name=X_75076_ }
C {devices/lab_pin.sym} 147020 -22910 0 0 {name=p146130 lab=_79952_/X }
C {devices/lab_pin.sym} 147100 -22910 0 1 {name=p146131 lab=_79957_/B }
C {sky130_stdcells/buf_2.sym} 147060 -22910 0 0 {name=X_79953_ }
C {devices/lab_pin.sym} 146980 -22810 0 0 {name=p146132 lab=_41449_/X }
C {devices/lab_pin.sym} 146980 -22770 0 0 {name=p146133 lab=_82335_/Q }
C {devices/lab_pin.sym} 146980 -22730 0 0 {name=p146134 lab=_41467_/X }
C {devices/lab_pin.sym} 147140 -22770 0 1 {name=p146135 lab=_41468_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -22770 0 0 {name=X_41468_ }
C {devices/lab_pin.sym} 146980 -22650 0 0 {name=p146136 lab=_72287_/X }
C {devices/lab_pin.sym} 146980 -22610 0 0 {name=p146137 lab=_85331_/Q }
C {devices/lab_pin.sym} 146980 -22570 0 0 {name=p146138 lab=_72225_/X }
C {devices/lab_pin.sym} 147140 -22610 0 1 {name=p146139 lab=_72288_/X }
C {sky130_stdcells/o21a_4.sym} 147060 -22610 0 0 {name=X_72288_ }
C {devices/lab_pin.sym} 147020 -22470 0 0 {name=p146140 lab=_43167_/A }
C {devices/lab_pin.sym} 147100 -22470 0 1 {name=p146141 lab=_43207_/X }
C {sky130_stdcells/buf_2.sym} 147060 -22470 0 0 {name=X_43207_ }
C {devices/lab_pin.sym} 147020 -22350 0 0 {name=p146142 lab=_61966_/A }
C {devices/lab_pin.sym} 147100 -22350 0 1 {name=p146143 lab=_62149_/C }
C {sky130_stdcells/buf_2.sym} 147060 -22350 0 0 {name=X_62041_ }
C {devices/lab_pin.sym} 147000 -22240 0 0 {name=p146144 lab=_78902_/Y }
C {devices/lab_pin.sym} 147000 -22200 0 0 {name=p146145 lab=_78903_/Y }
C {devices/lab_pin.sym} 147120 -22220 0 1 {name=p146146 lab=_78908_/A }
C {sky130_stdcells/xor2_4.sym} 147060 -22220 0 0 {name=X_78904_ }
C {devices/lab_pin.sym} 146980 -22110 0 0 {name=p146147 lab=_74028_/B }
C {devices/lab_pin.sym} 146980 -22070 0 0 {name=p146148 lab=_74028_/C }
C {devices/lab_pin.sym} 146980 -22030 0 0 {name=p146149 lab=_74026_/X }
C {devices/lab_pin.sym} 147140 -22070 0 1 {name=p146150 lab=_74027_/X }
C {sky130_stdcells/a21o_4.sym} 147060 -22070 0 0 {name=X_74027_ }
C {devices/lab_pin.sym} 146980 -21960 0 0 {name=p146151 lab=_40418_/X }
C {devices/lab_pin.sym} 146980 -21920 0 0 {name=p146152 lab=_40410_/X }
C {devices/lab_pin.sym} 146980 -21880 0 0 {name=p146153 lab=_88394_/Q }
C {devices/lab_pin.sym} 146980 -21840 0 0 {name=p146154 lab=_40411_/X }
C {devices/lab_pin.sym} 147140 -21900 0 1 {name=p146155 lab=_88394_/D }
C {sky130_stdcells/a2bb2o_4.sym} 147060 -21900 0 0 {name=X_40419_ }
C {devices/lab_pin.sym} 147020 -21750 0 0 {name=p146156 lab=_71239_/A }
C {devices/lab_pin.sym} 147100 -21750 0 1 {name=p146157 lab=_71239_/X }
C {sky130_stdcells/buf_2.sym} 147060 -21750 0 0 {name=X_71239_ }
C {devices/lab_pin.sym} 147020 -21630 0 0 {name=p146158 lab=_44187_/A }
C {devices/lab_pin.sym} 147100 -21630 0 1 {name=p146159 lab=_72720_/A }
C {sky130_stdcells/buf_2.sym} 147060 -21630 0 0 {name=X_44187_ }
C {devices/lab_pin.sym} 147000 -21520 0 0 {name=p146160 lab=_84233_/Q }
C {devices/lab_pin.sym} 147000 -21480 0 0 {name=p146161 lab=_83281_/Q }
C {devices/lab_pin.sym} 147120 -21500 0 1 {name=p146162 lab=_79887_/A }
C {sky130_stdcells/xor2_4.sym} 147060 -21500 0 0 {name=X_79884_ }
C {devices/lab_pin.sym} 147020 -21370 0 0 {name=p146163 lab=_41336_/X }
C {devices/lab_pin.sym} 147100 -21370 0 1 {name=p146164 lab=_41399_/X }
C {sky130_stdcells/buf_2.sym} 147060 -21370 0 0 {name=X_41399_ }
C {devices/lab_pin.sym} 146980 -21290 0 0 {name=p146165 lab=_43129_/X }
C {devices/lab_pin.sym} 146980 -21250 0 0 {name=p146166 lab=_43130_/X }
C {devices/lab_pin.sym} 146980 -21210 0 0 {name=p146167 lab=_40810_/X }
C {devices/lab_pin.sym} 146980 -21170 0 0 {name=p146168 lab=_43137_/Y }
C {devices/lab_pin.sym} 146980 -21130 0 0 {name=p146169 lab=_43127_/X }
C {devices/lab_pin.sym} 147140 -21210 0 1 {name=p146170 lab=_87562_/D }
C {sky130_stdcells/o32ai_4.sym} 147060 -21210 0 0 {name=X_43138_ }
C {devices/lab_pin.sym} 147020 -21050 0 0 {name=p146171 lab=_78828_/Y }
C {devices/lab_pin.sym} 147100 -21050 0 1 {name=p146172 lab=_78835_/Y }
C {sky130_stdcells/inv_2.sym} 147060 -21050 0 0 {name=X_78835_ }
C {devices/lab_pin.sym} 147020 -20930 0 0 {name=p146173 lab=_48995_/A }
C {devices/lab_pin.sym} 147100 -20930 0 1 {name=p146174 lab=_49022_/A }
C {sky130_stdcells/buf_2.sym} 147060 -20930 0 0 {name=X_48995_ }
C {devices/lab_pin.sym} 146980 -20830 0 0 {name=p146175 lab=_65789_/X }
C {devices/lab_pin.sym} 146980 -20790 0 0 {name=p146176 lab=_65233_/Y }
C {devices/lab_pin.sym} 146980 -20750 0 0 {name=p146177 lab=_65799_/Y }
C {devices/lab_pin.sym} 147140 -20790 0 1 {name=p146178 lab=_65800_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -20790 0 0 {name=X_65800_ }
C {devices/lab_pin.sym} 147000 -20660 0 0 {name=p146179 lab=_47946_/A }
C {devices/lab_pin.sym} 147000 -20620 0 0 {name=p146180 lab=_48234_/A }
C {devices/lab_pin.sym} 147120 -20640 0 1 {name=p146181 lab=_47946_/X }
C {sky130_stdcells/and2_4.sym} 147060 -20640 0 0 {name=X_47946_ }
C {devices/lab_pin.sym} 146980 -20550 0 0 {name=p146182 lab=_43053_/X }
C {devices/lab_pin.sym} 146980 -20510 0 0 {name=p146183 lab=_43054_/X }
C {devices/lab_pin.sym} 146980 -20470 0 0 {name=p146184 lab=_40673_/X }
C {devices/lab_pin.sym} 146980 -20430 0 0 {name=p146185 lab=_43068_/Y }
C {devices/lab_pin.sym} 146980 -20390 0 0 {name=p146186 lab=_43058_/X }
C {devices/lab_pin.sym} 147140 -20470 0 1 {name=p146187 lab=_43069_/Y }
C {sky130_stdcells/o32ai_4.sym} 147060 -20470 0 0 {name=X_43069_ }
C {devices/lab_pin.sym} 146980 -20340 0 0 {name=p146188 lab=_66757_/X }
C {devices/lab_pin.sym} 146980 -20300 0 0 {name=p146189 lab=_66771_/Y }
C {devices/lab_pin.sym} 146980 -20260 0 0 {name=p146190 lab=_66672_/X }
C {devices/lab_pin.sym} 146980 -20220 0 0 {name=p146191 lab=_66779_/Y }
C {devices/lab_pin.sym} 147140 -20280 0 1 {name=p146192 lab=_66780_/X }
C {sky130_stdcells/a211o_4.sym} 147060 -20280 0 0 {name=X_66780_ }
C {devices/lab_pin.sym} 146980 -20150 0 0 {name=p146193 lab=_78764_/Y }
C {devices/lab_pin.sym} 146980 -20110 0 0 {name=p146194 lab=_78765_/Y }
C {devices/lab_pin.sym} 146980 -20070 0 0 {name=p146195 lab=_78767_/B }
C {devices/lab_pin.sym} 147140 -20110 0 1 {name=p146196 lab=_78769_/A }
C {sky130_stdcells/a21oi_4.sym} 147060 -20110 0 0 {name=X_78766_ }
C {devices/lab_pin.sym} 147000 -19990 0 0 {name=p146197 lab=_64053_/A }
C {devices/lab_pin.sym} 147000 -19950 0 0 {name=p146198 lab=_59421_/A }
C {devices/lab_pin.sym} 147000 -19910 0 0 {name=p146199 lab=_63958_/C }
C {devices/lab_pin.sym} 147120 -19950 0 1 {name=p146200 lab=_63992_/X }
C {sky130_stdcells/and3_4.sym} 147060 -19950 0 0 {name=X_63992_ }
C {devices/lab_pin.sym} 146980 -19830 0 0 {name=p146201 lab=_75976_/A }
C {devices/lab_pin.sym} 146980 -19790 0 0 {name=p146202 lab=_75976_/B }
C {devices/lab_pin.sym} 146980 -19750 0 0 {name=p146203 lab=_75977_/Y }
C {devices/lab_pin.sym} 147140 -19790 0 1 {name=p146204 lab=_75978_/Y }
C {sky130_stdcells/a21oi_4.sym} 147060 -19790 0 0 {name=X_75978_ }
C {devices/lab_pin.sym} 147000 -19660 0 0 {name=p146205 lab=_65731_/A }
C {devices/lab_pin.sym} 147000 -19620 0 0 {name=p146206 lab=_85869_/Q }
C {devices/lab_pin.sym} 147120 -19640 0 1 {name=p146207 lab=_65731_/X }
C {sky130_stdcells/and2_4.sym} 147060 -19640 0 0 {name=X_65731_ }
C {devices/lab_pin.sym} 147020 -19510 0 0 {name=p146208 lab=_77717_/A }
C {devices/lab_pin.sym} 147100 -19510 0 1 {name=p146209 lab=_77718_/B }
C {sky130_stdcells/inv_2.sym} 147060 -19510 0 0 {name=X_77717_ }
C {devices/lab_pin.sym} 147000 -19410 0 0 {name=p146210 lab=_62930_/A }
C {devices/lab_pin.sym} 147000 -19370 0 0 {name=p146211 lab=_62930_/B }
C {devices/lab_pin.sym} 147000 -19330 0 0 {name=p146212 lab=_62943_/C }
C {devices/lab_pin.sym} 147120 -19370 0 1 {name=p146213 lab=_62943_/Y }
C {sky130_stdcells/nor3_4.sym} 147060 -19370 0 0 {name=X_62943_ }
C {devices/lab_pin.sym} 147000 -19250 0 0 {name=p146214 lab=_74912_/X }
C {devices/lab_pin.sym} 147000 -19210 0 0 {name=p146215 lab=_74923_/A }
C {devices/lab_pin.sym} 147000 -19170 0 0 {name=p146216 lab=_74923_/B }
C {devices/lab_pin.sym} 147120 -19210 0 1 {name=p146217 lab=_74929_/X }
C {sky130_stdcells/and3_4.sym} 147060 -19210 0 0 {name=X_74929_ }
C {devices/lab_pin.sym} 147020 -19070 0 0 {name=p146218 lab=_47877_/A }
C {devices/lab_pin.sym} 147100 -19070 0 1 {name=p146219 lab=_53697_/C }
C {sky130_stdcells/buf_2.sym} 147060 -19070 0 0 {name=X_47877_ }
C {devices/lab_pin.sym} 146980 -18970 0 0 {name=p146220 lab=_78693_/X }
C {devices/lab_pin.sym} 146980 -18930 0 0 {name=p146221 lab=_78694_/Y }
C {devices/lab_pin.sym} 146980 -18890 0 0 {name=p146222 lab=_78696_/Y }
C {devices/lab_pin.sym} 147140 -18930 0 1 {name=p146223 lab=_78697_/X }
C {sky130_stdcells/a21o_4.sym} 147060 -18930 0 0 {name=X_78697_ }
C {devices/lab_pin.sym} 146980 -18810 0 0 {name=p146224 lab=_49613_/Y }
C {devices/lab_pin.sym} 146980 -18770 0 0 {name=p146225 lab=_49596_/X }
C {devices/lab_pin.sym} 146980 -18730 0 0 {name=p146226 lab=_49615_/X }
C {devices/lab_pin.sym} 147140 -18770 0 1 {name=p146227 lab=_49616_/Y }
C {sky130_stdcells/a21oi_4.sym} 147060 -18770 0 0 {name=X_49616_ }
C {devices/lab_pin.sym} 147020 -18630 0 0 {name=p146228 lab=_68450_/A }
C {devices/lab_pin.sym} 147100 -18630 0 1 {name=p146229 lab=_68450_/X }
C {sky130_stdcells/buf_2.sym} 147060 -18630 0 0 {name=X_68450_ }
C {devices/lab_pin.sym} 147020 -18510 0 0 {name=p146230 lab=_82955_/Q }
C {devices/lab_pin.sym} 147100 -18510 0 1 {name=p146231 lab=_46828_/Y }
C {sky130_stdcells/inv_2.sym} 147060 -18510 0 0 {name=X_46828_ }
C {devices/lab_pin.sym} 146980 -18420 0 0 {name=p146232 lab=_65660_/X }
C {devices/lab_pin.sym} 146980 -18380 0 0 {name=p146233 lab=_83066_/Q }
C {devices/lab_pin.sym} 146980 -18340 0 0 {name=p146234 lab=_65568_/X }
C {devices/lab_pin.sym} 146980 -18300 0 0 {name=p146235 lab=_65661_/X }
C {devices/lab_pin.sym} 147140 -18360 0 1 {name=p146236 lab=_65662_/X }
C {sky130_stdcells/a211o_4.sym} 147060 -18360 0 0 {name=X_65662_ }
C {devices/lab_pin.sym} 147000 -18230 0 0 {name=p146237 lab=_77648_/A }
C {devices/lab_pin.sym} 147000 -18190 0 0 {name=p146238 lab=_81949_/Q }
C {devices/lab_pin.sym} 147000 -18150 0 0 {name=p146239 lab=_77648_/C }
C {devices/lab_pin.sym} 147120 -18190 0 1 {name=p146240 lab=_77648_/Y }
C {sky130_stdcells/nand3_4.sym} 147060 -18190 0 0 {name=X_77648_ }
C {devices/lab_pin.sym} 146980 -18070 0 0 {name=p146241 lab=_62872_/X }
C {devices/lab_pin.sym} 146980 -18030 0 0 {name=p146242 lab=_62838_/X }
C {devices/lab_pin.sym} 146980 -17990 0 0 {name=p146243 lab=_62873_/Y }
C {devices/lab_pin.sym} 147140 -18030 0 1 {name=p146244 lab=_84375_/D }
C {sky130_stdcells/a21oi_4.sym} 147060 -18030 0 0 {name=X_62874_ }
C {devices/lab_pin.sym} 147020 -17890 0 0 {name=p146245 lab=_67014_/X }
C {devices/lab_pin.sym} 147100 -17890 0 1 {name=p146246 lab=_67401_/X }
C {sky130_stdcells/buf_2.sym} 147060 -17890 0 0 {name=X_67401_ }
C {devices/lab_pin.sym} 147020 -17770 0 0 {name=p146247 lab=_45924_/A }
C {devices/lab_pin.sym} 147100 -17770 0 1 {name=p146248 lab=_65117_/A }
C {sky130_stdcells/buf_2.sym} 147060 -17770 0 0 {name=X_64613_ }
C {devices/lab_pin.sym} 146980 -17670 0 0 {name=p146249 lab=_86367_/Q }
C {devices/lab_pin.sym} 146980 -17630 0 0 {name=p146250 lab=_49524_/X }
C {devices/lab_pin.sym} 146980 -17590 0 0 {name=p146251 lab=_49546_/Y }
C {devices/lab_pin.sym} 147140 -17630 0 1 {name=p146252 lab=_49547_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -17630 0 0 {name=X_49547_ }
C {devices/lab_pin.sym} 147020 -17490 0 0 {name=p146253 lab=_59684_/X }
C {devices/lab_pin.sym} 147100 -17490 0 1 {name=p146254 lab=_61839_/B }
C {sky130_stdcells/buf_2.sym} 147060 -17490 0 0 {name=X_61825_ }
C {devices/lab_pin.sym} 147000 -17380 0 0 {name=p146255 lab=_44149_/A }
C {devices/lab_pin.sym} 147000 -17340 0 0 {name=p146256 lab=_68380_/Y }
C {devices/lab_pin.sym} 147120 -17360 0 1 {name=p146257 lab=_68381_/Y }
C {sky130_stdcells/nor2_4.sym} 147060 -17360 0 0 {name=X_68381_ }
C {devices/lab_pin.sym} 147000 -17240 0 0 {name=p146258 lab=_46733_/A }
C {devices/lab_pin.sym} 147000 -17200 0 0 {name=p146259 lab=_46758_/X }
C {devices/lab_pin.sym} 147120 -17220 0 1 {name=p146260 lab=_46759_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -17220 0 0 {name=X_46759_ }
C {devices/lab_pin.sym} 146980 -17120 0 0 {name=p146261 lab=_65453_/X }
C {devices/lab_pin.sym} 146980 -17080 0 0 {name=p146262 lab=_85590_/Q }
C {devices/lab_pin.sym} 146980 -17040 0 0 {name=p146263 lab=_65470_/X }
C {devices/lab_pin.sym} 146980 -17000 0 0 {name=p146264 lab=_65592_/X }
C {devices/lab_pin.sym} 147140 -17060 0 1 {name=p146265 lab=_65593_/X }
C {sky130_stdcells/a211o_4.sym} 147060 -17060 0 0 {name=X_65593_ }
C {devices/lab_pin.sym} 147000 -16920 0 0 {name=p146266 lab=_81945_/Q }
C {devices/lab_pin.sym} 147000 -16880 0 0 {name=p146267 lab=_82201_/D }
C {devices/lab_pin.sym} 147120 -16900 0 1 {name=p146268 lab=_81913_/D }
C {sky130_stdcells/xor2_4.sym} 147060 -16900 0 0 {name=X_77579_ }
C {devices/lab_pin.sym} 147020 -16770 0 0 {name=p146269 lab=_67093_/X }
C {devices/lab_pin.sym} 147100 -16770 0 1 {name=p146270 lab=_67333_/A }
C {sky130_stdcells/buf_2.sym} 147060 -16770 0 0 {name=X_67332_ }
C {devices/lab_pin.sym} 147000 -16660 0 0 {name=p146271 lab=_84798_/Q }
C {devices/lab_pin.sym} 147000 -16620 0 0 {name=p146272 lab=_84118_/Q }
C {devices/lab_pin.sym} 147120 -16640 0 1 {name=p146273 lab=_79318_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -16640 0 0 {name=X_79318_ }
C {devices/lab_pin.sym} 147000 -16540 0 0 {name=p146274 lab=_64234_/A }
C {devices/lab_pin.sym} 147000 -16500 0 0 {name=p146275 lab=_64234_/B }
C {devices/lab_pin.sym} 147000 -16460 0 0 {name=p146276 lab=_64544_/C }
C {devices/lab_pin.sym} 147000 -16420 0 0 {name=p146277 lab=_64221_/X }
C {devices/lab_pin.sym} 147120 -16480 0 1 {name=p146278 lab=_64544_/X }
C {sky130_stdcells/and4_4.sym} 147060 -16480 0 0 {name=X_64544_ }
C {devices/lab_pin.sym} 147020 -16330 0 0 {name=p146279 lab=_49451_/A }
C {devices/lab_pin.sym} 147100 -16330 0 1 {name=p146280 lab=_49500_/B }
C {sky130_stdcells/buf_2.sym} 147060 -16330 0 0 {name=X_49478_ }
C {devices/lab_pin.sym} 147000 -16220 0 0 {name=p146281 lab=_80608_/A }
C {devices/lab_pin.sym} 147000 -16180 0 0 {name=p146282 lab=_80608_/B }
C {devices/lab_pin.sym} 147120 -16200 0 1 {name=p146283 lab=_80617_/A }
C {sky130_stdcells/xor2_4.sym} 147060 -16200 0 0 {name=X_80590_ }
C {devices/lab_pin.sym} 147020 -16070 0 0 {name=p146284 lab=_61755_/X }
C {devices/lab_pin.sym} 147100 -16070 0 1 {name=p146285 lab=_61756_/X }
C {sky130_stdcells/buf_2.sym} 147060 -16070 0 0 {name=X_61756_ }
C {devices/lab_pin.sym} 147020 -15950 0 0 {name=p146286 lab=_74396_/A }
C {devices/lab_pin.sym} 147100 -15950 0 1 {name=p146287 lab=_48744_/A }
C {sky130_stdcells/buf_2.sym} 147060 -15950 0 0 {name=X_48429_ }
C {devices/lab_pin.sym} 147020 -15830 0 0 {name=p146288 lab=_60359_/A }
C {devices/lab_pin.sym} 147100 -15830 0 1 {name=p146289 lab=_60707_/X }
C {sky130_stdcells/buf_2.sym} 147060 -15830 0 0 {name=X_60707_ }
C {devices/lab_pin.sym} 146980 -15740 0 0 {name=p146290 lab=_87350_/Q }
C {devices/lab_pin.sym} 146980 -15700 0 0 {name=p146291 lab=_67239_/X }
C {devices/lab_pin.sym} 146980 -15660 0 0 {name=p146292 lab=_67240_/X }
C {devices/lab_pin.sym} 146980 -15620 0 0 {name=p146293 lab=_67262_/X }
C {devices/lab_pin.sym} 147140 -15680 0 1 {name=p146294 lab=_67263_/X }
C {sky130_stdcells/a211o_4.sym} 147060 -15680 0 0 {name=X_67263_ }
C {devices/lab_pin.sym} 147000 -15540 0 0 {name=p146295 lab=_79247_/X }
C {devices/lab_pin.sym} 147000 -15500 0 0 {name=p146296 lab=_79248_/Y }
C {devices/lab_pin.sym} 147120 -15520 0 1 {name=p146297 lab=_79250_/A }
C {sky130_stdcells/and2_4.sym} 147060 -15520 0 0 {name=X_79249_ }
C {devices/lab_pin.sym} 147000 -15410 0 0 {name=p146298 lab=_64474_/X }
C {devices/lab_pin.sym} 147000 -15370 0 0 {name=p146299 lab=_61169_/X }
C {devices/lab_pin.sym} 147000 -15330 0 0 {name=p146300 lab=_84834_/Q }
C {devices/lab_pin.sym} 147120 -15370 0 1 {name=p146301 lab=_64475_/Y }
C {sky130_stdcells/nand3_4.sym} 147060 -15370 0 0 {name=X_64475_ }
C {devices/lab_pin.sym} 147000 -15260 0 0 {name=p146302 lab=_58370_/A }
C {devices/lab_pin.sym} 147000 -15220 0 0 {name=p146303 lab=_72555_/B }
C {devices/lab_pin.sym} 147000 -15180 0 0 {name=p146304 lab=_61317_/X }
C {devices/lab_pin.sym} 147000 -15140 0 0 {name=p146305 lab=_72563_/B }
C {devices/lab_pin.sym} 147120 -15200 0 1 {name=p146306 lab=_61688_/A }
C {sky130_stdcells/nand4_4.sym} 147060 -15200 0 0 {name=X_61687_ }
C {devices/lab_pin.sym} 146980 -15080 0 0 {name=p146307 lab=_88089_/Q }
C {devices/lab_pin.sym} 146980 -15040 0 0 {name=p146308 lab=_68384_/X }
C {devices/lab_pin.sym} 146980 -15000 0 0 {name=p146309 lab=_68745_/X }
C {devices/lab_pin.sym} 146980 -14960 0 0 {name=p146310 lab=_69001_/Y }
C {devices/lab_pin.sym} 147140 -15020 0 1 {name=p146311 lab=_69002_/X }
C {sky130_stdcells/a211o_4.sym} 147060 -15020 0 0 {name=X_69002_ }
C {devices/lab_pin.sym} 147000 -14880 0 0 {name=p146312 lab=_66011_/X }
C {devices/lab_pin.sym} 147000 -14840 0 0 {name=p146313 lab=_66214_/B }
C {devices/lab_pin.sym} 147120 -14860 0 1 {name=p146314 lab=_66214_/X }
C {sky130_stdcells/and2_4.sym} 147060 -14860 0 0 {name=X_66214_ }
C {devices/lab_pin.sym} 147000 -14740 0 0 {name=p146315 lab=_51430_/X }
C {devices/lab_pin.sym} 147000 -14700 0 0 {name=p146316 lab=_52969_/B }
C {devices/lab_pin.sym} 147120 -14720 0 1 {name=p146317 lab=_51440_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -14720 0 0 {name=X_51440_ }
C {devices/lab_pin.sym} 147020 -14590 0 0 {name=p146318 lab=_63426_/A }
C {devices/lab_pin.sym} 147100 -14590 0 1 {name=p146319 lab=_63426_/X }
C {sky130_stdcells/buf_2.sym} 147060 -14590 0 0 {name=X_63426_ }
C {devices/lab_pin.sym} 146970 -14470 0 0 {name=p146320 lab=_82463_/CLK }
C {devices/lab_pin.sym} 146970 -14450 0 0 {name=p146321 lab=_80493_/X }
C {devices/lab_pin.sym} 147150 -14470 0 1 {name=p146322 lab=_82260_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -14460 0 0 {name=X_82260_ }
C {devices/lab_pin.sym} 147000 -14350 0 0 {name=p146323 lab=_61286_/A }
C {devices/lab_pin.sym} 147000 -14310 0 0 {name=p146324 lab=_60616_/B }
C {devices/lab_pin.sym} 147000 -14270 0 0 {name=p146325 lab=_60509_/Y }
C {devices/lab_pin.sym} 147120 -14310 0 1 {name=p146326 lab=_60638_/Y }
C {sky130_stdcells/nor3_4.sym} 147060 -14310 0 0 {name=X_60638_ }
C {devices/lab_pin.sym} 147020 -14170 0 0 {name=p146327 lab=_66717_/A }
C {devices/lab_pin.sym} 147100 -14170 0 1 {name=p146328 lab=_67194_/X }
C {sky130_stdcells/buf_2.sym} 147060 -14170 0 0 {name=X_67194_ }
C {devices/lab_pin.sym} 146970 -14050 0 0 {name=p146329 lab=_81211_/CLK }
C {devices/lab_pin.sym} 146970 -14030 0 0 {name=p146330 lab=_74849_/X }
C {devices/lab_pin.sym} 147150 -14050 0 1 {name=p146331 lab=_48947_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -14040 0 0 {name=X_81211_ }
C {devices/lab_pin.sym} 146980 -13930 0 0 {name=p146332 lab=_66142_/X }
C {devices/lab_pin.sym} 146980 -13890 0 0 {name=p146333 lab=_66144_/X }
C {devices/lab_pin.sym} 146980 -13850 0 0 {name=p146334 lab=_65937_/X }
C {devices/lab_pin.sym} 147140 -13890 0 1 {name=p146335 lab=_66145_/X }
C {sky130_stdcells/a21o_4.sym} 147060 -13890 0 0 {name=X_66145_ }
C {devices/lab_pin.sym} 146980 -13770 0 0 {name=p146336 lab=_65275_/B }
C {devices/lab_pin.sym} 146980 -13730 0 0 {name=p146337 lab=_51362_/X }
C {devices/lab_pin.sym} 146980 -13690 0 0 {name=p146338 lab=_51370_/Y }
C {devices/lab_pin.sym} 147140 -13730 0 1 {name=p146339 lab=_51371_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -13730 0 0 {name=X_51371_ }
C {devices/lab_pin.sym} 147020 -13590 0 0 {name=p146340 lab=_63356_/X }
C {devices/lab_pin.sym} 147100 -13590 0 1 {name=p146341 lab=_63357_/X }
C {sky130_stdcells/buf_2.sym} 147060 -13590 0 0 {name=X_63357_ }
C {devices/lab_pin.sym} 146970 -13470 0 0 {name=p146342 lab=_84945_/CLK }
C {devices/lab_pin.sym} 146970 -13450 0 0 {name=p146343 lab=_82191_/D }
C {devices/lab_pin.sym} 147150 -13470 0 1 {name=p146344 lab=_82191_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -13460 0 0 {name=X_82191_ }
C {devices/lab_pin.sym} 146980 -13370 0 0 {name=p146345 lab=_60435_/C }
C {devices/lab_pin.sym} 146980 -13330 0 0 {name=p146346 lab=_60562_/Y }
C {devices/lab_pin.sym} 146980 -13290 0 0 {name=p146347 lab=_60567_/Y }
C {devices/lab_pin.sym} 146980 -13250 0 0 {name=p146348 lab=_60476_/Y }
C {devices/lab_pin.sym} 146980 -13220 0 0 {name=p146349 lab=_60568_/Y }
C {devices/lab_pin.sym} 147140 -13290 0 1 {name=p146350 lab=_60569_/Y }
C {sky130_stdcells/a41oi_4.sym} 147060 -13290 0 0 {name=X_60569_ }
C {devices/lab_pin.sym} 146980 -13150 0 0 {name=p146351 lab=_85695_/Q }
C {devices/lab_pin.sym} 146980 -13110 0 0 {name=p146352 lab=_53093_/X }
C {devices/lab_pin.sym} 146980 -13070 0 0 {name=p146353 lab=_53109_/Y }
C {devices/lab_pin.sym} 147140 -13110 0 1 {name=p146354 lab=_53110_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -13110 0 0 {name=X_53110_ }
C {devices/lab_pin.sym} 147000 -12980 0 0 {name=p146355 lab=_50356_/A }
C {devices/lab_pin.sym} 147000 -12940 0 0 {name=p146356 lab=_50322_/B }
C {devices/lab_pin.sym} 147120 -12960 0 1 {name=p146357 lab=_50322_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -12960 0 0 {name=X_50322_ }
C {devices/lab_pin.sym} 147000 -12850 0 0 {name=p146358 lab=_62249_/A }
C {devices/lab_pin.sym} 147000 -12810 0 0 {name=p146359 lab=_59501_/X }
C {devices/lab_pin.sym} 147000 -12770 0 0 {name=p146360 lab=_62632_/C }
C {devices/lab_pin.sym} 147120 -12810 0 1 {name=p146361 lab=_62310_/C }
C {sky130_stdcells/nand3_4.sym} 147060 -12810 0 0 {name=X_62308_ }
C {devices/lab_pin.sym} 146970 -12670 0 0 {name=p146362 lab=_86758_/CLK }
C {devices/lab_pin.sym} 146970 -12650 0 0 {name=p146363 lab=_80766_/Q }
C {devices/lab_pin.sym} 147150 -12670 0 1 {name=p146364 lab=_40648_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -12660 0 0 {name=X_81142_ }
C {devices/lab_pin.sym} 146980 -12550 0 0 {name=p146365 lab=_85506_/Q }
C {devices/lab_pin.sym} 146980 -12510 0 0 {name=p146366 lab=_54035_/X }
C {devices/lab_pin.sym} 146980 -12470 0 0 {name=p146367 lab=_54089_/Y }
C {devices/lab_pin.sym} 147140 -12510 0 1 {name=p146368 lab=_54090_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -12510 0 0 {name=X_54090_ }
C {devices/lab_pin.sym} 147000 -12390 0 0 {name=p146369 lab=_66073_/X }
C {devices/lab_pin.sym} 147000 -12350 0 0 {name=p146370 lab=_65967_/B }
C {devices/lab_pin.sym} 147000 -12310 0 0 {name=p146371 lab=_66075_/X }
C {devices/lab_pin.sym} 147120 -12350 0 1 {name=p146372 lab=_66076_/Y }
C {sky130_stdcells/nand3_4.sym} 147060 -12350 0 0 {name=X_66076_ }
C {devices/lab_pin.sym} 147000 -12240 0 0 {name=p146373 lab=_63288_/A }
C {devices/lab_pin.sym} 147000 -12200 0 0 {name=p146374 lab=_64494_/B }
C {devices/lab_pin.sym} 147000 -12160 0 0 {name=p146375 lab=_63312_/C }
C {devices/lab_pin.sym} 147000 -12120 0 0 {name=p146376 lab=_63237_/X }
C {devices/lab_pin.sym} 147120 -12180 0 1 {name=p146377 lab=_63288_/X }
C {sky130_stdcells/and4_4.sym} 147060 -12180 0 0 {name=X_63288_ }
C {devices/lab_pin.sym} 147000 -12040 0 0 {name=p146378 lab=_53040_/X }
C {devices/lab_pin.sym} 147000 -12000 0 0 {name=p146379 lab=_53041_/B }
C {devices/lab_pin.sym} 147120 -12020 0 1 {name=p146380 lab=_53041_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -12020 0 0 {name=X_53041_ }
C {devices/lab_pin.sym} 146980 -11910 0 0 {name=p146381 lab=_65024_/X }
C {devices/lab_pin.sym} 146980 -11870 0 0 {name=p146382 lab=_65026_/X }
C {devices/lab_pin.sym} 146980 -11830 0 0 {name=p146383 lab=_64851_/X }
C {devices/lab_pin.sym} 147140 -11870 0 1 {name=p146384 lab=_65031_/A }
C {sky130_stdcells/a21o_4.sym} 147060 -11870 0 0 {name=X_65027_ }
C {devices/lab_pin.sym} 146980 -11760 0 0 {name=p146385 lab=_69832_/X }
C {devices/lab_pin.sym} 146980 -11720 0 0 {name=p146386 lab=_69902_/Y }
C {devices/lab_pin.sym} 146980 -11680 0 0 {name=p146387 lab=_69870_/X }
C {devices/lab_pin.sym} 146980 -11640 0 0 {name=p146388 lab=_69903_/Y }
C {devices/lab_pin.sym} 147140 -11700 0 1 {name=p146389 lab=_69904_/X }
C {sky130_stdcells/a211o_4.sym} 147060 -11700 0 0 {name=X_69904_ }
C {devices/lab_pin.sym} 146980 -11570 0 0 {name=p146390 lab=_86237_/Q }
C {devices/lab_pin.sym} 146980 -11530 0 0 {name=p146391 lab=_50250_/X }
C {devices/lab_pin.sym} 146980 -11490 0 0 {name=p146392 lab=_50252_/Y }
C {devices/lab_pin.sym} 147140 -11530 0 1 {name=p146393 lab=_50253_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -11530 0 0 {name=X_50253_ }
C {devices/lab_pin.sym} 146980 -11430 0 0 {name=p146394 lab=_61329_/B }
C {devices/lab_pin.sym} 146980 -11390 0 0 {name=p146395 lab=_62628_/C }
C {devices/lab_pin.sym} 146980 -11350 0 0 {name=p146396 lab=_60027_/A }
C {devices/lab_pin.sym} 146980 -11310 0 0 {name=p146397 lab=_60011_/X }
C {devices/lab_pin.sym} 146980 -11280 0 0 {name=p146398 lab=_62238_/X }
C {devices/lab_pin.sym} 147140 -11350 0 1 {name=p146399 lab=_62239_/X }
C {sky130_stdcells/a41o_4.sym} 147060 -11350 0 0 {name=X_62239_ }
C {devices/lab_pin.sym} 146970 -11190 0 0 {name=p146400 lab=_82394_/CLK }
C {devices/lab_pin.sym} 146970 -11170 0 0 {name=p146401 lab=_51769_/Y }
C {devices/lab_pin.sym} 147150 -11190 0 1 {name=p146402 lab=_85950_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -11180 0 0 {name=X_85950_ }
C {devices/lab_pin.sym} 146970 -11050 0 0 {name=p146403 lab=_81070_/CLK }
C {devices/lab_pin.sym} 146970 -11030 0 0 {name=p146404 lab=_81105_/Q }
C {devices/lab_pin.sym} 147150 -11050 0 1 {name=p146405 lab=_75287_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -11040 0 0 {name=X_81073_ }
C {devices/lab_pin.sym} 147000 -10920 0 0 {name=p146406 lab=_84931_/Q }
C {devices/lab_pin.sym} 147000 -10880 0 0 {name=p146407 lab=_84179_/Q }
C {devices/lab_pin.sym} 147120 -10900 0 1 {name=p146408 lab=_80024_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -10900 0 0 {name=X_80024_ }
C {devices/lab_pin.sym} 146970 -10770 0 0 {name=p146409 lab=_84727_/CLK }
C {devices/lab_pin.sym} 146970 -10750 0 0 {name=p146410 lab=_58235_/X }
C {devices/lab_pin.sym} 147150 -10770 0 1 {name=p146411 lab=_58232_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -10760 0 0 {name=X_84901_ }
C {devices/lab_pin.sym} 147000 -10640 0 0 {name=p146412 lab=_69791_/A }
C {devices/lab_pin.sym} 147000 -10600 0 0 {name=p146413 lab=_69835_/B }
C {devices/lab_pin.sym} 147120 -10620 0 1 {name=p146414 lab=_69835_/Y }
C {sky130_stdcells/nor2_4.sym} 147060 -10620 0 0 {name=X_69835_ }
C {devices/lab_pin.sym} 146980 -10510 0 0 {name=p146415 lab=_50182_/Y }
C {devices/lab_pin.sym} 146980 -10470 0 0 {name=p146416 lab=_50166_/X }
C {devices/lab_pin.sym} 146980 -10430 0 0 {name=p146417 lab=_50183_/X }
C {devices/lab_pin.sym} 147140 -10470 0 1 {name=p146418 lab=_50184_/Y }
C {sky130_stdcells/a21oi_4.sym} 147060 -10470 0 0 {name=X_50184_ }
C {devices/lab_pin.sym} 146970 -10330 0 0 {name=p146419 lab=_85879_/CLK }
C {devices/lab_pin.sym} 146970 -10310 0 0 {name=p146420 lab=_85881_/D }
C {devices/lab_pin.sym} 147150 -10330 0 1 {name=p146421 lab=_85881_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -10320 0 0 {name=X_85881_ }
C {devices/lab_pin.sym} 147020 -10190 0 0 {name=p146422 lab=_56808_/A }
C {devices/lab_pin.sym} 147100 -10190 0 1 {name=p146423 lab=_56800_/X }
C {sky130_stdcells/buf_2.sym} 147060 -10190 0 0 {name=X_56800_ }
C {devices/lab_pin.sym} 146970 -10070 0 0 {name=p146424 lab=_88394_/CLK }
C {devices/lab_pin.sym} 146970 -10050 0 0 {name=p146425 lab=_87620_/D }
C {devices/lab_pin.sym} 147150 -10070 0 1 {name=p146426 lab=_87620_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -10060 0 0 {name=X_87620_ }
C {devices/lab_pin.sym} 146970 -9930 0 0 {name=p146427 lab=_84714_/CLK }
C {devices/lab_pin.sym} 146970 -9910 0 0 {name=p146428 lab=_84832_/D }
C {devices/lab_pin.sym} 147150 -9930 0 1 {name=p146429 lab=_84832_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -9920 0 0 {name=X_84832_ }
C {devices/lab_pin.sym} 146980 -9810 0 0 {name=p146430 lab=_57765_/Y }
C {devices/lab_pin.sym} 146980 -9770 0 0 {name=p146431 lab=_57775_/Y }
C {devices/lab_pin.sym} 146980 -9730 0 0 {name=p146432 lab=_57779_/X }
C {devices/lab_pin.sym} 147140 -9770 0 1 {name=p146433 lab=_57780_/X }
C {sky130_stdcells/a21o_4.sym} 147060 -9770 0 0 {name=X_57780_ }
C {devices/lab_pin.sym} 147000 -9640 0 0 {name=p146434 lab=_69766_/A }
C {devices/lab_pin.sym} 147000 -9600 0 0 {name=p146435 lab=_42583_/Y }
C {devices/lab_pin.sym} 147120 -9620 0 1 {name=p146436 lab=_69766_/Y }
C {sky130_stdcells/nor2_4.sym} 147060 -9620 0 0 {name=X_69766_ }
C {devices/lab_pin.sym} 147000 -9520 0 0 {name=p146437 lab=_55013_/A }
C {devices/lab_pin.sym} 147000 -9480 0 0 {name=p146438 lab=_54978_/X }
C {devices/lab_pin.sym} 147000 -9440 0 0 {name=p146439 lab=_54974_/C }
C {devices/lab_pin.sym} 147000 -9400 0 0 {name=p146440 lab=_47586_/A }
C {devices/lab_pin.sym} 147120 -9460 0 1 {name=p146441 lab=_54992_/X }
C {sky130_stdcells/and4_4.sym} 147060 -9460 0 0 {name=X_54992_ }
C {devices/lab_pin.sym} 147000 -9320 0 0 {name=p146442 lab=_66956_/A }
C {devices/lab_pin.sym} 147000 -9280 0 0 {name=p146443 lab=_66978_/B }
C {devices/lab_pin.sym} 147120 -9300 0 1 {name=p146444 lab=_66978_/X }
C {sky130_stdcells/and2_4.sym} 147060 -9300 0 0 {name=X_66978_ }
C {devices/lab_pin.sym} 147020 -9170 0 0 {name=p146445 lab=_57140_/B }
C {devices/lab_pin.sym} 147100 -9170 0 1 {name=p146446 lab=_57023_/A }
C {sky130_stdcells/buf_2.sym} 147060 -9170 0 0 {name=X_56731_ }
C {devices/lab_pin.sym} 146980 -9080 0 0 {name=p146447 lab=_88005_/Q }
C {devices/lab_pin.sym} 146980 -9040 0 0 {name=p146448 lab=_68715_/X }
C {devices/lab_pin.sym} 146980 -9000 0 0 {name=p146449 lab=_68540_/X }
C {devices/lab_pin.sym} 146980 -8960 0 0 {name=p146450 lab=_68716_/X }
C {devices/lab_pin.sym} 147140 -9020 0 1 {name=p146451 lab=_68717_/X }
C {sky130_stdcells/a211o_4.sym} 147060 -9020 0 0 {name=X_68717_ }
C {devices/lab_pin.sym} 146970 -8870 0 0 {name=p146452 lab=_87553_/CLK }
C {devices/lab_pin.sym} 146970 -8850 0 0 {name=p146453 lab=_87551_/D }
C {devices/lab_pin.sym} 147150 -8870 0 1 {name=p146454 lab=_73275_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -8860 0 0 {name=X_87551_ }
C {devices/lab_pin.sym} 146980 -8750 0 0 {name=p146455 lab=_85537_/Q }
C {devices/lab_pin.sym} 146980 -8710 0 0 {name=p146456 lab=_53940_/X }
C {devices/lab_pin.sym} 146980 -8670 0 0 {name=p146457 lab=_53942_/Y }
C {devices/lab_pin.sym} 147140 -8710 0 1 {name=p146458 lab=_53943_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -8710 0 0 {name=X_53943_ }
C {devices/lab_pin.sym} 147020 -8570 0 0 {name=p146459 lab=_65929_/A }
C {devices/lab_pin.sym} 147100 -8570 0 1 {name=p146460 lab=_65970_/B }
C {sky130_stdcells/buf_2.sym} 147060 -8570 0 0 {name=X_65929_ }
C {devices/lab_pin.sym} 146970 -8450 0 0 {name=p146461 lab=_84766_/CLK }
C {devices/lab_pin.sym} 146970 -8430 0 0 {name=p146462 lab=_84763_/D }
C {devices/lab_pin.sym} 147150 -8450 0 1 {name=p146463 lab=_84763_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -8440 0 0 {name=X_84763_ }
C {devices/lab_pin.sym} 146970 -8310 0 0 {name=p146464 lab=_81975_/CLK }
C {devices/lab_pin.sym} 146970 -8290 0 0 {name=p146465 lab=_81975_/D }
C {devices/lab_pin.sym} 147150 -8310 0 1 {name=p146466 lab=_81975_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -8300 0 0 {name=X_81975_ }
C {devices/lab_pin.sym} 147020 -8170 0 0 {name=p146467 lab=_87817_/Q }
C {devices/lab_pin.sym} 147100 -8170 0 1 {name=p146468 lab=_69698_/B }
C {sky130_stdcells/inv_2.sym} 147060 -8170 0 0 {name=X_69697_ }
C {devices/lab_pin.sym} 146970 -8050 0 0 {name=p146469 lab=_86499_/CLK }
C {devices/lab_pin.sym} 146970 -8030 0 0 {name=p146470 lab=_48668_/Y }
C {devices/lab_pin.sym} 147150 -8050 0 1 {name=p146471 lab=_86502_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -8040 0 0 {name=X_86502_ }
C {devices/lab_pin.sym} 146970 -7910 0 0 {name=p146472 lab=_83716_/CLK }
C {devices/lab_pin.sym} 146970 -7890 0 0 {name=p146473 lab=_70728_/Y }
C {devices/lab_pin.sym} 147150 -7910 0 1 {name=p146474 lab=_46983_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -7900 0 0 {name=X_83714_ }
C {devices/lab_pin.sym} 147020 -7770 0 0 {name=p146475 lab=_84729_/Q }
C {devices/lab_pin.sym} 147100 -7770 0 1 {name=p146476 lab=_59450_/Y }
C {sky130_stdcells/inv_2.sym} 147060 -7770 0 0 {name=X_59450_ }
C {devices/lab_pin.sym} 147000 -7680 0 0 {name=p146477 lab=_56661_/Y }
C {devices/lab_pin.sym} 147000 -7640 0 0 {name=p146478 lab=_83328_/Q }
C {devices/lab_pin.sym} 147000 -7600 0 0 {name=p146479 lab=_83327_/Q }
C {devices/lab_pin.sym} 147000 -7560 0 0 {name=p146480 lab=_56682_/A }
C {devices/lab_pin.sym} 147120 -7620 0 1 {name=p146481 lab=_56663_/A }
C {sky130_stdcells/and4_4.sym} 147060 -7620 0 0 {name=X_56662_ }
C {devices/lab_pin.sym} 146970 -7470 0 0 {name=p146482 lab=_81169_/CLK }
C {devices/lab_pin.sym} 146970 -7450 0 0 {name=p146483 lab=_84102_/Q }
C {devices/lab_pin.sym} 147150 -7470 0 1 {name=p146484 lab=_80926_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -7460 0 0 {name=X_80926_ }
C {devices/lab_pin.sym} 147020 -7330 0 0 {name=p146485 lab=_67388_/X }
C {devices/lab_pin.sym} 147100 -7330 0 1 {name=p146486 lab=_68649_/A }
C {sky130_stdcells/buf_2.sym} 147060 -7330 0 0 {name=X_68648_ }
C {devices/lab_pin.sym} 146970 -7210 0 0 {name=p146487 lab=_87235_/CLK }
C {devices/lab_pin.sym} 146970 -7190 0 0 {name=p146488 lab=_87482_/D }
C {devices/lab_pin.sym} 147150 -7210 0 1 {name=p146489 lab=_87482_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -7200 0 0 {name=X_87482_ }
C {devices/lab_pin.sym} 147020 -7070 0 0 {name=p146490 lab=_53874_/A }
C {devices/lab_pin.sym} 147100 -7070 0 1 {name=p146491 lab=_53875_/B }
C {sky130_stdcells/buf_2.sym} 147060 -7070 0 0 {name=X_53874_ }
C {devices/lab_pin.sym} 146970 -6950 0 0 {name=p146492 lab=_84299_/CLK }
C {devices/lab_pin.sym} 146970 -6930 0 0 {name=p146493 lab=_84694_/D }
C {devices/lab_pin.sym} 147150 -6950 0 1 {name=p146494 lab=_80422_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -6940 0 0 {name=X_84694_ }
C {devices/lab_pin.sym} 146980 -6830 0 0 {name=p146495 lab=_58388_/X }
C {devices/lab_pin.sym} 146980 -6790 0 0 {name=p146496 lab=_83346_/Q }
C {devices/lab_pin.sym} 146980 -6750 0 0 {name=p146497 lab=_58400_/Y }
C {devices/lab_pin.sym} 147140 -6790 0 1 {name=p146498 lab=_58401_/X }
C {sky130_stdcells/o21a_4.sym} 147060 -6790 0 0 {name=X_58401_ }
C {devices/lab_pin.sym} 146980 -6680 0 0 {name=p146499 lab=_45426_/A }
C {devices/lab_pin.sym} 146980 -6640 0 0 {name=p146500 lab=_55641_/A }
C {devices/lab_pin.sym} 146980 -6600 0 0 {name=p146501 lab=_55611_/X }
C {devices/lab_pin.sym} 146980 -6560 0 0 {name=p146502 lab=_55612_/Y }
C {devices/lab_pin.sym} 147140 -6620 0 1 {name=p146503 lab=_55613_/X }
C {sky130_stdcells/a211o_4.sym} 147060 -6620 0 0 {name=X_55613_ }
C {devices/lab_pin.sym} 146970 -6470 0 0 {name=p146504 lab=_86246_/CLK }
C {devices/lab_pin.sym} 146970 -6450 0 0 {name=p146505 lab=_49211_/Y }
C {devices/lab_pin.sym} 147150 -6470 0 1 {name=p146506 lab=_64580_/B }
C {sky130_stdcells/dfxtp_4.sym} 147060 -6460 0 0 {name=X_86433_ }
C {devices/lab_pin.sym} 147020 -6330 0 0 {name=p146507 lab=_52688_/A }
C {devices/lab_pin.sym} 147100 -6330 0 1 {name=p146508 lab=_52852_/A }
C {sky130_stdcells/buf_2.sym} 147060 -6330 0 0 {name=X_52825_ }
C {devices/lab_pin.sym} 147020 -6210 0 0 {name=p146509 lab=_59286_/A }
C {devices/lab_pin.sym} 147100 -6210 0 1 {name=p146510 lab=_59381_/X }
C {sky130_stdcells/buf_2.sym} 147060 -6210 0 0 {name=X_59381_ }
C {devices/lab_pin.sym} 146970 -6090 0 0 {name=p146511 lab=_86422_/CLK }
C {devices/lab_pin.sym} 146970 -6070 0 0 {name=p146512 lab=_83645_/D }
C {devices/lab_pin.sym} 147150 -6090 0 1 {name=p146513 lab=_46385_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -6080 0 0 {name=X_83645_ }
C {devices/lab_pin.sym} 147020 -5950 0 0 {name=p146514 lab=_56593_/A }
C {devices/lab_pin.sym} 147100 -5950 0 1 {name=p146515 lab=_73078_/A }
C {sky130_stdcells/buf_2.sym} 147060 -5950 0 0 {name=X_56593_ }
C {devices/lab_pin.sym} 146970 -5830 0 0 {name=p146516 lab=_80991_/CLK }
C {devices/lab_pin.sym} 146970 -5810 0 0 {name=p146517 lab=_80889_/Q }
C {devices/lab_pin.sym} 147150 -5830 0 1 {name=p146518 lab=_75008_/B }
C {sky130_stdcells/dfxtp_4.sym} 147060 -5820 0 0 {name=X_80857_ }
C {devices/lab_pin.sym} 146980 -5710 0 0 {name=p146519 lab=_68576_/X }
C {devices/lab_pin.sym} 146980 -5670 0 0 {name=p146520 lab=_68578_/X }
C {devices/lab_pin.sym} 146980 -5630 0 0 {name=p146521 lab=_68558_/X }
C {devices/lab_pin.sym} 147140 -5670 0 1 {name=p146522 lab=_68579_/X }
C {sky130_stdcells/a21o_4.sym} 147060 -5670 0 0 {name=X_68579_ }
C {devices/lab_pin.sym} 147020 -5530 0 0 {name=p146523 lab=_70627_/A }
C {devices/lab_pin.sym} 147100 -5530 0 1 {name=p146524 lab=_70773_/A }
C {sky130_stdcells/buf_2.sym} 147060 -5530 0 0 {name=X_70610_ }
C {devices/lab_pin.sym} 146980 -5430 0 0 {name=p146525 lab=_58328_/X }
C {devices/lab_pin.sym} 146980 -5390 0 0 {name=p146526 lab=_83452_/Q }
C {devices/lab_pin.sym} 146980 -5350 0 0 {name=p146527 lab=_58331_/Y }
C {devices/lab_pin.sym} 147140 -5390 0 1 {name=p146528 lab=_84876_/D }
C {sky130_stdcells/o21a_4.sym} 147060 -5390 0 0 {name=X_58332_ }
C {devices/lab_pin.sym} 147000 -5260 0 0 {name=p146529 lab=_55498_/X }
C {devices/lab_pin.sym} 147000 -5220 0 0 {name=p146530 lab=_45519_/Y }
C {devices/lab_pin.sym} 147120 -5240 0 1 {name=p146531 lab=_55544_/Y }
C {sky130_stdcells/nor2_4.sym} 147060 -5240 0 0 {name=X_55544_ }
C {devices/lab_pin.sym} 146970 -5110 0 0 {name=p146532 lab=_83716_/CLK }
C {devices/lab_pin.sym} 146970 -5090 0 0 {name=p146533 lab=_86364_/D }
C {devices/lab_pin.sym} 147150 -5110 0 1 {name=p146534 lab=_86364_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -5100 0 0 {name=X_86364_ }
C {devices/lab_pin.sym} 146980 -4990 0 0 {name=p146535 lab=_40731_/X }
C {devices/lab_pin.sym} 146980 -4950 0 0 {name=p146536 lab=_82304_/Q }
C {devices/lab_pin.sym} 146980 -4910 0 0 {name=p146537 lab=_40769_/X }
C {devices/lab_pin.sym} 147140 -4950 0 1 {name=p146538 lab=_40770_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -4950 0 0 {name=X_40770_ }
C {devices/lab_pin.sym} 147020 -4810 0 0 {name=p146539 lab=_52620_/A }
C {devices/lab_pin.sym} 147100 -4810 0 1 {name=p146540 lab=_52757_/A }
C {sky130_stdcells/buf_2.sym} 147060 -4810 0 0 {name=X_52756_ }
C {devices/lab_pin.sym} 147000 -4710 0 0 {name=p146541 lab=_71859_/A }
C {devices/lab_pin.sym} 147000 -4670 0 0 {name=p146542 lab=_71590_/B }
C {devices/lab_pin.sym} 147000 -4630 0 0 {name=p146543 lab=_71582_/X }
C {devices/lab_pin.sym} 147120 -4670 0 1 {name=p146544 lab=_71590_/Y }
C {sky130_stdcells/nor3_4.sym} 147060 -4670 0 0 {name=X_71590_ }
C {devices/lab_pin.sym} 146970 -4530 0 0 {name=p146545 lab=_86499_/CLK }
C {devices/lab_pin.sym} 146970 -4510 0 0 {name=p146546 lab=_71198_/Y }
C {devices/lab_pin.sym} 147150 -4530 0 1 {name=p146547 lab=_48550_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -4520 0 0 {name=X_83576_ }
C {devices/lab_pin.sym} 146970 -4390 0 0 {name=p146548 lab=_80813_/CLK }
C {devices/lab_pin.sym} 146970 -4370 0 0 {name=p146549 lab=_80788_/D }
C {devices/lab_pin.sym} 147150 -4390 0 1 {name=p146550 lab=_75346_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -4380 0 0 {name=X_80788_ }
C {devices/lab_pin.sym} 147020 -4250 0 0 {name=p146551 lab=clkbuf_9_290_0_CLK/X }
C {devices/lab_pin.sym} 147100 -4250 0 1 {name=p146552 lab=_81065_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 147060 -4250 0 0 {name=Xclkbuf_10_581_0_CLK }
C {devices/lab_pin.sym} 146970 -4130 0 0 {name=p146553 lab=_88111_/CLK }
C {devices/lab_pin.sym} 146970 -4110 0 0 {name=p146554 lab=_88103_/D }
C {devices/lab_pin.sym} 147150 -4130 0 1 {name=p146555 lab=_73842_/A }
C {sky130_stdcells/dfxtp_4.sym} 147060 -4120 0 0 {name=X_88103_ }
C {devices/lab_pin.sym} 146970 -3990 0 0 {name=p146556 lab=_85315_/CLK }
C {devices/lab_pin.sym} 146970 -3970 0 0 {name=p146557 lab=_55117_/Y }
C {devices/lab_pin.sym} 147150 -3990 0 1 {name=p146558 lab=_85315_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -3980 0 0 {name=X_85315_ }
C {devices/lab_pin.sym} 147000 -3860 0 0 {name=p146559 lab=_51717_/A }
C {devices/lab_pin.sym} 147000 -3820 0 0 {name=p146560 lab=_53232_/B }
C {devices/lab_pin.sym} 147120 -3840 0 1 {name=p146561 lab=_51707_/Y }
C {sky130_stdcells/nand2_4.sym} 147060 -3840 0 0 {name=X_51707_ }
C {devices/lab_pin.sym} 147000 -3740 0 0 {name=p146562 lab=_71626_/A }
C {devices/lab_pin.sym} 147000 -3700 0 0 {name=p146563 lab=_70692_/B }
C {devices/lab_pin.sym} 147000 -3660 0 0 {name=p146564 lab=_70538_/X }
C {devices/lab_pin.sym} 147000 -3620 0 0 {name=p146565 lab=_70550_/D }
C {devices/lab_pin.sym} 147120 -3680 0 1 {name=p146566 lab=_70541_/Y }
C {sky130_stdcells/nor4_4.sym} 147060 -3680 0 0 {name=X_70541_ }
C {devices/lab_pin.sym} 146980 -3550 0 0 {name=p146567 lab=_58253_/X }
C {devices/lab_pin.sym} 146980 -3510 0 0 {name=p146568 lab=_83446_/Q }
C {devices/lab_pin.sym} 146980 -3470 0 0 {name=p146569 lab=_58262_/Y }
C {devices/lab_pin.sym} 147140 -3510 0 1 {name=p146570 lab=_84894_/D }
C {sky130_stdcells/o21a_4.sym} 147060 -3510 0 0 {name=X_58263_ }
C {devices/lab_pin.sym} 146970 -3370 0 0 {name=p146571 lab=_82743_/CLK }
C {devices/lab_pin.sym} 146970 -3350 0 0 {name=p146572 lab=_82527_/D }
C {devices/lab_pin.sym} 147150 -3370 0 1 {name=p146573 lab=_78767_/B }
C {sky130_stdcells/dfxtp_4.sym} 147060 -3360 0 0 {name=X_82527_ }
C {devices/lab_pin.sym} 147020 -3230 0 0 {name=p146574 lab=_55468_/X }
C {devices/lab_pin.sym} 147100 -3230 0 1 {name=p146575 lab=_55475_/X }
C {sky130_stdcells/buf_2.sym} 147060 -3230 0 0 {name=X_55475_ }
C {devices/lab_pin.sym} 146970 -3110 0 0 {name=p146576 lab=_86611_/CLK }
C {devices/lab_pin.sym} 146970 -3090 0 0 {name=p146577 lab=_86295_/D }
C {devices/lab_pin.sym} 147150 -3110 0 1 {name=p146578 lab=_86295_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -3100 0 0 {name=X_86295_ }
C {devices/lab_pin.sym} 146980 -2990 0 0 {name=p146579 lab=_85773_/Q }
C {devices/lab_pin.sym} 146980 -2950 0 0 {name=p146580 lab=_52684_/X }
C {devices/lab_pin.sym} 146980 -2910 0 0 {name=p146581 lab=_52686_/Y }
C {devices/lab_pin.sym} 147140 -2950 0 1 {name=p146582 lab=_52687_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -2950 0 0 {name=X_52687_ }
C {devices/lab_pin.sym} 147020 -2810 0 0 {name=p146583 lab=_57214_/A }
C {devices/lab_pin.sym} 147100 -2810 0 1 {name=p146584 lab=_85062_/D }
C {sky130_stdcells/inv_2.sym} 147060 -2810 0 0 {name=X_57214_ }
C {devices/lab_pin.sym} 146980 -2730 0 0 {name=p146585 lab=_42439_/X }
C {devices/lab_pin.sym} 146980 -2690 0 0 {name=p146586 lab=_42430_/X }
C {devices/lab_pin.sym} 146980 -2650 0 0 {name=p146587 lab=_40532_/X }
C {devices/lab_pin.sym} 146980 -2610 0 0 {name=p146588 lab=_87863_/Q }
C {devices/lab_pin.sym} 146980 -2570 0 0 {name=p146589 lab=_41967_/A }
C {devices/lab_pin.sym} 147140 -2650 0 1 {name=p146590 lab=_42440_/Y }
C {sky130_stdcells/o32ai_4.sym} 147060 -2650 0 0 {name=X_42440_ }
C {devices/lab_pin.sym} 146970 -2490 0 0 {name=p146591 lab=_88034_/CLK }
C {devices/lab_pin.sym} 146970 -2470 0 0 {name=p146592 lab=_88034_/D }
C {devices/lab_pin.sym} 147150 -2490 0 1 {name=p146593 lab=_88034_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -2480 0 0 {name=X_88034_ }
C {devices/lab_pin.sym} 146980 -2370 0 0 {name=p146594 lab=_85444_/Q }
C {devices/lab_pin.sym} 146980 -2330 0 0 {name=p146595 lab=_54404_/X }
C {devices/lab_pin.sym} 146980 -2290 0 0 {name=p146596 lab=_54425_/Y }
C {devices/lab_pin.sym} 147140 -2330 0 1 {name=p146597 lab=_54426_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -2330 0 0 {name=X_54426_ }
C {devices/lab_pin.sym} 147000 -2200 0 0 {name=p146598 lab=_73260_/A }
C {devices/lab_pin.sym} 147000 -2160 0 0 {name=p146599 lab=_86478_/Q }
C {devices/lab_pin.sym} 147120 -2180 0 1 {name=p146600 lab=_73260_/X }
C {sky130_stdcells/and2_4.sym} 147060 -2180 0 0 {name=X_73260_ }
C {devices/lab_pin.sym} 146970 -2050 0 0 {name=p146601 lab=_85248_/CLK }
C {devices/lab_pin.sym} 146970 -2030 0 0 {name=p146602 lab=_56297_/Y }
C {devices/lab_pin.sym} 147150 -2050 0 1 {name=p146603 lab=_55958_/B }
C {sky130_stdcells/dfxtp_4.sym} 147060 -2040 0 0 {name=X_85246_ }
C {devices/lab_pin.sym} 146980 -1930 0 0 {name=p146604 lab=_85973_/Q }
C {devices/lab_pin.sym} 146980 -1890 0 0 {name=p146605 lab=_51621_/X }
C {devices/lab_pin.sym} 146980 -1850 0 0 {name=p146606 lab=_51637_/Y }
C {devices/lab_pin.sym} 147140 -1890 0 1 {name=p146607 lab=_51638_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -1890 0 0 {name=X_51638_ }
C {devices/lab_pin.sym} 147020 -1750 0 0 {name=p146608 lab=_71054_/A }
C {devices/lab_pin.sym} 147100 -1750 0 1 {name=p146609 lab=_70472_/X }
C {sky130_stdcells/buf_2.sym} 147060 -1750 0 0 {name=X_70472_ }
C {devices/lab_pin.sym} 146970 -1630 0 0 {name=p146610 lab=_82833_/CLK }
C {devices/lab_pin.sym} 146970 -1610 0 0 {name=p146611 lab=_82458_/D }
C {devices/lab_pin.sym} 147150 -1630 0 1 {name=p146612 lab=_82458_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147060 -1620 0 0 {name=X_82458_ }
C {devices/lab_pin.sym} 147000 -1500 0 0 {name=p146613 lab=_58194_/A }
C {devices/lab_pin.sym} 147000 -1460 0 0 {name=p146614 lab=_58184_/B }
C {devices/lab_pin.sym} 147120 -1480 0 1 {name=p146615 lab=_58194_/Y }
C {sky130_stdcells/nor2_4.sym} 147060 -1480 0 0 {name=X_58194_ }
C {devices/lab_pin.sym} 146980 -1370 0 0 {name=p146616 lab=_72209_/X }
C {devices/lab_pin.sym} 146980 -1330 0 0 {name=p146617 lab=_85978_/Q }
C {devices/lab_pin.sym} 146980 -1290 0 0 {name=p146618 lab=_72210_/X }
C {devices/lab_pin.sym} 147140 -1330 0 1 {name=p146619 lab=_72211_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -1330 0 0 {name=X_72211_ }
C {devices/lab_pin.sym} 146980 -1210 0 0 {name=p146620 lab=_56997_/X }
C {devices/lab_pin.sym} 146980 -1170 0 0 {name=p146621 lab=_45659_/A }
C {devices/lab_pin.sym} 146980 -1130 0 0 {name=p146622 lab=_57144_/X }
C {devices/lab_pin.sym} 147140 -1170 0 1 {name=p146623 lab=_57145_/Y }
C {sky130_stdcells/o21ai_4.sym} 147060 -1170 0 0 {name=X_57145_ }
C {devices/lab_pin.sym} 146970 -1030 0 0 {name=p146624 lab=_81587_/CLK }
C {devices/lab_pin.sym} 146970 -1010 0 0 {name=p146625 lab=_83945_/Q }
C {devices/lab_pin.sym} 147150 -1030 0 1 {name=p146626 lab=_76785_/B }
C {sky130_stdcells/dfxtp_4.sym} 147060 -1020 0 0 {name=X_81409_ }
C {devices/lab_pin.sym} 146980 -930 0 0 {name=p146627 lab=_42350_/X }
C {devices/lab_pin.sym} 146980 -890 0 0 {name=p146628 lab=_42369_/X }
C {devices/lab_pin.sym} 146980 -850 0 0 {name=p146629 lab=_41773_/X }
C {devices/lab_pin.sym} 146980 -810 0 0 {name=p146630 lab=_87896_/Q }
C {devices/lab_pin.sym} 146980 -770 0 0 {name=p146631 lab=_42370_/X }
C {devices/lab_pin.sym} 147140 -850 0 1 {name=p146632 lab=_42371_/Y }
C {sky130_stdcells/o32ai_4.sym} 147060 -850 0 0 {name=X_42371_ }
C {devices/lab_pin.sym} 147020 -690 0 0 {name=p146633 lab=_54329_/A }
C {devices/lab_pin.sym} 147100 -690 0 1 {name=p146634 lab=_54362_/B }
C {sky130_stdcells/buf_2.sym} 147060 -690 0 0 {name=X_54357_ }
C {devices/lab_pin.sym} 147920 -42160 0 0 {name=p146635 lab=_73190_/X }
C {devices/lab_pin.sym} 147920 -42120 0 0 {name=p146636 lab=_73191_/B }
C {devices/lab_pin.sym} 148040 -42140 0 1 {name=p146637 lab=_73191_/X }
C {sky130_stdcells/and2_4.sym} 147980 -42140 0 0 {name=X_73191_ }
C {devices/lab_pin.sym} 147890 -42010 0 0 {name=p146638 lab=_85177_/CLK }
C {devices/lab_pin.sym} 147890 -41990 0 0 {name=p146639 lab=_85177_/D }
C {devices/lab_pin.sym} 148070 -42010 0 1 {name=p146640 lab=_56488_/C }
C {sky130_stdcells/dfxtp_4.sym} 147980 -42000 0 0 {name=X_85177_ }
C {devices/lab_pin.sym} 147940 -41870 0 0 {name=p146641 lab=clkbuf_9_298_0_CLK/X }
C {devices/lab_pin.sym} 148020 -41870 0 1 {name=p146642 lab=_83905_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 147980 -41870 0 0 {name=Xclkbuf_10_596_0_CLK }
C {devices/lab_pin.sym} 147900 -41770 0 0 {name=p146643 lab=_85986_/Q }
C {devices/lab_pin.sym} 147900 -41730 0 0 {name=p146644 lab=_51566_/X }
C {devices/lab_pin.sym} 147900 -41690 0 0 {name=p146645 lab=_51568_/Y }
C {devices/lab_pin.sym} 148060 -41730 0 1 {name=p146646 lab=_51569_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -41730 0 0 {name=X_51569_ }
C {devices/lab_pin.sym} 147890 -41590 0 0 {name=p146647 lab=_84766_/CLK }
C {devices/lab_pin.sym} 147890 -41570 0 0 {name=p146648 lab=_82389_/D }
C {devices/lab_pin.sym} 148070 -41590 0 1 {name=p146649 lab=_82389_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -41580 0 0 {name=X_82389_ }
C {devices/lab_pin.sym} 147940 -41450 0 0 {name=p146650 lab=_44109_/X }
C {devices/lab_pin.sym} 148020 -41450 0 1 {name=p146651 lab=_44110_/X }
C {sky130_stdcells/buf_2.sym} 147980 -41450 0 0 {name=X_44110_ }
C {devices/lab_pin.sym} 147900 -41370 0 0 {name=p146652 lab=_41239_/X }
C {devices/lab_pin.sym} 147900 -41330 0 0 {name=p146653 lab=_41241_/X }
C {devices/lab_pin.sym} 147900 -41290 0 0 {name=p146654 lab=_41321_/X }
C {devices/lab_pin.sym} 147900 -41250 0 0 {name=p146655 lab=_88236_/Q }
C {devices/lab_pin.sym} 147900 -41210 0 0 {name=p146656 lab=_41236_/X }
C {devices/lab_pin.sym} 148060 -41290 0 1 {name=p146657 lab=_41322_/Y }
C {sky130_stdcells/o32ai_4.sym} 147980 -41290 0 0 {name=X_41322_ }
C {devices/lab_pin.sym} 147900 -41150 0 0 {name=p146658 lab=_53306_/Y }
C {devices/lab_pin.sym} 147900 -41110 0 0 {name=p146659 lab=_53301_/X }
C {devices/lab_pin.sym} 147900 -41070 0 0 {name=p146660 lab=_53307_/X }
C {devices/lab_pin.sym} 148060 -41110 0 1 {name=p146661 lab=_53308_/Y }
C {sky130_stdcells/a21oi_4.sym} 147980 -41110 0 0 {name=X_53308_ }
C {devices/lab_pin.sym} 147900 -41010 0 0 {name=p146662 lab=_72137_/X }
C {devices/lab_pin.sym} 147900 -40970 0 0 {name=p146663 lab=_72139_/Y }
C {devices/lab_pin.sym} 147900 -40930 0 0 {name=p146664 lab=_72140_/Y }
C {devices/lab_pin.sym} 147900 -40890 0 0 {name=p146665 lab=_59342_/X }
C {devices/lab_pin.sym} 147900 -40850 0 0 {name=p146666 lab=_72141_/X }
C {devices/lab_pin.sym} 148060 -40930 0 1 {name=p146667 lab=_72142_/X }
C {sky130_stdcells/o32a_4.sym} 147980 -40930 0 0 {name=X_72142_ }
C {devices/lab_pin.sym} 147890 -40770 0 0 {name=p146668 lab=_84161_/CLK }
C {devices/lab_pin.sym} 147890 -40750 0 0 {name=p146669 lab=_66416_/X }
C {devices/lab_pin.sym} 148070 -40770 0 1 {name=p146670 lab=_66415_/C }
C {sky130_stdcells/dfxtp_4.sym} 147980 -40760 0 0 {name=X_84128_ }
C {devices/lab_pin.sym} 147900 -40650 0 0 {name=p146671 lab=_55876_/B }
C {devices/lab_pin.sym} 147900 -40610 0 0 {name=p146672 lab=_45060_/X }
C {devices/lab_pin.sym} 147900 -40570 0 0 {name=p146673 lab=_45040_/X }
C {devices/lab_pin.sym} 148060 -40610 0 1 {name=p146674 lab=_45090_/X }
C {sky130_stdcells/o21a_4.sym} 147980 -40610 0 0 {name=X_45090_ }
C {devices/lab_pin.sym} 147900 -40490 0 0 {name=p146675 lab=_57075_/Y }
C {devices/lab_pin.sym} 147900 -40450 0 0 {name=p146676 lab=_56903_/X }
C {devices/lab_pin.sym} 147900 -40410 0 0 {name=p146677 lab=_56952_/A }
C {devices/lab_pin.sym} 148060 -40450 0 1 {name=p146678 lab=_57076_/X }
C {sky130_stdcells/o21a_4.sym} 147980 -40450 0 0 {name=X_57076_ }
C {devices/lab_pin.sym} 147920 -40320 0 0 {name=p146679 lab=_54288_/A }
C {devices/lab_pin.sym} 147920 -40280 0 0 {name=p146680 lab=_46650_/A }
C {devices/lab_pin.sym} 148040 -40300 0 1 {name=p146681 lab=_54288_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -40300 0 0 {name=X_54288_ }
C {devices/lab_pin.sym} 147920 -40190 0 0 {name=p146682 lab=_56023_/A }
C {devices/lab_pin.sym} 147920 -40150 0 0 {name=p146683 lab=_56017_/B }
C {devices/lab_pin.sym} 147920 -40110 0 0 {name=p146684 lab=_56027_/C }
C {devices/lab_pin.sym} 148040 -40150 0 1 {name=p146685 lab=_56027_/Y }
C {sky130_stdcells/nand3_4.sym} 147980 -40150 0 0 {name=X_56027_ }
C {devices/lab_pin.sym} 147920 -40020 0 0 {name=p146686 lab=_44160_/A }
C {devices/lab_pin.sym} 147920 -39980 0 0 {name=p146687 lab=_87187_/Q }
C {devices/lab_pin.sym} 148040 -40000 0 1 {name=p146688 lab=_44041_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -40000 0 0 {name=X_44041_ }
C {devices/lab_pin.sym} 147900 -39890 0 0 {name=p146689 lab=_53237_/Y }
C {devices/lab_pin.sym} 147900 -39850 0 0 {name=p146690 lab=_53215_/X }
C {devices/lab_pin.sym} 147900 -39810 0 0 {name=p146691 lab=_53238_/X }
C {devices/lab_pin.sym} 148060 -39850 0 1 {name=p146692 lab=_85671_/D }
C {sky130_stdcells/a21oi_4.sym} 147980 -39850 0 0 {name=X_53239_ }
C {devices/lab_pin.sym} 147940 -39710 0 0 {name=p146693 lab=_41253_/A }
C {devices/lab_pin.sym} 148020 -39710 0 1 {name=p146694 lab=_41253_/X }
C {sky130_stdcells/buf_2.sym} 147980 -39710 0 0 {name=X_41253_ }
C {devices/lab_pin.sym} 147900 -39610 0 0 {name=p146695 lab=_83290_/Q }
C {devices/lab_pin.sym} 147900 -39570 0 0 {name=p146696 lab=_72051_/X }
C {devices/lab_pin.sym} 147900 -39530 0 0 {name=p146697 lab=_72072_/Y }
C {devices/lab_pin.sym} 148060 -39570 0 1 {name=p146698 lab=_72073_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -39570 0 0 {name=X_72073_ }
C {devices/lab_pin.sym} 147920 -39440 0 0 {name=p146699 lab=_81505_/Q }
C {devices/lab_pin.sym} 147920 -39400 0 0 {name=p146700 lab=_76949_/X }
C {devices/lab_pin.sym} 148040 -39420 0 1 {name=p146701 lab=_76951_/A }
C {sky130_stdcells/xor2_4.sym} 147980 -39420 0 0 {name=X_76950_ }
C {devices/lab_pin.sym} 147890 -39290 0 0 {name=p146702 lab=_82648_/CLK }
C {devices/lab_pin.sym} 147890 -39270 0 0 {name=p146703 lab=_67687_/X }
C {devices/lab_pin.sym} 148070 -39290 0 1 {name=p146704 lab=_84059_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -39280 0 0 {name=X_84059_ }
C {devices/lab_pin.sym} 147940 -39150 0 0 {name=p146705 lab=clkbuf_5_5_0_CLK/X }
C {devices/lab_pin.sym} 148020 -39150 0 1 {name=p146706 lab=clkbuf_7_21_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 147980 -39150 0 0 {name=Xclkbuf_6_10_0_CLK }
C {devices/lab_pin.sym} 147920 -39040 0 0 {name=p146707 lab=_75901_/A }
C {devices/lab_pin.sym} 147920 -39000 0 0 {name=p146708 lab=_84371_/Q }
C {devices/lab_pin.sym} 148040 -39020 0 1 {name=p146709 lab=_75901_/X }
C {sky130_stdcells/xor2_4.sym} 147980 -39020 0 0 {name=X_75901_ }
C {devices/lab_pin.sym} 147940 -38890 0 0 {name=p146710 lab=_70588_/A }
C {devices/lab_pin.sym} 148020 -38890 0 1 {name=p146711 lab=_71030_/B }
C {sky130_stdcells/buf_2.sym} 147980 -38890 0 0 {name=X_71024_ }
C {devices/lab_pin.sym} 147940 -38770 0 0 {name=p146712 lab=_41143_/A }
C {devices/lab_pin.sym} 148020 -38770 0 1 {name=p146713 lab=_41184_/X }
C {sky130_stdcells/buf_2.sym} 147980 -38770 0 0 {name=X_41184_ }
C {devices/lab_pin.sym} 147920 -38670 0 0 {name=p146714 lab=_76870_/Y }
C {devices/lab_pin.sym} 147920 -38630 0 0 {name=p146715 lab=_76910_/A }
C {devices/lab_pin.sym} 147920 -38590 0 0 {name=p146716 lab=_76881_/C }
C {devices/lab_pin.sym} 148040 -38630 0 1 {name=p146717 lab=_76888_/A }
C {sky130_stdcells/nand3_4.sym} 147980 -38630 0 0 {name=X_76881_ }
C {devices/lab_pin.sym} 147900 -38510 0 0 {name=p146718 lab=_86596_/Q }
C {devices/lab_pin.sym} 147900 -38470 0 0 {name=p146719 lab=_47760_/X }
C {devices/lab_pin.sym} 147900 -38430 0 0 {name=p146720 lab=_47799_/Y }
C {devices/lab_pin.sym} 148060 -38470 0 1 {name=p146721 lab=_47800_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -38470 0 0 {name=X_47800_ }
C {devices/lab_pin.sym} 147900 -38350 0 0 {name=p146722 lab=_78615_/X }
C {devices/lab_pin.sym} 147900 -38310 0 0 {name=p146723 lab=_78618_/Y }
C {devices/lab_pin.sym} 147900 -38270 0 0 {name=p146724 lab=_78610_/X }
C {devices/lab_pin.sym} 148060 -38310 0 1 {name=p146725 lab=_78621_/A }
C {sky130_stdcells/o21a_4.sym} 147980 -38310 0 0 {name=X_78620_ }
C {devices/lab_pin.sym} 147920 -38200 0 0 {name=p146726 lab=_75793_/A }
C {devices/lab_pin.sym} 147920 -38160 0 0 {name=p146727 lab=_75832_/B }
C {devices/lab_pin.sym} 147920 -38120 0 0 {name=p146728 lab=_75800_/A }
C {devices/lab_pin.sym} 147920 -38080 0 0 {name=p146729 lab=_75823_/C }
C {devices/lab_pin.sym} 148040 -38140 0 1 {name=p146730 lab=_75832_/X }
C {sky130_stdcells/and4_4.sym} 147980 -38140 0 0 {name=X_75832_ }
C {devices/lab_pin.sym} 147890 -37990 0 0 {name=p146731 lab=_83158_/CLK }
C {devices/lab_pin.sym} 147890 -37970 0 0 {name=p146732 lab=_42565_/Y }
C {devices/lab_pin.sym} 148070 -37990 0 1 {name=p146733 lab=_87818_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -37980 0 0 {name=X_87818_ }
C {devices/lab_pin.sym} 147900 -37870 0 0 {name=p146734 lab=_48778_/Y }
C {devices/lab_pin.sym} 147900 -37830 0 0 {name=p146735 lab=_48760_/X }
C {devices/lab_pin.sym} 147900 -37790 0 0 {name=p146736 lab=_48779_/X }
C {devices/lab_pin.sym} 148060 -37830 0 1 {name=p146737 lab=_48780_/Y }
C {sky130_stdcells/a21oi_4.sym} 147980 -37830 0 0 {name=X_48780_ }
C {devices/lab_pin.sym} 147900 -37710 0 0 {name=p146738 lab=_57975_/Y }
C {devices/lab_pin.sym} 147900 -37670 0 0 {name=p146739 lab=_57977_/Y }
C {devices/lab_pin.sym} 147900 -37630 0 0 {name=p146740 lab=_57909_/X }
C {devices/lab_pin.sym} 148060 -37670 0 1 {name=p146741 lab=_57978_/X }
C {sky130_stdcells/a21o_4.sym} 147980 -37670 0 0 {name=X_57978_ }
C {devices/lab_pin.sym} 147900 -37570 0 0 {name=p146742 lab=_45980_/X }
C {devices/lab_pin.sym} 147900 -37530 0 0 {name=p146743 lab=_45987_/X }
C {devices/lab_pin.sym} 147900 -37490 0 0 {name=p146744 lab=_40451_/X }
C {devices/lab_pin.sym} 147900 -37450 0 0 {name=p146745 lab=_86824_/Q }
C {devices/lab_pin.sym} 147900 -37410 0 0 {name=p146746 lab=_45982_/X }
C {devices/lab_pin.sym} 148060 -37490 0 1 {name=p146747 lab=_45992_/Y }
C {sky130_stdcells/o32ai_4.sym} 147980 -37490 0 0 {name=X_45992_ }
C {devices/lab_pin.sym} 147920 -37360 0 0 {name=p146748 lab=_47758_/A }
C {devices/lab_pin.sym} 147920 -37320 0 0 {name=p146749 lab=_47739_/B }
C {devices/lab_pin.sym} 147920 -37280 0 0 {name=p146750 lab=_47749_/C }
C {devices/lab_pin.sym} 147920 -37240 0 0 {name=p146751 lab=_53211_/D }
C {devices/lab_pin.sym} 148040 -37300 0 1 {name=p146752 lab=_47731_/X }
C {sky130_stdcells/and4_4.sym} 147980 -37300 0 0 {name=X_47731_ }
C {devices/lab_pin.sym} 147940 -37150 0 0 {name=p146753 lab=_59716_/Y }
C {devices/lab_pin.sym} 148020 -37150 0 1 {name=p146754 lab=_59717_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -37150 0 0 {name=X_59717_ }
C {devices/lab_pin.sym} 147940 -37030 0 0 {name=p146755 lab=_78551_/A }
C {devices/lab_pin.sym} 148020 -37030 0 1 {name=p146756 lab=_78554_/B }
C {sky130_stdcells/inv_2.sym} 147980 -37030 0 0 {name=X_78551_ }
C {devices/lab_pin.sym} 147900 -36930 0 0 {name=p146757 lab=_55958_/B }
C {devices/lab_pin.sym} 147900 -36890 0 0 {name=p146758 lab=_44874_/X }
C {devices/lab_pin.sym} 147900 -36850 0 0 {name=p146759 lab=_44926_/X }
C {devices/lab_pin.sym} 148060 -36890 0 1 {name=p146760 lab=_44943_/X }
C {sky130_stdcells/o21a_4.sym} 147980 -36890 0 0 {name=X_44943_ }
C {devices/lab_pin.sym} 147900 -36770 0 0 {name=p146761 lab=_85122_/Q }
C {devices/lab_pin.sym} 147900 -36730 0 0 {name=p146762 lab=_56753_/A }
C {devices/lab_pin.sym} 147900 -36690 0 0 {name=p146763 lab=_56928_/Y }
C {devices/lab_pin.sym} 148060 -36730 0 1 {name=p146764 lab=_56929_/X }
C {sky130_stdcells/a21o_4.sym} 147980 -36730 0 0 {name=X_56929_ }
C {devices/lab_pin.sym} 147890 -36590 0 0 {name=p146765 lab=_87749_/CLK }
C {devices/lab_pin.sym} 147890 -36570 0 0 {name=p146766 lab=_87749_/D }
C {devices/lab_pin.sym} 148070 -36590 0 1 {name=p146767 lab=_87749_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -36580 0 0 {name=X_87749_ }
C {devices/lab_pin.sym} 147920 -36460 0 0 {name=p146768 lab=_75761_/Y }
C {devices/lab_pin.sym} 147920 -36420 0 0 {name=p146769 lab=_75762_/Y }
C {devices/lab_pin.sym} 148040 -36440 0 1 {name=p146770 lab=_75766_/A }
C {sky130_stdcells/xor2_4.sym} 147980 -36440 0 0 {name=X_75763_ }
C {devices/lab_pin.sym} 147940 -36310 0 0 {name=p146771 lab=clkbuf_9_267_0_CLK/X }
C {devices/lab_pin.sym} 148020 -36310 0 1 {name=p146772 lab=_83932_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 147980 -36310 0 0 {name=Xclkbuf_10_534_0_CLK }
C {devices/lab_pin.sym} 147900 -36210 0 0 {name=p146773 lab=_88331_/Q }
C {devices/lab_pin.sym} 147900 -36170 0 0 {name=p146774 lab=_72974_/X }
C {devices/lab_pin.sym} 147900 -36130 0 0 {name=p146775 lab=_56548_/X }
C {devices/lab_pin.sym} 148060 -36170 0 1 {name=p146776 lab=_72975_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -36170 0 0 {name=X_72975_ }
C {devices/lab_pin.sym} 147940 -36030 0 0 {name=p146777 lab=clkbuf_6_25_0_CLK/A }
C {devices/lab_pin.sym} 148020 -36030 0 1 {name=p146778 lab=clkbuf_7_50_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 147980 -36030 0 0 {name=Xclkbuf_6_25_0_CLK }
C {devices/lab_pin.sym} 147920 -35920 0 0 {name=p146779 lab=_77502_/A }
C {devices/lab_pin.sym} 147920 -35880 0 0 {name=p146780 lab=_77501_/Y }
C {devices/lab_pin.sym} 148040 -35900 0 1 {name=p146781 lab=_82196_/D }
C {sky130_stdcells/xor2_4.sym} 147980 -35900 0 0 {name=X_77502_ }
C {devices/lab_pin.sym} 147940 -35770 0 0 {name=p146782 lab=MACRO_RD_SELECT }
C {devices/lab_pin.sym} 148020 -35770 0 1 {name=p146783 lab=_74714_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -35770 0 0 {name=X_74714_ }
C {devices/lab_pin.sym} 147940 -35650 0 0 {name=p146784 lab=_47662_/A }
C {devices/lab_pin.sym} 148020 -35650 0 1 {name=p146785 lab=_47663_/A }
C {sky130_stdcells/inv_2.sym} 147980 -35650 0 0 {name=X_47662_ }
C {devices/lab_pin.sym} 147920 -35560 0 0 {name=p146786 lab=_70383_/X }
C {devices/lab_pin.sym} 147920 -35520 0 0 {name=p146787 lab=_70979_/C }
C {devices/lab_pin.sym} 147920 -35480 0 0 {name=p146788 lab=_71940_/C }
C {devices/lab_pin.sym} 147920 -35440 0 0 {name=p146789 lab=_71928_/D }
C {devices/lab_pin.sym} 148040 -35500 0 1 {name=p146790 lab=_71926_/Y }
C {sky130_stdcells/nand4_4.sym} 147980 -35500 0 0 {name=X_71926_ }
C {devices/lab_pin.sym} 147940 -35350 0 0 {name=p146791 lab=_59648_/A }
C {devices/lab_pin.sym} 148020 -35350 0 1 {name=p146792 lab=_59743_/B }
C {sky130_stdcells/buf_2.sym} 147980 -35350 0 0 {name=X_59648_ }
C {devices/lab_pin.sym} 147920 -35240 0 0 {name=p146793 lab=_78482_/A }
C {devices/lab_pin.sym} 147920 -35200 0 0 {name=p146794 lab=_78482_/B }
C {devices/lab_pin.sym} 148040 -35220 0 1 {name=p146795 lab=_82766_/D }
C {sky130_stdcells/xnor2_4.sym} 147980 -35220 0 0 {name=X_78482_ }
C {devices/lab_pin.sym} 147940 -35090 0 0 {name=p146796 lab=_45197_/A }
C {devices/lab_pin.sym} 148020 -35090 0 1 {name=p146797 lab=_44874_/X }
C {sky130_stdcells/buf_2.sym} 147980 -35090 0 0 {name=X_44874_ }
C {devices/lab_pin.sym} 147940 -34970 0 0 {name=p146798 lab=_75694_/A }
C {devices/lab_pin.sym} 148020 -34970 0 1 {name=p146799 lab=_75696_/A }
C {sky130_stdcells/inv_2.sym} 147980 -34970 0 0 {name=X_75694_ }
C {devices/lab_pin.sym} 147920 -34880 0 0 {name=p146800 lab=_49397_/A }
C {devices/lab_pin.sym} 147920 -34840 0 0 {name=p146801 lab=_49420_/B }
C {devices/lab_pin.sym} 147920 -34800 0 0 {name=p146802 lab=_49408_/C }
C {devices/lab_pin.sym} 147920 -34760 0 0 {name=p146803 lab=_51787_/D }
C {devices/lab_pin.sym} 148040 -34820 0 1 {name=p146804 lab=_49401_/X }
C {sky130_stdcells/and4_4.sym} 147980 -34820 0 0 {name=X_49401_ }
C {devices/lab_pin.sym} 147940 -34670 0 0 {name=p146805 lab=_53097_/A }
C {devices/lab_pin.sym} 148020 -34670 0 1 {name=p146806 lab=_46892_/A }
C {sky130_stdcells/buf_2.sym} 147980 -34670 0 0 {name=X_46613_ }
C {devices/lab_pin.sym} 147940 -34550 0 0 {name=p146807 lab=_77433_/A }
C {devices/lab_pin.sym} 148020 -34550 0 1 {name=p146808 lab=_77433_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -34550 0 0 {name=X_77433_ }
C {devices/lab_pin.sym} 147900 -34470 0 0 {name=p146809 lab=_43810_/X }
C {devices/lab_pin.sym} 147900 -34430 0 0 {name=p146810 lab=_43824_/X }
C {devices/lab_pin.sym} 147900 -34390 0 0 {name=p146811 lab=_41125_/X }
C {devices/lab_pin.sym} 147900 -34350 0 0 {name=p146812 lab=_68427_/B }
C {devices/lab_pin.sym} 147900 -34310 0 0 {name=p146813 lab=_43811_/X }
C {devices/lab_pin.sym} 148060 -34390 0 1 {name=p146814 lab=_43826_/A }
C {sky130_stdcells/o32ai_4.sym} 147980 -34390 0 0 {name=X_43825_ }
C {devices/lab_pin.sym} 147940 -34230 0 0 {name=p146815 lab=_74691_/A }
C {devices/lab_pin.sym} 148020 -34230 0 1 {name=p146816 lab=_74645_/X }
C {sky130_stdcells/buf_2.sym} 147980 -34230 0 0 {name=X_74645_ }
C {devices/lab_pin.sym} 147940 -34110 0 0 {name=p146817 lab=_81242_/Q }
C {devices/lab_pin.sym} 148020 -34110 0 1 {name=p146818 lab=_47594_/A }
C {sky130_stdcells/inv_2.sym} 147980 -34110 0 0 {name=X_47593_ }
C {devices/lab_pin.sym} 147920 -34020 0 0 {name=p146819 lab=_71857_/A }
C {devices/lab_pin.sym} 147920 -33980 0 0 {name=p146820 lab=_71857_/B }
C {devices/lab_pin.sym} 147920 -33940 0 0 {name=p146821 lab=_71851_/X }
C {devices/lab_pin.sym} 147920 -33900 0 0 {name=p146822 lab=_71857_/D }
C {devices/lab_pin.sym} 148040 -33960 0 1 {name=p146823 lab=_71857_/Y }
C {sky130_stdcells/nor4_4.sym} 147980 -33960 0 0 {name=X_71857_ }
C {devices/lab_pin.sym} 147940 -33810 0 0 {name=p146824 lab=_59579_/A }
C {devices/lab_pin.sym} 148020 -33810 0 1 {name=p146825 lab=_59657_/A }
C {sky130_stdcells/inv_2.sym} 147980 -33810 0 0 {name=X_59579_ }
C {devices/lab_pin.sym} 147920 -33700 0 0 {name=p146826 lab=_49327_/X }
C {devices/lab_pin.sym} 147920 -33660 0 0 {name=p146827 lab=_50854_/B }
C {devices/lab_pin.sym} 148040 -33680 0 1 {name=p146828 lab=_49332_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -33680 0 0 {name=X_49332_ }
C {devices/lab_pin.sym} 147920 -33570 0 0 {name=p146829 lab=_61608_/X }
C {devices/lab_pin.sym} 147920 -33530 0 0 {name=p146830 lab=_61609_/X }
C {devices/lab_pin.sym} 147920 -33490 0 0 {name=p146831 lab=_61619_/C }
C {devices/lab_pin.sym} 148040 -33530 0 1 {name=p146832 lab=_61610_/Y }
C {sky130_stdcells/nand3_4.sym} 147980 -33530 0 0 {name=X_61610_ }
C {devices/lab_pin.sym} 147900 -33410 0 0 {name=p146833 lab=_52881_/B }
C {devices/lab_pin.sym} 147900 -33370 0 0 {name=p146834 lab=_70802_/X }
C {devices/lab_pin.sym} 147900 -33330 0 0 {name=p146835 lab=_70807_/Y }
C {devices/lab_pin.sym} 148060 -33370 0 1 {name=p146836 lab=_70808_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -33370 0 0 {name=X_70808_ }
C {devices/lab_pin.sym} 147940 -33230 0 0 {name=p146837 lab=_46366_/A }
C {devices/lab_pin.sym} 148020 -33230 0 1 {name=p146838 lab=_46547_/A }
C {sky130_stdcells/buf_2.sym} 147980 -33230 0 0 {name=X_46544_ }
C {devices/lab_pin.sym} 147940 -33110 0 0 {name=p146839 lab=clkbuf_9_274_0_CLK/X }
C {devices/lab_pin.sym} 148020 -33110 0 1 {name=p146840 lab=_81514_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 147980 -33110 0 0 {name=Xclkbuf_10_549_0_CLK }
C {devices/lab_pin.sym} 147920 -33000 0 0 {name=p146841 lab=_77362_/X }
C {devices/lab_pin.sym} 147920 -32960 0 0 {name=p146842 lab=_77363_/Y }
C {devices/lab_pin.sym} 148040 -32980 0 1 {name=p146843 lab=_82187_/D }
C {sky130_stdcells/xor2_4.sym} 147980 -32980 0 0 {name=X_77364_ }
C {devices/lab_pin.sym} 147940 -32850 0 0 {name=p146844 lab=_43756_/A }
C {devices/lab_pin.sym} 148020 -32850 0 1 {name=p146845 lab=_43756_/X }
C {sky130_stdcells/buf_2.sym} 147980 -32850 0 0 {name=X_43756_ }
C {devices/lab_pin.sym} 147920 -32760 0 0 {name=p146846 lab=_62570_/A }
C {devices/lab_pin.sym} 147920 -32720 0 0 {name=p146847 lab=_62140_/X }
C {devices/lab_pin.sym} 147920 -32680 0 0 {name=p146848 lab=_62601_/C }
C {devices/lab_pin.sym} 147920 -32640 0 0 {name=p146849 lab=_62623_/D }
C {devices/lab_pin.sym} 148040 -32700 0 1 {name=p146850 lab=_62590_/X }
C {sky130_stdcells/and4_4.sym} 147980 -32700 0 0 {name=X_62590_ }
C {devices/lab_pin.sym} 147900 -32580 0 0 {name=p146851 lab=_74575_/X }
C {devices/lab_pin.sym} 147900 -32540 0 0 {name=p146852 lab=_74569_/X }
C {devices/lab_pin.sym} 147900 -32500 0 0 {name=p146853 lab=_56069_/Y }
C {devices/lab_pin.sym} 147900 -32460 0 0 {name=p146854 lab=_74570_/X }
C {devices/lab_pin.sym} 148060 -32520 0 1 {name=p146855 lab=_74576_/X }
C {sky130_stdcells/a211o_4.sym} 147980 -32520 0 0 {name=X_74576_ }
C {devices/lab_pin.sym} 147940 -32370 0 0 {name=p146856 lab=_40968_/A }
C {devices/lab_pin.sym} 148020 -32370 0 1 {name=p146857 lab=_40968_/X }
C {sky130_stdcells/buf_2.sym} 147980 -32370 0 0 {name=X_40968_ }
C {devices/lab_pin.sym} 147920 -32270 0 0 {name=p146858 lab=_71235_/A }
C {devices/lab_pin.sym} 147920 -32230 0 0 {name=p146859 lab=_71246_/B }
C {devices/lab_pin.sym} 147920 -32190 0 0 {name=p146860 lab=_71785_/X }
C {devices/lab_pin.sym} 148040 -32230 0 1 {name=p146861 lab=_71788_/Y }
C {sky130_stdcells/nand3_4.sym} 147980 -32230 0 0 {name=X_71788_ }
C {devices/lab_pin.sym} 147940 -32090 0 0 {name=p146862 lab=_79102_/X }
C {devices/lab_pin.sym} 148020 -32090 0 1 {name=p146863 lab=_79109_/B }
C {sky130_stdcells/inv_2.sym} 147980 -32090 0 0 {name=X_79103_ }
C {devices/lab_pin.sym} 147920 -31980 0 0 {name=p146864 lab=_76328_/A }
C {devices/lab_pin.sym} 147920 -31940 0 0 {name=p146865 lab=_81518_/D }
C {devices/lab_pin.sym} 148040 -31960 0 1 {name=p146866 lab=_76315_/X }
C {sky130_stdcells/xor2_4.sym} 147980 -31960 0 0 {name=X_76315_ }
C {devices/lab_pin.sym} 147900 -31860 0 0 {name=p146867 lab=_41134_/X }
C {devices/lab_pin.sym} 147900 -31820 0 0 {name=p146868 lab=_42695_/X }
C {devices/lab_pin.sym} 147900 -31780 0 0 {name=p146869 lab=_68480_/B }
C {devices/lab_pin.sym} 147900 -31740 0 0 {name=p146870 lab=_42696_/X }
C {devices/lab_pin.sym} 148060 -31800 0 1 {name=p146871 lab=_42707_/X }
C {sky130_stdcells/a2bb2o_4.sym} 147980 -31800 0 0 {name=X_42707_ }
C {devices/lab_pin.sym} 147920 -31660 0 0 {name=p146872 lab=_49263_/A }
C {devices/lab_pin.sym} 147920 -31620 0 0 {name=p146873 lab=_52478_/B }
C {devices/lab_pin.sym} 148040 -31640 0 1 {name=p146874 lab=_49263_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -31640 0 0 {name=X_49263_ }
C {devices/lab_pin.sym} 147920 -31530 0 0 {name=p146875 lab=_61541_/A }
C {devices/lab_pin.sym} 147920 -31490 0 0 {name=p146876 lab=_61541_/B }
C {devices/lab_pin.sym} 147920 -31450 0 0 {name=p146877 lab=_61541_/C }
C {devices/lab_pin.sym} 148040 -31490 0 1 {name=p146878 lab=_61541_/Y }
C {sky130_stdcells/nand3_4.sym} 147980 -31490 0 0 {name=X_61541_ }
C {devices/lab_pin.sym} 147920 -31360 0 0 {name=p146879 lab=_73527_/A }
C {devices/lab_pin.sym} 147920 -31320 0 0 {name=p146880 lab=_72732_/B }
C {devices/lab_pin.sym} 148040 -31340 0 1 {name=p146881 lab=_73527_/Y }
C {sky130_stdcells/nor2_4.sym} 147980 -31340 0 0 {name=X_73527_ }
C {devices/lab_pin.sym} 147940 -31210 0 0 {name=p146882 lab=_46623_/A }
C {devices/lab_pin.sym} 148020 -31210 0 1 {name=p146883 lab=_46491_/A }
C {sky130_stdcells/buf_2.sym} 147980 -31210 0 0 {name=X_46475_ }
C {devices/lab_pin.sym} 147940 -31090 0 0 {name=p146884 lab=_70755_/A }
C {devices/lab_pin.sym} 148020 -31090 0 1 {name=p146885 lab=_70740_/A }
C {sky130_stdcells/buf_2.sym} 147980 -31090 0 0 {name=X_70739_ }
C {devices/lab_pin.sym} 147900 -30990 0 0 {name=p146886 lab=_77296_/A }
C {devices/lab_pin.sym} 147900 -30950 0 0 {name=p146887 lab=_77294_/Y }
C {devices/lab_pin.sym} 147900 -30910 0 0 {name=p146888 lab=_77312_/A }
C {devices/lab_pin.sym} 148060 -30950 0 1 {name=p146889 lab=_77295_/X }
C {sky130_stdcells/a21o_4.sym} 147980 -30950 0 0 {name=X_77295_ }
C {devices/lab_pin.sym} 147900 -30840 0 0 {name=p146890 lab=_40792_/X }
C {devices/lab_pin.sym} 147900 -30800 0 0 {name=p146891 lab=_43685_/X }
C {devices/lab_pin.sym} 147900 -30760 0 0 {name=p146892 lab=_87310_/Q }
C {devices/lab_pin.sym} 147900 -30720 0 0 {name=p146893 lab=_43686_/X }
C {devices/lab_pin.sym} 148060 -30780 0 1 {name=p146894 lab=_87310_/D }
C {sky130_stdcells/a2bb2o_4.sym} 147980 -30780 0 0 {name=X_43687_ }
C {devices/lab_pin.sym} 147940 -30630 0 0 {name=p146895 lab=_40898_/Y }
C {devices/lab_pin.sym} 148020 -30630 0 1 {name=p146896 lab=_40899_/X }
C {sky130_stdcells/buf_2.sym} 147980 -30630 0 0 {name=X_40899_ }
C {devices/lab_pin.sym} 147900 -30530 0 0 {name=p146897 lab=_48211_/Y }
C {devices/lab_pin.sym} 147900 -30490 0 0 {name=p146898 lab=_48175_/X }
C {devices/lab_pin.sym} 147900 -30450 0 0 {name=p146899 lab=_48213_/Y }
C {devices/lab_pin.sym} 148060 -30490 0 1 {name=p146900 lab=_48214_/Y }
C {sky130_stdcells/a21boi_4.sym} 147980 -30490 0 0 {name=X_48214_ }
C {devices/lab_pin.sym} 147920 -30360 0 0 {name=p146901 lab=_79034_/A }
C {devices/lab_pin.sym} 147920 -30320 0 0 {name=p146902 lab=_79033_/Y }
C {devices/lab_pin.sym} 148040 -30340 0 1 {name=p146903 lab=_79035_/B }
C {sky130_stdcells/xnor2_4.sym} 147980 -30340 0 0 {name=X_79034_ }
C {devices/lab_pin.sym} 147920 -30220 0 0 {name=p146904 lab=_45426_/A }
C {devices/lab_pin.sym} 147920 -30180 0 0 {name=p146905 lab=_45397_/X }
C {devices/lab_pin.sym} 148040 -30200 0 1 {name=p146906 lab=_45426_/Y }
C {sky130_stdcells/nor2_4.sym} 147980 -30200 0 0 {name=X_45426_ }
C {devices/lab_pin.sym} 147940 -30070 0 0 {name=p146907 lab=_64377_/A }
C {devices/lab_pin.sym} 148020 -30070 0 1 {name=p146908 lab=_64275_/A }
C {sky130_stdcells/buf_2.sym} 147980 -30070 0 0 {name=X_64260_ }
C {devices/lab_pin.sym} 147920 -29960 0 0 {name=p146909 lab=_81257_/Q }
C {devices/lab_pin.sym} 147920 -29920 0 0 {name=p146910 lab=_81513_/D }
C {devices/lab_pin.sym} 148040 -29940 0 1 {name=p146911 lab=_76251_/C }
C {sky130_stdcells/nand2_4.sym} 147980 -29940 0 0 {name=X_76246_ }
C {devices/lab_pin.sym} 147900 -29850 0 0 {name=p146912 lab=_42614_/X }
C {devices/lab_pin.sym} 147900 -29810 0 0 {name=p146913 lab=_42615_/X }
C {devices/lab_pin.sym} 147900 -29770 0 0 {name=p146914 lab=_40950_/X }
C {devices/lab_pin.sym} 147900 -29730 0 0 {name=p146915 lab=_87793_/Q }
C {devices/lab_pin.sym} 147900 -29690 0 0 {name=p146916 lab=_42637_/X }
C {devices/lab_pin.sym} 148060 -29770 0 1 {name=p146917 lab=_42639_/A }
C {sky130_stdcells/o32ai_4.sym} 147980 -29770 0 0 {name=X_42638_ }
C {devices/lab_pin.sym} 147920 -29620 0 0 {name=p146918 lab=_48660_/A }
C {devices/lab_pin.sym} 147920 -29580 0 0 {name=p146919 lab=_73457_/Y }
C {devices/lab_pin.sym} 148040 -29600 0 1 {name=p146920 lab=_73458_/X }
C {sky130_stdcells/xor2_4.sym} 147980 -29600 0 0 {name=X_73458_ }
C {devices/lab_pin.sym} 147900 -29490 0 0 {name=p146921 lab=_49187_/Y }
C {devices/lab_pin.sym} 147900 -29450 0 0 {name=p146922 lab=_49189_/X }
C {devices/lab_pin.sym} 147900 -29410 0 0 {name=p146923 lab=_49193_/X }
C {devices/lab_pin.sym} 148060 -29450 0 1 {name=p146924 lab=_86435_/D }
C {sky130_stdcells/a21oi_4.sym} 147980 -29450 0 0 {name=X_49194_ }
C {devices/lab_pin.sym} 147940 -29310 0 0 {name=p146925 lab=_61471_/Y }
C {devices/lab_pin.sym} 148020 -29310 0 1 {name=p146926 lab=_61472_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -29310 0 0 {name=X_61472_ }
C {devices/lab_pin.sym} 147900 -29210 0 0 {name=p146927 lab=_79330_/A }
C {devices/lab_pin.sym} 147900 -29170 0 0 {name=p146928 lab=_63189_/X }
C {devices/lab_pin.sym} 147900 -29130 0 0 {name=p146929 lab=_63210_/Y }
C {devices/lab_pin.sym} 148060 -29170 0 1 {name=p146930 lab=_63211_/X }
C {sky130_stdcells/a21o_4.sym} 147980 -29170 0 0 {name=X_63211_ }
C {devices/lab_pin.sym} 147940 -29030 0 0 {name=p146931 lab=_50105_/A }
C {devices/lab_pin.sym} 148020 -29030 0 1 {name=p146932 lab=_48801_/A }
C {sky130_stdcells/buf_2.sym} 147980 -29030 0 0 {name=X_48145_ }
C {devices/lab_pin.sym} 147920 -28930 0 0 {name=p146933 lab=_60513_/A }
C {devices/lab_pin.sym} 147920 -28890 0 0 {name=p146934 lab=_60513_/B }
C {devices/lab_pin.sym} 147920 -28850 0 0 {name=p146935 lab=_79157_/A }
C {devices/lab_pin.sym} 148040 -28890 0 1 {name=p146936 lab=_60423_/X }
C {sky130_stdcells/or3_4.sym} 147980 -28890 0 0 {name=X_60423_ }
C {devices/lab_pin.sym} 147900 -28770 0 0 {name=p146937 lab=_72389_/X }
C {devices/lab_pin.sym} 147900 -28730 0 0 {name=p146938 lab=_85673_/Q }
C {devices/lab_pin.sym} 147900 -28690 0 0 {name=p146939 lab=_72308_/X }
C {devices/lab_pin.sym} 148060 -28730 0 1 {name=p146940 lab=_72409_/X }
C {sky130_stdcells/o21a_4.sym} 147980 -28730 0 0 {name=X_72409_ }
C {devices/lab_pin.sym} 147940 -28590 0 0 {name=p146941 lab=_45284_/A }
C {devices/lab_pin.sym} 148020 -28590 0 1 {name=p146942 lab=_45357_/X }
C {sky130_stdcells/buf_2.sym} 147980 -28590 0 0 {name=X_45357_ }
C {devices/lab_pin.sym} 147920 -28500 0 0 {name=p146943 lab=_84882_/Q }
C {devices/lab_pin.sym} 147920 -28460 0 0 {name=p146944 lab=_64191_/B }
C {devices/lab_pin.sym} 147920 -28420 0 0 {name=p146945 lab=_63731_/D }
C {devices/lab_pin.sym} 147920 -28380 0 0 {name=p146946 lab=_64191_/D }
C {devices/lab_pin.sym} 148040 -28440 0 1 {name=p146947 lab=_64191_/Y }
C {sky130_stdcells/nand4_4.sym} 147980 -28440 0 0 {name=X_64191_ }
C {devices/lab_pin.sym} 147900 -28310 0 0 {name=p146948 lab=_76171_/Y }
C {devices/lab_pin.sym} 147900 -28270 0 0 {name=p146949 lab=_76175_/Y }
C {devices/lab_pin.sym} 147900 -28230 0 0 {name=p146950 lab=_76176_/Y }
C {devices/lab_pin.sym} 148060 -28270 0 1 {name=p146951 lab=_76177_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -28270 0 0 {name=X_76177_ }
C {devices/lab_pin.sym} 147940 -28130 0 0 {name=p146952 lab=_42547_/A }
C {devices/lab_pin.sym} 148020 -28130 0 1 {name=p146953 lab=_42569_/X }
C {sky130_stdcells/buf_2.sym} 147980 -28130 0 0 {name=X_42569_ }
C {devices/lab_pin.sym} 147920 -28020 0 0 {name=p146954 lab=_48627_/A }
C {devices/lab_pin.sym} 147920 -27980 0 0 {name=p146955 lab=_73388_/Y }
C {devices/lab_pin.sym} 148040 -28000 0 1 {name=p146956 lab=_73389_/X }
C {sky130_stdcells/xor2_4.sym} 147980 -28000 0 0 {name=X_73389_ }
C {devices/lab_pin.sym} 147940 -27870 0 0 {name=p146957 lab=_44308_/A }
C {devices/lab_pin.sym} 148020 -27870 0 1 {name=p146958 lab=_44308_/X }
C {sky130_stdcells/buf_2.sym} 147980 -27870 0 0 {name=X_44308_ }
C {devices/lab_pin.sym} 147900 -27790 0 0 {name=p146959 lab=_58551_/A }
C {devices/lab_pin.sym} 147900 -27750 0 0 {name=p146960 lab=_63131_/X }
C {devices/lab_pin.sym} 147900 -27710 0 0 {name=p146961 lab=_63117_/X }
C {devices/lab_pin.sym} 147900 -27670 0 0 {name=p146962 lab=_58326_/A }
C {devices/lab_pin.sym} 147900 -27630 0 0 {name=p146963 lab=_63118_/X }
C {devices/lab_pin.sym} 148060 -27710 0 1 {name=p146964 lab=_63142_/Y }
C {sky130_stdcells/o32ai_4.sym} 147980 -27710 0 0 {name=X_63142_ }
C {devices/lab_pin.sym} 147900 -27570 0 0 {name=p146965 lab=_75113_/A }
C {devices/lab_pin.sym} 147900 -27530 0 0 {name=p146966 lab=_81061_/Q }
C {devices/lab_pin.sym} 147900 -27490 0 0 {name=p146967 lab=_75113_/C }
C {devices/lab_pin.sym} 148060 -27530 0 1 {name=p146968 lab=_75129_/A }
C {sky130_stdcells/a21boi_4.sym} 147980 -27530 0 0 {name=X_75128_ }
C {devices/lab_pin.sym} 147940 -27390 0 0 {name=p146969 lab=_47972_/A }
C {devices/lab_pin.sym} 148020 -27390 0 1 {name=p146970 lab=_48086_/B }
C {sky130_stdcells/buf_2.sym} 147980 -27390 0 0 {name=X_48076_ }
C {devices/lab_pin.sym} 147900 -27310 0 0 {name=p146971 lab=_60353_/Y }
C {devices/lab_pin.sym} 147900 -27270 0 0 {name=p146972 lab=_60122_/Y }
C {devices/lab_pin.sym} 147900 -27230 0 0 {name=p146973 lab=_60350_/A }
C {devices/lab_pin.sym} 147900 -27190 0 0 {name=p146974 lab=_79615_/A }
C {devices/lab_pin.sym} 147900 -27150 0 0 {name=p146975 lab=_60341_/X }
C {devices/lab_pin.sym} 148060 -27230 0 1 {name=p146976 lab=_84624_/D }
C {sky130_stdcells/o32a_4.sym} 147980 -27230 0 0 {name=X_60354_ }
C {devices/lab_pin.sym} 147900 -27090 0 0 {name=p146977 lab=_45283_/Y }
C {devices/lab_pin.sym} 147900 -27050 0 0 {name=p146978 lab=_45286_/Y }
C {devices/lab_pin.sym} 147900 -27010 0 0 {name=p146979 lab=_45287_/X }
C {devices/lab_pin.sym} 148060 -27050 0 1 {name=p146980 lab=_45288_/X }
C {sky130_stdcells/a21o_4.sym} 147980 -27050 0 0 {name=X_45288_ }
C {devices/lab_pin.sym} 147940 -26910 0 0 {name=p146981 lab=_82390_/Q }
C {devices/lab_pin.sym} 148020 -26910 0 1 {name=p146982 lab=_54503_/D }
C {sky130_stdcells/inv_2.sym} 147980 -26910 0 0 {name=X_47027_ }
C {devices/lab_pin.sym} 147940 -26790 0 0 {name=p146983 lab=_44239_/A }
C {devices/lab_pin.sym} 148020 -26790 0 1 {name=p146984 lab=_44256_/A }
C {sky130_stdcells/buf_2.sym} 147980 -26790 0 0 {name=X_44239_ }
C {devices/lab_pin.sym} 147940 -26670 0 0 {name=p146985 lab=_69747_/A }
C {devices/lab_pin.sym} 148020 -26670 0 1 {name=p146986 lab=_67950_/X }
C {sky130_stdcells/buf_2.sym} 147980 -26670 0 0 {name=X_67950_ }
C {devices/lab_pin.sym} 147920 -26560 0 0 {name=p146987 lab=_75055_/Y }
C {devices/lab_pin.sym} 147920 -26520 0 0 {name=p146988 lab=_75059_/B }
C {devices/lab_pin.sym} 148040 -26540 0 1 {name=p146989 lab=_75059_/X }
C {sky130_stdcells/xor2_4.sym} 147980 -26540 0 0 {name=X_75059_ }
C {devices/lab_pin.sym} 147920 -26420 0 0 {name=p146990 lab=_79935_/Y }
C {devices/lab_pin.sym} 147920 -26380 0 0 {name=p146991 lab=_79936_/B }
C {devices/lab_pin.sym} 148040 -26400 0 1 {name=p146992 lab=_79936_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -26400 0 0 {name=X_79936_ }
C {devices/lab_pin.sym} 147940 -26270 0 0 {name=p146993 lab=_63010_/A }
C {devices/lab_pin.sym} 148020 -26270 0 1 {name=p146994 lab=_63073_/X }
C {sky130_stdcells/buf_2.sym} 147980 -26270 0 0 {name=X_63073_ }
C {devices/lab_pin.sym} 147920 -26160 0 0 {name=p146995 lab=_60285_/A }
C {devices/lab_pin.sym} 147920 -26120 0 0 {name=p146996 lab=_64386_/A }
C {devices/lab_pin.sym} 148040 -26140 0 1 {name=p146997 lab=_60285_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -26140 0 0 {name=X_60285_ }
C {devices/lab_pin.sym} 147900 -26040 0 0 {name=p146998 lab=_87941_/Q }
C {devices/lab_pin.sym} 147900 -26000 0 0 {name=p146999 lab=_66875_/X }
C {devices/lab_pin.sym} 147900 -25960 0 0 {name=p147000 lab=_66807_/X }
C {devices/lab_pin.sym} 147900 -25920 0 0 {name=p147001 lab=_66900_/X }
C {devices/lab_pin.sym} 148060 -25980 0 1 {name=p147002 lab=_66901_/X }
C {sky130_stdcells/a211o_4.sym} 147980 -25980 0 0 {name=X_66901_ }
C {devices/lab_pin.sym} 147940 -25830 0 0 {name=p147003 lab=_61736_/A }
C {devices/lab_pin.sym} 148020 -25830 0 1 {name=p147004 lab=_62142_/A }
C {sky130_stdcells/buf_2.sym} 147980 -25830 0 0 {name=X_62024_ }
C {devices/lab_pin.sym} 147900 -25740 0 0 {name=p147005 lab=_87900_/Q }
C {devices/lab_pin.sym} 147900 -25700 0 0 {name=p147006 lab=_67831_/X }
C {devices/lab_pin.sym} 147900 -25660 0 0 {name=p147007 lab=_67879_/X }
C {devices/lab_pin.sym} 147900 -25620 0 0 {name=p147008 lab=_67880_/X }
C {devices/lab_pin.sym} 148060 -25680 0 1 {name=p147009 lab=_67881_/X }
C {sky130_stdcells/a211o_4.sym} 147980 -25680 0 0 {name=X_67881_ }
C {devices/lab_pin.sym} 147900 -25550 0 0 {name=p147010 lab=_79859_/A }
C {devices/lab_pin.sym} 147900 -25510 0 0 {name=p147011 lab=_79858_/Y }
C {devices/lab_pin.sym} 147900 -25470 0 0 {name=p147012 lab=_79866_/X }
C {devices/lab_pin.sym} 148060 -25510 0 1 {name=p147013 lab=_79868_/B }
C {sky130_stdcells/o21ai_4.sym} 147980 -25510 0 0 {name=X_79867_ }
C {devices/lab_pin.sym} 147900 -25400 0 0 {name=p147014 lab=_72855_/A }
C {devices/lab_pin.sym} 147900 -25360 0 0 {name=p147015 lab=_44299_/A }
C {devices/lab_pin.sym} 147900 -25320 0 0 {name=p147016 lab=_69617_/X }
C {devices/lab_pin.sym} 147900 -25280 0 0 {name=p147017 lab=_69619_/Y }
C {devices/lab_pin.sym} 148060 -25340 0 1 {name=p147018 lab=_69620_/X }
C {sky130_stdcells/a211o_4.sym} 147980 -25340 0 0 {name=X_69620_ }
C {devices/lab_pin.sym} 147900 -25210 0 0 {name=p147019 lab=_66829_/X }
C {devices/lab_pin.sym} 147900 -25170 0 0 {name=p147020 lab=_66831_/X }
C {devices/lab_pin.sym} 147900 -25130 0 0 {name=p147021 lab=_66787_/X }
C {devices/lab_pin.sym} 148060 -25170 0 1 {name=p147022 lab=_66832_/X }
C {sky130_stdcells/a21o_4.sym} 147980 -25170 0 0 {name=X_66832_ }
C {devices/lab_pin.sym} 147920 -25050 0 0 {name=p147023 lab=_79122_/A }
C {devices/lab_pin.sym} 147920 -25010 0 0 {name=p147024 lab=_79122_/B }
C {devices/lab_pin.sym} 147920 -24970 0 0 {name=p147025 lab=_78818_/C }
C {devices/lab_pin.sym} 148040 -25010 0 1 {name=p147026 lab=_78818_/Y }
C {sky130_stdcells/nand3_4.sym} 147980 -25010 0 0 {name=X_78818_ }
C {devices/lab_pin.sym} 147940 -24870 0 0 {name=p147027 lab=_48978_/A }
C {devices/lab_pin.sym} 148020 -24870 0 1 {name=p147028 lab=_48979_/A }
C {sky130_stdcells/buf_2.sym} 147980 -24870 0 0 {name=X_48978_ }
C {devices/lab_pin.sym} 147920 -24760 0 0 {name=p147029 lab=_79796_/X }
C {devices/lab_pin.sym} 147920 -24720 0 0 {name=p147030 lab=_79798_/B }
C {devices/lab_pin.sym} 148040 -24740 0 1 {name=p147031 lab=_79798_/Y }
C {sky130_stdcells/xnor2_4.sym} 147980 -24740 0 0 {name=X_79798_ }
C {devices/lab_pin.sym} 147900 -24640 0 0 {name=p147032 lab=_69505_/X }
C {devices/lab_pin.sym} 147900 -24600 0 0 {name=p147033 lab=_46199_/X }
C {devices/lab_pin.sym} 147900 -24560 0 0 {name=p147034 lab=_69549_/Y }
C {devices/lab_pin.sym} 147900 -24520 0 0 {name=p147035 lab=_69550_/Y }
C {devices/lab_pin.sym} 148060 -24580 0 1 {name=p147036 lab=_69551_/X }
C {sky130_stdcells/a211o_4.sym} 147980 -24580 0 0 {name=X_69551_ }
C {devices/lab_pin.sym} 147900 -24450 0 0 {name=p147037 lab=_47925_/Y }
C {devices/lab_pin.sym} 147900 -24410 0 0 {name=p147038 lab=_47903_/X }
C {devices/lab_pin.sym} 147900 -24370 0 0 {name=p147039 lab=_47928_/X }
C {devices/lab_pin.sym} 148060 -24410 0 1 {name=p147040 lab=_86585_/D }
C {sky130_stdcells/a21oi_4.sym} 147980 -24410 0 0 {name=X_47929_ }
C {devices/lab_pin.sym} 147940 -24270 0 0 {name=p147041 lab=_68347_/A }
C {devices/lab_pin.sym} 148020 -24270 0 1 {name=p147042 lab=_66879_/A }
C {sky130_stdcells/buf_2.sym} 147980 -24270 0 0 {name=X_66763_ }
C {devices/lab_pin.sym} 147940 -24150 0 0 {name=p147043 lab=_78749_/A }
C {devices/lab_pin.sym} 148020 -24150 0 1 {name=p147044 lab=_78749_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -24150 0 0 {name=X_78749_ }
C {devices/lab_pin.sym} 147900 -24070 0 0 {name=p147045 lab=_63968_/Y }
C {devices/lab_pin.sym} 147900 -24030 0 0 {name=p147046 lab=_63969_/X }
C {devices/lab_pin.sym} 147900 -23990 0 0 {name=p147047 lab=_63971_/Y }
C {devices/lab_pin.sym} 147900 -23950 0 0 {name=p147048 lab=_63973_/Y }
C {devices/lab_pin.sym} 147900 -23920 0 0 {name=p147049 lab=_63974_/X }
C {devices/lab_pin.sym} 148060 -23990 0 1 {name=p147050 lab=_63975_/X }
C {sky130_stdcells/a41o_4.sym} 147980 -23990 0 0 {name=X_63975_ }
C {devices/lab_pin.sym} 147920 -23840 0 0 {name=p147051 lab=_68553_/A }
C {devices/lab_pin.sym} 147920 -23800 0 0 {name=p147052 lab=_87758_/Q }
C {devices/lab_pin.sym} 148040 -23820 0 1 {name=p147053 lab=_68502_/X }
C {sky130_stdcells/and2_4.sym} 147980 -23820 0 0 {name=X_68502_ }
C {devices/lab_pin.sym} 147900 -23710 0 0 {name=p147054 lab=_65712_/Y }
C {devices/lab_pin.sym} 147900 -23670 0 0 {name=p147055 lab=_65681_/X }
C {devices/lab_pin.sym} 147900 -23630 0 0 {name=p147056 lab=_65713_/X }
C {devices/lab_pin.sym} 148060 -23670 0 1 {name=p147057 lab=_84183_/D }
C {sky130_stdcells/a21o_4.sym} 147980 -23670 0 0 {name=X_65714_ }
C {devices/lab_pin.sym} 147900 -23550 0 0 {name=p147058 lab=_86103_/Q }
C {devices/lab_pin.sym} 147900 -23510 0 0 {name=p147059 lab=_50936_/X }
C {devices/lab_pin.sym} 147900 -23470 0 0 {name=p147060 lab=_50939_/Y }
C {devices/lab_pin.sym} 148060 -23510 0 1 {name=p147061 lab=_50940_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -23510 0 0 {name=X_50940_ }
C {devices/lab_pin.sym} 147920 -23400 0 0 {name=p147062 lab=_61618_/X }
C {devices/lab_pin.sym} 147920 -23360 0 0 {name=p147063 lab=_62926_/B }
C {devices/lab_pin.sym} 147920 -23320 0 0 {name=p147064 lab=_60255_/B }
C {devices/lab_pin.sym} 147920 -23280 0 0 {name=p147065 lab=_60228_/A }
C {devices/lab_pin.sym} 148040 -23340 0 1 {name=p147066 lab=_62928_/C }
C {sky130_stdcells/nand4_4.sym} 147980 -23340 0 0 {name=X_62926_ }
C {devices/lab_pin.sym} 147890 -23190 0 0 {name=p147067 lab=_81783_/CLK }
C {devices/lab_pin.sym} 147890 -23170 0 0 {name=p147068 lab=_76142_/B }
C {devices/lab_pin.sym} 148070 -23190 0 1 {name=p147069 lab=_41634_/B }
C {sky130_stdcells/dfxtp_4.sym} 147980 -23180 0 0 {name=X_81760_ }
C {devices/lab_pin.sym} 147920 -23060 0 0 {name=p147070 lab=_69383_/A }
C {devices/lab_pin.sym} 147920 -23020 0 0 {name=p147071 lab=_87258_/Q }
C {devices/lab_pin.sym} 148040 -23040 0 1 {name=p147072 lab=_69482_/X }
C {sky130_stdcells/and2_4.sym} 147980 -23040 0 0 {name=X_69482_ }
C {devices/lab_pin.sym} 147920 -22920 0 0 {name=p147073 lab=_66669_/A }
C {devices/lab_pin.sym} 147920 -22880 0 0 {name=p147074 lab=_66694_/B }
C {devices/lab_pin.sym} 148040 -22900 0 1 {name=p147075 lab=_66694_/X }
C {sky130_stdcells/and2_4.sym} 147980 -22900 0 0 {name=X_66694_ }
C {devices/lab_pin.sym} 147900 -22790 0 0 {name=p147076 lab=_68430_/X }
C {devices/lab_pin.sym} 147900 -22750 0 0 {name=p147077 lab=_68432_/X }
C {devices/lab_pin.sym} 147900 -22710 0 0 {name=p147078 lab=_68331_/X }
C {devices/lab_pin.sym} 148060 -22750 0 1 {name=p147079 lab=_68433_/Y }
C {sky130_stdcells/a21oi_4.sym} 147980 -22750 0 0 {name=X_68433_ }
C {devices/lab_pin.sym} 147890 -22610 0 0 {name=p147080 lab=_80679_/CLK }
C {devices/lab_pin.sym} 147890 -22590 0 0 {name=p147081 lab=_75897_/X }
C {devices/lab_pin.sym} 148070 -22610 0 1 {name=p147082 lab=_80679_/D }
C {sky130_stdcells/dfxtp_4.sym} 147980 -22600 0 0 {name=X_80711_ }
C {devices/lab_pin.sym} 147900 -22500 0 0 {name=p147083 lab=_65596_/X }
C {devices/lab_pin.sym} 147900 -22460 0 0 {name=p147084 lab=_83067_/Q }
C {devices/lab_pin.sym} 147900 -22420 0 0 {name=p147085 lab=_65540_/X }
C {devices/lab_pin.sym} 147900 -22380 0 0 {name=p147086 lab=_65644_/X }
C {devices/lab_pin.sym} 148060 -22440 0 1 {name=p147087 lab=_65645_/X }
C {sky130_stdcells/a211o_4.sym} 147980 -22440 0 0 {name=X_65645_ }
C {devices/lab_pin.sym} 147900 -22310 0 0 {name=p147088 lab=_86116_/Q }
C {devices/lab_pin.sym} 147900 -22270 0 0 {name=p147089 lab=_50856_/X }
C {devices/lab_pin.sym} 147900 -22230 0 0 {name=p147090 lab=_50870_/Y }
C {devices/lab_pin.sym} 148060 -22270 0 1 {name=p147091 lab=_50871_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -22270 0 0 {name=X_50871_ }
C {devices/lab_pin.sym} 147920 -22150 0 0 {name=p147092 lab=_62869_/A }
C {devices/lab_pin.sym} 147920 -22110 0 0 {name=p147093 lab=_62812_/B }
C {devices/lab_pin.sym} 147920 -22070 0 0 {name=p147094 lab=_61997_/X }
C {devices/lab_pin.sym} 148040 -22110 0 1 {name=p147095 lab=_62857_/Y }
C {sky130_stdcells/nand3_4.sym} 147980 -22110 0 0 {name=X_62857_ }
C {devices/lab_pin.sym} 147890 -21970 0 0 {name=p147096 lab=_81632_/CLK }
C {devices/lab_pin.sym} 147890 -21950 0 0 {name=p147097 lab=_80191_/Y }
C {devices/lab_pin.sym} 148070 -21970 0 1 {name=p147098 lab=_76728_/A }
C {sky130_stdcells/dfxtp_4.sym} 147980 -21960 0 0 {name=X_81691_ }
C {devices/lab_pin.sym} 147920 -21860 0 0 {name=p147099 lab=_52614_/A }
C {devices/lab_pin.sym} 147920 -21820 0 0 {name=p147100 lab=_52605_/X }
C {devices/lab_pin.sym} 147920 -21780 0 0 {name=p147101 lab=_52622_/C }
C {devices/lab_pin.sym} 147920 -21740 0 0 {name=p147102 lab=_50919_/D }
C {devices/lab_pin.sym} 148040 -21800 0 1 {name=p147103 lab=_52610_/X }
C {sky130_stdcells/and4_4.sym} 147980 -21800 0 0 {name=X_52610_ }
C {devices/lab_pin.sym} 147890 -21650 0 0 {name=p147104 lab=_83431_/CLK }
C {devices/lab_pin.sym} 147890 -21630 0 0 {name=p147105 lab=_71638_/Y }
C {devices/lab_pin.sym} 148070 -21650 0 1 {name=p147106 lab=_83430_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -21640 0 0 {name=X_83430_ }
C {devices/lab_pin.sym} 147940 -21510 0 0 {name=p147107 lab=_59668_/B }
C {devices/lab_pin.sym} 148020 -21510 0 1 {name=p147108 lab=_61809_/C }
C {sky130_stdcells/buf_2.sym} 147980 -21510 0 0 {name=X_61808_ }
C {devices/lab_pin.sym} 148040 -21400 0 1 {name=p147109 lab=_80642_/HI }
C {devices/lab_pin.sym} 148040 -21360 0 1 {name=p147110 lab=THREAD_COUNT[3] }
C {sky130_stdcells/conb_1.sym} 147980 -21380 0 0 {name=X_80642_ }
C {devices/lab_pin.sym} 147940 -21250 0 0 {name=p147111 lab=_68392_/A }
C {devices/lab_pin.sym} 148020 -21250 0 1 {name=p147112 lab=_68757_/A }
C {sky130_stdcells/buf_2.sym} 147980 -21250 0 0 {name=X_68364_ }
C {devices/lab_pin.sym} 147940 -21130 0 0 {name=p147113 lab=_53793_/A }
C {devices/lab_pin.sym} 148020 -21130 0 1 {name=p147114 lab=_53604_/A }
C {sky130_stdcells/buf_2.sym} 147980 -21130 0 0 {name=X_53590_ }
C {devices/lab_pin.sym} 147940 -21010 0 0 {name=p147115 lab=_64902_/A }
C {devices/lab_pin.sym} 148020 -21010 0 1 {name=p147116 lab=_65576_/X }
C {sky130_stdcells/buf_2.sym} 147980 -21010 0 0 {name=X_65576_ }
C {devices/lab_pin.sym} 147940 -20890 0 0 {name=p147117 lab=_62847_/A }
C {devices/lab_pin.sym} 148020 -20890 0 1 {name=p147118 lab=_62789_/A }
C {sky130_stdcells/buf_2.sym} 147980 -20890 0 0 {name=X_62788_ }
C {devices/lab_pin.sym} 147940 -20770 0 0 {name=p147119 lab=clkbuf_8_9_0_CLK/A }
C {devices/lab_pin.sym} 148020 -20770 0 1 {name=p147120 lab=clkbuf_8_8_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 147980 -20770 0 0 {name=Xclkbuf_8_8_0_CLK }
C {devices/lab_pin.sym} 147900 -20680 0 0 {name=p147121 lab=_88372_/Q }
C {devices/lab_pin.sym} 147900 -20640 0 0 {name=p147122 lab=_67311_/X }
C {devices/lab_pin.sym} 147900 -20600 0 0 {name=p147123 lab=_67313_/X }
C {devices/lab_pin.sym} 147900 -20560 0 0 {name=p147124 lab=_67314_/X }
C {devices/lab_pin.sym} 148060 -20620 0 1 {name=p147125 lab=_67315_/X }
C {sky130_stdcells/a211o_4.sym} 147980 -20620 0 0 {name=X_67315_ }
C {devices/lab_pin.sym} 147940 -20470 0 0 {name=p147126 lab=_52486_/A }
C {devices/lab_pin.sym} 148020 -20470 0 1 {name=p147127 lab=_52541_/X }
C {sky130_stdcells/buf_2.sym} 147980 -20470 0 0 {name=X_52541_ }
C {devices/lab_pin.sym} 147900 -20370 0 0 {name=p147128 lab=_58985_/A }
C {devices/lab_pin.sym} 147900 -20330 0 0 {name=p147129 lab=_64226_/X }
C {devices/lab_pin.sym} 147900 -20290 0 0 {name=p147130 lab=_64526_/Y }
C {devices/lab_pin.sym} 148060 -20330 0 1 {name=p147131 lab=_64527_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -20330 0 0 {name=X_64527_ }
C {devices/lab_pin.sym} 147890 -20190 0 0 {name=p147132 lab=_83756_/CLK }
C {devices/lab_pin.sym} 147890 -20170 0 0 {name=p147133 lab=_83361_/D }
C {devices/lab_pin.sym} 148070 -20190 0 1 {name=p147134 lab=_83361_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -20180 0 0 {name=X_83361_ }
C {devices/lab_pin.sym} 147940 -20050 0 0 {name=p147135 lab=_61842_/A }
C {devices/lab_pin.sym} 148020 -20050 0 1 {name=p147136 lab=_62149_/B }
C {sky130_stdcells/buf_2.sym} 147980 -20050 0 0 {name=X_61739_ }
C {devices/lab_pin.sym} 147900 -19950 0 0 {name=p147137 lab=_80557_/X }
C {devices/lab_pin.sym} 147900 -19910 0 0 {name=p147138 lab=_80561_/B }
C {devices/lab_pin.sym} 147900 -19870 0 0 {name=p147139 lab=_80572_/X }
C {devices/lab_pin.sym} 148060 -19910 0 1 {name=p147140 lab=_80573_/X }
C {sky130_stdcells/a21o_4.sym} 147980 -19910 0 0 {name=X_80573_ }
C {devices/lab_pin.sym} 147940 -19770 0 0 {name=p147141 lab=_68737_/A }
C {devices/lab_pin.sym} 148020 -19770 0 1 {name=p147142 lab=_68295_/X }
C {sky130_stdcells/buf_2.sym} 147980 -19770 0 0 {name=X_68295_ }
C {sky130_stdcells/decap_3.sym} 147980 -19620 0 0 {name=XPHY_208 }
C {sky130_stdcells/decap_3.sym} 147980 -19440 0 0 {name=XPHY_219 }
C {devices/lab_pin.sym} 147890 -19290 0 0 {name=p147143 lab=_85100_/CLK }
C {devices/lab_pin.sym} 147890 -19270 0 0 {name=p147144 lab=_57022_/Y }
C {devices/lab_pin.sym} 148070 -19290 0 1 {name=p147145 lab=_45719_/A }
C {sky130_stdcells/dfxtp_4.sym} 147980 -19280 0 0 {name=X_85100_ }
C {devices/lab_pin.sym} 147890 -19150 0 0 {name=p147146 lab=_80835_/CLK }
C {devices/lab_pin.sym} 147890 -19130 0 0 {name=p147147 lab=_77044_/B }
C {devices/lab_pin.sym} 148070 -19150 0 1 {name=p147148 lab=_82312_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -19140 0 0 {name=X_82312_ }
C {devices/lab_pin.sym} 147900 -19030 0 0 {name=p147149 lab=_55257_/X }
C {devices/lab_pin.sym} 147900 -18990 0 0 {name=p147150 lab=_55259_/X }
C {devices/lab_pin.sym} 147900 -18950 0 0 {name=p147151 lab=_55138_/X }
C {devices/lab_pin.sym} 148060 -18990 0 1 {name=p147152 lab=_55264_/A }
C {sky130_stdcells/a21o_4.sym} 147980 -18990 0 0 {name=X_55260_ }
C {devices/lab_pin.sym} 147890 -18850 0 0 {name=p147153 lab=_85761_/CLK }
C {devices/lab_pin.sym} 147890 -18830 0 0 {name=p147154 lab=_86080_/D }
C {devices/lab_pin.sym} 148070 -18850 0 1 {name=p147155 lab=_86080_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -18840 0 0 {name=X_86080_ }
C {devices/lab_pin.sym} 147900 -18740 0 0 {name=p147156 lab=_88375_/Q }
C {devices/lab_pin.sym} 147900 -18700 0 0 {name=p147157 lab=_67193_/X }
C {devices/lab_pin.sym} 147900 -18660 0 0 {name=p147158 lab=_67194_/X }
C {devices/lab_pin.sym} 147900 -18620 0 0 {name=p147159 lab=_67245_/X }
C {devices/lab_pin.sym} 148060 -18680 0 1 {name=p147160 lab=_67246_/X }
C {sky130_stdcells/a211o_4.sym} 147980 -18680 0 0 {name=X_67246_ }
C {devices/lab_pin.sym} 147920 -18540 0 0 {name=p147161 lab=_52476_/A }
C {devices/lab_pin.sym} 147920 -18500 0 0 {name=p147162 lab=_46367_/Y }
C {devices/lab_pin.sym} 148040 -18520 0 1 {name=p147163 lab=_52472_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -18520 0 0 {name=X_52472_ }
C {devices/lab_pin.sym} 147920 -18410 0 0 {name=p147164 lab=_64223_/A }
C {devices/lab_pin.sym} 147920 -18370 0 0 {name=p147165 lab=_64458_/B }
C {devices/lab_pin.sym} 147920 -18330 0 0 {name=p147166 lab=_64545_/C }
C {devices/lab_pin.sym} 148040 -18370 0 1 {name=p147167 lab=_64458_/X }
C {sky130_stdcells/and3_4.sym} 147980 -18370 0 0 {name=X_64458_ }
C {devices/lab_pin.sym} 147890 -18230 0 0 {name=p147168 lab=_85538_/CLK }
C {devices/lab_pin.sym} 147890 -18210 0 0 {name=p147169 lab=_72065_/Y }
C {devices/lab_pin.sym} 148070 -18230 0 1 {name=p147170 lab=_83292_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -18220 0 0 {name=X_83292_ }
C {devices/lab_pin.sym} 147920 -18100 0 0 {name=p147171 lab=_54215_/A }
C {devices/lab_pin.sym} 147920 -18060 0 0 {name=p147172 lab=_47431_/Y }
C {devices/lab_pin.sym} 148040 -18080 0 1 {name=p147173 lab=_54211_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -18080 0 0 {name=X_54211_ }
C {devices/lab_pin.sym} 147890 -17950 0 0 {name=p147174 lab=_85031_/CLK }
C {devices/lab_pin.sym} 147890 -17930 0 0 {name=p147175 lab=_57351_/Y }
C {devices/lab_pin.sym} 148070 -17950 0 1 {name=p147176 lab=_57349_/B }
C {sky130_stdcells/dfxtp_4.sym} 147980 -17940 0 0 {name=X_85031_ }
C {devices/lab_pin.sym} 147900 -17830 0 0 {name=p147177 lab=_51419_/Y }
C {devices/lab_pin.sym} 147900 -17790 0 0 {name=p147178 lab=_51420_/X }
C {devices/lab_pin.sym} 147900 -17750 0 0 {name=p147179 lab=_51422_/X }
C {devices/lab_pin.sym} 148060 -17790 0 1 {name=p147180 lab=_51423_/Y }
C {sky130_stdcells/a21oi_4.sym} 147980 -17790 0 0 {name=X_51423_ }
C {devices/lab_pin.sym} 147940 -17650 0 0 {name=p147181 lab=_63471_/A }
C {devices/lab_pin.sym} 148020 -17650 0 1 {name=p147182 lab=_63410_/D }
C {sky130_stdcells/buf_2.sym} 147980 -17650 0 0 {name=X_63409_ }
C {devices/lab_pin.sym} 147890 -17530 0 0 {name=p147183 lab=_81859_/CLK }
C {devices/lab_pin.sym} 147890 -17510 0 0 {name=p147184 lab=_80287_/X }
C {devices/lab_pin.sym} 148070 -17530 0 1 {name=p147185 lab=_82243_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -17520 0 0 {name=X_82243_ }
C {devices/lab_pin.sym} 147940 -17390 0 0 {name=p147186 lab=_55711_/A }
C {devices/lab_pin.sym} 148020 -17390 0 1 {name=p147187 lab=_55192_/A }
C {sky130_stdcells/buf_2.sym} 147980 -17390 0 0 {name=X_55191_ }
C {devices/lab_pin.sym} 147920 -17280 0 0 {name=p147188 lab=_67131_/A }
C {devices/lab_pin.sym} 147920 -17240 0 0 {name=p147189 lab=_87610_/Q }
C {devices/lab_pin.sym} 148040 -17260 0 1 {name=p147190 lab=_67177_/X }
C {sky130_stdcells/and2_4.sym} 147980 -17260 0 0 {name=X_67177_ }
C {devices/lab_pin.sym} 147920 -17140 0 0 {name=p147191 lab=_59421_/A }
C {devices/lab_pin.sym} 147920 -17100 0 0 {name=p147192 lab=_64418_/B }
C {devices/lab_pin.sym} 148040 -17120 0 1 {name=p147193 lab=_64389_/Y }
C {sky130_stdcells/nor2_4.sym} 147980 -17120 0 0 {name=X_64389_ }
C {devices/lab_pin.sym} 147920 -17000 0 0 {name=p147194 lab=_54149_/A }
C {devices/lab_pin.sym} 147920 -16960 0 0 {name=p147195 lab=_47306_/A }
C {devices/lab_pin.sym} 148040 -16980 0 1 {name=p147196 lab=_54142_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -16980 0 0 {name=X_54142_ }
C {devices/lab_pin.sym} 147900 -16880 0 0 {name=p147197 lab=_66125_/X }
C {devices/lab_pin.sym} 147900 -16840 0 0 {name=p147198 lab=_86226_/Q }
C {devices/lab_pin.sym} 147900 -16800 0 0 {name=p147199 lab=_66021_/X }
C {devices/lab_pin.sym} 147900 -16760 0 0 {name=p147200 lab=_66127_/X }
C {devices/lab_pin.sym} 148060 -16820 0 1 {name=p147201 lab=_66128_/X }
C {sky130_stdcells/a211o_4.sym} 147980 -16820 0 0 {name=X_66128_ }
C {devices/lab_pin.sym} 147920 -16680 0 0 {name=p147202 lab=_51350_/A }
C {devices/lab_pin.sym} 147920 -16640 0 0 {name=p147203 lab=_49320_/B }
C {devices/lab_pin.sym} 148040 -16660 0 1 {name=p147204 lab=_51354_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -16660 0 0 {name=X_51354_ }
C {devices/lab_pin.sym} 147890 -16530 0 0 {name=p147205 lab=_82575_/CLK }
C {devices/lab_pin.sym} 147890 -16510 0 0 {name=p147206 lab=_84166_/Q }
C {devices/lab_pin.sym} 148070 -16530 0 1 {name=p147207 lab=_77994_/A }
C {sky130_stdcells/dfxtp_4.sym} 147980 -16520 0 0 {name=X_82174_ }
C {devices/lab_pin.sym} 147900 -16410 0 0 {name=p147208 lab=_50303_/Y }
C {devices/lab_pin.sym} 147900 -16370 0 0 {name=p147209 lab=_50299_/X }
C {devices/lab_pin.sym} 147900 -16330 0 0 {name=p147210 lab=_50304_/Y }
C {devices/lab_pin.sym} 148060 -16370 0 1 {name=p147211 lab=_86227_/D }
C {sky130_stdcells/a21boi_4.sym} 147980 -16370 0 0 {name=X_50305_ }
C {devices/lab_pin.sym} 147890 -16230 0 0 {name=p147212 lab=_81125_/CLK }
C {devices/lab_pin.sym} 147890 -16210 0 0 {name=p147213 lab=_81125_/D }
C {devices/lab_pin.sym} 148070 -16230 0 1 {name=p147214 lab=_40741_/A }
C {sky130_stdcells/dfxtp_4.sym} 147980 -16220 0 0 {name=X_81125_ }
C {devices/lab_pin.sym} 147900 -16110 0 0 {name=p147215 lab=_58796_/X }
C {devices/lab_pin.sym} 147900 -16070 0 0 {name=p147216 lab=_86083_/Q }
C {devices/lab_pin.sym} 147900 -16030 0 0 {name=p147217 lab=_58949_/X }
C {devices/lab_pin.sym} 148060 -16070 0 1 {name=p147218 lab=_58950_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -16070 0 0 {name=X_58950_ }
C {devices/lab_pin.sym} 147920 -15940 0 0 {name=p147219 lab=_54068_/X }
C {devices/lab_pin.sym} 147920 -15900 0 0 {name=p147220 lab=_54073_/B }
C {devices/lab_pin.sym} 148040 -15920 0 1 {name=p147221 lab=_54073_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -15920 0 0 {name=X_54073_ }
C {devices/lab_pin.sym} 147920 -15800 0 0 {name=p147222 lab=_65980_/X }
C {devices/lab_pin.sym} 147920 -15760 0 0 {name=p147223 lab=_86551_/Q }
C {devices/lab_pin.sym} 148040 -15780 0 1 {name=p147224 lab=_66059_/X }
C {sky130_stdcells/and2_4.sym} 147980 -15780 0 0 {name=X_66059_ }
C {devices/lab_pin.sym} 147940 -15650 0 0 {name=p147225 lab=_51259_/A }
C {devices/lab_pin.sym} 148020 -15650 0 1 {name=p147226 lab=_51285_/X }
C {sky130_stdcells/buf_2.sym} 147980 -15650 0 0 {name=X_51285_ }
C {devices/lab_pin.sym} 147890 -15530 0 0 {name=p147227 lab=_86982_/CLK }
C {devices/lab_pin.sym} 147890 -15510 0 0 {name=p147228 lab=_86982_/D }
C {devices/lab_pin.sym} 148070 -15530 0 1 {name=p147229 lab=_86982_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -15520 0 0 {name=X_86982_ }
C {devices/lab_pin.sym} 147900 -15410 0 0 {name=p147230 lab=_53022_/Y }
C {devices/lab_pin.sym} 147900 -15370 0 0 {name=p147231 lab=_53001_/X }
C {devices/lab_pin.sym} 147900 -15330 0 0 {name=p147232 lab=_53023_/X }
C {devices/lab_pin.sym} 148060 -15370 0 1 {name=p147233 lab=_53024_/Y }
C {sky130_stdcells/a21oi_4.sym} 147980 -15370 0 0 {name=X_53024_ }
C {devices/lab_pin.sym} 147940 -15230 0 0 {name=p147234 lab=_64713_/A }
C {devices/lab_pin.sym} 148020 -15230 0 1 {name=p147235 lab=_58876_/A }
C {sky130_stdcells/buf_2.sym} 147980 -15230 0 0 {name=X_57901_ }
C {devices/lab_pin.sym} 147940 -15110 0 0 {name=p147236 lab=_50595_/A }
C {devices/lab_pin.sym} 148020 -15110 0 1 {name=p147237 lab=_50505_/A }
C {sky130_stdcells/buf_2.sym} 147980 -15110 0 0 {name=X_50236_ }
C {devices/lab_pin.sym} 147890 -14990 0 0 {name=p147238 lab=_86091_/CLK }
C {devices/lab_pin.sym} 147890 -14970 0 0 {name=p147239 lab=_51861_/Y }
C {devices/lab_pin.sym} 148070 -14990 0 1 {name=p147240 lab=_85933_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -14980 0 0 {name=X_85933_ }
C {devices/lab_pin.sym} 147890 -14850 0 0 {name=p147241 lab=_85332_/CLK }
C {devices/lab_pin.sym} 147890 -14830 0 0 {name=p147242 lab=_75550_/Y }
C {devices/lab_pin.sym} 148070 -14850 0 1 {name=p147243 lab=_81056_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -14840 0 0 {name=X_81056_ }
C {devices/lab_pin.sym} 147900 -14730 0 0 {name=p147244 lab=_58787_/X }
C {devices/lab_pin.sym} 147900 -14690 0 0 {name=p147245 lab=_86089_/Q }
C {devices/lab_pin.sym} 147900 -14650 0 0 {name=p147246 lab=_58880_/X }
C {devices/lab_pin.sym} 148060 -14690 0 1 {name=p147247 lab=_58881_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -14690 0 0 {name=X_58881_ }
C {devices/lab_pin.sym} 147920 -14560 0 0 {name=p147248 lab=_80005_/X }
C {devices/lab_pin.sym} 147920 -14520 0 0 {name=p147249 lab=_80006_/X }
C {devices/lab_pin.sym} 148040 -14540 0 1 {name=p147250 lab=_80007_/Y }
C {sky130_stdcells/xnor2_4.sym} 147980 -14540 0 0 {name=X_80007_ }
C {devices/lab_pin.sym} 147920 -14420 0 0 {name=p147251 lab=_57806_/X }
C {devices/lab_pin.sym} 147920 -14380 0 0 {name=p147252 lab=_57832_/B }
C {devices/lab_pin.sym} 148040 -14400 0 1 {name=p147253 lab=_57832_/Y }
C {sky130_stdcells/nor2_4.sym} 147980 -14400 0 0 {name=X_57832_ }
C {devices/lab_pin.sym} 147900 -14300 0 0 {name=p147254 lab=_69746_/X }
C {devices/lab_pin.sym} 147900 -14260 0 0 {name=p147255 lab=_69813_/Y }
C {devices/lab_pin.sym} 147900 -14220 0 0 {name=p147256 lab=_69815_/X }
C {devices/lab_pin.sym} 147900 -14180 0 0 {name=p147257 lab=_69817_/Y }
C {devices/lab_pin.sym} 148060 -14240 0 1 {name=p147258 lab=_69818_/X }
C {sky130_stdcells/a211o_4.sym} 147980 -14240 0 0 {name=X_69818_ }
C {devices/lab_pin.sym} 147920 -14110 0 0 {name=p147259 lab=_50677_/A }
C {devices/lab_pin.sym} 147920 -14070 0 0 {name=p147260 lab=_51256_/B }
C {devices/lab_pin.sym} 147920 -14030 0 0 {name=p147261 lab=_50147_/C }
C {devices/lab_pin.sym} 148040 -14070 0 1 {name=p147262 lab=_50167_/X }
C {sky130_stdcells/and3_4.sym} 147980 -14070 0 0 {name=X_50167_ }
C {devices/lab_pin.sym} 147890 -13930 0 0 {name=p147263 lab=_85859_/CLK }
C {devices/lab_pin.sym} 147890 -13910 0 0 {name=p147264 lab=_85864_/D }
C {devices/lab_pin.sym} 148070 -13930 0 1 {name=p147265 lab=_85864_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -13920 0 0 {name=X_85864_ }
C {devices/lab_pin.sym} 147890 -13790 0 0 {name=p147266 lab=_88108_/CLK }
C {devices/lab_pin.sym} 147890 -13770 0 0 {name=p147267 lab=_87603_/D }
C {devices/lab_pin.sym} 148070 -13790 0 1 {name=p147268 lab=_73554_/A }
C {sky130_stdcells/dfxtp_4.sym} 147980 -13780 0 0 {name=X_87603_ }
C {devices/lab_pin.sym} 147890 -13650 0 0 {name=p147269 lab=_84815_/CLK }
C {devices/lab_pin.sym} 147890 -13630 0 0 {name=p147270 lab=_84815_/D }
C {devices/lab_pin.sym} 148070 -13650 0 1 {name=p147271 lab=_84815_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -13640 0 0 {name=X_84815_ }
C {devices/lab_pin.sym} 147940 -13510 0 0 {name=p147272 lab=_58793_/A }
C {devices/lab_pin.sym} 148020 -13510 0 1 {name=p147273 lab=_57763_/X }
C {sky130_stdcells/buf_2.sym} 147980 -13510 0 0 {name=X_57763_ }
C {devices/lab_pin.sym} 147920 -13400 0 0 {name=p147274 lab=_68587_/X }
C {devices/lab_pin.sym} 147920 -13360 0 0 {name=p147275 lab=_69749_/B }
C {devices/lab_pin.sym} 148040 -13380 0 1 {name=p147276 lab=_69749_/Y }
C {sky130_stdcells/nor2_4.sym} 147980 -13380 0 0 {name=X_69749_ }
C {devices/lab_pin.sym} 147900 -13270 0 0 {name=p147277 lab=_50096_/Y }
C {devices/lab_pin.sym} 147900 -13230 0 0 {name=p147278 lab=_50092_/X }
C {devices/lab_pin.sym} 147900 -13190 0 0 {name=p147279 lab=_50097_/X }
C {devices/lab_pin.sym} 148060 -13230 0 1 {name=p147280 lab=_86265_/D }
C {sky130_stdcells/a21oi_4.sym} 147980 -13230 0 0 {name=X_50098_ }
C {devices/lab_pin.sym} 147900 -13110 0 0 {name=p147281 lab=_54970_/Y }
C {devices/lab_pin.sym} 147900 -13070 0 0 {name=p147282 lab=_54971_/X }
C {devices/lab_pin.sym} 147900 -13030 0 0 {name=p147283 lab=_54974_/X }
C {devices/lab_pin.sym} 148060 -13070 0 1 {name=p147284 lab=_54975_/Y }
C {sky130_stdcells/a21oi_4.sym} 147980 -13070 0 0 {name=X_54975_ }
C {devices/lab_pin.sym} 147890 -12930 0 0 {name=p147285 lab=_86736_/CLK }
C {devices/lab_pin.sym} 147890 -12910 0 0 {name=p147286 lab=_85795_/D }
C {devices/lab_pin.sym} 148070 -12930 0 1 {name=p147287 lab=_65375_/B }
C {sky130_stdcells/dfxtp_4.sym} 147980 -12920 0 0 {name=X_85795_ }
C {devices/lab_pin.sym} 147920 -12800 0 0 {name=p147288 lab=_59501_/X }
C {devices/lab_pin.sym} 147920 -12760 0 0 {name=p147289 lab=_58532_/X }
C {devices/lab_pin.sym} 148040 -12780 0 1 {name=p147290 lab=_59502_/Y }
C {sky130_stdcells/nor2_4.sym} 147980 -12780 0 0 {name=X_59502_ }
C {devices/lab_pin.sym} 147940 -12650 0 0 {name=p147291 lab=clkbuf_4_0_1_CLK/A }
C {devices/lab_pin.sym} 148020 -12650 0 1 {name=p147292 lab=clkbuf_4_0_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 147980 -12650 0 0 {name=Xclkbuf_4_0_1_CLK }
C {devices/lab_pin.sym} 147900 -12550 0 0 {name=p147293 lab=_45890_/X }
C {devices/lab_pin.sym} 147900 -12510 0 0 {name=p147294 lab=_44228_/X }
C {devices/lab_pin.sym} 147900 -12470 0 0 {name=p147295 lab=_56663_/X }
C {devices/lab_pin.sym} 148060 -12510 0 1 {name=p147296 lab=_56714_/Y }
C {sky130_stdcells/a21oi_4.sym} 147980 -12510 0 0 {name=X_56714_ }
C {devices/lab_pin.sym} 147890 -12370 0 0 {name=p147297 lab=_88084_/CLK }
C {devices/lab_pin.sym} 147890 -12350 0 0 {name=p147298 lab=_87534_/D }
C {devices/lab_pin.sym} 148070 -12370 0 1 {name=p147299 lab=_87534_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -12360 0 0 {name=X_87534_ }
C {devices/lab_pin.sym} 147900 -12270 0 0 {name=p147300 lab=_41937_/X }
C {devices/lab_pin.sym} 147900 -12230 0 0 {name=p147301 lab=_41919_/X }
C {devices/lab_pin.sym} 147900 -12190 0 0 {name=p147302 lab=_40673_/X }
C {devices/lab_pin.sym} 147900 -12150 0 0 {name=p147303 lab=_41938_/Y }
C {devices/lab_pin.sym} 147900 -12110 0 0 {name=p147304 lab=_41939_/X }
C {devices/lab_pin.sym} 148060 -12190 0 1 {name=p147305 lab=_88100_/D }
C {sky130_stdcells/o32ai_4.sym} 147980 -12190 0 0 {name=X_41940_ }
C {devices/lab_pin.sym} 147900 -12050 0 0 {name=p147306 lab=_53924_/Y }
C {devices/lab_pin.sym} 147900 -12010 0 0 {name=p147307 lab=_53914_/X }
C {devices/lab_pin.sym} 147900 -11970 0 0 {name=p147308 lab=_53925_/Y }
C {devices/lab_pin.sym} 148060 -12010 0 1 {name=p147309 lab=_85541_/D }
C {sky130_stdcells/a21boi_4.sym} 147980 -12010 0 0 {name=X_53926_ }
C {devices/lab_pin.sym} 147900 -11900 0 0 {name=p147310 lab=_72755_/X }
C {devices/lab_pin.sym} 147900 -11860 0 0 {name=p147311 lab=_83081_/Q }
C {devices/lab_pin.sym} 147900 -11820 0 0 {name=p147312 lab=_45885_/X }
C {devices/lab_pin.sym} 147900 -11780 0 0 {name=p147313 lab=_72759_/X }
C {devices/lab_pin.sym} 148060 -11840 0 1 {name=p147314 lab=_72761_/B }
C {sky130_stdcells/a211o_4.sym} 147980 -11840 0 0 {name=X_72760_ }
C {devices/lab_pin.sym} 147890 -11690 0 0 {name=p147315 lab=_84746_/CLK }
C {devices/lab_pin.sym} 147890 -11670 0 0 {name=p147316 lab=_59385_/Y }
C {devices/lab_pin.sym} 148070 -11690 0 1 {name=p147317 lab=_84746_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -11680 0 0 {name=X_84746_ }
C {devices/lab_pin.sym} 147940 -11550 0 0 {name=p147318 lab=_64601_/A }
C {devices/lab_pin.sym} 148020 -11550 0 1 {name=p147319 lab=_57694_/X }
C {sky130_stdcells/buf_2.sym} 147980 -11550 0 0 {name=X_57694_ }
C {devices/lab_pin.sym} 147890 -11430 0 0 {name=p147320 lab=_82301_/CLK }
C {devices/lab_pin.sym} 147890 -11410 0 0 {name=p147321 lab=_83886_/Q }
C {devices/lab_pin.sym} 148070 -11430 0 1 {name=p147322 lab=_81958_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -11420 0 0 {name=X_81958_ }
C {devices/lab_pin.sym} 147920 -11300 0 0 {name=p147323 lab=_71711_/A }
C {devices/lab_pin.sym} 147920 -11260 0 0 {name=p147324 lab=_70698_/B }
C {devices/lab_pin.sym} 148040 -11280 0 1 {name=p147325 lab=_71711_/Y }
C {sky130_stdcells/nor2_4.sym} 147980 -11280 0 0 {name=X_71711_ }
C {devices/lab_pin.sym} 147940 -11150 0 0 {name=p147326 lab=_59433_/A }
C {devices/lab_pin.sym} 148020 -11150 0 1 {name=p147327 lab=_59433_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -11150 0 0 {name=X_59433_ }
C {devices/lab_pin.sym} 147890 -11030 0 0 {name=p147328 lab=_84087_/CLK }
C {devices/lab_pin.sym} 147890 -11010 0 0 {name=p147329 lab=_84085_/Q }
C {devices/lab_pin.sym} 148070 -11030 0 1 {name=p147330 lab=_80909_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -11020 0 0 {name=X_80909_ }
C {devices/lab_pin.sym} 147940 -10890 0 0 {name=p147331 lab=_83332_/Q }
C {devices/lab_pin.sym} 148020 -10890 0 1 {name=p147332 lab=_56645_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -10890 0 0 {name=X_56645_ }
C {devices/lab_pin.sym} 147890 -10770 0 0 {name=p147333 lab=_87210_/CLK }
C {devices/lab_pin.sym} 147890 -10750 0 0 {name=p147334 lab=_87465_/D }
C {devices/lab_pin.sym} 148070 -10770 0 1 {name=p147335 lab=_87465_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -10760 0 0 {name=X_87465_ }
C {devices/lab_pin.sym} 147940 -10630 0 0 {name=p147336 lab=_41880_/A }
C {devices/lab_pin.sym} 148020 -10630 0 1 {name=p147337 lab=_41872_/A }
C {sky130_stdcells/buf_2.sym} 147980 -10630 0 0 {name=X_41871_ }
C {devices/lab_pin.sym} 147900 -10530 0 0 {name=p147338 lab=_85554_/Q }
C {devices/lab_pin.sym} 147900 -10490 0 0 {name=p147339 lab=_53846_/X }
C {devices/lab_pin.sym} 147900 -10450 0 0 {name=p147340 lab=_53856_/Y }
C {devices/lab_pin.sym} 148060 -10490 0 1 {name=p147341 lab=_53857_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -10490 0 0 {name=X_53857_ }
C {devices/lab_pin.sym} 147920 -10370 0 0 {name=p147342 lab=_72697_/A }
C {devices/lab_pin.sym} 147920 -10330 0 0 {name=p147343 lab=_72697_/B }
C {devices/lab_pin.sym} 147920 -10290 0 0 {name=p147344 lab=_55200_/C }
C {devices/lab_pin.sym} 148040 -10330 0 1 {name=p147345 lab=_72691_/Y }
C {sky130_stdcells/nand3_4.sym} 147980 -10330 0 0 {name=X_72691_ }
C {devices/lab_pin.sym} 147890 -10190 0 0 {name=p147346 lab=_84393_/CLK }
C {devices/lab_pin.sym} 147890 -10170 0 0 {name=p147347 lab=_84677_/D }
C {devices/lab_pin.sym} 148070 -10190 0 1 {name=p147348 lab=_59992_/C }
C {sky130_stdcells/dfxtp_4.sym} 147980 -10180 0 0 {name=X_84677_ }
C {devices/lab_pin.sym} 147890 -10050 0 0 {name=p147349 lab=_82436_/CLK }
C {devices/lab_pin.sym} 147890 -10030 0 0 {name=p147350 lab=_78080_/X }
C {devices/lab_pin.sym} 148070 -10050 0 1 {name=p147351 lab=_81857_/D }
C {sky130_stdcells/dfxtp_4.sym} 147980 -10040 0 0 {name=X_81889_ }
C {devices/lab_pin.sym} 147940 -9910 0 0 {name=p147352 lab=_43610_/A }
C {devices/lab_pin.sym} 148020 -9910 0 1 {name=p147353 lab=_68468_/B }
C {sky130_stdcells/inv_2.sym} 147980 -9910 0 0 {name=X_43610_ }
C {devices/lab_pin.sym} 147940 -9790 0 0 {name=p147354 lab=_74492_/A }
C {devices/lab_pin.sym} 148020 -9790 0 1 {name=p147355 lab=_74430_/X }
C {sky130_stdcells/buf_2.sym} 147980 -9790 0 0 {name=X_74430_ }
C {devices/lab_pin.sym} 147890 -9670 0 0 {name=p147356 lab=_86414_/CLK }
C {devices/lab_pin.sym} 147890 -9650 0 0 {name=p147357 lab=_86416_/D }
C {devices/lab_pin.sym} 148070 -9670 0 1 {name=p147358 lab=_65054_/B }
C {sky130_stdcells/dfxtp_4.sym} 147980 -9660 0 0 {name=X_86416_ }
C {devices/lab_pin.sym} 147940 -9530 0 0 {name=p147359 lab=_40756_/A }
C {devices/lab_pin.sym} 148020 -9530 0 1 {name=p147360 lab=_40822_/X }
C {sky130_stdcells/buf_2.sym} 147980 -9530 0 0 {name=X_40822_ }
C {devices/lab_pin.sym} 147900 -9430 0 0 {name=p147361 lab=_85750_/Q }
C {devices/lab_pin.sym} 147900 -9390 0 0 {name=p147362 lab=_52792_/X }
C {devices/lab_pin.sym} 147900 -9350 0 0 {name=p147363 lab=_52807_/Y }
C {devices/lab_pin.sym} 148060 -9390 0 1 {name=p147364 lab=_52808_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -9390 0 0 {name=X_52808_ }
C {devices/lab_pin.sym} 147920 -9270 0 0 {name=p147365 lab=_71637_/A }
C {devices/lab_pin.sym} 147920 -9230 0 0 {name=p147366 lab=_71256_/B }
C {devices/lab_pin.sym} 147920 -9190 0 0 {name=p147367 lab=_71644_/C }
C {devices/lab_pin.sym} 148040 -9230 0 1 {name=p147368 lab=_71642_/Y }
C {sky130_stdcells/nand3_4.sym} 147980 -9230 0 0 {name=X_71642_ }
C {devices/lab_pin.sym} 147940 -9090 0 0 {name=p147369 lab=_84747_/Q }
C {devices/lab_pin.sym} 148020 -9090 0 1 {name=p147370 lab=_59364_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -9090 0 0 {name=X_59364_ }
C {devices/lab_pin.sym} 147890 -8970 0 0 {name=p147371 lab=_83627_/CLK }
C {devices/lab_pin.sym} 147890 -8950 0 0 {name=p147372 lab=_83628_/D }
C {devices/lab_pin.sym} 148070 -8970 0 1 {name=p147373 lab=_83628_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -8960 0 0 {name=X_83628_ }
C {devices/lab_pin.sym} 147940 -8830 0 0 {name=p147374 lab=_44549_/A }
C {devices/lab_pin.sym} 148020 -8830 0 1 {name=p147375 lab=_44590_/X }
C {sky130_stdcells/buf_2.sym} 147980 -8830 0 0 {name=X_44590_ }
C {devices/lab_pin.sym} 147900 -8740 0 0 {name=p147376 lab=_56568_/X }
C {devices/lab_pin.sym} 147900 -8700 0 0 {name=p147377 lab=_56575_/X }
C {devices/lab_pin.sym} 147900 -8660 0 0 {name=p147378 lab=_55622_/B }
C {devices/lab_pin.sym} 147900 -8620 0 0 {name=p147379 lab=_56572_/X }
C {devices/lab_pin.sym} 148060 -8680 0 1 {name=p147380 lab=_85151_/D }
C {sky130_stdcells/a2bb2o_4.sym} 147980 -8680 0 0 {name=X_56576_ }
C {devices/lab_pin.sym} 147890 -8530 0 0 {name=p147381 lab=_87144_/CLK }
C {devices/lab_pin.sym} 147890 -8510 0 0 {name=p147382 lab=_87396_/D }
C {devices/lab_pin.sym} 148070 -8530 0 1 {name=p147383 lab=_87396_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -8520 0 0 {name=X_87396_ }
C {devices/lab_pin.sym} 147940 -8390 0 0 {name=p147384 lab=_53733_/A }
C {devices/lab_pin.sym} 148020 -8390 0 1 {name=p147385 lab=_53806_/B }
C {sky130_stdcells/buf_2.sym} 147980 -8390 0 0 {name=X_53788_ }
C {devices/lab_pin.sym} 147900 -8290 0 0 {name=p147386 lab=_58310_/X }
C {devices/lab_pin.sym} 147900 -8250 0 0 {name=p147387 lab=_83457_/Q }
C {devices/lab_pin.sym} 147900 -8210 0 0 {name=p147388 lab=_58314_/Y }
C {devices/lab_pin.sym} 148060 -8250 0 1 {name=p147389 lab=_58315_/X }
C {sky130_stdcells/o21a_4.sym} 147980 -8250 0 0 {name=X_58315_ }
C {devices/lab_pin.sym} 147940 -8110 0 0 {name=p147390 lab=_55507_/X }
C {devices/lab_pin.sym} 148020 -8110 0 1 {name=p147391 lab=_55527_/X }
C {sky130_stdcells/buf_2.sym} 147980 -8110 0 0 {name=X_55527_ }
C {devices/lab_pin.sym} 147940 -7990 0 0 {name=p147392 lab=_43540_/Y }
C {devices/lab_pin.sym} 148020 -7990 0 1 {name=p147393 lab=_87368_/D }
C {sky130_stdcells/inv_2.sym} 147980 -7990 0 0 {name=X_43541_ }
C {devices/lab_pin.sym} 147920 -7890 0 0 {name=p147394 lab=_45954_/X }
C {devices/lab_pin.sym} 147920 -7850 0 0 {name=p147395 lab=_58334_/A }
C {devices/lab_pin.sym} 147920 -7810 0 0 {name=p147396 lab=_56167_/A }
C {devices/lab_pin.sym} 148040 -7850 0 1 {name=p147397 lab=_74361_/Y }
C {sky130_stdcells/nand3_4.sym} 147980 -7850 0 0 {name=X_74361_ }
C {devices/lab_pin.sym} 147890 -7710 0 0 {name=p147398 lab=_86351_/CLK }
C {devices/lab_pin.sym} 147890 -7690 0 0 {name=p147399 lab=_86347_/D }
C {devices/lab_pin.sym} 148070 -7710 0 1 {name=p147400 lab=_86347_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -7700 0 0 {name=X_86347_ }
C {devices/lab_pin.sym} 147920 -7580 0 0 {name=p147401 lab=_52744_/A }
C {devices/lab_pin.sym} 147920 -7540 0 0 {name=p147402 lab=_52739_/B }
C {devices/lab_pin.sym} 148040 -7560 0 1 {name=p147403 lab=_52739_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -7560 0 0 {name=X_52739_ }
C {devices/lab_pin.sym} 147940 -7430 0 0 {name=p147404 lab=_40753_/A }
C {devices/lab_pin.sym} 148020 -7430 0 1 {name=p147405 lab=_40753_/X }
C {sky130_stdcells/buf_2.sym} 147980 -7430 0 0 {name=X_40753_ }
C {devices/lab_pin.sym} 147900 -7330 0 0 {name=p147406 lab=_71556_/Y }
C {devices/lab_pin.sym} 147900 -7290 0 0 {name=p147407 lab=_83452_/Q }
C {devices/lab_pin.sym} 147900 -7250 0 0 {name=p147408 lab=_71572_/Y }
C {devices/lab_pin.sym} 148060 -7290 0 1 {name=p147409 lab=_71573_/X }
C {sky130_stdcells/a21o_4.sym} 147980 -7290 0 0 {name=X_71573_ }
C {devices/lab_pin.sym} 147900 -7170 0 0 {name=p147410 lab=_59219_/X }
C {devices/lab_pin.sym} 147900 -7130 0 0 {name=p147411 lab=_85737_/Q }
C {devices/lab_pin.sym} 147900 -7090 0 0 {name=p147412 lab=_59220_/X }
C {devices/lab_pin.sym} 148060 -7130 0 1 {name=p147413 lab=_59295_/X }
C {sky130_stdcells/o21a_4.sym} 147980 -7130 0 0 {name=X_59295_ }
C {devices/lab_pin.sym} 147890 -6990 0 0 {name=p147414 lab=_86592_/CLK }
C {devices/lab_pin.sym} 147890 -6970 0 0 {name=p147415 lab=_71249_/Y }
C {devices/lab_pin.sym} 148070 -6990 0 1 {name=p147416 lab=_83559_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -6980 0 0 {name=X_83559_ }
C {devices/lab_pin.sym} 147920 -6860 0 0 {name=p147417 lab=_81530_/Q }
C {devices/lab_pin.sym} 147920 -6820 0 0 {name=p147418 lab=_76100_/B }
C {devices/lab_pin.sym} 148040 -6840 0 1 {name=p147419 lab=_76100_/X }
C {sky130_stdcells/xor2_4.sym} 147980 -6840 0 0 {name=X_76100_ }
C {devices/lab_pin.sym} 147920 -6720 0 0 {name=p147420 lab=_73312_/A }
C {devices/lab_pin.sym} 147920 -6680 0 0 {name=p147421 lab=_73311_/X }
C {devices/lab_pin.sym} 148040 -6700 0 1 {name=p147422 lab=_73313_/B }
C {sky130_stdcells/nand2_4.sym} 147980 -6700 0 0 {name=X_73312_ }
C {devices/lab_pin.sym} 147940 -6570 0 0 {name=p147423 lab=_46347_/A }
C {devices/lab_pin.sym} 148020 -6570 0 1 {name=p147424 lab=_46288_/A }
C {sky130_stdcells/buf_2.sym} 147980 -6570 0 0 {name=X_46260_ }
C {devices/lab_pin.sym} 147920 -6470 0 0 {name=p147425 lab=_70526_/A }
C {devices/lab_pin.sym} 147920 -6430 0 0 {name=p147426 lab=_70954_/B }
C {devices/lab_pin.sym} 147920 -6390 0 0 {name=p147427 lab=_70962_/C }
C {devices/lab_pin.sym} 148040 -6430 0 1 {name=p147428 lab=_70524_/Y }
C {sky130_stdcells/nand3_4.sym} 147980 -6430 0 0 {name=X_70524_ }
C {devices/lab_pin.sym} 147940 -6290 0 0 {name=p147429 lab=_58246_/A }
C {devices/lab_pin.sym} 148020 -6290 0 1 {name=p147430 lab=_58246_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -6290 0 0 {name=X_58246_ }
C {devices/lab_pin.sym} 147920 -6180 0 0 {name=p147431 lab=_77080_/A }
C {devices/lab_pin.sym} 147920 -6140 0 0 {name=p147432 lab=_77079_/Y }
C {devices/lab_pin.sym} 148040 -6160 0 1 {name=p147433 lab=_77081_/B }
C {sky130_stdcells/xor2_4.sym} 147980 -6160 0 0 {name=X_77080_ }
C {devices/lab_pin.sym} 147940 -6030 0 0 {name=p147434 lab=_43518_/A }
C {devices/lab_pin.sym} 148020 -6030 0 1 {name=p147435 lab=_43472_/X }
C {sky130_stdcells/buf_2.sym} 147980 -6030 0 0 {name=X_43472_ }
C {devices/lab_pin.sym} 147940 -5910 0 0 {name=p147436 lab=_55457_/X }
C {devices/lab_pin.sym} 148020 -5910 0 1 {name=p147437 lab=_55458_/X }
C {sky130_stdcells/buf_2.sym} 147980 -5910 0 0 {name=X_55458_ }
C {devices/lab_pin.sym} 147900 -5810 0 0 {name=p147438 lab=_70273_/A }
C {devices/lab_pin.sym} 147900 -5770 0 0 {name=p147439 lab=_74288_/X }
C {devices/lab_pin.sym} 147900 -5730 0 0 {name=p147440 lab=_74291_/Y }
C {devices/lab_pin.sym} 148060 -5770 0 1 {name=p147441 lab=_74292_/X }
C {sky130_stdcells/a21bo_4.sym} 147980 -5770 0 0 {name=X_74292_ }
C {devices/lab_pin.sym} 147890 -5630 0 0 {name=p147442 lab=_85957_/CLK }
C {devices/lab_pin.sym} 147890 -5610 0 0 {name=p147443 lab=_86278_/D }
C {devices/lab_pin.sym} 148070 -5630 0 1 {name=p147444 lab=_72436_/B }
C {sky130_stdcells/dfxtp_4.sym} 147980 -5620 0 0 {name=X_86278_ }
C {devices/lab_pin.sym} 147900 -5530 0 0 {name=p147445 lab=_40635_/X }
C {devices/lab_pin.sym} 147900 -5490 0 0 {name=p147446 lab=_40638_/X }
C {devices/lab_pin.sym} 147900 -5450 0 0 {name=p147447 lab=_40682_/X }
C {devices/lab_pin.sym} 147900 -5410 0 0 {name=p147448 lab=_88354_/Q }
C {devices/lab_pin.sym} 147900 -5370 0 0 {name=p147449 lab=_40683_/X }
C {devices/lab_pin.sym} 148060 -5450 0 1 {name=p147450 lab=_40685_/A }
C {sky130_stdcells/o32ai_4.sym} 147980 -5450 0 0 {name=X_40684_ }
C {devices/lab_pin.sym} 147900 -5310 0 0 {name=p147451 lab=_85197_/Q }
C {devices/lab_pin.sym} 147900 -5270 0 0 {name=p147452 lab=_45176_/X }
C {devices/lab_pin.sym} 147900 -5230 0 0 {name=p147453 lab=_45210_/X }
C {devices/lab_pin.sym} 148060 -5270 0 1 {name=p147454 lab=_45211_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -5270 0 0 {name=X_45211_ }
C {devices/lab_pin.sym} 147920 -5140 0 0 {name=p147455 lab=_76031_/A }
C {devices/lab_pin.sym} 147920 -5100 0 0 {name=p147456 lab=_76030_/Y }
C {devices/lab_pin.sym} 148040 -5120 0 1 {name=p147457 lab=_81745_/D }
C {sky130_stdcells/xor2_4.sym} 147980 -5120 0 0 {name=X_76031_ }
C {devices/lab_pin.sym} 147900 -5030 0 0 {name=p147458 lab=_42417_/X }
C {devices/lab_pin.sym} 147900 -4990 0 0 {name=p147459 lab=_42410_/X }
C {devices/lab_pin.sym} 147900 -4950 0 0 {name=p147460 lab=_40491_/X }
C {devices/lab_pin.sym} 147900 -4910 0 0 {name=p147461 lab=_87871_/Q }
C {devices/lab_pin.sym} 147900 -4870 0 0 {name=p147462 lab=_42411_/X }
C {devices/lab_pin.sym} 148060 -4950 0 1 {name=p147463 lab=_42424_/A }
C {sky130_stdcells/o32ai_4.sym} 147980 -4950 0 0 {name=X_42423_ }
C {devices/lab_pin.sym} 147890 -4790 0 0 {name=p147464 lab=_87776_/CLK }
C {devices/lab_pin.sym} 147890 -4770 0 0 {name=p147465 lab=_42135_/Y }
C {devices/lab_pin.sym} 148070 -4790 0 1 {name=p147466 lab=_88017_/Q }
C {sky130_stdcells/dfxtp_4.sym} 147980 -4780 0 0 {name=X_88017_ }
C {devices/lab_pin.sym} 147900 -4670 0 0 {name=p147467 lab=_54407_/Y }
C {devices/lab_pin.sym} 147900 -4630 0 0 {name=p147468 lab=_54394_/X }
C {devices/lab_pin.sym} 147900 -4590 0 0 {name=p147469 lab=_54408_/X }
C {devices/lab_pin.sym} 148060 -4630 0 1 {name=p147470 lab=_85448_/D }
C {sky130_stdcells/a21oi_4.sym} 147980 -4630 0 0 {name=X_54409_ }
C {devices/lab_pin.sym} 147900 -4510 0 0 {name=p147471 lab=_73230_/X }
C {devices/lab_pin.sym} 147900 -4470 0 0 {name=p147472 lab=_73232_/Y }
C {devices/lab_pin.sym} 147900 -4430 0 0 {name=p147473 lab=_73242_/X }
C {devices/lab_pin.sym} 148060 -4470 0 1 {name=p147474 lab=_73243_/X }
C {sky130_stdcells/a21o_4.sym} 147980 -4470 0 0 {name=X_73243_ }
C {devices/lab_pin.sym} 147890 -4330 0 0 {name=p147475 lab=_85192_/CLK }
C {devices/lab_pin.sym} 147890 -4310 0 0 {name=p147476 lab=_85229_/D }
C {devices/lab_pin.sym} 148070 -4330 0 1 {name=p147477 lab=_56341_/C }
C {sky130_stdcells/dfxtp_4.sym} 147980 -4320 0 0 {name=X_85229_ }
C {devices/lab_pin.sym} 147920 -4200 0 0 {name=p147478 lab=_86762_/Q }
C {devices/lab_pin.sym} 147920 -4160 0 0 {name=p147479 lab=_46125_/A }
C {devices/lab_pin.sym} 148040 -4180 0 1 {name=p147480 lab=_46196_/A }
C {sky130_stdcells/or2_4.sym} 147980 -4180 0 0 {name=X_46191_ }
C {devices/lab_pin.sym} 147940 -4050 0 0 {name=p147481 lab=_70454_/Y }
C {devices/lab_pin.sym} 148020 -4050 0 1 {name=p147482 lab=_70455_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -4050 0 0 {name=X_70455_ }
C {devices/lab_pin.sym} 147940 -3930 0 0 {name=p147483 lab=_58177_/A }
C {devices/lab_pin.sym} 148020 -3930 0 1 {name=p147484 lab=_58177_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -3930 0 0 {name=X_58177_ }
C {devices/lab_pin.sym} 147900 -3830 0 0 {name=p147485 lab=_56719_/A }
C {devices/lab_pin.sym} 147900 -3790 0 0 {name=p147486 lab=_56719_/B }
C {devices/lab_pin.sym} 147900 -3750 0 0 {name=p147487 lab=_55388_/Y }
C {devices/lab_pin.sym} 148060 -3790 0 1 {name=p147488 lab=_55389_/Y }
C {sky130_stdcells/a21oi_4.sym} 147980 -3790 0 0 {name=X_55389_ }
C {devices/lab_pin.sym} 147900 -3670 0 0 {name=p147489 lab=_45139_/X }
C {devices/lab_pin.sym} 147900 -3630 0 0 {name=p147490 lab=_45141_/Y }
C {devices/lab_pin.sym} 147900 -3590 0 0 {name=p147491 lab=_45125_/X }
C {devices/lab_pin.sym} 148060 -3630 0 1 {name=p147492 lab=_45142_/Y }
C {sky130_stdcells/a21oi_4.sym} 147980 -3630 0 0 {name=X_45142_ }
C {devices/lab_pin.sym} 147920 -3520 0 0 {name=p147493 lab=_83334_/Q }
C {devices/lab_pin.sym} 147920 -3480 0 0 {name=p147494 lab=_83333_/Q }
C {devices/lab_pin.sym} 147920 -3440 0 0 {name=p147495 lab=_56675_/X }
C {devices/lab_pin.sym} 147920 -3400 0 0 {name=p147496 lab=_56876_/X }
C {devices/lab_pin.sym} 148040 -3460 0 1 {name=p147497 lab=_57129_/A }
C {sky130_stdcells/nand4_4.sym} 147980 -3460 0 0 {name=X_57128_ }
C {devices/lab_pin.sym} 147900 -3340 0 0 {name=p147498 lab=_41721_/X }
C {devices/lab_pin.sym} 147900 -3300 0 0 {name=p147499 lab=_42342_/X }
C {devices/lab_pin.sym} 147900 -3260 0 0 {name=p147500 lab=_87906_/Q }
C {devices/lab_pin.sym} 147900 -3220 0 0 {name=p147501 lab=_42343_/X }
C {devices/lab_pin.sym} 148060 -3280 0 1 {name=p147502 lab=_42354_/X }
C {sky130_stdcells/a2bb2o_4.sym} 147980 -3280 0 0 {name=X_42354_ }
C {devices/lab_pin.sym} 147900 -3150 0 0 {name=p147503 lab=_88323_/Q }
C {devices/lab_pin.sym} 147900 -3110 0 0 {name=p147504 lab=_72731_/X }
C {devices/lab_pin.sym} 147900 -3070 0 0 {name=p147505 lab=_56548_/X }
C {devices/lab_pin.sym} 148060 -3110 0 1 {name=p147506 lab=_73174_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -3110 0 0 {name=X_73174_ }
C {devices/lab_pin.sym} 147940 -2970 0 0 {name=p147507 lab=DATA_TO_HASH[3] }
C {devices/lab_pin.sym} 148020 -2970 0 1 {name=p147508 lab=_70387_/A }
C {sky130_stdcells/buf_2.sym} 147980 -2970 0 0 {name=X_70386_ }
C {devices/lab_pin.sym} 147900 -2870 0 0 {name=p147509 lab=_41290_/X }
C {devices/lab_pin.sym} 147900 -2830 0 0 {name=p147510 lab=_82909_/Q }
C {devices/lab_pin.sym} 147900 -2790 0 0 {name=p147511 lab=_41304_/X }
C {devices/lab_pin.sym} 148060 -2830 0 1 {name=p147512 lab=_41305_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -2830 0 0 {name=X_41305_ }
C {devices/lab_pin.sym} 147900 -2710 0 0 {name=p147513 lab=_59381_/X }
C {devices/lab_pin.sym} 147900 -2670 0 0 {name=p147514 lab=_85985_/Q }
C {devices/lab_pin.sym} 147900 -2630 0 0 {name=p147515 lab=_72124_/X }
C {devices/lab_pin.sym} 148060 -2670 0 1 {name=p147516 lab=_72125_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -2670 0 0 {name=X_72125_ }
C {devices/lab_pin.sym} 147900 -2550 0 0 {name=p147517 lab=_86293_/Q }
C {devices/lab_pin.sym} 147900 -2510 0 0 {name=p147518 lab=_49934_/X }
C {devices/lab_pin.sym} 147900 -2470 0 0 {name=p147519 lab=_49949_/Y }
C {devices/lab_pin.sym} 148060 -2510 0 1 {name=p147520 lab=_49950_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -2510 0 0 {name=X_49950_ }
C {devices/lab_pin.sym} 147940 -2370 0 0 {name=p147521 lab=_45297_/A }
C {devices/lab_pin.sym} 148020 -2370 0 1 {name=p147522 lab=_45073_/X }
C {sky130_stdcells/buf_2.sym} 147980 -2370 0 0 {name=X_45073_ }
C {devices/lab_pin.sym} 147900 -2270 0 0 {name=p147523 lab=_57057_/X }
C {devices/lab_pin.sym} 147900 -2230 0 0 {name=p147524 lab=_57058_/Y }
C {devices/lab_pin.sym} 147900 -2190 0 0 {name=p147525 lab=_56953_/X }
C {devices/lab_pin.sym} 148060 -2230 0 1 {name=p147526 lab=_57059_/Y }
C {sky130_stdcells/a21oi_4.sym} 147980 -2230 0 0 {name=X_57059_ }
C {devices/lab_pin.sym} 147940 -2090 0 0 {name=p147527 lab=_42284_/Y }
C {devices/lab_pin.sym} 148020 -2090 0 1 {name=p147528 lab=_42285_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -2090 0 0 {name=X_42285_ }
C {devices/lab_pin.sym} 147900 -1990 0 0 {name=p147529 lab=_77983_/A }
C {devices/lab_pin.sym} 147900 -1950 0 0 {name=p147530 lab=_77983_/C }
C {devices/lab_pin.sym} 147900 -1910 0 0 {name=p147531 lab=_77983_/B }
C {devices/lab_pin.sym} 148060 -1950 0 1 {name=p147532 lab=_77984_/A }
C {sky130_stdcells/a21o_4.sym} 147980 -1950 0 0 {name=X_77982_ }
C {devices/lab_pin.sym} 147920 -1820 0 0 {name=p147533 lab=_48901_/A }
C {devices/lab_pin.sym} 147920 -1780 0 0 {name=p147534 lab=_48901_/B }
C {devices/lab_pin.sym} 148040 -1800 0 1 {name=p147535 lab=_48901_/Y }
C {sky130_stdcells/nand2_4.sym} 147980 -1800 0 0 {name=X_48901_ }
C {devices/lab_pin.sym} 147920 -1700 0 0 {name=p147536 lab=_44024_/A }
C {devices/lab_pin.sym} 147920 -1660 0 0 {name=p147537 lab=_64629_/A }
C {devices/lab_pin.sym} 147920 -1620 0 0 {name=p147538 lab=_57736_/A }
C {devices/lab_pin.sym} 147920 -1580 0 0 {name=p147539 lab=_58834_/A }
C {devices/lab_pin.sym} 148040 -1640 0 1 {name=p147540 lab=_44025_/A }
C {sky130_stdcells/and4_4.sym} 147980 -1640 0 0 {name=X_44024_ }
C {devices/lab_pin.sym} 147920 -1500 0 0 {name=p147541 lab=_84218_/Q }
C {devices/lab_pin.sym} 147920 -1460 0 0 {name=p147542 lab=_83266_/Q }
C {devices/lab_pin.sym} 148040 -1480 0 1 {name=p147543 lab=_79721_/X }
C {sky130_stdcells/xor2_4.sym} 147980 -1480 0 0 {name=X_79721_ }
C {devices/lab_pin.sym} 147940 -1350 0 0 {name=p147544 lab=_41235_/X }
C {devices/lab_pin.sym} 148020 -1350 0 1 {name=p147545 lab=_41236_/X }
C {sky130_stdcells/buf_2.sym} 147980 -1350 0 0 {name=X_41236_ }
C {devices/lab_pin.sym} 147940 -1230 0 0 {name=p147546 lab=_60069_/Y }
C {devices/lab_pin.sym} 148020 -1230 0 1 {name=p147547 lab=_60070_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -1230 0 0 {name=X_60070_ }
C {devices/lab_pin.sym} 147900 -1130 0 0 {name=p147548 lab=_72054_/Y }
C {devices/lab_pin.sym} 147900 -1090 0 0 {name=p147549 lab=_72033_/X }
C {devices/lab_pin.sym} 147900 -1050 0 0 {name=p147550 lab=_72055_/Y }
C {devices/lab_pin.sym} 148060 -1090 0 1 {name=p147551 lab=_83294_/D }
C {sky130_stdcells/a21boi_4.sym} 147980 -1090 0 0 {name=X_72056_ }
C {devices/lab_pin.sym} 147940 -950 0 0 {name=p147552 lab=_76918_/B }
C {devices/lab_pin.sym} 148020 -950 0 1 {name=p147553 lab=_76933_/Y }
C {sky130_stdcells/inv_2.sym} 147980 -950 0 0 {name=X_76933_ }
C {devices/lab_pin.sym} 147940 -830 0 0 {name=p147554 lab=_49854_/A }
C {devices/lab_pin.sym} 148020 -830 0 1 {name=p147555 lab=_49901_/A }
C {sky130_stdcells/buf_2.sym} 147980 -830 0 0 {name=X_49881_ }
C {devices/lab_pin.sym} 147900 -730 0 0 {name=p147556 lab=_51350_/B }
C {devices/lab_pin.sym} 147900 -690 0 0 {name=p147557 lab=_70983_/A }
C {devices/lab_pin.sym} 147900 -650 0 0 {name=p147558 lab=_71006_/Y }
C {devices/lab_pin.sym} 148060 -690 0 1 {name=p147559 lab=_71007_/Y }
C {sky130_stdcells/o21ai_4.sym} 147980 -690 0 0 {name=X_71007_ }
C {devices/lab_pin.sym} 148820 -42170 0 0 {name=p147560 lab=_86474_/Q }
C {devices/lab_pin.sym} 148820 -42130 0 0 {name=p147561 lab=_48809_/X }
C {devices/lab_pin.sym} 148820 -42090 0 0 {name=p147562 lab=_48831_/Y }
C {devices/lab_pin.sym} 148980 -42130 0 1 {name=p147563 lab=_48832_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -42130 0 0 {name=X_48832_ }
C {devices/lab_pin.sym} 148840 -42000 0 0 {name=p147564 lab=_79652_/A }
C {devices/lab_pin.sym} 148840 -41960 0 0 {name=p147565 lab=_79638_/Y }
C {devices/lab_pin.sym} 148960 -41980 0 1 {name=p147566 lab=_79652_/X }
C {sky130_stdcells/or2_4.sym} 148900 -41980 0 0 {name=X_79652_ }
C {devices/lab_pin.sym} 148840 -41860 0 0 {name=p147567 lab=_81718_/Q }
C {devices/lab_pin.sym} 148840 -41820 0 0 {name=p147568 lab=_41145_/B }
C {devices/lab_pin.sym} 148960 -41840 0 1 {name=p147569 lab=_41167_/X }
C {sky130_stdcells/or2_4.sym} 148900 -41840 0 0 {name=X_41167_ }
C {devices/lab_pin.sym} 148840 -41720 0 0 {name=p147570 lab=_81674_/Q }
C {devices/lab_pin.sym} 148840 -41680 0 0 {name=p147571 lab=_76864_/B }
C {devices/lab_pin.sym} 148960 -41700 0 1 {name=p147572 lab=_81370_/D }
C {sky130_stdcells/xor2_4.sym} 148900 -41700 0 0 {name=X_76864_ }
C {devices/lab_pin.sym} 148860 -41570 0 0 {name=p147573 lab=clkbuf_9_236_0_CLK/X }
C {devices/lab_pin.sym} 148940 -41570 0 1 {name=p147574 lab=_83666_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 148900 -41570 0 0 {name=Xclkbuf_10_473_0_CLK }
C {devices/lab_pin.sym} 148820 -41470 0 0 {name=p147575 lab=_78591_/A }
C {devices/lab_pin.sym} 148820 -41430 0 0 {name=p147576 lab=_78602_/Y }
C {devices/lab_pin.sym} 148820 -41390 0 0 {name=p147577 lab=_78575_/B }
C {devices/lab_pin.sym} 148980 -41430 0 1 {name=p147578 lab=_78603_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -41430 0 0 {name=X_78603_ }
C {devices/lab_pin.sym} 148860 -41290 0 0 {name=p147579 lab=_75815_/A }
C {devices/lab_pin.sym} 148940 -41290 0 1 {name=p147580 lab=_75815_/Y }
C {sky130_stdcells/inv_2.sym} 148900 -41290 0 0 {name=X_75815_ }
C {devices/lab_pin.sym} 148840 -41180 0 0 {name=p147581 lab=_48777_/A }
C {devices/lab_pin.sym} 148840 -41140 0 0 {name=p147582 lab=_48763_/B }
C {devices/lab_pin.sym} 148960 -41160 0 1 {name=p147583 lab=_48763_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -41160 0 0 {name=X_48763_ }
C {devices/lab_pin.sym} 148840 -41040 0 0 {name=p147584 lab=_84206_/Q }
C {devices/lab_pin.sym} 148840 -41000 0 0 {name=p147585 lab=_83254_/Q }
C {devices/lab_pin.sym} 148960 -41020 0 1 {name=p147586 lab=_79584_/A }
C {sky130_stdcells/or2_4.sym} 148900 -41020 0 0 {name=X_79583_ }
C {devices/lab_pin.sym} 148860 -40890 0 0 {name=p147587 lab=_43605_/A }
C {devices/lab_pin.sym} 148940 -40890 0 1 {name=p147588 lab=_45975_/X }
C {sky130_stdcells/buf_2.sym} 148900 -40890 0 0 {name=X_45975_ }
C {devices/lab_pin.sym} 148860 -40770 0 0 {name=p147589 lab=_41098_/A }
C {devices/lab_pin.sym} 148940 -40770 0 1 {name=p147590 lab=_41098_/X }
C {sky130_stdcells/buf_2.sym} 148900 -40770 0 0 {name=X_41098_ }
C {devices/lab_pin.sym} 148840 -40660 0 0 {name=p147591 lab=_76781_/Y }
C {devices/lab_pin.sym} 148840 -40620 0 0 {name=p147592 lab=_76794_/X }
C {devices/lab_pin.sym} 148960 -40640 0 1 {name=p147593 lab=_76795_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -40640 0 0 {name=X_76795_ }
C {devices/lab_pin.sym} 148860 -40510 0 0 {name=p147594 lab=_47714_/A }
C {devices/lab_pin.sym} 148940 -40510 0 1 {name=p147595 lab=_47714_/X }
C {sky130_stdcells/buf_2.sym} 148900 -40510 0 0 {name=X_47714_ }
C {devices/lab_pin.sym} 148860 -40390 0 0 {name=p147596 lab=_82802_/Q }
C {devices/lab_pin.sym} 148940 -40390 0 1 {name=p147597 lab=_78534_/Y }
C {sky130_stdcells/inv_2.sym} 148900 -40390 0 0 {name=X_78534_ }
C {devices/lab_pin.sym} 148860 -40270 0 0 {name=p147598 lab=_45237_/A }
C {devices/lab_pin.sym} 148940 -40270 0 1 {name=p147599 lab=_44926_/X }
C {sky130_stdcells/buf_2.sym} 148900 -40270 0 0 {name=X_44926_ }
C {devices/lab_pin.sym} 148840 -40180 0 0 {name=p147600 lab=_61744_/X }
C {devices/lab_pin.sym} 148840 -40140 0 0 {name=p147601 lab=_63738_/B }
C {devices/lab_pin.sym} 148840 -40100 0 0 {name=p147602 lab=_63738_/C }
C {devices/lab_pin.sym} 148840 -40060 0 0 {name=p147603 lab=_63738_/D }
C {devices/lab_pin.sym} 148960 -40120 0 1 {name=p147604 lab=_63760_/Y }
C {sky130_stdcells/nand4_4.sym} 148900 -40120 0 0 {name=X_63760_ }
C {devices/lab_pin.sym} 148820 -39990 0 0 {name=p147605 lab=_75734_/A }
C {devices/lab_pin.sym} 148820 -39950 0 0 {name=p147606 lab=_75733_/Y }
C {devices/lab_pin.sym} 148820 -39910 0 0 {name=p147607 lab=_75745_/X }
C {devices/lab_pin.sym} 148980 -39950 0 1 {name=p147608 lab=_75747_/B }
C {sky130_stdcells/o21ai_4.sym} 148900 -39950 0 0 {name=X_75746_ }
C {devices/lab_pin.sym} 148860 -39810 0 0 {name=p147609 lab=_48694_/A }
C {devices/lab_pin.sym} 148940 -39810 0 1 {name=p147610 lab=_48695_/B }
C {sky130_stdcells/buf_2.sym} 148900 -39810 0 0 {name=X_48694_ }
C {devices/lab_pin.sym} 148820 -39720 0 0 {name=p147611 lab=_72806_/X }
C {devices/lab_pin.sym} 148820 -39680 0 0 {name=p147612 lab=_86202_/Q }
C {devices/lab_pin.sym} 148820 -39640 0 0 {name=p147613 lab=_72955_/X }
C {devices/lab_pin.sym} 148820 -39600 0 0 {name=p147614 lab=_72957_/X }
C {devices/lab_pin.sym} 148980 -39660 0 1 {name=p147615 lab=_72958_/X }
C {sky130_stdcells/a211o_4.sym} 148900 -39660 0 0 {name=X_72958_ }
C {devices/lab_pin.sym} 148840 -39530 0 0 {name=p147616 lab=_60921_/X }
C {devices/lab_pin.sym} 148840 -39490 0 0 {name=p147617 lab=_60934_/X }
C {devices/lab_pin.sym} 148840 -39450 0 0 {name=p147618 lab=_63781_/C }
C {devices/lab_pin.sym} 148960 -39490 0 1 {name=p147619 lab=_60972_/X }
C {sky130_stdcells/and3_4.sym} 148900 -39490 0 0 {name=X_60972_ }
C {devices/lab_pin.sym} 148840 -39380 0 0 {name=p147620 lab=_62711_/A }
C {devices/lab_pin.sym} 148840 -39340 0 0 {name=p147621 lab=_64276_/C }
C {devices/lab_pin.sym} 148840 -39300 0 0 {name=p147622 lab=_62676_/C }
C {devices/lab_pin.sym} 148840 -39260 0 0 {name=p147623 lab=_62657_/X }
C {devices/lab_pin.sym} 148960 -39320 0 1 {name=p147624 lab=_62711_/X }
C {sky130_stdcells/and4_4.sym} 148900 -39320 0 0 {name=X_62711_ }
C {devices/lab_pin.sym} 148840 -39200 0 0 {name=p147625 lab=_47655_/A }
C {devices/lab_pin.sym} 148840 -39160 0 0 {name=p147626 lab=_47645_/B }
C {devices/lab_pin.sym} 148840 -39120 0 0 {name=p147627 lab=_47614_/X }
C {devices/lab_pin.sym} 148840 -39080 0 0 {name=p147628 lab=_53165_/D }
C {devices/lab_pin.sym} 148960 -39140 0 1 {name=p147629 lab=_47645_/X }
C {sky130_stdcells/and4_4.sym} 148900 -39140 0 0 {name=X_47645_ }
C {devices/lab_pin.sym} 148820 -39010 0 0 {name=p147630 lab=_56645_/Y }
C {devices/lab_pin.sym} 148820 -38970 0 0 {name=p147631 lab=_71891_/Y }
C {devices/lab_pin.sym} 148820 -38930 0 0 {name=p147632 lab=_71908_/Y }
C {devices/lab_pin.sym} 148980 -38970 0 1 {name=p147633 lab=_71909_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -38970 0 0 {name=X_71909_ }
C {devices/lab_pin.sym} 148840 -38840 0 0 {name=p147634 lab=_78465_/A }
C {devices/lab_pin.sym} 148840 -38800 0 0 {name=p147635 lab=_78464_/X }
C {devices/lab_pin.sym} 148960 -38820 0 1 {name=p147636 lab=_78475_/A }
C {sky130_stdcells/xor2_4.sym} 148900 -38820 0 0 {name=X_78465_ }
C {devices/lab_pin.sym} 148860 -38690 0 0 {name=p147637 lab=_45980_/A }
C {devices/lab_pin.sym} 148940 -38690 0 1 {name=p147638 lab=_44857_/X }
C {sky130_stdcells/buf_2.sym} 148900 -38690 0 0 {name=X_44857_ }
C {devices/lab_pin.sym} 148860 -38570 0 0 {name=p147639 lab=clkbuf_9_244_0_CLK/X }
C {devices/lab_pin.sym} 148940 -38570 0 1 {name=p147640 lab=_86600_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 148900 -38570 0 0 {name=Xclkbuf_10_488_0_CLK }
C {devices/lab_pin.sym} 148860 -38450 0 0 {name=p147641 lab=_63849_/A }
C {devices/lab_pin.sym} 148940 -38450 0 1 {name=p147642 lab=_63701_/B }
C {sky130_stdcells/buf_2.sym} 148900 -38450 0 0 {name=X_63691_ }
C {devices/lab_pin.sym} 148840 -38340 0 0 {name=p147643 lab=_81118_/Q }
C {devices/lab_pin.sym} 148840 -38300 0 0 {name=p147644 lab=_75677_/B }
C {devices/lab_pin.sym} 148960 -38320 0 1 {name=p147645 lab=_75677_/Y }
C {sky130_stdcells/xnor2_4.sym} 148900 -38320 0 0 {name=X_75677_ }
C {devices/lab_pin.sym} 148860 -38190 0 0 {name=p147646 lab=_73351_/A }
C {devices/lab_pin.sym} 148940 -38190 0 1 {name=p147647 lab=_72889_/X }
C {sky130_stdcells/buf_2.sym} 148900 -38190 0 0 {name=X_72889_ }
C {devices/lab_pin.sym} 148820 -38100 0 0 {name=p147648 lab=_65428_/X }
C {devices/lab_pin.sym} 148820 -38060 0 0 {name=p147649 lab=_83081_/Q }
C {devices/lab_pin.sym} 148820 -38020 0 0 {name=p147650 lab=_65407_/X }
C {devices/lab_pin.sym} 148820 -37980 0 0 {name=p147651 lab=_65429_/X }
C {devices/lab_pin.sym} 148980 -38040 0 1 {name=p147652 lab=_65431_/B }
C {sky130_stdcells/a211o_4.sym} 148900 -38040 0 0 {name=X_65430_ }
C {devices/lab_pin.sym} 148840 -37900 0 0 {name=p147653 lab=_77416_/A }
C {devices/lab_pin.sym} 148840 -37860 0 0 {name=p147654 lab=_77415_/X }
C {devices/lab_pin.sym} 148960 -37880 0 1 {name=p147655 lab=_77416_/X }
C {sky130_stdcells/xor2_4.sym} 148900 -37880 0 0 {name=X_77416_ }
C {devices/lab_pin.sym} 148860 -37750 0 0 {name=p147656 lab=_43808_/A }
C {devices/lab_pin.sym} 148940 -37750 0 1 {name=p147657 lab=_87257_/D }
C {sky130_stdcells/inv_2.sym} 148900 -37750 0 0 {name=X_43808_ }
C {devices/lab_pin.sym} 148840 -37640 0 0 {name=p147658 lab=_60325_/B }
C {devices/lab_pin.sym} 148840 -37600 0 0 {name=p147659 lab=_62642_/B }
C {devices/lab_pin.sym} 148960 -37620 0 1 {name=p147660 lab=_62642_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -37620 0 0 {name=X_62642_ }
C {devices/lab_pin.sym} 148860 -37490 0 0 {name=p147661 lab=_74627_/Y }
C {devices/lab_pin.sym} 148940 -37490 0 1 {name=p147662 lab=_74675_/A }
C {sky130_stdcells/buf_2.sym} 148900 -37490 0 0 {name=X_74628_ }
C {devices/lab_pin.sym} 148860 -37370 0 0 {name=p147663 lab=_47530_/A }
C {devices/lab_pin.sym} 148940 -37370 0 1 {name=p147664 lab=_47595_/A }
C {sky130_stdcells/buf_2.sym} 148900 -37370 0 0 {name=X_47576_ }
C {devices/lab_pin.sym} 148860 -37250 0 0 {name=p147665 lab=_78395_/X }
C {devices/lab_pin.sym} 148940 -37250 0 1 {name=p147666 lab=_78400_/A }
C {sky130_stdcells/buf_2.sym} 148900 -37250 0 0 {name=X_78396_ }
C {devices/lab_pin.sym} 148860 -37130 0 0 {name=p147667 lab=_44803_/A }
C {devices/lab_pin.sym} 148940 -37130 0 1 {name=p147668 lab=_44788_/X }
C {sky130_stdcells/buf_2.sym} 148900 -37130 0 0 {name=X_44788_ }
C {devices/lab_pin.sym} 148820 -37030 0 0 {name=p147669 lab=_86411_/Q }
C {devices/lab_pin.sym} 148820 -36990 0 0 {name=p147670 lab=_49300_/X }
C {devices/lab_pin.sym} 148820 -36950 0 0 {name=p147671 lab=_49314_/Y }
C {devices/lab_pin.sym} 148980 -36990 0 1 {name=p147672 lab=_49315_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -36990 0 0 {name=X_49315_ }
C {devices/lab_pin.sym} 148860 -36850 0 0 {name=p147673 lab=_47972_/A }
C {devices/lab_pin.sym} 148940 -36850 0 1 {name=p147674 lab=_46527_/X }
C {sky130_stdcells/buf_2.sym} 148900 -36850 0 0 {name=X_46527_ }
C {devices/lab_pin.sym} 148820 -36760 0 0 {name=p147675 lab=_65334_/X }
C {devices/lab_pin.sym} 148820 -36720 0 0 {name=p147676 lab=_86116_/Q }
C {devices/lab_pin.sym} 148820 -36680 0 0 {name=p147677 lab=_65256_/X }
C {devices/lab_pin.sym} 148820 -36640 0 0 {name=p147678 lab=_65360_/X }
C {devices/lab_pin.sym} 148980 -36700 0 1 {name=p147679 lab=_65361_/X }
C {sky130_stdcells/a211o_4.sym} 148900 -36700 0 0 {name=X_65361_ }
C {devices/lab_pin.sym} 148840 -36570 0 0 {name=p147680 lab=_77334_/Y }
C {devices/lab_pin.sym} 148840 -36530 0 0 {name=p147681 lab=_77316_/B }
C {devices/lab_pin.sym} 148840 -36490 0 0 {name=p147682 lab=_77316_/A }
C {devices/lab_pin.sym} 148960 -36530 0 1 {name=p147683 lab=_77347_/Y }
C {sky130_stdcells/nand3_4.sym} 148900 -36530 0 0 {name=X_77347_ }
C {devices/lab_pin.sym} 148860 -36390 0 0 {name=p147684 lab=_51337_/A }
C {devices/lab_pin.sym} 148940 -36390 0 1 {name=p147685 lab=_48759_/A }
C {sky130_stdcells/buf_2.sym} 148900 -36390 0 0 {name=X_43739_ }
C {devices/lab_pin.sym} 148860 -36270 0 0 {name=p147686 lab=_56863_/X }
C {devices/lab_pin.sym} 148940 -36270 0 1 {name=p147687 lab=_74559_/X }
C {sky130_stdcells/buf_2.sym} 148900 -36270 0 0 {name=X_74559_ }
C {devices/lab_pin.sym} 148820 -36190 0 0 {name=p147688 lab=_62565_/X }
C {devices/lab_pin.sym} 148820 -36150 0 0 {name=p147689 lab=_62569_/Y }
C {devices/lab_pin.sym} 148820 -36110 0 0 {name=p147690 lab=_62571_/X }
C {devices/lab_pin.sym} 148820 -36070 0 0 {name=p147691 lab=_84872_/Q }
C {devices/lab_pin.sym} 148820 -36030 0 0 {name=p147692 lab=_62572_/X }
C {devices/lab_pin.sym} 148980 -36110 0 1 {name=p147693 lab=_62573_/Y }
C {sky130_stdcells/o32ai_4.sym} 148900 -36110 0 0 {name=X_62573_ }
C {devices/lab_pin.sym} 148860 -35950 0 0 {name=p147694 lab=clkbuf_9_205_0_CLK/X }
C {devices/lab_pin.sym} 148940 -35950 0 1 {name=p147695 lab=_83520_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 148900 -35950 0 0 {name=Xclkbuf_10_411_0_CLK }
C {devices/lab_pin.sym} 148840 -35840 0 0 {name=p147696 lab=_67028_/A }
C {devices/lab_pin.sym} 148840 -35800 0 0 {name=p147697 lab=_67100_/B }
C {devices/lab_pin.sym} 148960 -35820 0 1 {name=p147698 lab=_67100_/X }
C {sky130_stdcells/and2_4.sym} 148900 -35820 0 0 {name=X_67100_ }
C {devices/lab_pin.sym} 148820 -35710 0 0 {name=p147699 lab=_64301_/Y }
C {devices/lab_pin.sym} 148820 -35670 0 0 {name=p147700 lab=_64311_/X }
C {devices/lab_pin.sym} 148820 -35630 0 0 {name=p147701 lab=_64269_/X }
C {devices/lab_pin.sym} 148980 -35670 0 1 {name=p147702 lab=_64312_/X }
C {sky130_stdcells/o21a_4.sym} 148900 -35670 0 0 {name=X_64312_ }
C {devices/lab_pin.sym} 148820 -35550 0 0 {name=p147703 lab=_86425_/Q }
C {devices/lab_pin.sym} 148820 -35510 0 0 {name=p147704 lab=_49222_/X }
C {devices/lab_pin.sym} 148820 -35470 0 0 {name=p147705 lab=_49245_/Y }
C {devices/lab_pin.sym} 148980 -35510 0 1 {name=p147706 lab=_49246_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -35510 0 0 {name=X_49246_ }
C {devices/lab_pin.sym} 148840 -35390 0 0 {name=p147707 lab=_61482_/A }
C {devices/lab_pin.sym} 148840 -35350 0 0 {name=p147708 lab=_61522_/X }
C {devices/lab_pin.sym} 148840 -35310 0 0 {name=p147709 lab=_61541_/C }
C {devices/lab_pin.sym} 148960 -35350 0 1 {name=p147710 lab=_61524_/Y }
C {sky130_stdcells/nand3_4.sym} 148900 -35350 0 0 {name=X_61524_ }
C {devices/lab_pin.sym} 148840 -35220 0 0 {name=p147711 lab=_68405_/A }
C {devices/lab_pin.sym} 148840 -35180 0 0 {name=p147712 lab=_86912_/Q }
C {devices/lab_pin.sym} 148960 -35200 0 1 {name=p147713 lab=_68080_/X }
C {sky130_stdcells/and2_4.sym} 148900 -35200 0 0 {name=X_68080_ }
C {devices/lab_pin.sym} 148820 -35090 0 0 {name=p147714 lab=_86735_/Q }
C {devices/lab_pin.sym} 148820 -35050 0 0 {name=p147715 lab=_46430_/X }
C {devices/lab_pin.sym} 148820 -35010 0 0 {name=p147716 lab=_46457_/Y }
C {devices/lab_pin.sym} 148980 -35050 0 1 {name=p147717 lab=_46458_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -35050 0 0 {name=X_46458_ }
C {devices/lab_pin.sym} 148820 -34930 0 0 {name=p147718 lab=_64915_/X }
C {devices/lab_pin.sym} 148820 -34890 0 0 {name=p147719 lab=_65281_/Y }
C {devices/lab_pin.sym} 148820 -34850 0 0 {name=p147720 lab=_65291_/Y }
C {devices/lab_pin.sym} 148980 -34890 0 1 {name=p147721 lab=_65292_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -34890 0 0 {name=X_65292_ }
C {devices/lab_pin.sym} 148840 -34760 0 0 {name=p147722 lab=_77279_/A }
C {devices/lab_pin.sym} 148840 -34720 0 0 {name=p147723 lab=_82086_/D }
C {devices/lab_pin.sym} 148960 -34740 0 1 {name=p147724 lab=_77278_/X }
C {sky130_stdcells/or2_4.sym} 148900 -34740 0 0 {name=X_77278_ }
C {devices/lab_pin.sym} 148860 -34610 0 0 {name=p147725 lab=_66910_/A }
C {devices/lab_pin.sym} 148940 -34610 0 1 {name=p147726 lab=_67031_/X }
C {sky130_stdcells/buf_2.sym} 148900 -34610 0 0 {name=X_67031_ }
C {devices/lab_pin.sym} 148820 -34510 0 0 {name=p147727 lab=_82648_/Q }
C {devices/lab_pin.sym} 148820 -34470 0 0 {name=p147728 lab=_82520_/D }
C {devices/lab_pin.sym} 148820 -34430 0 0 {name=p147729 lab=_79016_/Y }
C {devices/lab_pin.sym} 148980 -34470 0 1 {name=p147730 lab=_79017_/Y }
C {sky130_stdcells/a21oi_4.sym} 148900 -34470 0 0 {name=X_79017_ }
C {devices/lab_pin.sym} 148840 -34340 0 0 {name=p147731 lab=_45409_/A }
C {devices/lab_pin.sym} 148840 -34300 0 0 {name=p147732 lab=_44892_/X }
C {devices/lab_pin.sym} 148960 -34320 0 1 {name=p147733 lab=_45409_/Y }
C {sky130_stdcells/nor2_4.sym} 148900 -34320 0 0 {name=X_45409_ }
C {devices/lab_pin.sym} 148860 -34190 0 0 {name=p147734 lab=_64243_/A }
C {devices/lab_pin.sym} 148940 -34190 0 1 {name=p147735 lab=_64273_/A }
C {sky130_stdcells/buf_2.sym} 148900 -34190 0 0 {name=X_64243_ }
C {devices/lab_pin.sym} 148860 -34070 0 0 {name=p147736 lab=_76233_/C }
C {devices/lab_pin.sym} 148940 -34070 0 1 {name=p147737 lab=_76229_/Y }
C {sky130_stdcells/inv_2.sym} 148900 -34070 0 0 {name=X_76229_ }
C {devices/lab_pin.sym} 148860 -33950 0 0 {name=p147738 lab=_61394_/A }
C {devices/lab_pin.sym} 148940 -33950 0 1 {name=p147739 lab=_61455_/X }
C {sky130_stdcells/buf_2.sym} 148900 -33950 0 0 {name=X_61455_ }
C {devices/lab_pin.sym} 148840 -33840 0 0 {name=p147740 lab=_49156_/X }
C {devices/lab_pin.sym} 148840 -33800 0 0 {name=p147741 lab=_50712_/B }
C {devices/lab_pin.sym} 148960 -33820 0 1 {name=p147742 lab=_49177_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -33820 0 0 {name=X_49177_ }
C {devices/lab_pin.sym} 148840 -33700 0 0 {name=p147743 lab=_46389_/A }
C {devices/lab_pin.sym} 148840 -33660 0 0 {name=p147744 lab=_46380_/B }
C {devices/lab_pin.sym} 148960 -33680 0 1 {name=p147745 lab=_46389_/X }
C {sky130_stdcells/or2_4.sym} 148900 -33680 0 0 {name=X_46389_ }
C {devices/lab_pin.sym} 148840 -33570 0 0 {name=p147746 lab=_60636_/B }
C {devices/lab_pin.sym} 148840 -33530 0 0 {name=p147747 lab=_60406_/B }
C {devices/lab_pin.sym} 148840 -33490 0 0 {name=p147748 lab=_60512_/A }
C {devices/lab_pin.sym} 148960 -33530 0 1 {name=p147749 lab=_60406_/X }
C {sky130_stdcells/and3_4.sym} 148900 -33530 0 0 {name=X_60406_ }
C {devices/lab_pin.sym} 148840 -33400 0 0 {name=p147750 lab=_48138_/A }
C {devices/lab_pin.sym} 148840 -33360 0 0 {name=p147751 lab=_48337_/A }
C {devices/lab_pin.sym} 148960 -33380 0 1 {name=p147752 lab=_48128_/X }
C {sky130_stdcells/and2_4.sym} 148900 -33380 0 0 {name=X_48128_ }
C {devices/lab_pin.sym} 148820 -33290 0 0 {name=p147753 lab=_64170_/X }
C {devices/lab_pin.sym} 148820 -33250 0 0 {name=p147754 lab=_63741_/X }
C {devices/lab_pin.sym} 148820 -33210 0 0 {name=p147755 lab=_64171_/Y }
C {devices/lab_pin.sym} 148820 -33170 0 0 {name=p147756 lab=_64172_/Y }
C {devices/lab_pin.sym} 148820 -33140 0 0 {name=p147757 lab=_64173_/X }
C {devices/lab_pin.sym} 148980 -33210 0 1 {name=p147758 lab=_64174_/X }
C {sky130_stdcells/a41o_4.sym} 148900 -33210 0 0 {name=X_64174_ }
C {devices/lab_pin.sym} 148840 -33070 0 0 {name=p147759 lab=_61375_/A }
C {devices/lab_pin.sym} 148840 -33030 0 0 {name=p147760 lab=_61386_/B }
C {devices/lab_pin.sym} 148840 -32990 0 0 {name=p147761 lab=_61375_/C }
C {devices/lab_pin.sym} 148960 -33030 0 1 {name=p147762 lab=_61386_/Y }
C {sky130_stdcells/nand3_4.sym} 148900 -33030 0 0 {name=X_61386_ }
C {devices/lab_pin.sym} 148860 -32890 0 0 {name=p147763 lab=clkbuf_9_213_0_CLK/X }
C {devices/lab_pin.sym} 148940 -32890 0 1 {name=p147764 lab=_82792_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 148900 -32890 0 0 {name=Xclkbuf_10_426_0_CLK }
C {devices/lab_pin.sym} 148860 -32770 0 0 {name=p147765 lab=_63020_/A }
C {devices/lab_pin.sym} 148940 -32770 0 1 {name=p147766 lab=_63125_/X }
C {sky130_stdcells/buf_2.sym} 148900 -32770 0 0 {name=X_63125_ }
C {devices/lab_pin.sym} 148820 -32670 0 0 {name=p147767 lab=_48054_/Y }
C {devices/lab_pin.sym} 148820 -32630 0 0 {name=p147768 lab=_48055_/X }
C {devices/lab_pin.sym} 148820 -32590 0 0 {name=p147769 lab=_48058_/X }
C {devices/lab_pin.sym} 148980 -32630 0 1 {name=p147770 lab=_86572_/D }
C {sky130_stdcells/a21oi_4.sym} 148900 -32630 0 0 {name=X_48059_ }
C {devices/lab_pin.sym} 148840 -32520 0 0 {name=p147771 lab=_60337_/A }
C {devices/lab_pin.sym} 148840 -32480 0 0 {name=p147772 lab=_60284_/A }
C {devices/lab_pin.sym} 148840 -32440 0 0 {name=p147773 lab=_60337_/C }
C {devices/lab_pin.sym} 148840 -32400 0 0 {name=p147774 lab=_60337_/D }
C {devices/lab_pin.sym} 148960 -32460 0 1 {name=p147775 lab=_60337_/Y }
C {sky130_stdcells/nand4_4.sym} 148900 -32460 0 0 {name=X_60337_ }
C {devices/lab_pin.sym} 148820 -32330 0 0 {name=p147776 lab=_68978_/X }
C {devices/lab_pin.sym} 148820 -32290 0 0 {name=p147777 lab=_68981_/X }
C {devices/lab_pin.sym} 148820 -32250 0 0 {name=p147778 lab=_68773_/X }
C {devices/lab_pin.sym} 148980 -32290 0 1 {name=p147779 lab=_68982_/X }
C {sky130_stdcells/a21o_4.sym} 148900 -32290 0 0 {name=X_68982_ }
C {devices/lab_pin.sym} 148820 -32170 0 0 {name=p147780 lab=_86079_/Q }
C {devices/lab_pin.sym} 148820 -32130 0 0 {name=p147781 lab=_51047_/X }
C {devices/lab_pin.sym} 148820 -32090 0 0 {name=p147782 lab=_51069_/Y }
C {devices/lab_pin.sym} 148980 -32130 0 1 {name=p147783 lab=_51070_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -32130 0 0 {name=X_51070_ }
C {devices/lab_pin.sym} 148820 -32020 0 0 {name=p147784 lab=_87142_/Q }
C {devices/lab_pin.sym} 148820 -31980 0 0 {name=p147785 lab=_67906_/X }
C {devices/lab_pin.sym} 148820 -31940 0 0 {name=p147786 lab=_67908_/X }
C {devices/lab_pin.sym} 148820 -31900 0 0 {name=p147787 lab=_67932_/X }
C {devices/lab_pin.sym} 148980 -31960 0 1 {name=p147788 lab=_67933_/X }
C {sky130_stdcells/a211o_4.sym} 148900 -31960 0 0 {name=X_67933_ }
C {devices/lab_pin.sym} 148860 -31810 0 0 {name=p147789 lab=_63231_/A }
C {devices/lab_pin.sym} 148940 -31810 0 1 {name=p147790 lab=_63056_/X }
C {sky130_stdcells/buf_2.sym} 148900 -31810 0 0 {name=X_63056_ }
C {devices/lab_pin.sym} 148840 -31700 0 0 {name=p147791 lab=_58108_/A }
C {devices/lab_pin.sym} 148840 -31660 0 0 {name=p147792 lab=_84172_/Q }
C {devices/lab_pin.sym} 148960 -31680 0 1 {name=p147793 lab=_79919_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -31680 0 0 {name=X_79919_ }
C {devices/lab_pin.sym} 148840 -31570 0 0 {name=p147794 lab=_60268_/A }
C {devices/lab_pin.sym} 148840 -31530 0 0 {name=p147795 lab=_60267_/X }
C {devices/lab_pin.sym} 148840 -31490 0 0 {name=p147796 lab=_60268_/C }
C {devices/lab_pin.sym} 148960 -31530 0 1 {name=p147797 lab=_60268_/Y }
C {sky130_stdcells/nand3_4.sym} 148900 -31530 0 0 {name=X_60268_ }
C {devices/lab_pin.sym} 148840 -31420 0 0 {name=p147798 lab=_50025_/A }
C {devices/lab_pin.sym} 148840 -31380 0 0 {name=p147799 lab=_50040_/B }
C {devices/lab_pin.sym} 148840 -31340 0 0 {name=p147800 lab=_50025_/C }
C {devices/lab_pin.sym} 148840 -31300 0 0 {name=p147801 lab=_53234_/D }
C {devices/lab_pin.sym} 148960 -31360 0 1 {name=p147802 lab=_50021_/X }
C {sky130_stdcells/and4_4.sym} 148900 -31360 0 0 {name=X_50021_ }
C {devices/lab_pin.sym} 148860 -31210 0 0 {name=p147803 lab=_61842_/A }
C {devices/lab_pin.sym} 148940 -31210 0 1 {name=p147804 lab=_62007_/X }
C {sky130_stdcells/buf_2.sym} 148900 -31210 0 0 {name=X_62007_ }
C {devices/lab_pin.sym} 148810 -31090 0 0 {name=p147805 lab=_82925_/CLK }
C {devices/lab_pin.sym} 148810 -31070 0 0 {name=p147806 lab=_78247_/X }
C {devices/lab_pin.sym} 148990 -31090 0 1 {name=p147807 lab=_82930_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -31080 0 0 {name=X_82930_ }
C {devices/lab_pin.sym} 148860 -30950 0 0 {name=p147808 lab=_66673_/X }
C {devices/lab_pin.sym} 148940 -30950 0 1 {name=p147809 lab=_68651_/A }
C {sky130_stdcells/buf_2.sym} 148900 -30950 0 0 {name=X_67864_ }
C {devices/lab_pin.sym} 148860 -30830 0 0 {name=p147810 lab=_60168_/A }
C {devices/lab_pin.sym} 148940 -30830 0 1 {name=p147811 lab=_60199_/X }
C {sky130_stdcells/buf_2.sym} 148900 -30830 0 0 {name=X_60199_ }
C {devices/lab_pin.sym} 148860 -30710 0 0 {name=p147812 lab=_64732_/A }
C {devices/lab_pin.sym} 148940 -30710 0 1 {name=p147813 lab=_69603_/X }
C {sky130_stdcells/buf_2.sym} 148900 -30710 0 0 {name=X_69603_ }
C {devices/lab_pin.sym} 148840 -30600 0 0 {name=p147814 lab=_66815_/A }
C {devices/lab_pin.sym} 148840 -30560 0 0 {name=p147815 lab=_66814_/X }
C {devices/lab_pin.sym} 148960 -30580 0 1 {name=p147816 lab=_66815_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -30580 0 0 {name=X_66815_ }
C {devices/lab_pin.sym} 148810 -30450 0 0 {name=p147817 lab=_82859_/CLK }
C {devices/lab_pin.sym} 148810 -30430 0 0 {name=p147818 lab=_78154_/B }
C {devices/lab_pin.sym} 148990 -30450 0 1 {name=p147819 lab=_82861_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -30440 0 0 {name=X_82861_ }
C {devices/lab_pin.sym} 148860 -30310 0 0 {name=p147820 lab=_68451_/A }
C {devices/lab_pin.sym} 148940 -30310 0 1 {name=p147821 lab=_67891_/A }
C {sky130_stdcells/buf_2.sym} 148900 -30310 0 0 {name=X_67795_ }
C {devices/lab_pin.sym} 148810 -30190 0 0 {name=p147822 lab=_84606_/CLK }
C {devices/lab_pin.sym} 148810 -30170 0 0 {name=p147823 lab=_60561_/Y }
C {devices/lab_pin.sym} 148990 -30190 0 1 {name=p147824 lab=_79140_/A }
C {sky130_stdcells/dfxtp_4.sym} 148900 -30180 0 0 {name=X_84600_ }
C {devices/lab_pin.sym} 148810 -30050 0 0 {name=p147825 lab=_81811_/CLK }
C {devices/lab_pin.sym} 148810 -30030 0 0 {name=p147826 lab=_81620_/Q }
C {devices/lab_pin.sym} 148990 -30050 0 1 {name=p147827 lab=_81812_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -30040 0 0 {name=X_81812_ }
C {devices/lab_pin.sym} 148820 -29940 0 0 {name=p147828 lab=_87510_/Q }
C {devices/lab_pin.sym} 148820 -29900 0 0 {name=p147829 lab=_69468_/X }
C {devices/lab_pin.sym} 148820 -29860 0 0 {name=p147830 lab=_69343_/X }
C {devices/lab_pin.sym} 148820 -29820 0 0 {name=p147831 lab=_69533_/X }
C {devices/lab_pin.sym} 148980 -29880 0 1 {name=p147832 lab=_69534_/X }
C {sky130_stdcells/a211o_4.sym} 148900 -29880 0 0 {name=X_69534_ }
C {devices/lab_pin.sym} 148820 -29750 0 0 {name=p147833 lab=_85383_/Q }
C {devices/lab_pin.sym} 148820 -29710 0 0 {name=p147834 lab=_54757_/X }
C {devices/lab_pin.sym} 148820 -29670 0 0 {name=p147835 lab=_54759_/Y }
C {devices/lab_pin.sym} 148980 -29710 0 1 {name=p147836 lab=_54760_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -29710 0 0 {name=X_54760_ }
C {devices/lab_pin.sym} 148820 -29600 0 0 {name=p147837 lab=_87948_/Q }
C {devices/lab_pin.sym} 148820 -29560 0 0 {name=p147838 lab=_66697_/X }
C {devices/lab_pin.sym} 148820 -29520 0 0 {name=p147839 lab=_66675_/X }
C {devices/lab_pin.sym} 148820 -29480 0 0 {name=p147840 lab=_66745_/X }
C {devices/lab_pin.sym} 148980 -29540 0 1 {name=p147841 lab=_66746_/X }
C {sky130_stdcells/a211o_4.sym} 148900 -29540 0 0 {name=X_66746_ }
C {devices/lab_pin.sym} 148810 -29390 0 0 {name=p147842 lab=_83572_/CLK }
C {devices/lab_pin.sym} 148810 -29370 0 0 {name=p147843 lab=_53727_/Y }
C {devices/lab_pin.sym} 148990 -29390 0 1 {name=p147844 lab=_85580_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -29380 0 0 {name=X_85580_ }
C {devices/lab_pin.sym} 148860 -29250 0 0 {name=p147845 lab=_51265_/A }
C {devices/lab_pin.sym} 148940 -29250 0 1 {name=p147846 lab=_51972_/X }
C {sky130_stdcells/buf_2.sym} 148900 -29250 0 0 {name=X_51972_ }
C {devices/lab_pin.sym} 148840 -29150 0 0 {name=p147847 lab=_63942_/A }
C {devices/lab_pin.sym} 148840 -29110 0 0 {name=p147848 lab=_59411_/A }
C {devices/lab_pin.sym} 148840 -29070 0 0 {name=p147849 lab=_63958_/C }
C {devices/lab_pin.sym} 148960 -29110 0 1 {name=p147850 lab=_63958_/X }
C {sky130_stdcells/and3_4.sym} 148900 -29110 0 0 {name=X_63958_ }
C {devices/lab_pin.sym} 148810 -28970 0 0 {name=p147851 lab=_82792_/CLK }
C {devices/lab_pin.sym} 148810 -28950 0 0 {name=p147852 lab=_82824_/Q }
C {devices/lab_pin.sym} 148990 -28970 0 1 {name=p147853 lab=_82792_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -28960 0 0 {name=X_82792_ }
C {devices/lab_pin.sym} 148840 -28850 0 0 {name=p147854 lab=_52194_/A }
C {devices/lab_pin.sym} 148840 -28810 0 0 {name=p147855 lab=_53720_/B }
C {devices/lab_pin.sym} 148840 -28770 0 0 {name=p147856 lab=_53734_/C }
C {devices/lab_pin.sym} 148960 -28810 0 1 {name=p147857 lab=_53711_/X }
C {sky130_stdcells/and3_4.sym} 148900 -28810 0 0 {name=X_53711_ }
C {devices/lab_pin.sym} 148810 -28670 0 0 {name=p147858 lab=_84531_/CLK }
C {devices/lab_pin.sym} 148810 -28650 0 0 {name=p147859 lab=_84531_/D }
C {devices/lab_pin.sym} 148990 -28670 0 1 {name=p147860 lab=_84531_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -28660 0 0 {name=X_84531_ }
C {devices/lab_pin.sym} 148860 -28530 0 0 {name=p147861 lab=_50952_/A }
C {devices/lab_pin.sym} 148940 -28530 0 1 {name=p147862 lab=_50948_/C }
C {sky130_stdcells/buf_2.sym} 148900 -28530 0 0 {name=X_50923_ }
C {devices/lab_pin.sym} 148840 -28440 0 0 {name=p147863 lab=_61593_/B }
C {devices/lab_pin.sym} 148840 -28400 0 0 {name=p147864 lab=_62858_/X }
C {devices/lab_pin.sym} 148840 -28360 0 0 {name=p147865 lab=_62859_/X }
C {devices/lab_pin.sym} 148840 -28320 0 0 {name=p147866 lab=_62908_/X }
C {devices/lab_pin.sym} 148960 -28380 0 1 {name=p147867 lab=_62909_/Y }
C {sky130_stdcells/nand4_4.sym} 148900 -28380 0 0 {name=X_62909_ }
C {devices/lab_pin.sym} 148810 -28230 0 0 {name=p147868 lab=_88175_/CLK }
C {devices/lab_pin.sym} 148810 -28210 0 0 {name=p147869 lab=_81743_/D }
C {devices/lab_pin.sym} 148990 -28230 0 1 {name=p147870 lab=_81743_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -28220 0 0 {name=X_81743_ }
C {devices/lab_pin.sym} 148860 -28090 0 0 {name=p147871 lab=_68617_/A }
C {devices/lab_pin.sym} 148940 -28090 0 1 {name=p147872 lab=_69465_/X }
C {sky130_stdcells/buf_2.sym} 148900 -28090 0 0 {name=X_69465_ }
C {devices/lab_pin.sym} 148840 -27980 0 0 {name=p147873 lab=_54682_/A }
C {devices/lab_pin.sym} 148840 -27940 0 0 {name=p147874 lab=_47352_/A }
C {devices/lab_pin.sym} 148960 -27960 0 1 {name=p147875 lab=_54691_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -27960 0 0 {name=X_54691_ }
C {devices/lab_pin.sym} 148820 -27860 0 0 {name=p147876 lab=_87887_/Q }
C {devices/lab_pin.sym} 148820 -27820 0 0 {name=p147877 lab=_66562_/X }
C {devices/lab_pin.sym} 148820 -27780 0 0 {name=p147878 lab=_66675_/X }
C {devices/lab_pin.sym} 148820 -27740 0 0 {name=p147879 lab=_66676_/X }
C {devices/lab_pin.sym} 148980 -27800 0 1 {name=p147880 lab=_66677_/X }
C {sky130_stdcells/a211o_4.sym} 148900 -27800 0 0 {name=X_66677_ }
C {devices/lab_pin.sym} 148840 -27680 0 0 {name=p147881 lab=_63883_/Y }
C {devices/lab_pin.sym} 148840 -27640 0 0 {name=p147882 lab=_63884_/Y }
C {devices/lab_pin.sym} 148840 -27600 0 0 {name=p147883 lab=_63885_/Y }
C {devices/lab_pin.sym} 148840 -27560 0 0 {name=p147884 lab=_63888_/Y }
C {devices/lab_pin.sym} 148960 -27620 0 1 {name=p147885 lab=_63889_/X }
C {sky130_stdcells/and4_4.sym} 148900 -27620 0 0 {name=X_63889_ }
C {devices/lab_pin.sym} 148820 -27490 0 0 {name=p147886 lab=_56114_/X }
C {devices/lab_pin.sym} 148820 -27450 0 0 {name=p147887 lab=_56426_/X }
C {devices/lab_pin.sym} 148820 -27410 0 0 {name=p147888 lab=_56429_/Y }
C {devices/lab_pin.sym} 148980 -27450 0 1 {name=p147889 lab=_56430_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -27450 0 0 {name=X_56430_ }
C {devices/lab_pin.sym} 148840 -27320 0 0 {name=p147890 lab=_44149_/A }
C {devices/lab_pin.sym} 148840 -27280 0 0 {name=p147891 lab=_68415_/Y }
C {devices/lab_pin.sym} 148960 -27300 0 1 {name=p147892 lab=_68416_/Y }
C {sky130_stdcells/nor2_4.sym} 148900 -27300 0 0 {name=X_68416_ }
C {devices/lab_pin.sym} 148810 -27170 0 0 {name=p147893 lab=_87260_/CLK }
C {devices/lab_pin.sym} 148810 -27150 0 0 {name=p147894 lab=_43822_/X }
C {devices/lab_pin.sym} 148990 -27170 0 1 {name=p147895 lab=_87250_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -27160 0 0 {name=X_87250_ }
C {devices/lab_pin.sym} 148820 -27050 0 0 {name=p147896 lab=_53639_/Y }
C {devices/lab_pin.sym} 148820 -27010 0 0 {name=p147897 lab=_53603_/X }
C {devices/lab_pin.sym} 148820 -26970 0 0 {name=p147898 lab=_53641_/Y }
C {devices/lab_pin.sym} 148980 -27010 0 1 {name=p147899 lab=_53642_/Y }
C {sky130_stdcells/a21boi_4.sym} 148900 -27010 0 0 {name=X_53642_ }
C {devices/lab_pin.sym} 148820 -26890 0 0 {name=p147900 lab=_65625_/X }
C {devices/lab_pin.sym} 148820 -26850 0 0 {name=p147901 lab=_65627_/X }
C {devices/lab_pin.sym} 148820 -26810 0 0 {name=p147902 lab=_65566_/X }
C {devices/lab_pin.sym} 148980 -26850 0 1 {name=p147903 lab=_65628_/X }
C {sky130_stdcells/a21o_4.sym} 148900 -26850 0 0 {name=X_65628_ }
C {devices/lab_pin.sym} 148810 -26710 0 0 {name=p147904 lab=_82436_/CLK }
C {devices/lab_pin.sym} 148810 -26690 0 0 {name=p147905 lab=_84462_/D }
C {devices/lab_pin.sym} 148990 -26710 0 1 {name=p147906 lab=_79130_/B }
C {sky130_stdcells/dfxtp_4.sym} 148900 -26700 0 0 {name=X_84462_ }
C {devices/lab_pin.sym} 148840 -26580 0 0 {name=p147907 lab=_50845_/A }
C {devices/lab_pin.sym} 148840 -26540 0 0 {name=p147908 lab=_50854_/B }
C {devices/lab_pin.sym} 148960 -26560 0 1 {name=p147909 lab=_50854_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -26560 0 0 {name=X_50854_ }
C {devices/lab_pin.sym} 148810 -26430 0 0 {name=p147910 lab=_81671_/CLK }
C {devices/lab_pin.sym} 148810 -26410 0 0 {name=p147911 lab=_81674_/D }
C {devices/lab_pin.sym} 148990 -26430 0 1 {name=p147912 lab=_81674_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -26420 0 0 {name=X_81674_ }
C {devices/lab_pin.sym} 148860 -26290 0 0 {name=p147913 lab=_66540_/A }
C {devices/lab_pin.sym} 148940 -26290 0 1 {name=p147914 lab=_69396_/X }
C {sky130_stdcells/buf_2.sym} 148900 -26290 0 0 {name=X_69396_ }
C {devices/lab_pin.sym} 148810 -26170 0 0 {name=p147915 lab=_86490_/CLK }
C {devices/lab_pin.sym} 148810 -26150 0 0 {name=p147916 lab=_86201_/D }
C {devices/lab_pin.sym} 148990 -26170 0 1 {name=p147917 lab=_86201_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -26160 0 0 {name=X_86201_ }
C {devices/lab_pin.sym} 148810 -26030 0 0 {name=p147918 lab=_83761_/CLK }
C {devices/lab_pin.sym} 148810 -26010 0 0 {name=p147919 lab=_71681_/Y }
C {devices/lab_pin.sym} 148990 -26030 0 1 {name=p147920 lab=_83413_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -26020 0 0 {name=X_83413_ }
C {devices/lab_pin.sym} 148820 -25910 0 0 {name=p147921 lab=_56159_/X }
C {devices/lab_pin.sym} 148820 -25870 0 0 {name=p147922 lab=_56350_/X }
C {devices/lab_pin.sym} 148820 -25830 0 0 {name=p147923 lab=_56360_/Y }
C {devices/lab_pin.sym} 148980 -25870 0 1 {name=p147924 lab=_85221_/D }
C {sky130_stdcells/o21ai_4.sym} 148900 -25870 0 0 {name=X_56361_ }
C {devices/lab_pin.sym} 148840 -25740 0 0 {name=p147925 lab=_80625_/A }
C {devices/lab_pin.sym} 148840 -25700 0 0 {name=p147926 lab=_63365_/C }
C {devices/lab_pin.sym} 148960 -25720 0 1 {name=p147927 lab=_80625_/X }
C {sky130_stdcells/xor2_4.sym} 148900 -25720 0 0 {name=X_80625_ }
C {devices/lab_pin.sym} 148860 -25590 0 0 {name=p147928 lab=_68347_/A }
C {devices/lab_pin.sym} 148940 -25590 0 1 {name=p147929 lab=_68517_/A }
C {sky130_stdcells/buf_2.sym} 148900 -25590 0 0 {name=X_68347_ }
C {devices/lab_pin.sym} 148810 -25470 0 0 {name=p147930 lab=_87169_/CLK }
C {devices/lab_pin.sym} 148810 -25450 0 0 {name=p147931 lab=_44215_/X }
C {devices/lab_pin.sym} 148990 -25470 0 1 {name=p147932 lab=_44067_/B }
C {sky130_stdcells/dfxtp_4.sym} 148900 -25460 0 0 {name=X_87181_ }
C {devices/lab_pin.sym} 148820 -25350 0 0 {name=p147933 lab=_85610_/Q }
C {devices/lab_pin.sym} 148820 -25310 0 0 {name=p147934 lab=_53540_/X }
C {devices/lab_pin.sym} 148820 -25270 0 0 {name=p147935 lab=_53572_/Y }
C {devices/lab_pin.sym} 148980 -25310 0 1 {name=p147936 lab=_53573_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -25310 0 0 {name=X_53573_ }
C {devices/lab_pin.sym} 148840 -25190 0 0 {name=p147937 lab=_65559_/A }
C {devices/lab_pin.sym} 148840 -25150 0 0 {name=p147938 lab=_65559_/B }
C {devices/lab_pin.sym} 148840 -25110 0 0 {name=p147939 lab=_65559_/C }
C {devices/lab_pin.sym} 148960 -25150 0 1 {name=p147940 lab=_65559_/X }
C {sky130_stdcells/and3_4.sym} 148900 -25150 0 0 {name=X_65559_ }
C {devices/lab_pin.sym} 148810 -25010 0 0 {name=p147941 lab=_84393_/CLK }
C {devices/lab_pin.sym} 148810 -24990 0 0 {name=p147942 lab=_62654_/Y }
C {devices/lab_pin.sym} 148990 -25010 0 1 {name=p147943 lab=_75923_/B }
C {sky130_stdcells/dfxtp_4.sym} 148900 -25000 0 0 {name=X_84393_ }
C {devices/lab_pin.sym} 148840 -24880 0 0 {name=p147944 lab=_50777_/A }
C {devices/lab_pin.sym} 148840 -24840 0 0 {name=p147945 lab=_49265_/B }
C {devices/lab_pin.sym} 148960 -24860 0 1 {name=p147946 lab=_50785_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -24860 0 0 {name=X_50785_ }
C {devices/lab_pin.sym} 148860 -24730 0 0 {name=p147947 lab=_58605_/A }
C {devices/lab_pin.sym} 148940 -24730 0 1 {name=p147948 lab=_58100_/X }
C {sky130_stdcells/buf_2.sym} 148900 -24730 0 0 {name=X_58100_ }
C {devices/lab_pin.sym} 148860 -24610 0 0 {name=p147949 lab=_44095_/X }
C {devices/lab_pin.sym} 148940 -24610 0 1 {name=p147950 lab=_55312_/X }
C {sky130_stdcells/buf_2.sym} 148900 -24610 0 0 {name=X_55312_ }
C {devices/lab_pin.sym} 148810 -24490 0 0 {name=p147951 lab=_85527_/CLK }
C {devices/lab_pin.sym} 148810 -24470 0 0 {name=p147952 lab=_86132_/D }
C {devices/lab_pin.sym} 148990 -24490 0 1 {name=p147953 lab=_86132_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -24480 0 0 {name=X_86132_ }
C {devices/lab_pin.sym} 148840 -24370 0 0 {name=p147954 lab=_52524_/A }
C {devices/lab_pin.sym} 148840 -24330 0 0 {name=p147955 lab=_52509_/B }
C {devices/lab_pin.sym} 148840 -24290 0 0 {name=p147956 lab=_52498_/C }
C {devices/lab_pin.sym} 148960 -24330 0 1 {name=p147957 lab=_52524_/X }
C {sky130_stdcells/and3_4.sym} 148900 -24330 0 0 {name=X_52524_ }
C {devices/lab_pin.sym} 148860 -24190 0 0 {name=p147958 lab=_64776_/A }
C {devices/lab_pin.sym} 148940 -24190 0 1 {name=p147959 lab=_59081_/A }
C {sky130_stdcells/buf_2.sym} 148900 -24190 0 0 {name=X_59080_ }
C {devices/lab_pin.sym} 148810 -24070 0 0 {name=p147960 lab=_83491_/CLK }
C {devices/lab_pin.sym} 148810 -24050 0 0 {name=p147961 lab=_71877_/X }
C {devices/lab_pin.sym} 148990 -24070 0 1 {name=p147962 lab=_83344_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -24060 0 0 {name=X_83344_ }
C {devices/lab_pin.sym} 148820 -23950 0 0 {name=p147963 lab=_56005_/X }
C {devices/lab_pin.sym} 148820 -23910 0 0 {name=p147964 lab=_56290_/X }
C {devices/lab_pin.sym} 148820 -23870 0 0 {name=p147965 lab=_56291_/Y }
C {devices/lab_pin.sym} 148980 -23910 0 1 {name=p147966 lab=_85248_/D }
C {sky130_stdcells/o21ai_4.sym} 148900 -23910 0 0 {name=X_56292_ }
C {devices/lab_pin.sym} 148840 -23780 0 0 {name=p147967 lab=_80547_/X }
C {devices/lab_pin.sym} 148840 -23740 0 0 {name=p147968 lab=_80549_/B }
C {devices/lab_pin.sym} 148960 -23760 0 1 {name=p147969 lab=_80556_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -23760 0 0 {name=X_80556_ }
C {devices/lab_pin.sym} 148820 -23650 0 0 {name=p147970 lab=_83994_/Q }
C {devices/lab_pin.sym} 148820 -23610 0 0 {name=p147971 lab=_68259_/X }
C {devices/lab_pin.sym} 148820 -23570 0 0 {name=p147972 lab=_68277_/X }
C {devices/lab_pin.sym} 148980 -23610 0 1 {name=p147973 lab=_68278_/X }
C {sky130_stdcells/a21bo_4.sym} 148900 -23610 0 0 {name=X_68278_ }
C {devices/lab_pin.sym} 148820 -23490 0 0 {name=p147974 lab=_58030_/X }
C {devices/lab_pin.sym} 148820 -23450 0 0 {name=p147975 lab=_85483_/Q }
C {devices/lab_pin.sym} 148820 -23410 0 0 {name=p147976 lab=_57962_/X }
C {devices/lab_pin.sym} 148980 -23450 0 1 {name=p147977 lab=_58031_/X }
C {sky130_stdcells/o21a_4.sym} 148900 -23450 0 0 {name=X_58031_ }
C {devices/lab_pin.sym} 148840 -23330 0 0 {name=p147978 lab=_55243_/A }
C {devices/lab_pin.sym} 148840 -23290 0 0 {name=p147979 lab=_55243_/B }
C {devices/lab_pin.sym} 148840 -23250 0 0 {name=p147980 lab=_56889_/B }
C {devices/lab_pin.sym} 148960 -23290 0 1 {name=p147981 lab=_55288_/B }
C {sky130_stdcells/nand3_4.sym} 148900 -23290 0 0 {name=X_55243_ }
C {devices/lab_pin.sym} 148820 -23170 0 0 {name=p147982 lab=_67224_/X }
C {devices/lab_pin.sym} 148820 -23130 0 0 {name=p147983 lab=_67228_/X }
C {devices/lab_pin.sym} 148820 -23090 0 0 {name=p147984 lab=_67204_/X }
C {devices/lab_pin.sym} 148980 -23130 0 1 {name=p147985 lab=_67229_/X }
C {sky130_stdcells/a21o_4.sym} 148900 -23130 0 0 {name=X_67229_ }
C {devices/lab_pin.sym} 148810 -22990 0 0 {name=p147986 lab=_85745_/CLK }
C {devices/lab_pin.sym} 148810 -22970 0 0 {name=p147987 lab=_51161_/Y }
C {devices/lab_pin.sym} 148990 -22990 0 1 {name=p147988 lab=_86063_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -22980 0 0 {name=X_86063_ }
C {devices/lab_pin.sym} 148820 -22870 0 0 {name=p147989 lab=_52453_/Y }
C {devices/lab_pin.sym} 148820 -22830 0 0 {name=p147990 lab=_52430_/X }
C {devices/lab_pin.sym} 148820 -22790 0 0 {name=p147991 lab=_52454_/Y }
C {devices/lab_pin.sym} 148980 -22830 0 1 {name=p147992 lab=_52455_/Y }
C {sky130_stdcells/a21boi_4.sym} 148900 -22830 0 0 {name=X_52455_ }
C {devices/lab_pin.sym} 148810 -22690 0 0 {name=p147993 lab=_83275_/CLK }
C {devices/lab_pin.sym} 148810 -22670 0 0 {name=p147994 lab=_83275_/D }
C {devices/lab_pin.sym} 148990 -22690 0 1 {name=p147995 lab=_83275_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -22680 0 0 {name=X_83275_ }
C {devices/lab_pin.sym} 148860 -22550 0 0 {name=p147996 lab=_80487_/A }
C {devices/lab_pin.sym} 148940 -22550 0 1 {name=p147997 lab=_80487_/Y }
C {sky130_stdcells/inv_2.sym} 148900 -22550 0 0 {name=X_80487_ }
C {devices/lab_pin.sym} 148810 -22430 0 0 {name=p147998 lab=_85049_/CLK }
C {devices/lab_pin.sym} 148810 -22410 0 0 {name=p147999 lab=_57403_/X }
C {devices/lab_pin.sym} 148990 -22430 0 1 {name=p148000 lab=_85014_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -22420 0 0 {name=X_85014_ }
C {devices/lab_pin.sym} 148840 -22320 0 0 {name=p148001 lab=_51220_/A }
C {devices/lab_pin.sym} 148840 -22280 0 0 {name=p148002 lab=_51230_/X }
C {devices/lab_pin.sym} 148840 -22240 0 0 {name=p148003 lab=_51225_/C }
C {devices/lab_pin.sym} 148840 -22200 0 0 {name=p148004 lab=_52934_/D }
C {devices/lab_pin.sym} 148960 -22260 0 1 {name=p148005 lab=_51406_/X }
C {sky130_stdcells/and4_4.sym} 148900 -22260 0 0 {name=X_51406_ }
C {devices/lab_pin.sym} 148820 -22130 0 0 {name=p148006 lab=_70238_/X }
C {devices/lab_pin.sym} 148820 -22090 0 0 {name=p148007 lab=_83826_/Q }
C {devices/lab_pin.sym} 148820 -22050 0 0 {name=p148008 lab=_70239_/X }
C {devices/lab_pin.sym} 148980 -22090 0 1 {name=p148009 lab=_83826_/D }
C {sky130_stdcells/a21o_4.sym} 148900 -22090 0 0 {name=X_70240_ }
C {devices/lab_pin.sym} 148810 -21950 0 0 {name=p148010 lab=_81094_/CLK }
C {devices/lab_pin.sym} 148810 -21930 0 0 {name=p148011 lab=_82258_/Q }
C {devices/lab_pin.sym} 148990 -21950 0 1 {name=p148012 lab=_77455_/A }
C {sky130_stdcells/dfxtp_4.sym} 148900 -21940 0 0 {name=X_82226_ }
C {devices/lab_pin.sym} 148860 -21810 0 0 {name=p148013 lab=_55244_/A }
C {devices/lab_pin.sym} 148940 -21810 0 1 {name=p148014 lab=_55174_/X }
C {sky130_stdcells/buf_2.sym} 148900 -21810 0 0 {name=X_55174_ }
C {devices/lab_pin.sym} 148820 -21710 0 0 {name=p148015 lab=_52384_/Y }
C {devices/lab_pin.sym} 148820 -21670 0 0 {name=p148016 lab=_52364_/X }
C {devices/lab_pin.sym} 148820 -21630 0 0 {name=p148017 lab=_52385_/X }
C {devices/lab_pin.sym} 148980 -21670 0 1 {name=p148018 lab=_52386_/Y }
C {sky130_stdcells/a21oi_4.sym} 148900 -21670 0 0 {name=X_52386_ }
C {devices/lab_pin.sym} 148860 -21530 0 0 {name=p148019 lab=clkbuf_8_53_0_CLK/A }
C {devices/lab_pin.sym} 148940 -21530 0 1 {name=p148020 lab=clkbuf_8_53_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 148900 -21530 0 0 {name=Xclkbuf_8_53_0_CLK }
C {devices/lab_pin.sym} 148840 -21420 0 0 {name=p148021 lab=_54134_/A }
C {devices/lab_pin.sym} 148840 -21380 0 0 {name=p148022 lab=_54125_/B }
C {devices/lab_pin.sym} 148960 -21400 0 1 {name=p148023 lab=_54125_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -21400 0 0 {name=X_54125_ }
C {devices/lab_pin.sym} 148860 -21270 0 0 {name=p148024 lab=_51337_/A }
C {devices/lab_pin.sym} 148940 -21270 0 1 {name=p148025 lab=_51822_/A }
C {sky130_stdcells/buf_2.sym} 148900 -21270 0 0 {name=X_51337_ }
C {devices/lab_pin.sym} 148860 -21150 0 0 {name=p148026 lab=_70231_/A }
C {devices/lab_pin.sym} 148940 -21150 0 1 {name=p148027 lab=_70183_/A }
C {sky130_stdcells/buf_2.sym} 148900 -21150 0 0 {name=X_70171_ }
C {devices/lab_pin.sym} 148810 -21030 0 0 {name=p148028 lab=_84175_/CLK }
C {devices/lab_pin.sym} 148810 -21010 0 0 {name=p148029 lab=_80419_/B }
C {devices/lab_pin.sym} 148990 -21030 0 1 {name=p148030 lab=_82157_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -21020 0 0 {name=X_82157_ }
C {devices/lab_pin.sym} 148840 -20910 0 0 {name=p148031 lab=_59873_/A }
C {devices/lab_pin.sym} 148840 -20870 0 0 {name=p148032 lab=_59873_/B }
C {devices/lab_pin.sym} 148840 -20830 0 0 {name=p148033 lab=_59982_/C }
C {devices/lab_pin.sym} 148960 -20870 0 1 {name=p148034 lab=_59982_/Y }
C {sky130_stdcells/nor3_4.sym} 148900 -20870 0 0 {name=X_59982_ }
C {devices/lab_pin.sym} 148810 -20730 0 0 {name=p148035 lab=_81087_/CLK }
C {devices/lab_pin.sym} 148810 -20710 0 0 {name=p148036 lab=_79751_/X }
C {devices/lab_pin.sym} 148990 -20730 0 1 {name=p148037 lab=_75889_/A }
C {sky130_stdcells/dfxtp_4.sym} 148900 -20720 0 0 {name=X_81108_ }
C {devices/lab_pin.sym} 148820 -20630 0 0 {name=p148038 lab=_42052_/X }
C {devices/lab_pin.sym} 148820 -20590 0 0 {name=p148039 lab=_42043_/X }
C {devices/lab_pin.sym} 148820 -20550 0 0 {name=p148040 lab=_40959_/X }
C {devices/lab_pin.sym} 148820 -20510 0 0 {name=p148041 lab=_88047_/Q }
C {devices/lab_pin.sym} 148820 -20470 0 0 {name=p148042 lab=_42044_/X }
C {devices/lab_pin.sym} 148980 -20550 0 1 {name=p148043 lab=_42071_/A }
C {sky130_stdcells/o32ai_4.sym} 148900 -20550 0 0 {name=X_42070_ }
C {devices/lab_pin.sym} 148840 -20400 0 0 {name=p148044 lab=_54031_/A }
C {devices/lab_pin.sym} 148840 -20360 0 0 {name=p148045 lab=_49322_/B }
C {devices/lab_pin.sym} 148960 -20380 0 1 {name=p148046 lab=_54056_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -20380 0 0 {name=X_54056_ }
C {devices/lab_pin.sym} 148860 -20250 0 0 {name=p148047 lab=_84788_/Q }
C {devices/lab_pin.sym} 148940 -20250 0 1 {name=p148048 lab=_79180_/A }
C {sky130_stdcells/inv_2.sym} 148900 -20250 0 0 {name=X_58933_ }
C {devices/lab_pin.sym} 148840 -20140 0 0 {name=p148049 lab=_51280_/A }
C {devices/lab_pin.sym} 148840 -20100 0 0 {name=p148050 lab=_50757_/B }
C {devices/lab_pin.sym} 148960 -20120 0 1 {name=p148051 lab=_51268_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -20120 0 0 {name=X_51268_ }
C {devices/lab_pin.sym} 148810 -19990 0 0 {name=p148052 lab=_86965_/CLK }
C {devices/lab_pin.sym} 148810 -19970 0 0 {name=p148053 lab=_44770_/Y }
C {devices/lab_pin.sym} 148990 -19990 0 1 {name=p148054 lab=_86965_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -19980 0 0 {name=X_86965_ }
C {devices/lab_pin.sym} 148810 -19850 0 0 {name=p148055 lab=_81970_/CLK }
C {devices/lab_pin.sym} 148810 -19830 0 0 {name=p148056 lab=_82132_/Q }
C {devices/lab_pin.sym} 148990 -19850 0 1 {name=p148057 lab=_82088_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -19840 0 0 {name=X_82088_ }
C {devices/lab_pin.sym} 148860 -19710 0 0 {name=p148058 lab=_41021_/A }
C {devices/lab_pin.sym} 148940 -19710 0 1 {name=p148059 lab=_41021_/X }
C {sky130_stdcells/buf_2.sym} 148900 -19710 0 0 {name=X_41021_ }
C {devices/lab_pin.sym} 148860 -19590 0 0 {name=p148060 lab=_53062_/A }
C {devices/lab_pin.sym} 148940 -19590 0 1 {name=p148061 lab=_53019_/C }
C {sky130_stdcells/buf_2.sym} 148900 -19590 0 0 {name=X_53007_ }
C {devices/lab_pin.sym} 148860 -19470 0 0 {name=p148062 lab=_50655_/A }
C {devices/lab_pin.sym} 148940 -19470 0 1 {name=p148063 lab=_50219_/X }
C {sky130_stdcells/buf_2.sym} 148900 -19470 0 0 {name=X_50219_ }
C {devices/lab_pin.sym} 148860 -19350 0 0 {name=p148064 lab=_72894_/X }
C {devices/lab_pin.sym} 148940 -19350 0 1 {name=p148065 lab=_73930_/X }
C {sky130_stdcells/buf_2.sym} 148900 -19350 0 0 {name=X_73930_ }
C {devices/lab_pin.sym} 148810 -19230 0 0 {name=p148066 lab=_86560_/CLK }
C {devices/lab_pin.sym} 148810 -19210 0 0 {name=p148067 lab=_85916_/D }
C {devices/lab_pin.sym} 148990 -19230 0 1 {name=p148068 lab=_65972_/B }
C {sky130_stdcells/dfxtp_4.sym} 148900 -19220 0 0 {name=X_85916_ }
C {devices/lab_pin.sym} 148810 -19090 0 0 {name=p148069 lab=_81038_/CLK }
C {devices/lab_pin.sym} 148810 -19070 0 0 {name=p148070 lab=_81039_/D }
C {devices/lab_pin.sym} 148990 -19090 0 1 {name=p148071 lab=_81039_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -19080 0 0 {name=X_81039_ }
C {devices/lab_pin.sym} 148860 -18950 0 0 {name=p148072 lab=_58864_/A }
C {devices/lab_pin.sym} 148940 -18950 0 1 {name=p148073 lab=_58864_/X }
C {sky130_stdcells/buf_2.sym} 148900 -18950 0 0 {name=X_58864_ }
C {devices/lab_pin.sym} 148860 -18830 0 0 {name=p148074 lab=clkbuf_8_69_0_CLK/A }
C {devices/lab_pin.sym} 148940 -18830 0 1 {name=p148075 lab=clkbuf_8_68_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 148900 -18830 0 0 {name=Xclkbuf_8_68_0_CLK }
C {devices/lab_pin.sym} 148840 -18720 0 0 {name=p148076 lab=_51184_/X }
C {devices/lab_pin.sym} 148840 -18680 0 0 {name=p148077 lab=_52889_/B }
C {devices/lab_pin.sym} 148960 -18700 0 1 {name=p148078 lab=_51199_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -18700 0 0 {name=X_51199_ }
C {devices/lab_pin.sym} 148810 -18570 0 0 {name=p148079 lab=_86896_/CLK }
C {devices/lab_pin.sym} 148810 -18550 0 0 {name=p148080 lab=_45146_/Y }
C {devices/lab_pin.sym} 148990 -18570 0 1 {name=p148081 lab=_64392_/B }
C {sky130_stdcells/dfxtp_4.sym} 148900 -18560 0 0 {name=X_86896_ }
C {devices/lab_pin.sym} 148820 -18450 0 0 {name=p148082 lab=_57739_/X }
C {devices/lab_pin.sym} 148820 -18410 0 0 {name=p148083 lab=_85724_/Q }
C {devices/lab_pin.sym} 148820 -18370 0 0 {name=p148084 lab=_57814_/X }
C {devices/lab_pin.sym} 148980 -18410 0 1 {name=p148085 lab=_57815_/X }
C {sky130_stdcells/o21a_4.sym} 148900 -18410 0 0 {name=X_57815_ }
C {devices/lab_pin.sym} 148840 -18280 0 0 {name=p148086 lab=_73954_/A }
C {devices/lab_pin.sym} 148840 -18240 0 0 {name=p148087 lab=_66087_/B }
C {devices/lab_pin.sym} 148960 -18260 0 1 {name=p148088 lab=_73861_/X }
C {sky130_stdcells/and2_4.sym} 148900 -18260 0 0 {name=X_73861_ }
C {devices/lab_pin.sym} 148810 -18130 0 0 {name=p148089 lab=_83303_/CLK }
C {devices/lab_pin.sym} 148810 -18110 0 0 {name=p148090 lab=_52316_/Y }
C {devices/lab_pin.sym} 148990 -18130 0 1 {name=p148091 lab=_85847_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -18120 0 0 {name=X_85847_ }
C {devices/lab_pin.sym} 148820 -18010 0 0 {name=p148092 lab=_58740_/X }
C {devices/lab_pin.sym} 148820 -17970 0 0 {name=p148093 lab=_85455_/Q }
C {devices/lab_pin.sym} 148820 -17930 0 0 {name=p148094 lab=_58794_/X }
C {devices/lab_pin.sym} 148980 -17970 0 1 {name=p148095 lab=_58795_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -17970 0 0 {name=X_58795_ }
C {devices/lab_pin.sym} 148840 -17840 0 0 {name=p148096 lab=_75607_/B }
C {devices/lab_pin.sym} 148840 -17800 0 0 {name=p148097 lab=_75891_/A }
C {devices/lab_pin.sym} 148960 -17820 0 1 {name=p148098 lab=_75600_/X }
C {sky130_stdcells/xor2_4.sym} 148900 -17820 0 0 {name=X_75600_ }
C {devices/lab_pin.sym} 148860 -17690 0 0 {name=p148099 lab=_73067_/A }
C {devices/lab_pin.sym} 148940 -17690 0 1 {name=p148100 lab=_72812_/X }
C {sky130_stdcells/buf_2.sym} 148900 -17690 0 0 {name=X_72812_ }
C {devices/lab_pin.sym} 148860 -17570 0 0 {name=p148101 lab=_82986_/Q }
C {devices/lab_pin.sym} 148940 -17570 0 1 {name=p148102 lab=_45761_/A }
C {sky130_stdcells/inv_2.sym} 148900 -17570 0 0 {name=X_45760_ }
C {devices/lab_pin.sym} 148820 -17490 0 0 {name=p148103 lab=_46213_/X }
C {devices/lab_pin.sym} 148820 -17450 0 0 {name=p148104 lab=_57744_/Y }
C {devices/lab_pin.sym} 148820 -17410 0 0 {name=p148105 lab=_57745_/Y }
C {devices/lab_pin.sym} 148820 -17370 0 0 {name=p148106 lab=_57700_/X }
C {devices/lab_pin.sym} 148820 -17330 0 0 {name=p148107 lab=_57703_/X }
C {devices/lab_pin.sym} 148980 -17410 0 1 {name=p148108 lab=_57746_/X }
C {sky130_stdcells/o32a_4.sym} 148900 -17410 0 0 {name=X_57746_ }
C {devices/lab_pin.sym} 148820 -17270 0 0 {name=p148109 lab=_76576_/X }
C {devices/lab_pin.sym} 148820 -17230 0 0 {name=p148110 lab=_76577_/Y }
C {devices/lab_pin.sym} 148820 -17190 0 0 {name=p148111 lab=_76579_/Y }
C {devices/lab_pin.sym} 148980 -17230 0 1 {name=p148112 lab=_76614_/A }
C {sky130_stdcells/a21o_4.sym} 148900 -17230 0 0 {name=X_76580_ }
C {devices/lab_pin.sym} 148820 -17130 0 0 {name=p148113 lab=_42970_/X }
C {devices/lab_pin.sym} 148820 -17090 0 0 {name=p148114 lab=_42971_/X }
C {devices/lab_pin.sym} 148820 -17050 0 0 {name=p148115 lab=_40432_/X }
C {devices/lab_pin.sym} 148820 -17010 0 0 {name=p148116 lab=_87624_/Q }
C {devices/lab_pin.sym} 148820 -16970 0 0 {name=p148117 lab=_42954_/X }
C {devices/lab_pin.sym} 148980 -17050 0 1 {name=p148118 lab=_42972_/Y }
C {sky130_stdcells/o32ai_4.sym} 148900 -17050 0 0 {name=X_42972_ }
C {devices/lab_pin.sym} 148820 -16910 0 0 {name=p148119 lab=_85345_/Q }
C {devices/lab_pin.sym} 148820 -16870 0 0 {name=p148120 lab=_54249_/X }
C {devices/lab_pin.sym} 148820 -16830 0 0 {name=p148121 lab=_54957_/Y }
C {devices/lab_pin.sym} 148980 -16870 0 1 {name=p148122 lab=_54958_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -16870 0 0 {name=X_54958_ }
C {devices/lab_pin.sym} 148840 -16750 0 0 {name=p148123 lab=_73790_/X }
C {devices/lab_pin.sym} 148840 -16710 0 0 {name=p148124 lab=_73792_/B }
C {devices/lab_pin.sym} 148840 -16670 0 0 {name=p148125 lab=_73779_/Y }
C {devices/lab_pin.sym} 148960 -16710 0 1 {name=p148126 lab=_73792_/Y }
C {sky130_stdcells/nand3_4.sym} 148900 -16710 0 0 {name=X_73792_ }
C {devices/lab_pin.sym} 148810 -16570 0 0 {name=p148127 lab=_85778_/CLK }
C {devices/lab_pin.sym} 148810 -16550 0 0 {name=p148128 lab=_52662_/Y }
C {devices/lab_pin.sym} 148990 -16570 0 1 {name=p148129 lab=_85778_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -16560 0 0 {name=X_85778_ }
C {devices/lab_pin.sym} 148820 -16470 0 0 {name=p148130 lab=_44707_/X }
C {devices/lab_pin.sym} 148820 -16430 0 0 {name=p148131 lab=_44708_/X }
C {devices/lab_pin.sym} 148820 -16390 0 0 {name=p148132 lab=_40678_/A }
C {devices/lab_pin.sym} 148820 -16350 0 0 {name=p148133 lab=_44709_/Y }
C {devices/lab_pin.sym} 148820 -16310 0 0 {name=p148134 lab=_44710_/X }
C {devices/lab_pin.sym} 148980 -16390 0 1 {name=p148135 lab=_86991_/D }
C {sky130_stdcells/o32ai_4.sym} 148900 -16390 0 0 {name=X_44711_ }
C {devices/lab_pin.sym} 148840 -16240 0 0 {name=p148136 lab=_75528_/B }
C {devices/lab_pin.sym} 148840 -16200 0 0 {name=p148137 lab=_75528_/A }
C {devices/lab_pin.sym} 148960 -16220 0 1 {name=p148138 lab=_75531_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -16220 0 0 {name=X_75531_ }
C {devices/lab_pin.sym} 148810 -16090 0 0 {name=p148139 lab=_87767_/CLK }
C {devices/lab_pin.sym} 148810 -16070 0 0 {name=p148140 lab=_87517_/D }
C {devices/lab_pin.sym} 148990 -16090 0 1 {name=p148141 lab=_87517_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -16080 0 0 {name=X_87517_ }
C {devices/lab_pin.sym} 148820 -15990 0 0 {name=p148142 lab=_41887_/X }
C {devices/lab_pin.sym} 148820 -15950 0 0 {name=p148143 lab=_41919_/X }
C {devices/lab_pin.sym} 148820 -15910 0 0 {name=p148144 lab=_40650_/X }
C {devices/lab_pin.sym} 148820 -15870 0 0 {name=p148145 lab=_41922_/Y }
C {devices/lab_pin.sym} 148820 -15830 0 0 {name=p148146 lab=_41891_/X }
C {devices/lab_pin.sym} 148980 -15910 0 1 {name=p148147 lab=_88104_/D }
C {sky130_stdcells/o32ai_4.sym} 148900 -15910 0 0 {name=X_41923_ }
C {devices/lab_pin.sym} 148820 -15770 0 0 {name=p148148 lab=_85544_/Q }
C {devices/lab_pin.sym} 148820 -15730 0 0 {name=p148149 lab=_53896_/X }
C {devices/lab_pin.sym} 148820 -15690 0 0 {name=p148150 lab=_53908_/Y }
C {devices/lab_pin.sym} 148980 -15730 0 1 {name=p148151 lab=_53909_/Y }
C {sky130_stdcells/o21ai_4.sym} 148900 -15730 0 0 {name=X_53909_ }
C {devices/lab_pin.sym} 148820 -15610 0 0 {name=p148152 lab=_44514_/Y }
C {devices/lab_pin.sym} 148820 -15570 0 0 {name=p148153 lab=_56275_/X }
C {devices/lab_pin.sym} 148820 -15530 0 0 {name=p148154 lab=_72742_/Y }
C {devices/lab_pin.sym} 148980 -15570 0 1 {name=p148155 lab=_72764_/C }
C {sky130_stdcells/a21o_4.sym} 148900 -15570 0 0 {name=X_72743_ }
C {devices/lab_pin.sym} 148810 -15430 0 0 {name=p148156 lab=_83402_/CLK }
C {devices/lab_pin.sym} 148810 -15410 0 0 {name=p148157 lab=_59452_/X }
C {devices/lab_pin.sym} 148990 -15430 0 1 {name=p148158 lab=_84729_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -15420 0 0 {name=X_84729_ }
C {devices/lab_pin.sym} 148860 -15290 0 0 {name=p148159 lab=_45265_/A }
C {devices/lab_pin.sym} 148940 -15290 0 1 {name=p148160 lab=_45691_/X }
C {sky130_stdcells/buf_2.sym} 148900 -15290 0 0 {name=X_45691_ }
C {devices/lab_pin.sym} 148860 -15170 0 0 {name=p148161 lab=_57650_/A }
C {devices/lab_pin.sym} 148940 -15170 0 1 {name=p148162 lab=_57677_/X }
C {sky130_stdcells/buf_2.sym} 148900 -15170 0 0 {name=X_57677_ }
C {devices/lab_pin.sym} 148860 -15050 0 0 {name=p148163 lab=_54889_/A }
C {devices/lab_pin.sym} 148940 -15050 0 1 {name=p148164 lab=_54910_/C }
C {sky130_stdcells/buf_2.sym} 148900 -15050 0 0 {name=X_54889_ }
C {devices/lab_pin.sym} 148860 -14930 0 0 {name=p148165 lab=_47525_/A }
C {devices/lab_pin.sym} 148940 -14930 0 1 {name=p148166 lab=_47444_/A }
C {sky130_stdcells/buf_2.sym} 148900 -14930 0 0 {name=X_47430_ }
C {devices/lab_pin.sym} 148820 -14830 0 0 {name=p148167 lab=_59394_/X }
C {devices/lab_pin.sym} 148820 -14790 0 0 {name=p148168 lab=_83483_/Q }
C {devices/lab_pin.sym} 148820 -14750 0 0 {name=p148169 lab=_59415_/Y }
C {devices/lab_pin.sym} 148980 -14790 0 1 {name=p148170 lab=_84739_/D }
C {sky130_stdcells/o21a_4.sym} 148900 -14790 0 0 {name=X_59416_ }
C {devices/lab_pin.sym} 148860 -14650 0 0 {name=p148171 lab=_78250_/A }
C {devices/lab_pin.sym} 148940 -14650 0 1 {name=p148172 lab=_78250_/Y }
C {sky130_stdcells/inv_2.sym} 148900 -14650 0 0 {name=X_78250_ }
C {devices/lab_pin.sym} 148820 -14550 0 0 {name=p148173 lab=_56626_/X }
C {devices/lab_pin.sym} 148820 -14510 0 0 {name=p148174 lab=_56553_/Y }
C {devices/lab_pin.sym} 148820 -14470 0 0 {name=p148175 lab=_56627_/Y }
C {devices/lab_pin.sym} 148980 -14510 0 1 {name=p148176 lab=_56628_/Y }
C {sky130_stdcells/a21oi_4.sym} 148900 -14510 0 0 {name=X_56628_ }
C {devices/lab_pin.sym} 148860 -14370 0 0 {name=p148177 lab=_44642_/A }
C {devices/lab_pin.sym} 148940 -14370 0 1 {name=p148178 lab=_87021_/D }
C {sky130_stdcells/inv_2.sym} 148900 -14370 0 0 {name=X_44642_ }
C {devices/lab_pin.sym} 148820 -14270 0 0 {name=p148179 lab=_75458_/X }
C {devices/lab_pin.sym} 148820 -14230 0 0 {name=p148180 lab=_75509_/C }
C {devices/lab_pin.sym} 148820 -14190 0 0 {name=p148181 lab=_75509_/A }
C {devices/lab_pin.sym} 148980 -14230 0 1 {name=p148182 lab=_75462_/X }
C {sky130_stdcells/a21o_4.sym} 148900 -14230 0 0 {name=X_75462_ }
C {devices/lab_pin.sym} 148810 -14090 0 0 {name=p148183 lab=_87221_/CLK }
C {devices/lab_pin.sym} 148810 -14070 0 0 {name=p148184 lab=_43385_/X }
C {devices/lab_pin.sym} 148990 -14090 0 1 {name=p148185 lab=_87448_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -14080 0 0 {name=X_87448_ }
C {devices/lab_pin.sym} 148820 -13980 0 0 {name=p148186 lab=_40528_/X }
C {devices/lab_pin.sym} 148820 -13940 0 0 {name=p148187 lab=_41847_/X }
C {devices/lab_pin.sym} 148820 -13900 0 0 {name=p148188 lab=_67218_/B }
C {devices/lab_pin.sym} 148820 -13860 0 0 {name=p148189 lab=_41848_/X }
C {devices/lab_pin.sym} 148980 -13920 0 1 {name=p148190 lab=_88120_/D }
C {sky130_stdcells/a2bb2o_4.sym} 148900 -13920 0 0 {name=X_41854_ }
C {devices/lab_pin.sym} 148860 -13770 0 0 {name=p148191 lab=_72688_/A }
C {devices/lab_pin.sym} 148940 -13770 0 1 {name=p148192 lab=_72683_/B }
C {sky130_stdcells/buf_2.sym} 148900 -13770 0 0 {name=X_72674_ }
C {devices/lab_pin.sym} 148840 -13680 0 0 {name=p148193 lab=_77202_/A }
C {devices/lab_pin.sym} 148840 -13640 0 0 {name=p148194 lab=_77184_/X }
C {devices/lab_pin.sym} 148840 -13600 0 0 {name=p148195 lab=_77202_/B }
C {devices/lab_pin.sym} 148840 -13560 0 0 {name=p148196 lab=_77202_/C }
C {devices/lab_pin.sym} 148960 -13620 0 1 {name=p148197 lab=_77201_/Y }
C {sky130_stdcells/nand4_4.sym} 148900 -13620 0 0 {name=X_77201_ }
C {devices/lab_pin.sym} 148860 -13470 0 0 {name=p148198 lab=_46280_/A }
C {devices/lab_pin.sym} 148940 -13470 0 1 {name=p148199 lab=_74413_/X }
C {sky130_stdcells/buf_2.sym} 148900 -13470 0 0 {name=X_74413_ }
C {devices/lab_pin.sym} 148820 -13370 0 0 {name=p148200 lab=_40773_/X }
C {devices/lab_pin.sym} 148820 -13330 0 0 {name=p148201 lab=_82297_/Q }
C {devices/lab_pin.sym} 148820 -13290 0 0 {name=p148202 lab=_40804_/X }
C {devices/lab_pin.sym} 148980 -13330 0 1 {name=p148203 lab=_40806_/A }
C {sky130_stdcells/o21ai_4.sym} 148900 -13330 0 0 {name=X_40805_ }
C {devices/lab_pin.sym} 148840 -13200 0 0 {name=p148204 lab=_47333_/X }
C {devices/lab_pin.sym} 148840 -13160 0 0 {name=p148205 lab=_53005_/B }
C {devices/lab_pin.sym} 148960 -13180 0 1 {name=p148206 lab=_47361_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -13180 0 0 {name=X_47361_ }
C {devices/lab_pin.sym} 148820 -13070 0 0 {name=p148207 lab=_59346_/X }
C {devices/lab_pin.sym} 148820 -13030 0 0 {name=p148208 lab=_85637_/Q }
C {devices/lab_pin.sym} 148820 -12990 0 0 {name=p148209 lab=_59308_/X }
C {devices/lab_pin.sym} 148980 -13030 0 1 {name=p148210 lab=_59347_/X }
C {sky130_stdcells/o21a_4.sym} 148900 -13030 0 0 {name=X_59347_ }
C {devices/lab_pin.sym} 148860 -12890 0 0 {name=p148211 lab=_71628_/A }
C {devices/lab_pin.sym} 148940 -12890 0 1 {name=p148212 lab=_71625_/Y }
C {sky130_stdcells/inv_2.sym} 148900 -12890 0 0 {name=X_71625_ }
C {devices/lab_pin.sym} 148840 -12780 0 0 {name=p148213 lab=_78191_/A }
C {devices/lab_pin.sym} 148840 -12740 0 0 {name=p148214 lab=_78192_/A }
C {devices/lab_pin.sym} 148960 -12760 0 1 {name=p148215 lab=_78182_/B }
C {sky130_stdcells/xor2_4.sym} 148900 -12760 0 0 {name=X_78181_ }
C {devices/lab_pin.sym} 148860 -12630 0 0 {name=p148216 lab=_44573_/A }
C {devices/lab_pin.sym} 148940 -12630 0 1 {name=p148217 lab=_44573_/Y }
C {sky130_stdcells/inv_2.sym} 148900 -12630 0 0 {name=X_44573_ }
C {devices/lab_pin.sym} 148860 -12510 0 0 {name=p148218 lab=_55624_/X }
C {devices/lab_pin.sym} 148940 -12510 0 1 {name=p148219 lab=_56564_/B }
C {sky130_stdcells/buf_2.sym} 148900 -12510 0 0 {name=X_56559_ }
C {devices/lab_pin.sym} 148840 -12400 0 0 {name=p148220 lab=_75393_/A }
C {devices/lab_pin.sym} 148840 -12360 0 0 {name=p148221 lab=_75393_/B }
C {devices/lab_pin.sym} 148960 -12380 0 1 {name=p148222 lab=_75393_/Y }
C {sky130_stdcells/nor2_4.sym} 148900 -12380 0 0 {name=X_75393_ }
C {devices/lab_pin.sym} 148820 -12270 0 0 {name=p148223 lab=_40385_/B }
C {devices/lab_pin.sym} 148820 -12230 0 0 {name=p148224 lab=_82883_/Q }
C {devices/lab_pin.sym} 148820 -12190 0 0 {name=p148225 lab=_41784_/X }
C {devices/lab_pin.sym} 148980 -12230 0 1 {name=p148226 lab=_41785_/X }
C {sky130_stdcells/o21a_4.sym} 148900 -12230 0 0 {name=X_41785_ }
C {devices/lab_pin.sym} 148810 -12090 0 0 {name=p148227 lab=_87993_/CLK }
C {devices/lab_pin.sym} 148810 -12070 0 0 {name=p148228 lab=_43521_/X }
C {devices/lab_pin.sym} 148990 -12090 0 1 {name=p148229 lab=_87379_/Q }
C {sky130_stdcells/dfxtp_4.sym} 148900 -12080 0 0 {name=X_87379_ }
C {devices/lab_pin.sym} 148860 -11950 0 0 {name=p148230 lab=_48499_/A }
C {devices/lab_pin.sym} 148940 -11950 0 1 {name=p148231 lab=_71959_/A }
C {sky130_stdcells/buf_2.sym} 148900 -11950 0 0 {name=X_49100_ }
C {devices/lab_pin.sym} 148820 -11850 0 0 {name=p148232 lab=_46297_/Y }
C {devices/lab_pin.sym} 148820 -11810 0 0 {name=p148233 lab=_46300_/X }
C {devices/lab_pin.sym} 148820 -11770 0 0 {name=p148234 lab=_46311_/X }
C {devices/lab_pin.sym} 148980 -11810 0 1 {name=p148235 lab=_86749_/D }
C {sky130_stdcells/a21oi_4.sym} 148900 -11810 0 0 {name=X_46312_ }
C {devices/lab_pin.sym} 148840 -11680 0 0 {name=p148236 lab=_82100_/Q }
C {devices/lab_pin.sym} 148840 -11640 0 0 {name=p148237 lab=_77132_/B }
C {devices/lab_pin.sym} 148960 -11660 0 1 {name=p148238 lab=_77132_/X }
C {sky130_stdcells/xor2_4.sym} 148900 -11660 0 0 {name=X_77132_ }
C {devices/lab_pin.sym} 148820 -11570 0 0 {name=p148239 lab=_43518_/X }
C {devices/lab_pin.sym} 148820 -11530 0 0 {name=p148240 lab=_43523_/X }
C {devices/lab_pin.sym} 148820 -11490 0 0 {name=p148241 lab=_40371_/X }
C {devices/lab_pin.sym} 148820 -11450 0 0 {name=p148242 lab=_87377_/Q }
C {devices/lab_pin.sym} 148820 -11410 0 0 {name=p148243 lab=_43506_/X }
C {devices/lab_pin.sym} 148980 -11490 0 1 {name=p148244 lab=_43524_/Y }
C {sky130_stdcells/o32ai_4.sym} 148900 -11490 0 0 {name=X_43524_ }
C {devices/lab_pin.sym} 148820 -11350 0 0 {name=p148245 lab=_70328_/C }
C {devices/lab_pin.sym} 148820 -11310 0 0 {name=p148246 lab=_74340_/X }
C {devices/lab_pin.sym} 148820 -11270 0 0 {name=p148247 lab=_74343_/Y }
C {devices/lab_pin.sym} 148980 -11310 0 1 {name=p148248 lab=_83091_/D }
C {sky130_stdcells/a21bo_4.sym} 148900 -11310 0 0 {name=X_74344_ }
C {devices/lab_pin.sym} 148860 -11170 0 0 {name=p148249 lab=_40736_/A }
C {devices/lab_pin.sym} 148940 -11170 0 1 {name=p148250 lab=_40765_/B }
C {sky130_stdcells/buf_2.sym} 148900 -11170 0 0 {name=X_40736_ }
C {devices/lab_pin.sym} 148860 -11050 0 0 {name=p148251 lab=_59053_/A }
C {devices/lab_pin.sym} 148940 -11050 0 1 {name=p148252 lab=_59278_/X }
C {sky130_stdcells/buf_2.sym} 148900 -11050 0 0 {name=X_59278_ }
C {devices/lab_pin.sym} 148860 -10930 0 0 {name=p148253 lab=_47198_/X }
C {devices/lab_pin.sym} 148940 -10930 0 1 {name=p148254 lab=_47330_/A }
C {sky130_stdcells/buf_2.sym} 148900 -10930 0 0 {name=X_47292_ }
C {devices/lab_pin.sym} 148860 -10810 0 0 {name=p148255 lab=_71556_/A }
C {devices/lab_pin.sym} 148940 -10810 0 1 {name=p148256 lab=_71556_/Y }
C {sky130_stdcells/inv_2.sym} 148900 -10810 0 0 {name=X_71556_ }
C {devices/lab_pin.sym} 148860 -10690 0 0 {name=p148257 lab=_49031_/A }
C {devices/lab_pin.sym} 148940 -10690 0 1 {name=p148258 lab=_53854_/B }
C {sky130_stdcells/buf_2.sym} 148900 -10690 0 0 {name=X_49031_ }
C {devices/lab_pin.sym} 148860 -10570 0 0 {name=p148259 lab=_46290_/A }
C {devices/lab_pin.sym} 148940 -10570 0 1 {name=p148260 lab=_46623_/A }
C {sky130_stdcells/buf_2.sym} 148900 -10570 0 0 {name=X_46243_ }
C {devices/lab_pin.sym} 148860 -10450 0 0 {name=p148261 lab=_71170_/A }
C {devices/lab_pin.sym} 148940 -10450 0 1 {name=p148262 lab=_70966_/A }
C {sky130_stdcells/buf_2.sym} 148900 -10450 0 0 {name=X_70507_ }
C {devices/lab_pin.sym} 148860 -10330 0 0 {name=p148263 lab=_58229_/A }
C {devices/lab_pin.sym} 148940 -10330 0 1 {name=p148264 lab=_58229_/Y }
C {sky130_stdcells/inv_2.sym} 148900 -10330 0 0 {name=X_58229_ }
C {sky130_stdcells/decap_3.sym} 148900 -10180 0 0 {name=XPHY_550 }
C {devices/lab_pin.sym} 148820 -10050 0 0 {name=p148265 lab=_77068_/A }
C {devices/lab_pin.sym} 148820 -10010 0 0 {name=p148266 lab=_77067_/A }
C {devices/lab_pin.sym} 148820 -9970 0 0 {name=p148267 lab=_77062_/Y }
C {devices/lab_pin.sym} 148980 -10010 0 1 {name=p148268 lab=_77063_/Y }
C {sky130_stdcells/a21boi_4.sym} 148900 -10010 0 0 {name=X_77063_ }
C {devices/lab_pin.sym} 148860 -9870 0 0 {name=p148269 lab=_43020_/A }
C {devices/lab_pin.sym} 148940 -9870 0 1 {name=p148270 lab=_43528_/A }
C {sky130_stdcells/buf_2.sym} 148900 -9870 0 0 {name=X_43455_ }
C {devices/lab_pin.sym} 148820 -9770 0 0 {name=p148271 lab=_74272_/X }
C {devices/lab_pin.sym} 148820 -9730 0 0 {name=p148272 lab=_74274_/X }
C {devices/lab_pin.sym} 148820 -9690 0 0 {name=p148273 lab=_74019_/X }
C {devices/lab_pin.sym} 148980 -9730 0 1 {name=p148274 lab=_74278_/A }
C {sky130_stdcells/a21o_4.sym} 148900 -9730 0 0 {name=X_74275_ }
C {sky130_stdcells/decap_3.sym} 148900 -9560 0 0 {name=XPHY_561 }
C {devices/lab_pin.sym} 148860 -9410 0 0 {name=p148275 lab=_40667_/A }
C {devices/lab_pin.sym} 148940 -9410 0 1 {name=p148276 lab=_40667_/X }
C {sky130_stdcells/buf_2.sym} 148900 -9410 0 0 {name=X_40667_ }
C {devices/lab_pin.sym} 148860 -9290 0 0 {name=p148277 lab=_71487_/A }
C {devices/lab_pin.sym} 148940 -9290 0 1 {name=p148278 lab=_71487_/X }
C {sky130_stdcells/buf_2.sym} 148900 -9290 0 0 {name=X_71487_ }
C {sky130_stdcells/decap_3.sym} 148900 -9140 0 0 {name=XPHY_572 }
C {sky130_stdcells/decap_3.sym} 148900 -8960 0 0 {name=XPHY_583 }
C {devices/lab_pin.sym} 148820 -8830 0 0 {name=p148279 lab=_76009_/Y }
C {devices/lab_pin.sym} 148820 -8790 0 0 {name=p148280 lab=_76010_/A }
C {devices/lab_pin.sym} 148820 -8750 0 0 {name=p148281 lab=_76013_/Y }
C {devices/lab_pin.sym} 148980 -8790 0 1 {name=p148282 lab=_76015_/B }
C {sky130_stdcells/a21boi_4.sym} 148900 -8790 0 0 {name=X_76014_ }
C {devices/lab_pin.sym} 148820 -8690 0 0 {name=p148283 lab=_42401_/X }
C {devices/lab_pin.sym} 148820 -8650 0 0 {name=p148284 lab=_42397_/X }
C {devices/lab_pin.sym} 148820 -8610 0 0 {name=p148285 lab=_40446_/X }
C {devices/lab_pin.sym} 148820 -8570 0 0 {name=p148286 lab=_87878_/Q }
C {devices/lab_pin.sym} 148820 -8530 0 0 {name=p148287 lab=_42398_/X }
C {devices/lab_pin.sym} 148980 -8610 0 1 {name=p148288 lab=_42407_/A }
C {sky130_stdcells/o32ai_4.sym} 148900 -8610 0 0 {name=X_42406_ }
C {sky130_stdcells/decap_3.sym} 148900 -8420 0 0 {name=XPHY_594 }
C {devices/lab_pin.sym} 148840 -8290 0 0 {name=p148289 lab=_61198_/X }
C {devices/lab_pin.sym} 148840 -8250 0 0 {name=p148290 lab=_61107_/X }
C {devices/lab_pin.sym} 148840 -8210 0 0 {name=p148291 lab=_61230_/C }
C {devices/lab_pin.sym} 148960 -8250 0 1 {name=p148292 lab=_61241_/A }
C {sky130_stdcells/nand3_4.sym} 148900 -8250 0 0 {name=X_61240_ }
C {devices/lab_pin.sym} 148820 -8140 0 0 {name=p148293 lab=_69804_/Y }
C {devices/lab_pin.sym} 148820 -8100 0 0 {name=p148294 lab=_73224_/X }
C {devices/lab_pin.sym} 148820 -8060 0 0 {name=p148295 lab=_73194_/X }
C {devices/lab_pin.sym} 148820 -8020 0 0 {name=p148296 lab=_73225_/Y }
C {devices/lab_pin.sym} 148980 -8080 0 1 {name=p148297 lab=_73226_/X }
C {sky130_stdcells/a211o_4.sym} 148900 -8080 0 0 {name=X_73226_ }
C {devices/lab_pin.sym} 148840 -7950 0 0 {name=p148298 lab=_46162_/X }
C {devices/lab_pin.sym} 148840 -7910 0 0 {name=p148299 lab=_46173_/X }
C {devices/lab_pin.sym} 148840 -7870 0 0 {name=p148300 lab=_46166_/C }
C {devices/lab_pin.sym} 148960 -7910 0 1 {name=p148301 lab=_46174_/X }
C {sky130_stdcells/and3_4.sym} 148900 -7910 0 0 {name=X_46174_ }
C {devices/lab_pin.sym} 148840 -7790 0 0 {name=p148302 lab=_70442_/A }
C {devices/lab_pin.sym} 148840 -7750 0 0 {name=p148303 lab=_70947_/B }
C {devices/lab_pin.sym} 148840 -7710 0 0 {name=p148304 lab=_70431_/C }
C {devices/lab_pin.sym} 148960 -7750 0 1 {name=p148305 lab=_70438_/Y }
C {sky130_stdcells/nand3_4.sym} 148900 -7750 0 0 {name=X_70438_ }
C {devices/lab_pin.sym} 148860 -7610 0 0 {name=p148306 lab=_43396_/A }
C {devices/lab_pin.sym} 148940 -7610 0 1 {name=p148307 lab=_43386_/X }
C {sky130_stdcells/buf_2.sym} 148900 -7610 0 0 {name=X_43386_ }
C {devices/lab_pin.sym} 148860 -7490 0 0 {name=p148308 lab=_40755_/A }
C {devices/lab_pin.sym} 148940 -7490 0 1 {name=p148309 lab=_40599_/A }
C {sky130_stdcells/buf_2.sym} 148900 -7490 0 0 {name=X_40598_ }
C {devices/lab_pin.sym} 148860 -7370 0 0 {name=p148310 lab=_44972_/X }
C {devices/lab_pin.sym} 148940 -7370 0 1 {name=p148311 lab=_45125_/X }
C {sky130_stdcells/buf_2.sym} 148900 -7370 0 0 {name=X_45125_ }
C {devices/lab_pin.sym} 148860 -7250 0 0 {name=p148312 lab=_42337_/A }
C {devices/lab_pin.sym} 148940 -7250 0 1 {name=p148313 lab=_87915_/D }
C {sky130_stdcells/inv_2.sym} 148900 -7250 0 0 {name=X_42337_ }
C {devices/lab_pin.sym} 148860 -7130 0 0 {name=p148314 lab=_64250_/C }
C {devices/lab_pin.sym} 148940 -7130 0 1 {name=p148315 lab=_64211_/C }
C {sky130_stdcells/buf_2.sym} 148900 -7130 0 0 {name=X_61171_ }
C {devices/lab_pin.sym} 148860 -7010 0 0 {name=p148316 lab=_72757_/A }
C {devices/lab_pin.sym} 148940 -7010 0 1 {name=p148317 lab=_73495_/A }
C {sky130_stdcells/buf_2.sym} 148900 -7010 0 0 {name=X_73157_ }
C {devices/lab_pin.sym} 148860 -6890 0 0 {name=p148318 lab=_70361_/Y }
C {devices/lab_pin.sym} 148940 -6890 0 1 {name=p148319 lab=_70370_/A }
C {sky130_stdcells/buf_2.sym} 148900 -6890 0 0 {name=X_70369_ }
C {devices/lab_pin.sym} 148840 -6790 0 0 {name=p148320 lab=_60122_/A }
C {devices/lab_pin.sym} 148840 -6750 0 0 {name=p148321 lab=_60267_/A }
C {devices/lab_pin.sym} 148840 -6710 0 0 {name=p148322 lab=_60122_/C }
C {devices/lab_pin.sym} 148960 -6750 0 1 {name=p148323 lab=_60122_/Y }
C {sky130_stdcells/nand3_4.sym} 148900 -6750 0 0 {name=X_60122_ }
C {devices/lab_pin.sym} 148840 -6620 0 0 {name=p148324 lab=_74391_/A }
C {devices/lab_pin.sym} 148840 -6580 0 0 {name=p148325 lab=_50719_/B }
C {devices/lab_pin.sym} 148960 -6600 0 1 {name=p148326 lab=_72108_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -6600 0 0 {name=X_72108_ }
C {devices/lab_pin.sym} 148820 -6490 0 0 {name=p148327 lab=_49929_/Y }
C {devices/lab_pin.sym} 148820 -6450 0 0 {name=p148328 lab=_49924_/X }
C {devices/lab_pin.sym} 148820 -6410 0 0 {name=p148329 lab=_49932_/X }
C {devices/lab_pin.sym} 148980 -6450 0 1 {name=p148330 lab=_49933_/Y }
C {sky130_stdcells/a21oi_4.sym} 148900 -6450 0 0 {name=X_49933_ }
C {devices/lab_pin.sym} 148860 -6310 0 0 {name=p148331 lab=_45197_/A }
C {devices/lab_pin.sym} 148940 -6310 0 1 {name=p148332 lab=_45056_/X }
C {sky130_stdcells/buf_2.sym} 148900 -6310 0 0 {name=X_45056_ }
C {devices/lab_pin.sym} 148820 -6230 0 0 {name=p148333 lab=_42252_/X }
C {devices/lab_pin.sym} 148820 -6190 0 0 {name=p148334 lab=_42243_/X }
C {devices/lab_pin.sym} 148820 -6150 0 0 {name=p148335 lab=_41498_/X }
C {devices/lab_pin.sym} 148820 -6110 0 0 {name=p148336 lab=_87948_/Q }
C {devices/lab_pin.sym} 148820 -6070 0 0 {name=p148337 lab=_42244_/X }
C {devices/lab_pin.sym} 148980 -6150 0 1 {name=p148338 lab=_42269_/A }
C {sky130_stdcells/o32ai_4.sym} 148900 -6150 0 0 {name=X_42268_ }
C {devices/lab_pin.sym} 148860 -5990 0 0 {name=p148339 lab=_77965_/A }
C {devices/lab_pin.sym} 148940 -5990 0 1 {name=p148340 lab=_77967_/B }
C {sky130_stdcells/inv_2.sym} 148900 -5990 0 0 {name=X_77965_ }
C {devices/lab_pin.sym} 148820 -5890 0 0 {name=p148341 lab=_69725_/B }
C {devices/lab_pin.sym} 148820 -5850 0 0 {name=p148342 lab=_73086_/X }
C {devices/lab_pin.sym} 148820 -5810 0 0 {name=p148343 lab=_73087_/X }
C {devices/lab_pin.sym} 148980 -5850 0 1 {name=p148344 lab=_73088_/X }
C {sky130_stdcells/o21a_4.sym} 148900 -5850 0 0 {name=X_73088_ }
C {devices/lab_pin.sym} 148860 -5710 0 0 {name=p148345 lab=HASH_EN }
C {devices/lab_pin.sym} 148940 -5710 0 1 {name=p148346 lab=_44010_/A }
C {sky130_stdcells/buf_2.sym} 148900 -5710 0 0 {name=X_44007_ }
C {devices/lab_pin.sym} 148840 -5600 0 0 {name=p148347 lab=_79704_/A }
C {devices/lab_pin.sym} 148840 -5560 0 0 {name=p148348 lab=_79704_/B }
C {devices/lab_pin.sym} 148960 -5580 0 1 {name=p148349 lab=_79704_/X }
C {sky130_stdcells/and2_4.sym} 148900 -5580 0 0 {name=X_79704_ }
C {devices/lab_pin.sym} 148820 -5470 0 0 {name=p148350 lab=_41042_/X }
C {devices/lab_pin.sym} 148820 -5430 0 0 {name=p148351 lab=_81709_/Q }
C {devices/lab_pin.sym} 148820 -5390 0 0 {name=p148352 lab=_41218_/X }
C {devices/lab_pin.sym} 148980 -5430 0 1 {name=p148353 lab=_41219_/X }
C {sky130_stdcells/o21a_4.sym} 148900 -5430 0 0 {name=X_41219_ }
C {devices/lab_pin.sym} 148820 -5320 0 0 {name=p148354 lab=_64817_/X }
C {devices/lab_pin.sym} 148820 -5280 0 0 {name=p148355 lab=_86165_/Q }
C {devices/lab_pin.sym} 148820 -5240 0 0 {name=p148356 lab=_64927_/X }
C {devices/lab_pin.sym} 148820 -5200 0 0 {name=p148357 lab=_64929_/X }
C {devices/lab_pin.sym} 148980 -5260 0 1 {name=p148358 lab=_64930_/X }
C {sky130_stdcells/a211o_4.sym} 148900 -5260 0 0 {name=X_64930_ }
C {devices/lab_pin.sym} 148860 -5110 0 0 {name=p148359 lab=_72584_/C }
C {devices/lab_pin.sym} 148940 -5110 0 1 {name=p148360 lab=_60053_/X }
C {sky130_stdcells/buf_2.sym} 148900 -5110 0 0 {name=X_60053_ }
C {devices/lab_pin.sym} 148820 -5010 0 0 {name=p148361 lab=_72037_/Y }
C {devices/lab_pin.sym} 148820 -4970 0 0 {name=p148362 lab=_72033_/X }
C {devices/lab_pin.sym} 148820 -4930 0 0 {name=p148363 lab=_72038_/Y }
C {devices/lab_pin.sym} 148980 -4970 0 1 {name=p148364 lab=_72039_/Y }
C {sky130_stdcells/a21boi_4.sym} 148900 -4970 0 0 {name=X_72039_ }
C {devices/lab_pin.sym} 148860 -4830 0 0 {name=p148365 lab=_81503_/Q }
C {devices/lab_pin.sym} 148940 -4830 0 1 {name=p148366 lab=_76918_/A }
C {sky130_stdcells/inv_2.sym} 148900 -4830 0 0 {name=X_76916_ }
C {devices/lab_pin.sym} 148840 -4720 0 0 {name=p148367 lab=_49864_/A }
C {devices/lab_pin.sym} 148840 -4680 0 0 {name=p148368 lab=_53076_/B }
C {devices/lab_pin.sym} 148960 -4700 0 1 {name=p148369 lab=_49864_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -4700 0 0 {name=X_49864_ }
C {devices/lab_pin.sym} 148860 -4570 0 0 {name=p148370 lab=_41878_/A }
C {devices/lab_pin.sym} 148940 -4570 0 1 {name=p148371 lab=_42199_/X }
C {sky130_stdcells/buf_2.sym} 148900 -4570 0 0 {name=X_42199_ }
C {devices/lab_pin.sym} 148820 -4470 0 0 {name=p148372 lab=_77880_/B }
C {devices/lab_pin.sym} 148820 -4430 0 0 {name=p148373 lab=_77893_/X }
C {devices/lab_pin.sym} 148820 -4390 0 0 {name=p148374 lab=_77895_/Y }
C {devices/lab_pin.sym} 148980 -4430 0 1 {name=p148375 lab=_77902_/B }
C {sky130_stdcells/a21oi_4.sym} 148900 -4430 0 0 {name=X_77896_ }
C {devices/lab_pin.sym} 148860 -4290 0 0 {name=p148376 lab=clkbuf_3_7_0_CLK/X }
C {devices/lab_pin.sym} 148940 -4290 0 1 {name=p148377 lab=clkbuf_3_7_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 148900 -4290 0 0 {name=Xclkbuf_3_7_1_CLK }
C {devices/lab_pin.sym} 148820 -4190 0 0 {name=p148378 lab=_48812_/Y }
C {devices/lab_pin.sym} 148820 -4150 0 0 {name=p148379 lab=_48813_/X }
C {devices/lab_pin.sym} 148820 -4110 0 0 {name=p148380 lab=_48814_/X }
C {devices/lab_pin.sym} 148980 -4150 0 1 {name=p148381 lab=_48815_/Y }
C {sky130_stdcells/a21oi_4.sym} 148900 -4150 0 0 {name=X_48815_ }
C {devices/lab_pin.sym} 148820 -4030 0 0 {name=p148382 lab=_79630_/A }
C {devices/lab_pin.sym} 148820 -3990 0 0 {name=p148383 lab=_79629_/X }
C {devices/lab_pin.sym} 148820 -3950 0 0 {name=p148384 lab=_79634_/Y }
C {devices/lab_pin.sym} 148980 -3990 0 1 {name=p148385 lab=_79652_/A }
C {sky130_stdcells/a21boi_4.sym} 148900 -3990 0 0 {name=X_79635_ }
C {devices/lab_pin.sym} 148820 -3880 0 0 {name=p148386 lab=_64858_/X }
C {devices/lab_pin.sym} 148820 -3840 0 0 {name=p148387 lab=_85528_/Q }
C {devices/lab_pin.sym} 148820 -3800 0 0 {name=p148388 lab=_64859_/X }
C {devices/lab_pin.sym} 148820 -3760 0 0 {name=p148389 lab=_64860_/X }
C {devices/lab_pin.sym} 148980 -3820 0 1 {name=p148390 lab=_64861_/X }
C {sky130_stdcells/a211o_4.sym} 148900 -3820 0 0 {name=X_64861_ }
C {devices/lab_pin.sym} 148840 -3680 0 0 {name=p148391 lab=_76847_/A }
C {devices/lab_pin.sym} 148840 -3640 0 0 {name=p148392 lab=_76847_/B }
C {devices/lab_pin.sym} 148960 -3660 0 1 {name=p148393 lab=_76847_/Y }
C {sky130_stdcells/xnor2_4.sym} 148900 -3660 0 0 {name=X_76847_ }
C {devices/lab_pin.sym} 148860 -3530 0 0 {name=p148394 lab=_49794_/X }
C {devices/lab_pin.sym} 148940 -3530 0 1 {name=p148395 lab=_49795_/X }
C {sky130_stdcells/buf_2.sym} 148900 -3530 0 0 {name=X_49795_ }
C {devices/lab_pin.sym} 148860 -3410 0 0 {name=p148396 lab=_66553_/X }
C {devices/lab_pin.sym} 148940 -3410 0 1 {name=p148397 lab=_68721_/A }
C {sky130_stdcells/buf_2.sym} 148900 -3410 0 0 {name=X_66600_ }
C {devices/lab_pin.sym} 148840 -3320 0 0 {name=p148398 lab=_61796_/X }
C {devices/lab_pin.sym} 148840 -3280 0 0 {name=p148399 lab=_63860_/B }
C {devices/lab_pin.sym} 148840 -3240 0 0 {name=p148400 lab=_63738_/C }
C {devices/lab_pin.sym} 148840 -3200 0 0 {name=p148401 lab=_63860_/D }
C {devices/lab_pin.sym} 148960 -3260 0 1 {name=p148402 lab=_63812_/Y }
C {sky130_stdcells/nand4_4.sym} 148900 -3260 0 0 {name=X_63812_ }
C {devices/lab_pin.sym} 148840 -3120 0 0 {name=p148403 lab=_48737_/A }
C {devices/lab_pin.sym} 148840 -3080 0 0 {name=p148404 lab=_48435_/B }
C {devices/lab_pin.sym} 148960 -3100 0 1 {name=p148405 lab=_48746_/Y }
C {sky130_stdcells/nand2_4.sym} 148900 -3100 0 0 {name=X_48746_ }
C {devices/lab_pin.sym} 148820 -3000 0 0 {name=p148406 lab=_87977_/Q }
C {devices/lab_pin.sym} 148820 -2960 0 0 {name=p148407 lab=_67533_/X }
C {devices/lab_pin.sym} 148820 -2920 0 0 {name=p148408 lab=_67508_/X }
C {devices/lab_pin.sym} 148820 -2880 0 0 {name=p148409 lab=_67579_/X }
C {devices/lab_pin.sym} 148980 -2940 0 1 {name=p148410 lab=_67580_/X }
C {sky130_stdcells/a211o_4.sym} 148900 -2940 0 0 {name=X_67580_ }
C {devices/lab_pin.sym} 148840 -2800 0 0 {name=p148411 lab=_79566_/A }
C {devices/lab_pin.sym} 148840 -2760 0 0 {name=p148412 lab=_79566_/B }
C {devices/lab_pin.sym} 148960 -2780 0 1 {name=p148413 lab=_79569_/A }
C {sky130_stdcells/nand2_4.sym} 148900 -2780 0 0 {name=X_79566_ }
C {devices/lab_pin.sym} 148820 -2680 0 0 {name=p148414 lab=_44216_/X }
C {devices/lab_pin.sym} 148820 -2640 0 0 {name=p148415 lab=_44217_/X }
C {devices/lab_pin.sym} 148820 -2600 0 0 {name=p148416 lab=_44153_/X }
C {devices/lab_pin.sym} 148820 -2560 0 0 {name=p148417 lab=_45950_/B }
C {devices/lab_pin.sym} 148980 -2620 0 1 {name=p148418 lab=_45958_/X }
C {sky130_stdcells/a211o_4.sym} 148900 -2620 0 0 {name=X_45958_ }
C {devices/lab_pin.sym} 148840 -2480 0 0 {name=p148419 lab=_64767_/A }
C {devices/lab_pin.sym} 148840 -2440 0 0 {name=p148420 lab=_85818_/Q }
C {devices/lab_pin.sym} 148960 -2460 0 1 {name=p148421 lab=_64792_/X }
C {sky130_stdcells/and2_4.sym} 148900 -2460 0 0 {name=X_64792_ }
C {devices/lab_pin.sym} 148860 -2330 0 0 {name=p148422 lab=_76755_/Y }
C {devices/lab_pin.sym} 148940 -2330 0 1 {name=p148423 lab=_81358_/D }
C {sky130_stdcells/inv_2.sym} 148900 -2330 0 0 {name=X_76778_ }
C {devices/lab_pin.sym} 148860 -2210 0 0 {name=p148424 lab=_69245_/A }
C {devices/lab_pin.sym} 148940 -2210 0 1 {name=p148425 lab=_66531_/X }
C {sky130_stdcells/buf_2.sym} 148900 -2210 0 0 {name=X_66531_ }
C {devices/lab_pin.sym} 148820 -2110 0 0 {name=p148426 lab=_78497_/X }
C {devices/lab_pin.sym} 148820 -2070 0 0 {name=p148427 lab=_78515_/Y }
C {devices/lab_pin.sym} 148820 -2030 0 0 {name=p148428 lab=_78516_/Y }
C {devices/lab_pin.sym} 148980 -2070 0 1 {name=p148429 lab=_78517_/Y }
C {sky130_stdcells/a21oi_4.sym} 148900 -2070 0 0 {name=X_78517_ }
C {devices/lab_pin.sym} 148820 -1950 0 0 {name=p148430 lab=_44890_/X }
C {devices/lab_pin.sym} 148820 -1910 0 0 {name=p148431 lab=_44902_/X }
C {devices/lab_pin.sym} 148820 -1870 0 0 {name=p148432 lab=_44908_/Y }
C {devices/lab_pin.sym} 148980 -1910 0 1 {name=p148433 lab=_44909_/Y }
C {sky130_stdcells/a21oi_4.sym} 148900 -1910 0 0 {name=X_44909_ }
C {devices/lab_pin.sym} 148820 -1810 0 0 {name=p148434 lab=_63732_/X }
C {devices/lab_pin.sym} 148820 -1770 0 0 {name=p148435 lab=_63736_/X }
C {devices/lab_pin.sym} 148820 -1730 0 0 {name=p148436 lab=_63738_/Y }
C {devices/lab_pin.sym} 148820 -1690 0 0 {name=p148437 lab=_63739_/Y }
C {devices/lab_pin.sym} 148820 -1660 0 0 {name=p148438 lab=_63742_/Y }
C {devices/lab_pin.sym} 148980 -1730 0 1 {name=p148439 lab=_63743_/X }
C {sky130_stdcells/a41o_4.sym} 148900 -1730 0 0 {name=X_63743_ }
C {devices/lab_pin.sym} 148820 -1590 0 0 {name=p148440 lab=_75723_/B }
C {devices/lab_pin.sym} 148820 -1550 0 0 {name=p148441 lab=_75723_/A }
C {devices/lab_pin.sym} 148820 -1510 0 0 {name=p148442 lab=_75728_/Y }
C {devices/lab_pin.sym} 148980 -1550 0 1 {name=p148443 lab=_75730_/B }
C {sky130_stdcells/a21oi_4.sym} 148900 -1550 0 0 {name=X_75729_ }
C {devices/lab_pin.sym} 148860 -1410 0 0 {name=p148444 lab=_60915_/X }
C {devices/lab_pin.sym} 148940 -1410 0 1 {name=p148445 lab=_63972_/A }
C {sky130_stdcells/buf_2.sym} 148900 -1410 0 0 {name=X_60955_ }
C {devices/lab_pin.sym} 148820 -1310 0 0 {name=p148446 lab=_48652_/X }
C {devices/lab_pin.sym} 148820 -1270 0 0 {name=p148447 lab=_82341_/Q }
C {devices/lab_pin.sym} 148820 -1230 0 0 {name=p148448 lab=_48676_/Y }
C {devices/lab_pin.sym} 148980 -1270 0 1 {name=p148449 lab=_74501_/A }
C {sky130_stdcells/o21ai_4.sym} 148900 -1270 0 0 {name=X_48677_ }
C {devices/lab_pin.sym} 148820 -1150 0 0 {name=p148450 lab=_79489_/A }
C {devices/lab_pin.sym} 148820 -1110 0 0 {name=p148451 lab=_79488_/Y }
C {devices/lab_pin.sym} 148820 -1070 0 0 {name=p148452 lab=_79496_/X }
C {devices/lab_pin.sym} 148980 -1110 0 1 {name=p148453 lab=_79498_/B }
C {sky130_stdcells/o21ai_4.sym} 148900 -1110 0 0 {name=X_79497_ }
C {devices/lab_pin.sym} 148860 -970 0 0 {name=p148454 lab=_45889_/A }
C {devices/lab_pin.sym} 148940 -970 0 1 {name=p148455 lab=_45893_/B }
C {sky130_stdcells/buf_2.sym} 148900 -970 0 0 {name=X_45889_ }
C {devices/lab_pin.sym} 148820 -880 0 0 {name=p148456 lab=_87531_/Q }
C {devices/lab_pin.sym} 148820 -840 0 0 {name=p148457 lab=_69044_/X }
C {devices/lab_pin.sym} 148820 -800 0 0 {name=p148458 lab=_69248_/X }
C {devices/lab_pin.sym} 148820 -760 0 0 {name=p148459 lab=_69249_/X }
C {devices/lab_pin.sym} 148980 -820 0 1 {name=p148460 lab=_69250_/X }
C {sky130_stdcells/a211o_4.sym} 148900 -820 0 0 {name=X_69250_ }
C {devices/lab_pin.sym} 148860 -670 0 0 {name=p148461 lab=_55013_/D }
C {devices/lab_pin.sym} 148940 -670 0 1 {name=p148462 lab=_53155_/D }
C {sky130_stdcells/buf_2.sym} 148900 -670 0 0 {name=X_47628_ }
C {devices/lab_pin.sym} 149760 -42170 0 0 {name=p148463 lab=_65107_/X }
C {devices/lab_pin.sym} 149760 -42130 0 0 {name=p148464 lab=_66476_/B }
C {devices/lab_pin.sym} 149760 -42090 0 0 {name=p148465 lab=_65110_/X }
C {devices/lab_pin.sym} 149880 -42130 0 1 {name=p148466 lab=_66462_/Y }
C {sky130_stdcells/nand3_4.sym} 149820 -42130 0 0 {name=X_66462_ }
C {devices/lab_pin.sym} 149760 -42000 0 0 {name=p148467 lab=_78466_/A }
C {devices/lab_pin.sym} 149760 -41960 0 0 {name=p148468 lab=_78466_/B }
C {devices/lab_pin.sym} 149880 -41980 0 1 {name=p148469 lab=_78448_/X }
C {sky130_stdcells/xor2_4.sym} 149820 -41980 0 0 {name=X_78448_ }
C {devices/lab_pin.sym} 149760 -41860 0 0 {name=p148470 lab=_63696_/A }
C {devices/lab_pin.sym} 149760 -41820 0 0 {name=p148471 lab=_62140_/X }
C {devices/lab_pin.sym} 149880 -41840 0 1 {name=p148472 lab=_63674_/X }
C {sky130_stdcells/and2_4.sym} 149820 -41840 0 0 {name=X_63674_ }
C {devices/lab_pin.sym} 149780 -41710 0 0 {name=p148473 lab=_60996_/B }
C {devices/lab_pin.sym} 149860 -41710 0 1 {name=p148474 lab=_60901_/B }
C {sky130_stdcells/buf_2.sym} 149820 -41710 0 0 {name=X_60886_ }
C {devices/lab_pin.sym} 149780 -41590 0 0 {name=p148475 lab=clkbuf_9_175_0_CLK/X }
C {devices/lab_pin.sym} 149860 -41590 0 1 {name=p148476 lab=_85651_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 149820 -41590 0 0 {name=Xclkbuf_10_350_0_CLK }
C {devices/lab_pin.sym} 149740 -41490 0 0 {name=p148477 lab=_67252_/X }
C {devices/lab_pin.sym} 149740 -41450 0 0 {name=p148478 lab=_67254_/X }
C {devices/lab_pin.sym} 149740 -41410 0 0 {name=p148479 lab=_68173_/X }
C {devices/lab_pin.sym} 149900 -41450 0 1 {name=p148480 lab=_68201_/Y }
C {sky130_stdcells/a21oi_4.sym} 149820 -41450 0 0 {name=X_68201_ }
C {devices/lab_pin.sym} 149760 -41320 0 0 {name=p148481 lab=_65285_/A }
C {devices/lab_pin.sym} 149760 -41280 0 0 {name=p148482 lab=_65413_/B }
C {devices/lab_pin.sym} 149880 -41300 0 1 {name=p148483 lab=_65413_/X }
C {sky130_stdcells/and2_4.sym} 149820 -41300 0 0 {name=X_65413_ }
C {devices/lab_pin.sym} 149740 -41210 0 0 {name=p148484 lab=_62618_/X }
C {devices/lab_pin.sym} 149740 -41170 0 0 {name=p148485 lab=_62622_/Y }
C {devices/lab_pin.sym} 149740 -41130 0 0 {name=p148486 lab=_62624_/X }
C {devices/lab_pin.sym} 149740 -41090 0 0 {name=p148487 lab=_84867_/Q }
C {devices/lab_pin.sym} 149740 -41050 0 0 {name=p148488 lab=_62212_/A }
C {devices/lab_pin.sym} 149900 -41130 0 1 {name=p148489 lab=_62625_/Y }
C {sky130_stdcells/o32ai_4.sym} 149820 -41130 0 0 {name=X_62625_ }
C {devices/lab_pin.sym} 149740 -40990 0 0 {name=p148490 lab=_69177_/X }
C {devices/lab_pin.sym} 149740 -40950 0 0 {name=p148491 lab=_69180_/X }
C {devices/lab_pin.sym} 149740 -40910 0 0 {name=p148492 lab=_69025_/X }
C {devices/lab_pin.sym} 149900 -40950 0 1 {name=p148493 lab=_69181_/X }
C {sky130_stdcells/a21o_4.sym} 149820 -40950 0 0 {name=X_69181_ }
C {devices/lab_pin.sym} 149760 -40840 0 0 {name=p148494 lab=_47530_/X }
C {devices/lab_pin.sym} 149760 -40800 0 0 {name=p148495 lab=_47595_/B }
C {devices/lab_pin.sym} 149760 -40760 0 0 {name=p148496 lab=_47519_/X }
C {devices/lab_pin.sym} 149760 -40720 0 0 {name=p148497 lab=_53118_/D }
C {devices/lab_pin.sym} 149880 -40780 0 1 {name=p148498 lab=_47559_/X }
C {sky130_stdcells/and4_4.sym} 149820 -40780 0 0 {name=X_47559_ }
C {devices/lab_pin.sym} 149740 -40650 0 0 {name=p148499 lab=_66282_/X }
C {devices/lab_pin.sym} 149740 -40610 0 0 {name=p148500 lab=_65999_/Y }
C {devices/lab_pin.sym} 149740 -40570 0 0 {name=p148501 lab=_66392_/Y }
C {devices/lab_pin.sym} 149900 -40610 0 1 {name=p148502 lab=_66393_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -40610 0 0 {name=X_66393_ }
C {devices/lab_pin.sym} 149780 -40470 0 0 {name=p148503 lab=_78379_/A }
C {devices/lab_pin.sym} 149860 -40470 0 1 {name=p148504 lab=_78380_/B }
C {sky130_stdcells/inv_2.sym} 149820 -40470 0 0 {name=X_78379_ }
C {devices/lab_pin.sym} 149780 -40350 0 0 {name=p148505 lab=clkbuf_9_490_0_CLK/X }
C {devices/lab_pin.sym} 149860 -40350 0 1 {name=p148506 lab=_85557_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 149820 -40350 0 0 {name=Xclkbuf_10_980_0_CLK }
C {devices/lab_pin.sym} 149760 -40240 0 0 {name=p148507 lab=_84756_/Q }
C {devices/lab_pin.sym} 149760 -40200 0 0 {name=p148508 lab=_84148_/Q }
C {devices/lab_pin.sym} 149880 -40220 0 1 {name=p148509 lab=_80410_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -40220 0 0 {name=X_80410_ }
C {devices/lab_pin.sym} 149740 -40110 0 0 {name=p148510 lab=_82071_/D }
C {devices/lab_pin.sym} 149740 -40070 0 0 {name=p148511 lab=_68120_/X }
C {devices/lab_pin.sym} 149740 -40030 0 0 {name=p148512 lab=_68131_/X }
C {devices/lab_pin.sym} 149900 -40070 0 1 {name=p148513 lab=_68132_/X }
C {sky130_stdcells/a21bo_4.sym} 149820 -40070 0 0 {name=X_68132_ }
C {devices/lab_pin.sym} 149740 -39960 0 0 {name=p148514 lab=_65342_/X }
C {devices/lab_pin.sym} 149740 -39920 0 0 {name=p148515 lab=_86725_/Q }
C {devices/lab_pin.sym} 149740 -39880 0 0 {name=p148516 lab=_65239_/X }
C {devices/lab_pin.sym} 149740 -39840 0 0 {name=p148517 lab=_65343_/X }
C {devices/lab_pin.sym} 149900 -39900 0 1 {name=p148518 lab=_65344_/X }
C {sky130_stdcells/a211o_4.sym} 149820 -39900 0 0 {name=X_65344_ }
C {devices/lab_pin.sym} 149760 -39760 0 0 {name=p148519 lab=_50575_/A }
C {devices/lab_pin.sym} 149760 -39720 0 0 {name=p148520 lab=_48901_/B }
C {devices/lab_pin.sym} 149880 -39740 0 1 {name=p148521 lab=_50570_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -39740 0 0 {name=X_50570_ }
C {devices/lab_pin.sym} 149760 -39640 0 0 {name=p148522 lab=_62556_/A }
C {devices/lab_pin.sym} 149760 -39600 0 0 {name=p148523 lab=_63280_/B }
C {devices/lab_pin.sym} 149760 -39560 0 0 {name=p148524 lab=_59977_/A }
C {devices/lab_pin.sym} 149760 -39520 0 0 {name=p148525 lab=_62548_/D }
C {devices/lab_pin.sym} 149880 -39580 0 1 {name=p148526 lab=_62556_/X }
C {sky130_stdcells/and4_4.sym} 149820 -39580 0 0 {name=X_62556_ }
C {devices/lab_pin.sym} 149730 -39430 0 0 {name=p148527 lab=_83926_/CLK }
C {devices/lab_pin.sym} 149730 -39410 0 0 {name=p148528 lab=_81390_/D }
C {devices/lab_pin.sym} 149910 -39430 0 1 {name=p148529 lab=_76907_/B }
C {sky130_stdcells/dfxtp_4.sym} 149820 -39420 0 0 {name=X_81390_ }
C {devices/lab_pin.sym} 149780 -39290 0 0 {name=p148530 lab=clkbuf_9_471_0_CLK/A }
C {devices/lab_pin.sym} 149860 -39290 0 1 {name=p148531 lab=clkbuf_9_471_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 149820 -39290 0 0 {name=Xclkbuf_9_471_0_CLK }
C {devices/lab_pin.sym} 149760 -39190 0 0 {name=p148532 lab=_61518_/A }
C {devices/lab_pin.sym} 149760 -39150 0 0 {name=p148533 lab=_61518_/B }
C {devices/lab_pin.sym} 149760 -39110 0 0 {name=p148534 lab=_84475_/Q }
C {devices/lab_pin.sym} 149880 -39150 0 1 {name=p148535 lab=_61507_/Y }
C {sky130_stdcells/nor3_4.sym} 149820 -39150 0 0 {name=X_61507_ }
C {devices/lab_pin.sym} 149740 -39030 0 0 {name=p148536 lab=_64710_/B }
C {devices/lab_pin.sym} 149740 -38990 0 0 {name=p148537 lab=_49204_/X }
C {devices/lab_pin.sym} 149740 -38950 0 0 {name=p148538 lab=_49228_/Y }
C {devices/lab_pin.sym} 149900 -38990 0 1 {name=p148539 lab=_49229_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -38990 0 0 {name=X_49229_ }
C {devices/lab_pin.sym} 149740 -38870 0 0 {name=p148540 lab=_80324_/A }
C {devices/lab_pin.sym} 149740 -38830 0 0 {name=p148541 lab=_80326_/X }
C {devices/lab_pin.sym} 149740 -38790 0 0 {name=p148542 lab=_80327_/Y }
C {devices/lab_pin.sym} 149900 -38830 0 1 {name=p148543 lab=_80341_/Y }
C {sky130_stdcells/a21boi_4.sym} 149820 -38830 0 0 {name=X_80341_ }
C {devices/lab_pin.sym} 149740 -38710 0 0 {name=p148544 lab=_68056_/X }
C {devices/lab_pin.sym} 149740 -38670 0 0 {name=p148545 lab=_68061_/X }
C {devices/lab_pin.sym} 149740 -38630 0 0 {name=p148546 lab=_68062_/X }
C {devices/lab_pin.sym} 149900 -38670 0 1 {name=p148547 lab=_68063_/Y }
C {sky130_stdcells/a21oi_4.sym} 149820 -38670 0 0 {name=X_68063_ }
C {devices/lab_pin.sym} 149760 -38540 0 0 {name=p148548 lab=_65403_/A }
C {devices/lab_pin.sym} 149760 -38500 0 0 {name=p148549 lab=_65275_/B }
C {devices/lab_pin.sym} 149880 -38520 0 1 {name=p148550 lab=_65275_/X }
C {sky130_stdcells/and2_4.sym} 149820 -38520 0 0 {name=X_65275_ }
C {devices/lab_pin.sym} 149780 -38390 0 0 {name=p148551 lab=_62269_/A }
C {devices/lab_pin.sym} 149860 -38390 0 1 {name=p148552 lab=_62487_/X }
C {sky130_stdcells/buf_2.sym} 149820 -38390 0 0 {name=X_62487_ }
C {devices/lab_pin.sym} 149780 -38270 0 0 {name=p148553 lab=clkbuf_9_182_0_CLK/X }
C {devices/lab_pin.sym} 149860 -38270 0 1 {name=p148554 lab=_85704_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 149820 -38270 0 0 {name=Xclkbuf_10_365_0_CLK }
C {devices/lab_pin.sym} 149780 -38150 0 0 {name=p148555 lab=_67013_/X }
C {devices/lab_pin.sym} 149860 -38150 0 1 {name=p148556 lab=_67014_/X }
C {sky130_stdcells/buf_2.sym} 149820 -38150 0 0 {name=X_67014_ }
C {devices/lab_pin.sym} 149780 -38030 0 0 {name=p148557 lab=_52215_/A }
C {devices/lab_pin.sym} 149860 -38030 0 1 {name=p148558 lab=_52250_/A }
C {sky130_stdcells/buf_2.sym} 149820 -38030 0 0 {name=X_52240_ }
C {devices/lab_pin.sym} 149780 -37910 0 0 {name=p148559 lab=_64249_/A }
C {devices/lab_pin.sym} 149860 -37910 0 1 {name=p148560 lab=_64226_/X }
C {sky130_stdcells/buf_2.sym} 149820 -37910 0 0 {name=X_64226_ }
C {devices/lab_pin.sym} 149730 -37790 0 0 {name=p148561 lab=_83562_/CLK }
C {devices/lab_pin.sym} 149730 -37770 0 0 {name=p148562 lab=_83060_/D }
C {devices/lab_pin.sym} 149910 -37790 0 1 {name=p148563 lab=_83060_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -37780 0 0 {name=X_83060_ }
C {devices/lab_pin.sym} 149780 -37650 0 0 {name=p148564 lab=_84824_/Q }
C {devices/lab_pin.sym} 149860 -37650 0 1 {name=p148565 lab=_61438_/X }
C {sky130_stdcells/buf_2.sym} 149820 -37650 0 0 {name=X_61438_ }
C {devices/lab_pin.sym} 149740 -37550 0 0 {name=p148566 lab=_80636_/A }
C {devices/lab_pin.sym} 149740 -37510 0 0 {name=p148567 lab=_80270_/X }
C {devices/lab_pin.sym} 149740 -37470 0 0 {name=p148568 lab=_80271_/Y }
C {devices/lab_pin.sym} 149900 -37510 0 1 {name=p148569 lab=_80288_/A }
C {sky130_stdcells/a21boi_4.sym} 149820 -37510 0 0 {name=X_80272_ }
C {devices/lab_pin.sym} 149780 -37370 0 0 {name=p148570 lab=clkbuf_9_497_0_CLK/X }
C {devices/lab_pin.sym} 149860 -37370 0 1 {name=p148571 lab=_85593_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 149820 -37370 0 0 {name=Xclkbuf_10_995_0_CLK }
C {devices/lab_pin.sym} 149730 -37250 0 0 {name=p148572 lab=_82139_/CLK }
C {devices/lab_pin.sym} 149730 -37230 0 0 {name=p148573 lab=_82043_/Q }
C {devices/lab_pin.sym} 149910 -37250 0 1 {name=p148574 lab=_82011_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -37240 0 0 {name=X_82011_ }
C {devices/lab_pin.sym} 149760 -37130 0 0 {name=p148575 lab=_50469_/A }
C {devices/lab_pin.sym} 149760 -37090 0 0 {name=p148576 lab=_52194_/B }
C {devices/lab_pin.sym} 149760 -37050 0 0 {name=p148577 lab=_52182_/C }
C {devices/lab_pin.sym} 149880 -37090 0 1 {name=p148578 lab=_52171_/X }
C {sky130_stdcells/and3_4.sym} 149820 -37090 0 0 {name=X_52171_ }
C {devices/lab_pin.sym} 149760 -36980 0 0 {name=p148579 lab=_64524_/B }
C {devices/lab_pin.sym} 149760 -36940 0 0 {name=p148580 lab=_64179_/B }
C {devices/lab_pin.sym} 149760 -36900 0 0 {name=p148581 lab=_64179_/C }
C {devices/lab_pin.sym} 149760 -36860 0 0 {name=p148582 lab=_64179_/D }
C {devices/lab_pin.sym} 149880 -36920 0 1 {name=p148583 lab=_64157_/Y }
C {sky130_stdcells/nand4_4.sym} 149820 -36920 0 0 {name=X_64157_ }
C {devices/lab_pin.sym} 149780 -36770 0 0 {name=p148584 lab=_61368_/Y }
C {devices/lab_pin.sym} 149860 -36770 0 1 {name=p148585 lab=_61369_/Y }
C {sky130_stdcells/inv_2.sym} 149820 -36770 0 0 {name=X_61369_ }
C {devices/lab_pin.sym} 149780 -36650 0 0 {name=p148586 lab=clkbuf_9_486_0_CLK/A }
C {devices/lab_pin.sym} 149860 -36650 0 1 {name=p148587 lab=clkbuf_9_486_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 149820 -36650 0 0 {name=Xclkbuf_9_486_0_CLK }
C {devices/lab_pin.sym} 149740 -36550 0 0 {name=p148588 lab=_51118_/Y }
C {devices/lab_pin.sym} 149740 -36510 0 0 {name=p148589 lab=_51119_/X }
C {devices/lab_pin.sym} 149740 -36470 0 0 {name=p148590 lab=_51121_/X }
C {devices/lab_pin.sym} 149900 -36510 0 1 {name=p148591 lab=_51122_/Y }
C {sky130_stdcells/a21oi_4.sym} 149820 -36510 0 0 {name=X_51122_ }
C {devices/lab_pin.sym} 149760 -36400 0 0 {name=p148592 lab=_63097_/A }
C {devices/lab_pin.sym} 149760 -36360 0 0 {name=p148593 lab=_64320_/B }
C {devices/lab_pin.sym} 149760 -36320 0 0 {name=p148594 lab=_63108_/C }
C {devices/lab_pin.sym} 149760 -36280 0 0 {name=p148595 lab=_63085_/D }
C {devices/lab_pin.sym} 149880 -36340 0 1 {name=p148596 lab=_63108_/X }
C {sky130_stdcells/and4_4.sym} 149820 -36340 0 0 {name=X_63108_ }
C {devices/lab_pin.sym} 149760 -36200 0 0 {name=p148597 lab=_68987_/A }
C {devices/lab_pin.sym} 149760 -36160 0 0 {name=p148598 lab=_87739_/Q }
C {devices/lab_pin.sym} 149880 -36180 0 1 {name=p148599 lab=_68965_/X }
C {sky130_stdcells/and2_4.sym} 149820 -36180 0 0 {name=X_68965_ }
C {devices/lab_pin.sym} 149760 -36070 0 0 {name=p148600 lab=_64116_/A }
C {devices/lab_pin.sym} 149760 -36030 0 0 {name=p148601 lab=_64087_/X }
C {devices/lab_pin.sym} 149760 -35990 0 0 {name=p148602 lab=_64088_/C }
C {devices/lab_pin.sym} 149880 -36030 0 1 {name=p148603 lab=_64088_/Y }
C {sky130_stdcells/nor3_4.sym} 149820 -36030 0 0 {name=X_64088_ }
C {devices/lab_pin.sym} 149760 -35900 0 0 {name=p148604 lab=_51058_/A }
C {devices/lab_pin.sym} 149760 -35860 0 0 {name=p148605 lab=_46912_/X }
C {devices/lab_pin.sym} 149880 -35880 0 1 {name=p148606 lab=_51053_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -35880 0 0 {name=X_51053_ }
C {devices/lab_pin.sym} 149740 -35780 0 0 {name=p148607 lab=_56208_/C }
C {devices/lab_pin.sym} 149740 -35740 0 0 {name=p148608 lab=_55605_/X }
C {devices/lab_pin.sym} 149740 -35700 0 0 {name=p148609 lab=_44090_/B }
C {devices/lab_pin.sym} 149740 -35660 0 0 {name=p148610 lab=_55929_/X }
C {devices/lab_pin.sym} 149900 -35720 0 1 {name=p148611 lab=_55930_/X }
C {sky130_stdcells/a211o_4.sym} 149820 -35720 0 0 {name=X_55930_ }
C {devices/lab_pin.sym} 149740 -35600 0 0 {name=p148612 lab=_87387_/Q }
C {devices/lab_pin.sym} 149740 -35560 0 0 {name=p148613 lab=_67868_/X }
C {devices/lab_pin.sym} 149740 -35520 0 0 {name=p148614 lab=_67821_/X }
C {devices/lab_pin.sym} 149740 -35480 0 0 {name=p148615 lab=_67915_/X }
C {devices/lab_pin.sym} 149900 -35540 0 1 {name=p148616 lab=_67916_/X }
C {sky130_stdcells/a211o_4.sym} 149820 -35540 0 0 {name=X_67916_ }
C {devices/lab_pin.sym} 149760 -35420 0 0 {name=p148617 lab=_63039_/A }
C {devices/lab_pin.sym} 149760 -35380 0 0 {name=p148618 lab=_64248_/C }
C {devices/lab_pin.sym} 149760 -35340 0 0 {name=p148619 lab=_63028_/X }
C {devices/lab_pin.sym} 149760 -35300 0 0 {name=p148620 lab=_63014_/D }
C {devices/lab_pin.sym} 149880 -35360 0 1 {name=p148621 lab=_63039_/X }
C {sky130_stdcells/and4_4.sym} 149820 -35360 0 0 {name=X_63039_ }
C {devices/lab_pin.sym} 149730 -35210 0 0 {name=p148622 lab=_85822_/CLK }
C {devices/lab_pin.sym} 149730 -35190 0 0 {name=p148623 lab=_46289_/Y }
C {devices/lab_pin.sym} 149910 -35210 0 1 {name=p148624 lab=_86750_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -35200 0 0 {name=X_86750_ }
C {devices/lab_pin.sym} 149730 -35070 0 0 {name=p148625 lab=_80991_/CLK }
C {devices/lab_pin.sym} 149730 -35050 0 0 {name=p148626 lab=_83962_/D }
C {devices/lab_pin.sym} 149910 -35070 0 1 {name=p148627 lab=_80818_/D }
C {sky130_stdcells/dfxtp_4.sym} 149820 -35060 0 0 {name=X_83962_ }
C {devices/lab_pin.sym} 149760 -34940 0 0 {name=p148628 lab=_68779_/A }
C {devices/lab_pin.sym} 149760 -34900 0 0 {name=p148629 lab=_68896_/B }
C {devices/lab_pin.sym} 149880 -34920 0 1 {name=p148630 lab=_68896_/X }
C {sky130_stdcells/and2_4.sym} 149820 -34920 0 0 {name=X_68896_ }
C {devices/lab_pin.sym} 149780 -34790 0 0 {name=p148631 lab=_46308_/A }
C {devices/lab_pin.sym} 149860 -34790 0 1 {name=p148632 lab=_50025_/A }
C {sky130_stdcells/buf_2.sym} 149820 -34790 0 0 {name=X_50004_ }
C {devices/lab_pin.sym} 149730 -34670 0 0 {name=p148633 lab=_85700_/CLK }
C {devices/lab_pin.sym} 149730 -34650 0 0 {name=p148634 lab=_53079_/Y }
C {devices/lab_pin.sym} 149910 -34670 0 1 {name=p148635 lab=_85701_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -34660 0 0 {name=X_85701_ }
C {devices/lab_pin.sym} 149730 -34530 0 0 {name=p148636 lab=_81195_/CLK }
C {devices/lab_pin.sym} 149730 -34510 0 0 {name=p148637 lab=_78307_/X }
C {devices/lab_pin.sym} 149910 -34530 0 1 {name=p148638 lab=_82913_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -34520 0 0 {name=X_82913_ }
C {devices/lab_pin.sym} 149740 -34420 0 0 {name=p148639 lab=_45122_/A }
C {devices/lab_pin.sym} 149740 -34380 0 0 {name=p148640 lab=_55522_/X }
C {devices/lab_pin.sym} 149740 -34340 0 0 {name=p148641 lab=_55532_/X }
C {devices/lab_pin.sym} 149740 -34300 0 0 {name=p148642 lab=_55860_/X }
C {devices/lab_pin.sym} 149900 -34360 0 1 {name=p148643 lab=_55862_/B }
C {sky130_stdcells/a211o_4.sym} 149820 -34360 0 0 {name=X_55861_ }
C {devices/lab_pin.sym} 149730 -34210 0 0 {name=p148644 lab=_86361_/CLK }
C {devices/lab_pin.sym} 149730 -34190 0 0 {name=p148645 lab=_86681_/D }
C {devices/lab_pin.sym} 149910 -34210 0 1 {name=p148646 lab=_59094_/A }
C {sky130_stdcells/dfxtp_4.sym} 149820 -34200 0 0 {name=X_86681_ }
C {devices/lab_pin.sym} 149740 -34090 0 0 {name=p148647 lab=_67844_/X }
C {devices/lab_pin.sym} 149740 -34050 0 0 {name=p148648 lab=_67846_/X }
C {devices/lab_pin.sym} 149740 -34010 0 0 {name=p148649 lab=_67799_/X }
C {devices/lab_pin.sym} 149900 -34050 0 1 {name=p148650 lab=_67847_/X }
C {sky130_stdcells/a21o_4.sym} 149820 -34050 0 0 {name=X_67847_ }
C {devices/lab_pin.sym} 149730 -33910 0 0 {name=p148651 lab=_82299_/CLK }
C {devices/lab_pin.sym} 149730 -33890 0 0 {name=p148652 lab=_83893_/D }
C {devices/lab_pin.sym} 149910 -33910 0 1 {name=p148653 lab=_83893_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -33900 0 0 {name=X_83893_ }
C {devices/lab_pin.sym} 149780 -33770 0 0 {name=p148654 lab=clkbuf_9_151_0_CLK/X }
C {devices/lab_pin.sym} 149860 -33770 0 1 {name=p148655 lab=_84321_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 149820 -33770 0 0 {name=Xclkbuf_10_303_0_CLK }
C {devices/lab_pin.sym} 149740 -33670 0 0 {name=p148656 lab=_84971_/Q }
C {devices/lab_pin.sym} 149740 -33630 0 0 {name=p148657 lab=_57562_/X }
C {devices/lab_pin.sym} 149740 -33590 0 0 {name=p148658 lab=_57599_/Y }
C {devices/lab_pin.sym} 149900 -33630 0 1 {name=p148659 lab=_57600_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -33630 0 0 {name=X_57600_ }
C {devices/lab_pin.sym} 149780 -33490 0 0 {name=p148660 lab=_54892_/A }
C {devices/lab_pin.sym} 149860 -33490 0 1 {name=p148661 lab=_54812_/X }
C {sky130_stdcells/buf_2.sym} 149820 -33490 0 0 {name=X_54812_ }
C {devices/lab_pin.sym} 149730 -33370 0 0 {name=p148662 lab=_86592_/CLK }
C {devices/lab_pin.sym} 149730 -33350 0 0 {name=p148663 lab=_53459_/Y }
C {devices/lab_pin.sym} 149910 -33370 0 1 {name=p148664 lab=_85632_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -33360 0 0 {name=X_85632_ }
C {devices/lab_pin.sym} 149740 -33250 0 0 {name=p148665 lab=_58085_/X }
C {devices/lab_pin.sym} 149740 -33210 0 0 {name=p148666 lab=_85472_/Q }
C {devices/lab_pin.sym} 149740 -33170 0 0 {name=p148667 lab=_58579_/X }
C {devices/lab_pin.sym} 149900 -33210 0 1 {name=p148668 lab=_58580_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -33210 0 0 {name=X_58580_ }
C {devices/lab_pin.sym} 149730 -33070 0 0 {name=p148669 lab=_82748_/CLK }
C {devices/lab_pin.sym} 149730 -33050 0 0 {name=p148670 lab=_82844_/D }
C {devices/lab_pin.sym} 149910 -33070 0 1 {name=p148671 lab=_82844_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -33060 0 0 {name=X_82844_ }
C {devices/lab_pin.sym} 149760 -32940 0 0 {name=p148672 lab=_55711_/X }
C {devices/lab_pin.sym} 149760 -32900 0 0 {name=p148673 lab=_85228_/Q }
C {devices/lab_pin.sym} 149880 -32920 0 1 {name=p148674 lab=_55792_/X }
C {sky130_stdcells/and2_4.sym} 149820 -32920 0 0 {name=X_55792_ }
C {devices/lab_pin.sym} 149740 -32820 0 0 {name=p148675 lab=_87149_/Q }
C {devices/lab_pin.sym} 149740 -32780 0 0 {name=p148676 lab=_67706_/X }
C {devices/lab_pin.sym} 149740 -32740 0 0 {name=p148677 lab=_67755_/X }
C {devices/lab_pin.sym} 149740 -32700 0 0 {name=p148678 lab=_67777_/X }
C {devices/lab_pin.sym} 149900 -32760 0 1 {name=p148679 lab=_67778_/X }
C {sky130_stdcells/a211o_4.sym} 149820 -32760 0 0 {name=X_67778_ }
C {devices/lab_pin.sym} 149780 -32610 0 0 {name=p148680 lab=clkbuf_9_466_0_CLK/X }
C {devices/lab_pin.sym} 149860 -32610 0 1 {name=p148681 lab=_87045_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 149820 -32610 0 0 {name=Xclkbuf_10_933_0_CLK }
C {devices/lab_pin.sym} 149760 -32500 0 0 {name=p148682 lab=_57531_/A }
C {devices/lab_pin.sym} 149760 -32460 0 0 {name=p148683 lab=_50275_/B }
C {devices/lab_pin.sym} 149880 -32480 0 1 {name=p148684 lab=_57531_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -32480 0 0 {name=X_57531_ }
C {devices/lab_pin.sym} 149740 -32370 0 0 {name=p148685 lab=_69036_/X }
C {devices/lab_pin.sym} 149740 -32330 0 0 {name=p148686 lab=_69038_/X }
C {devices/lab_pin.sym} 149740 -32290 0 0 {name=p148687 lab=_69500_/X }
C {devices/lab_pin.sym} 149900 -32330 0 1 {name=p148688 lab=_69517_/Y }
C {sky130_stdcells/a21oi_4.sym} 149820 -32330 0 0 {name=X_69517_ }
C {devices/lab_pin.sym} 149730 -32190 0 0 {name=p148689 lab=_87859_/CLK }
C {devices/lab_pin.sym} 149730 -32170 0 0 {name=p148690 lab=_40704_/Y }
C {devices/lab_pin.sym} 149910 -32190 0 1 {name=p148691 lab=_88351_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -32180 0 0 {name=X_88351_ }
C {devices/lab_pin.sym} 149760 -32080 0 0 {name=p148692 lab=_54748_/A }
C {devices/lab_pin.sym} 149760 -32040 0 0 {name=p148693 lab=_54755_/B }
C {devices/lab_pin.sym} 149760 -32000 0 0 {name=p148694 lab=_54748_/C }
C {devices/lab_pin.sym} 149760 -31960 0 0 {name=p148695 lab=_54743_/D }
C {devices/lab_pin.sym} 149880 -32020 0 1 {name=p148696 lab=_54743_/X }
C {sky130_stdcells/and4_4.sym} 149820 -32020 0 0 {name=X_54743_ }
C {devices/lab_pin.sym} 149740 -31900 0 0 {name=p148697 lab=_88397_/Q }
C {devices/lab_pin.sym} 149740 -31860 0 0 {name=p148698 lab=_66633_/X }
C {devices/lab_pin.sym} 149740 -31820 0 0 {name=p148699 lab=_66682_/X }
C {devices/lab_pin.sym} 149740 -31780 0 0 {name=p148700 lab=_66728_/X }
C {devices/lab_pin.sym} 149900 -31840 0 1 {name=p148701 lab=_66729_/X }
C {sky130_stdcells/a211o_4.sym} 149820 -31840 0 0 {name=X_66729_ }
C {devices/lab_pin.sym} 149730 -31690 0 0 {name=p148702 lab=_83310_/CLK }
C {devices/lab_pin.sym} 149730 -31670 0 0 {name=p148703 lab=_53815_/Y }
C {devices/lab_pin.sym} 149910 -31690 0 1 {name=p148704 lab=_85563_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -31680 0 0 {name=X_85563_ }
C {devices/lab_pin.sym} 149740 -31570 0 0 {name=p148705 lab=_85917_/Q }
C {devices/lab_pin.sym} 149740 -31530 0 0 {name=p148706 lab=_51945_/X }
C {devices/lab_pin.sym} 149740 -31490 0 0 {name=p148707 lab=_51954_/Y }
C {devices/lab_pin.sym} 149900 -31530 0 1 {name=p148708 lab=_51955_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -31530 0 0 {name=X_51955_ }
C {devices/lab_pin.sym} 149730 -31390 0 0 {name=p148709 lab=_82965_/CLK }
C {devices/lab_pin.sym} 149730 -31370 0 0 {name=p148710 lab=_82775_/D }
C {devices/lab_pin.sym} 149910 -31390 0 1 {name=p148711 lab=_82967_/D }
C {sky130_stdcells/dfxtp_4.sym} 149820 -31380 0 0 {name=X_82775_ }
C {devices/lab_pin.sym} 149780 -31250 0 0 {name=p148712 lab=clkbuf_9_424_0_CLK/A }
C {devices/lab_pin.sym} 149860 -31250 0 1 {name=p148713 lab=clkbuf_9_424_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 149820 -31250 0 0 {name=Xclkbuf_9_424_0_CLK }
C {devices/lab_pin.sym} 149730 -31130 0 0 {name=p148714 lab=_87553_/CLK }
C {devices/lab_pin.sym} 149730 -31110 0 0 {name=p148715 lab=_87302_/D }
C {devices/lab_pin.sym} 149910 -31130 0 1 {name=p148716 lab=_43703_/A }
C {sky130_stdcells/dfxtp_4.sym} 149820 -31120 0 0 {name=X_87302_ }
C {devices/lab_pin.sym} 149730 -30990 0 0 {name=p148717 lab=_84498_/CLK }
C {devices/lab_pin.sym} 149730 -30970 0 0 {name=p148718 lab=_84514_/D }
C {devices/lab_pin.sym} 149910 -30990 0 1 {name=p148719 lab=_61174_/C }
C {sky130_stdcells/dfxtp_4.sym} 149820 -30980 0 0 {name=X_84514_ }
C {devices/lab_pin.sym} 149760 -30860 0 0 {name=p148720 lab=_50906_/A }
C {devices/lab_pin.sym} 149760 -30820 0 0 {name=p148721 lab=_51770_/B }
C {devices/lab_pin.sym} 149880 -30840 0 1 {name=p148722 lab=_50906_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -30840 0 0 {name=X_50906_ }
C {devices/lab_pin.sym} 149780 -30710 0 0 {name=p148723 lab=_57461_/Y }
C {devices/lab_pin.sym} 149860 -30710 0 1 {name=p148724 lab=_85000_/D }
C {sky130_stdcells/inv_2.sym} 149820 -30710 0 0 {name=X_57462_ }
C {devices/lab_pin.sym} 149730 -30590 0 0 {name=p148725 lab=_84020_/CLK }
C {devices/lab_pin.sym} 149730 -30570 0 0 {name=p148726 lab=_81726_/D }
C {devices/lab_pin.sym} 149910 -30590 0 1 {name=p148727 lab=_81726_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -30580 0 0 {name=X_81726_ }
C {devices/lab_pin.sym} 149760 -30460 0 0 {name=p148728 lab=_69445_/X }
C {devices/lab_pin.sym} 149760 -30420 0 0 {name=p148729 lab=_69448_/B }
C {devices/lab_pin.sym} 149880 -30440 0 1 {name=p148730 lab=_69448_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -30440 0 0 {name=X_69448_ }
C {devices/lab_pin.sym} 149730 -30310 0 0 {name=p148731 lab=_87026_/CLK }
C {devices/lab_pin.sym} 149730 -30290 0 0 {name=p148732 lab=_41078_/Y }
C {devices/lab_pin.sym} 149910 -30310 0 1 {name=p148733 lab=_69486_/B }
C {sky130_stdcells/dfxtp_4.sym} 149820 -30300 0 0 {name=X_88282_ }
C {devices/lab_pin.sym} 149760 -30200 0 0 {name=p148734 lab=_54674_/A }
C {devices/lab_pin.sym} 149760 -30160 0 0 {name=p148735 lab=_54674_/B }
C {devices/lab_pin.sym} 149760 -30120 0 0 {name=p148736 lab=_54674_/C }
C {devices/lab_pin.sym} 149760 -30080 0 0 {name=p148737 lab=_47320_/A }
C {devices/lab_pin.sym} 149880 -30140 0 1 {name=p148738 lab=_54674_/X }
C {sky130_stdcells/and4_4.sym} 149820 -30140 0 0 {name=X_54674_ }
C {devices/lab_pin.sym} 149730 -29990 0 0 {name=p148739 lab=_85492_/CLK }
C {devices/lab_pin.sym} 149730 -29970 0 0 {name=p148740 lab=_85494_/D }
C {devices/lab_pin.sym} 149910 -29990 0 1 {name=p148741 lab=_85494_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -29980 0 0 {name=X_85494_ }
C {devices/lab_pin.sym} 149780 -29850 0 0 {name=p148742 lab=_51804_/A }
C {devices/lab_pin.sym} 149860 -29850 0 1 {name=p148743 lab=_51887_/A }
C {sky130_stdcells/buf_2.sym} 149820 -29850 0 0 {name=X_51886_ }
C {devices/lab_pin.sym} 149780 -29730 0 0 {name=p148744 lab=clkbuf_9_159_0_CLK/X }
C {devices/lab_pin.sym} 149860 -29730 0 1 {name=p148745 lab=_85381_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 149820 -29730 0 0 {name=Xclkbuf_10_318_0_CLK }
C {devices/lab_pin.sym} 149740 -29630 0 0 {name=p148746 lab=_59177_/X }
C {devices/lab_pin.sym} 149740 -29590 0 0 {name=p148747 lab=_86065_/Q }
C {devices/lab_pin.sym} 149740 -29550 0 0 {name=p148748 lab=_59200_/X }
C {devices/lab_pin.sym} 149900 -29590 0 1 {name=p148749 lab=_59201_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -29590 0 0 {name=X_59201_ }
C {devices/lab_pin.sym} 149740 -29470 0 0 {name=p148750 lab=_56074_/X }
C {devices/lab_pin.sym} 149740 -29430 0 0 {name=p148751 lab=_56409_/X }
C {devices/lab_pin.sym} 149740 -29390 0 0 {name=p148752 lab=_56412_/Y }
C {devices/lab_pin.sym} 149900 -29430 0 1 {name=p148753 lab=_85204_/D }
C {sky130_stdcells/o21ai_4.sym} 149820 -29430 0 0 {name=X_56413_ }
C {devices/lab_pin.sym} 149730 -29290 0 0 {name=p148754 lab=_87748_/CLK }
C {devices/lab_pin.sym} 149730 -29270 0 0 {name=p148755 lab=_87233_/D }
C {devices/lab_pin.sym} 149910 -29290 0 1 {name=p148756 lab=_68815_/B }
C {sky130_stdcells/dfxtp_4.sym} 149820 -29280 0 0 {name=X_87233_ }
C {devices/lab_pin.sym} 149740 -29170 0 0 {name=p148757 lab=_53623_/Y }
C {devices/lab_pin.sym} 149740 -29130 0 0 {name=p148758 lab=_53619_/X }
C {devices/lab_pin.sym} 149740 -29090 0 0 {name=p148759 lab=_53624_/X }
C {devices/lab_pin.sym} 149900 -29130 0 1 {name=p148760 lab=_53625_/Y }
C {sky130_stdcells/a21oi_4.sym} 149820 -29130 0 0 {name=X_53625_ }
C {devices/lab_pin.sym} 149730 -28990 0 0 {name=p148761 lab=_84452_/CLK }
C {devices/lab_pin.sym} 149730 -28970 0 0 {name=p148762 lab=_84445_/D }
C {devices/lab_pin.sym} 149910 -28990 0 1 {name=p148763 lab=_78068_/B }
C {sky130_stdcells/dfxtp_4.sym} 149820 -28980 0 0 {name=X_84445_ }
C {devices/lab_pin.sym} 149740 -28870 0 0 {name=p148764 lab=_86123_/Q }
C {devices/lab_pin.sym} 149740 -28830 0 0 {name=p148765 lab=_50820_/X }
C {devices/lab_pin.sym} 149740 -28790 0 0 {name=p148766 lab=_50836_/Y }
C {devices/lab_pin.sym} 149900 -28830 0 1 {name=p148767 lab=_50837_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -28830 0 0 {name=X_50837_ }
C {devices/lab_pin.sym} 149780 -28690 0 0 {name=p148768 lab=clkbuf_9_474_0_CLK/X }
C {devices/lab_pin.sym} 149860 -28690 0 1 {name=p148769 lab=_84970_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 149820 -28690 0 0 {name=Xclkbuf_10_948_0_CLK }
C {devices/lab_pin.sym} 149740 -28590 0 0 {name=p148770 lab=_56600_/X }
C {devices/lab_pin.sym} 149740 -28550 0 0 {name=p148771 lab=_57391_/Y }
C {devices/lab_pin.sym} 149740 -28510 0 0 {name=p148772 lab=_57392_/Y }
C {devices/lab_pin.sym} 149900 -28550 0 1 {name=p148773 lab=_57393_/Y }
C {sky130_stdcells/a21oi_4.sym} 149820 -28550 0 0 {name=X_57393_ }
C {devices/lab_pin.sym} 149730 -28410 0 0 {name=p148774 lab=_81697_/CLK }
C {devices/lab_pin.sym} 149730 -28390 0 0 {name=p148775 lab=_76707_/A }
C {devices/lab_pin.sym} 149910 -28410 0 1 {name=p148776 lab=_81657_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -28400 0 0 {name=X_81657_ }
C {devices/lab_pin.sym} 149740 -28300 0 0 {name=p148777 lab=_69329_/X }
C {devices/lab_pin.sym} 149740 -28260 0 0 {name=p148778 lab=_68798_/Y }
C {devices/lab_pin.sym} 149740 -28220 0 0 {name=p148779 lab=_69325_/X }
C {devices/lab_pin.sym} 149740 -28180 0 0 {name=p148780 lab=_69378_/Y }
C {devices/lab_pin.sym} 149900 -28240 0 1 {name=p148781 lab=_69379_/X }
C {sky130_stdcells/a211o_4.sym} 149820 -28240 0 0 {name=X_69379_ }
C {devices/lab_pin.sym} 149780 -28090 0 0 {name=p148782 lab=_58602_/A }
C {devices/lab_pin.sym} 149860 -28090 0 1 {name=p148783 lab=_59133_/A }
C {sky130_stdcells/buf_2.sym} 149820 -28090 0 0 {name=X_59132_ }
C {devices/lab_pin.sym} 149740 -27990 0 0 {name=p148784 lab=_71397_/X }
C {devices/lab_pin.sym} 149740 -27950 0 0 {name=p148785 lab=_83509_/Q }
C {devices/lab_pin.sym} 149740 -27910 0 0 {name=p148786 lab=_71409_/Y }
C {devices/lab_pin.sym} 149900 -27950 0 1 {name=p148787 lab=_83509_/D }
C {sky130_stdcells/a21o_4.sym} 149820 -27950 0 0 {name=X_71410_ }
C {devices/lab_pin.sym} 149740 -27830 0 0 {name=p148788 lab=_56121_/X }
C {devices/lab_pin.sym} 149740 -27790 0 0 {name=p148789 lab=_56337_/X }
C {devices/lab_pin.sym} 149740 -27750 0 0 {name=p148790 lab=_56343_/Y }
C {devices/lab_pin.sym} 149900 -27790 0 1 {name=p148791 lab=_56344_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -27790 0 0 {name=X_56344_ }
C {devices/lab_pin.sym} 149760 -27660 0 0 {name=p148792 lab=_80608_/A }
C {devices/lab_pin.sym} 149760 -27620 0 0 {name=p148793 lab=_80608_/B }
C {devices/lab_pin.sym} 149880 -27640 0 1 {name=p148794 lab=_80608_/X }
C {sky130_stdcells/or2_4.sym} 149820 -27640 0 0 {name=X_80608_ }
C {devices/lab_pin.sym} 149730 -27510 0 0 {name=p148795 lab=_86941_/CLK }
C {devices/lab_pin.sym} 149730 -27490 0 0 {name=p148796 lab=_87164_/D }
C {devices/lab_pin.sym} 149910 -27510 0 1 {name=p148797 lab=_87164_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -27500 0 0 {name=X_87164_ }
C {devices/lab_pin.sym} 149780 -27370 0 0 {name=p148798 lab=_41569_/Y }
C {devices/lab_pin.sym} 149860 -27370 0 1 {name=p148799 lab=_41570_/X }
C {sky130_stdcells/buf_2.sym} 149820 -27370 0 0 {name=X_41570_ }
C {devices/lab_pin.sym} 149780 -27250 0 0 {name=p148800 lab=_53687_/A }
C {devices/lab_pin.sym} 149860 -27250 0 1 {name=p148801 lab=_53556_/X }
C {sky130_stdcells/buf_2.sym} 149820 -27250 0 0 {name=X_53556_ }
C {devices/lab_pin.sym} 149740 -27150 0 0 {name=p148802 lab=_72389_/X }
C {devices/lab_pin.sym} 149740 -27110 0 0 {name=p148803 lab=_85675_/Q }
C {devices/lab_pin.sym} 149740 -27070 0 0 {name=p148804 lab=_72308_/X }
C {devices/lab_pin.sym} 149900 -27110 0 1 {name=p148805 lab=_72390_/X }
C {sky130_stdcells/o21a_4.sym} 149820 -27110 0 0 {name=X_72390_ }
C {devices/lab_pin.sym} 149730 -26970 0 0 {name=p148806 lab=_84507_/CLK }
C {devices/lab_pin.sym} 149730 -26950 0 0 {name=p148807 lab=_84376_/D }
C {devices/lab_pin.sym} 149910 -26970 0 1 {name=p148808 lab=_62864_/C }
C {sky130_stdcells/dfxtp_4.sym} 149820 -26960 0 0 {name=X_84376_ }
C {devices/lab_pin.sym} 149780 -26830 0 0 {name=p148809 lab=clkbuf_9_438_0_CLK/A }
C {devices/lab_pin.sym} 149860 -26830 0 1 {name=p148810 lab=clkbuf_9_439_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 149820 -26830 0 0 {name=Xclkbuf_9_439_0_CLK }
C {devices/lab_pin.sym} 149780 -26710 0 0 {name=p148811 lab=_50768_/A }
C {devices/lab_pin.sym} 149860 -26710 0 1 {name=p148812 lab=_50768_/X }
C {sky130_stdcells/buf_2.sym} 149820 -26710 0 0 {name=X_50768_ }
C {devices/lab_pin.sym} 149730 -26590 0 0 {name=p148813 lab=_84087_/CLK }
C {devices/lab_pin.sym} 149730 -26570 0 0 {name=p148814 lab=_84188_/Q }
C {devices/lab_pin.sym} 149910 -26590 0 1 {name=p148815 lab=_76819_/A }
C {sky130_stdcells/dfxtp_4.sym} 149820 -26580 0 0 {name=X_81588_ }
C {devices/lab_pin.sym} 149730 -26450 0 0 {name=p148816 lab=_86736_/CLK }
C {devices/lab_pin.sym} 149730 -26430 0 0 {name=p148817 lab=_50877_/Y }
C {devices/lab_pin.sym} 149910 -26450 0 1 {name=p148818 lab=_86115_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -26440 0 0 {name=X_86115_ }
C {devices/lab_pin.sym} 149740 -26340 0 0 {name=p148819 lab=_40520_/X }
C {devices/lab_pin.sym} 149740 -26300 0 0 {name=p148820 lab=_40508_/X }
C {devices/lab_pin.sym} 149740 -26260 0 0 {name=p148821 lab=_88378_/Q }
C {devices/lab_pin.sym} 149740 -26220 0 0 {name=p148822 lab=_40510_/X }
C {devices/lab_pin.sym} 149900 -26280 0 1 {name=p148823 lab=_40521_/X }
C {sky130_stdcells/a2bb2o_4.sym} 149820 -26280 0 0 {name=X_40521_ }
C {devices/lab_pin.sym} 149740 -26150 0 0 {name=p148824 lab=_65049_/B }
C {devices/lab_pin.sym} 149740 -26110 0 0 {name=p148825 lab=_52422_/X }
C {devices/lab_pin.sym} 149740 -26070 0 0 {name=p148826 lab=_52506_/Y }
C {devices/lab_pin.sym} 149900 -26110 0 1 {name=p148827 lab=_52507_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -26110 0 0 {name=X_52507_ }
C {devices/lab_pin.sym} 149740 -25990 0 0 {name=p148828 lab=_59061_/X }
C {devices/lab_pin.sym} 149740 -25950 0 0 {name=p148829 lab=_86076_/Q }
C {devices/lab_pin.sym} 149740 -25910 0 0 {name=p148830 lab=_59062_/X }
C {devices/lab_pin.sym} 149900 -25950 0 1 {name=p148831 lab=_59063_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -25950 0 0 {name=X_59063_ }
C {devices/lab_pin.sym} 149780 -25810 0 0 {name=p148832 lab=_71485_/B }
C {devices/lab_pin.sym} 149860 -25810 0 1 {name=p148833 lab=_71342_/B }
C {sky130_stdcells/buf_2.sym} 149820 -25810 0 0 {name=X_71341_ }
C {devices/lab_pin.sym} 149730 -25690 0 0 {name=p148834 lab=_83333_/CLK }
C {devices/lab_pin.sym} 149730 -25670 0 0 {name=p148835 lab=_83327_/D }
C {devices/lab_pin.sym} 149910 -25690 0 1 {name=p148836 lab=_83327_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -25680 0 0 {name=X_83327_ }
C {devices/lab_pin.sym} 149780 -25550 0 0 {name=p148837 lab=_56274_/X }
C {devices/lab_pin.sym} 149860 -25550 0 1 {name=p148838 lab=_56275_/X }
C {sky130_stdcells/buf_2.sym} 149820 -25550 0 0 {name=X_56275_ }
C {devices/lab_pin.sym} 149760 -25440 0 0 {name=p148839 lab=_80539_/A }
C {devices/lab_pin.sym} 149760 -25400 0 0 {name=p148840 lab=_84321_/Q }
C {devices/lab_pin.sym} 149880 -25420 0 1 {name=p148841 lab=_80540_/B }
C {sky130_stdcells/xor2_4.sym} 149820 -25420 0 0 {name=X_80539_ }
C {devices/lab_pin.sym} 149730 -25290 0 0 {name=p148842 lab=_88267_/CLK }
C {devices/lab_pin.sym} 149730 -25270 0 0 {name=p148843 lab=_87095_/D }
C {devices/lab_pin.sym} 149910 -25290 0 1 {name=p148844 lab=_87095_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -25280 0 0 {name=X_87095_ }
C {devices/lab_pin.sym} 149740 -25170 0 0 {name=p148845 lab=_85627_/Q }
C {devices/lab_pin.sym} 149740 -25130 0 0 {name=p148846 lab=_53476_/X }
C {devices/lab_pin.sym} 149740 -25090 0 0 {name=p148847 lab=_53486_/Y }
C {devices/lab_pin.sym} 149900 -25130 0 1 {name=p148848 lab=_53487_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -25130 0 0 {name=X_53487_ }
C {devices/lab_pin.sym} 149780 -24990 0 0 {name=p148849 lab=_50577_/A }
C {devices/lab_pin.sym} 149860 -24990 0 1 {name=p148850 lab=_50699_/X }
C {sky130_stdcells/buf_2.sym} 149820 -24990 0 0 {name=X_50699_ }
C {devices/lab_pin.sym} 149780 -24870 0 0 {name=p148851 lab=_58635_/A }
C {devices/lab_pin.sym} 149860 -24870 0 1 {name=p148852 lab=_58701_/A }
C {sky130_stdcells/buf_2.sym} 149820 -24870 0 0 {name=X_58014_ }
C {devices/lab_pin.sym} 149740 -24780 0 0 {name=p148853 lab=_41032_/X }
C {devices/lab_pin.sym} 149740 -24740 0 0 {name=p148854 lab=_43216_/X }
C {devices/lab_pin.sym} 149740 -24700 0 0 {name=p148855 lab=_87522_/Q }
C {devices/lab_pin.sym} 149740 -24660 0 0 {name=p148856 lab=_43218_/X }
C {devices/lab_pin.sym} 149900 -24720 0 1 {name=p148857 lab=_87522_/D }
C {sky130_stdcells/a2bb2o_4.sym} 149820 -24720 0 0 {name=X_43240_ }
C {devices/lab_pin.sym} 149740 -24590 0 0 {name=p148858 lab=_55227_/A }
C {devices/lab_pin.sym} 149740 -24550 0 0 {name=p148859 lab=_55225_/X }
C {devices/lab_pin.sym} 149740 -24510 0 0 {name=p148860 lab=_83315_/Q }
C {devices/lab_pin.sym} 149900 -24550 0 1 {name=p148861 lab=_55226_/Y }
C {sky130_stdcells/a21oi_4.sym} 149820 -24550 0 0 {name=X_55226_ }
C {devices/lab_pin.sym} 149760 -24420 0 0 {name=p148862 lab=_73972_/X }
C {devices/lab_pin.sym} 149760 -24380 0 0 {name=p148863 lab=_66211_/B }
C {devices/lab_pin.sym} 149880 -24400 0 1 {name=p148864 lab=_74060_/X }
C {sky130_stdcells/and2_4.sym} 149820 -24400 0 0 {name=X_74060_ }
C {devices/lab_pin.sym} 149730 -24270 0 0 {name=p148865 lab=_85535_/CLK }
C {devices/lab_pin.sym} 149730 -24250 0 0 {name=p148866 lab=_51252_/Y }
C {devices/lab_pin.sym} 149910 -24270 0 1 {name=p148867 lab=_64670_/B }
C {sky130_stdcells/dfxtp_4.sym} 149820 -24260 0 0 {name=X_86046_ }
C {devices/lab_pin.sym} 149780 -24130 0 0 {name=p148868 lab=_40451_/X }
C {devices/lab_pin.sym} 149860 -24130 0 1 {name=p148869 lab=_40452_/X }
C {sky130_stdcells/buf_2.sym} 149820 -24130 0 0 {name=X_40452_ }
C {devices/lab_pin.sym} 149780 -24010 0 0 {name=p148870 lab=_52438_/A }
C {devices/lab_pin.sym} 149860 -24010 0 1 {name=p148871 lab=_52438_/X }
C {sky130_stdcells/buf_2.sym} 149820 -24010 0 0 {name=X_52438_ }
C {devices/lab_pin.sym} 149740 -23910 0 0 {name=p148872 lab=_53187_/B }
C {devices/lab_pin.sym} 149740 -23870 0 0 {name=p148873 lab=_71265_/X }
C {devices/lab_pin.sym} 149740 -23830 0 0 {name=p148874 lab=_71271_/Y }
C {devices/lab_pin.sym} 149900 -23870 0 1 {name=p148875 lab=_83552_/D }
C {sky130_stdcells/o21ai_4.sym} 149820 -23870 0 0 {name=X_71272_ }
C {devices/lab_pin.sym} 149730 -23730 0 0 {name=p148876 lab=_81227_/CLK }
C {devices/lab_pin.sym} 149730 -23710 0 0 {name=p148877 lab=_83258_/D }
C {devices/lab_pin.sym} 149910 -23730 0 1 {name=p148878 lab=_72394_/A }
C {sky130_stdcells/dfxtp_4.sym} 149820 -23720 0 0 {name=X_83258_ }
C {devices/lab_pin.sym} 149740 -23620 0 0 {name=p148879 lab=_72806_/X }
C {devices/lab_pin.sym} 149740 -23580 0 0 {name=p148880 lab=_86200_/Q }
C {devices/lab_pin.sym} 149740 -23540 0 0 {name=p148881 lab=_72955_/X }
C {devices/lab_pin.sym} 149740 -23500 0 0 {name=p148882 lab=_73010_/X }
C {devices/lab_pin.sym} 149900 -23560 0 1 {name=p148883 lab=_73011_/X }
C {sky130_stdcells/a211o_4.sym} 149820 -23560 0 0 {name=X_73011_ }
C {devices/lab_pin.sym} 149780 -23410 0 0 {name=p148884 lab=_70337_/A }
C {devices/lab_pin.sym} 149860 -23410 0 1 {name=p148885 lab=_70238_/A }
C {sky130_stdcells/buf_2.sym} 149820 -23410 0 0 {name=X_70223_ }
C {devices/lab_pin.sym} 149730 -23290 0 0 {name=p148886 lab=_82965_/CLK }
C {devices/lab_pin.sym} 149730 -23270 0 0 {name=p148887 lab=_82209_/D }
C {devices/lab_pin.sym} 149910 -23290 0 1 {name=p148888 lab=_82209_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -23280 0 0 {name=X_82209_ }
C {devices/lab_pin.sym} 149740 -23190 0 0 {name=p148889 lab=_43046_/X }
C {devices/lab_pin.sym} 149740 -23150 0 0 {name=p148890 lab=_43125_/X }
C {devices/lab_pin.sym} 149740 -23110 0 0 {name=p148891 lab=_40881_/X }
C {devices/lab_pin.sym} 149740 -23070 0 0 {name=p148892 lab=_43170_/Y }
C {devices/lab_pin.sym} 149740 -23030 0 0 {name=p148893 lab=_43142_/X }
C {devices/lab_pin.sym} 149900 -23110 0 1 {name=p148894 lab=_43171_/Y }
C {sky130_stdcells/o32ai_4.sym} 149820 -23110 0 0 {name=X_43171_ }
C {devices/lab_pin.sym} 149780 -22950 0 0 {name=p148895 lab=_44058_/A }
C {devices/lab_pin.sym} 149860 -22950 0 1 {name=p148896 lab=_55157_/X }
C {sky130_stdcells/buf_2.sym} 149820 -22950 0 0 {name=X_55157_ }
C {devices/lab_pin.sym} 149780 -22830 0 0 {name=p148897 lab=_40586_/A }
C {devices/lab_pin.sym} 149860 -22830 0 1 {name=p148898 lab=_46317_/A }
C {sky130_stdcells/buf_2.sym} 149820 -22830 0 0 {name=X_40383_ }
C {devices/lab_pin.sym} 149780 -22710 0 0 {name=p148899 lab=_52247_/A }
C {devices/lab_pin.sym} 149860 -22710 0 1 {name=p148900 lab=_52369_/X }
C {sky130_stdcells/buf_2.sym} 149820 -22710 0 0 {name=X_52369_ }
C {devices/lab_pin.sym} 149730 -22590 0 0 {name=p148901 lab=_83188_/CLK }
C {devices/lab_pin.sym} 149730 -22570 0 0 {name=p148902 lab=_83189_/D }
C {devices/lab_pin.sym} 149910 -22590 0 1 {name=p148903 lab=_70229_/C }
C {sky130_stdcells/dfxtp_4.sym} 149820 -22580 0 0 {name=X_83189_ }
C {devices/lab_pin.sym} 149780 -22450 0 0 {name=p148904 lab=_42122_/A }
C {devices/lab_pin.sym} 149860 -22450 0 1 {name=p148905 lab=_88025_/D }
C {sky130_stdcells/inv_2.sym} 149820 -22450 0 0 {name=X_42122_ }
C {devices/lab_pin.sym} 149780 -22330 0 0 {name=p148906 lab=_43013_/X }
C {devices/lab_pin.sym} 149860 -22330 0 1 {name=p148907 lab=_54245_/A }
C {sky130_stdcells/buf_2.sym} 149820 -22330 0 0 {name=X_54108_ }
C {devices/lab_pin.sym} 149760 -22240 0 0 {name=p148908 lab=_70154_/A }
C {devices/lab_pin.sym} 149760 -22200 0 0 {name=p148909 lab=_70144_/X }
C {devices/lab_pin.sym} 149760 -22160 0 0 {name=p148910 lab=_70149_/X }
C {devices/lab_pin.sym} 149760 -22120 0 0 {name=p148911 lab=_70153_/Y }
C {devices/lab_pin.sym} 149880 -22180 0 1 {name=p148912 lab=_70154_/X }
C {sky130_stdcells/and4_4.sym} 149820 -22180 0 0 {name=X_70154_ }
C {devices/lab_pin.sym} 149740 -22050 0 0 {name=p148913 lab=_55086_/Y }
C {devices/lab_pin.sym} 149740 -22010 0 0 {name=p148914 lab=_55076_/X }
C {devices/lab_pin.sym} 149740 -21970 0 0 {name=p148915 lab=_55087_/X }
C {devices/lab_pin.sym} 149900 -22010 0 1 {name=p148916 lab=_85321_/D }
C {sky130_stdcells/a21oi_4.sym} 149820 -22010 0 0 {name=X_55088_ }
C {devices/lab_pin.sym} 149740 -21910 0 0 {name=p148917 lab=_59923_/Y }
C {devices/lab_pin.sym} 149740 -21870 0 0 {name=p148918 lab=_59943_/A }
C {devices/lab_pin.sym} 149740 -21830 0 0 {name=p148919 lab=_59880_/X }
C {devices/lab_pin.sym} 149740 -21790 0 0 {name=p148920 lab=_59884_/X }
C {devices/lab_pin.sym} 149740 -21760 0 0 {name=p148921 lab=_59927_/A }
C {devices/lab_pin.sym} 149900 -21830 0 1 {name=p148922 lab=_59968_/A }
C {sky130_stdcells/a41o_4.sym} 149820 -21830 0 0 {name=X_59965_ }
C {devices/lab_pin.sym} 149730 -21670 0 0 {name=p148923 lab=_88001_/CLK }
C {devices/lab_pin.sym} 149730 -21650 0 0 {name=p148924 lab=_42176_/X }
C {devices/lab_pin.sym} 149910 -21670 0 1 {name=p148925 lab=_87997_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -21660 0 0 {name=X_87997_ }
C {devices/lab_pin.sym} 149760 -21540 0 0 {name=p148926 lab=_46948_/A }
C {devices/lab_pin.sym} 149760 -21500 0 0 {name=p148927 lab=_52752_/B }
C {devices/lab_pin.sym} 149880 -21520 0 1 {name=p148928 lab=_46930_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -21520 0 0 {name=X_46930_ }
C {devices/lab_pin.sym} 149740 -21410 0 0 {name=p148929 lab=_58913_/Y }
C {devices/lab_pin.sym} 149740 -21370 0 0 {name=p148930 lab=_58915_/Y }
C {devices/lab_pin.sym} 149740 -21330 0 0 {name=p148931 lab=_58883_/X }
C {devices/lab_pin.sym} 149900 -21370 0 1 {name=p148932 lab=_58916_/X }
C {sky130_stdcells/a21o_4.sym} 149820 -21370 0 0 {name=X_58916_ }
C {devices/lab_pin.sym} 149760 -21250 0 0 {name=p148933 lab=_46471_/A }
C {devices/lab_pin.sym} 149760 -21210 0 0 {name=p148934 lab=_53964_/B }
C {devices/lab_pin.sym} 149760 -21170 0 0 {name=p148935 lab=_53969_/C }
C {devices/lab_pin.sym} 149880 -21210 0 1 {name=p148936 lab=_54039_/X }
C {sky130_stdcells/and3_4.sym} 149820 -21210 0 0 {name=X_54039_ }
C {devices/lab_pin.sym} 149740 -21110 0 0 {name=p148937 lab=_42052_/X }
C {devices/lab_pin.sym} 149740 -21070 0 0 {name=p148938 lab=_42043_/X }
C {devices/lab_pin.sym} 149740 -21030 0 0 {name=p148939 lab=_40909_/X }
C {devices/lab_pin.sym} 149740 -20990 0 0 {name=p148940 lab=_73438_/A }
C {devices/lab_pin.sym} 149740 -20950 0 0 {name=p148941 lab=_42044_/X }
C {devices/lab_pin.sym} 149900 -21030 0 1 {name=p148942 lab=_42053_/Y }
C {sky130_stdcells/o32ai_4.sym} 149820 -21030 0 0 {name=X_42053_ }
C {devices/lab_pin.sym} 149740 -20890 0 0 {name=p148943 lab=_77747_/X }
C {devices/lab_pin.sym} 149740 -20850 0 0 {name=p148944 lab=_77751_/C }
C {devices/lab_pin.sym} 149740 -20810 0 0 {name=p148945 lab=_77751_/B }
C {devices/lab_pin.sym} 149900 -20850 0 1 {name=p148946 lab=_77752_/A }
C {sky130_stdcells/a21o_4.sym} 149820 -20850 0 0 {name=X_77750_ }
C {devices/lab_pin.sym} 149760 -20720 0 0 {name=p148947 lab=_74959_/Y }
C {devices/lab_pin.sym} 149760 -20680 0 0 {name=p148948 lab=_74962_/B }
C {devices/lab_pin.sym} 149880 -20700 0 1 {name=p148949 lab=_74963_/B }
C {sky130_stdcells/nand2_4.sym} 149820 -20700 0 0 {name=X_74962_ }
C {devices/lab_pin.sym} 149780 -20570 0 0 {name=p148950 lab=_70048_/A }
C {devices/lab_pin.sym} 149860 -20570 0 1 {name=p148951 lab=_70085_/X }
C {sky130_stdcells/buf_2.sym} 149820 -20570 0 0 {name=X_70085_ }
C {devices/lab_pin.sym} 149730 -20450 0 0 {name=p148952 lab=_88215_/CLK }
C {devices/lab_pin.sym} 149730 -20430 0 0 {name=p148953 lab=_86948_/D }
C {devices/lab_pin.sym} 149910 -20450 0 1 {name=p148954 lab=_86948_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -20440 0 0 {name=X_86948_ }
C {devices/lab_pin.sym} 149780 -20310 0 0 {name=p148955 lab=_62288_/A }
C {devices/lab_pin.sym} 149860 -20310 0 1 {name=p148956 lab=_59896_/X }
C {sky130_stdcells/buf_2.sym} 149820 -20310 0 0 {name=X_59896_ }
C {devices/lab_pin.sym} 149780 -20190 0 0 {name=p148957 lab=_41003_/X }
C {devices/lab_pin.sym} 149860 -20190 0 1 {name=p148958 lab=_41004_/X }
C {sky130_stdcells/buf_2.sym} 149820 -20190 0 0 {name=X_41004_ }
C {devices/lab_pin.sym} 149760 -20080 0 0 {name=p148959 lab=_81351_/D }
C {devices/lab_pin.sym} 149760 -20040 0 0 {name=p148960 lab=_76691_/A }
C {devices/lab_pin.sym} 149880 -20060 0 1 {name=p148961 lab=_76701_/X }
C {sky130_stdcells/and2_4.sym} 149820 -20060 0 0 {name=X_76701_ }
C {devices/lab_pin.sym} 149760 -19950 0 0 {name=p148962 lab=_73911_/X }
C {devices/lab_pin.sym} 149760 -19910 0 0 {name=p148963 lab=_73913_/B }
C {devices/lab_pin.sym} 149760 -19870 0 0 {name=p148964 lab=_73913_/C }
C {devices/lab_pin.sym} 149880 -19910 0 1 {name=p148965 lab=_73913_/Y }
C {sky130_stdcells/nand3_4.sym} 149820 -19910 0 0 {name=X_73913_ }
C {devices/lab_pin.sym} 149780 -19770 0 0 {name=p148966 lab=_46861_/A }
C {devices/lab_pin.sym} 149860 -19770 0 1 {name=p148967 lab=_52718_/B }
C {sky130_stdcells/inv_2.sym} 149820 -19770 0 0 {name=X_46861_ }
C {devices/lab_pin.sym} 149780 -19650 0 0 {name=p148968 lab=_58847_/A }
C {devices/lab_pin.sym} 149860 -19650 0 1 {name=p148969 lab=_58847_/X }
C {sky130_stdcells/buf_2.sym} 149820 -19650 0 0 {name=X_58847_ }
C {devices/lab_pin.sym} 149760 -19550 0 0 {name=p148970 lab=_77676_/X }
C {devices/lab_pin.sym} 149760 -19510 0 0 {name=p148971 lab=_77679_/Y }
C {devices/lab_pin.sym} 149760 -19470 0 0 {name=p148972 lab=_77677_/Y }
C {devices/lab_pin.sym} 149880 -19510 0 1 {name=p148973 lab=_77693_/D }
C {sky130_stdcells/nand3_4.sym} 149820 -19510 0 0 {name=X_77681_ }
C {devices/lab_pin.sym} 149760 -19380 0 0 {name=p148974 lab=_74888_/A }
C {devices/lab_pin.sym} 149760 -19340 0 0 {name=p148975 lab=_74900_/A }
C {devices/lab_pin.sym} 149880 -19360 0 1 {name=p148976 lab=_74893_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -19360 0 0 {name=X_74893_ }
C {devices/lab_pin.sym} 149730 -19230 0 0 {name=p148977 lab=_86878_/CLK }
C {devices/lab_pin.sym} 149730 -19210 0 0 {name=p148978 lab=_45407_/Y }
C {devices/lab_pin.sym} 149910 -19230 0 1 {name=p148979 lab=_61714_/A }
C {sky130_stdcells/dfxtp_4.sym} 149820 -19220 0 0 {name=X_86879_ }
C {devices/lab_pin.sym} 149760 -19100 0 0 {name=p148980 lab=_48557_/A }
C {devices/lab_pin.sym} 149760 -19060 0 0 {name=p148981 lab=_50503_/B }
C {devices/lab_pin.sym} 149880 -19080 0 1 {name=p148982 lab=_48600_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -19080 0 0 {name=X_48600_ }
C {devices/lab_pin.sym} 149760 -18960 0 0 {name=p148983 lab=_79419_/B }
C {devices/lab_pin.sym} 149760 -18920 0 0 {name=p148984 lab=_79419_/A }
C {devices/lab_pin.sym} 149880 -18940 0 1 {name=p148985 lab=_79420_/X }
C {sky130_stdcells/and2_4.sym} 149820 -18940 0 0 {name=X_79420_ }
C {devices/lab_pin.sym} 149760 -18820 0 0 {name=p148986 lab=_57468_/A }
C {devices/lab_pin.sym} 149760 -18780 0 0 {name=p148987 lab=_45740_/B }
C {devices/lab_pin.sym} 149880 -18800 0 1 {name=p148988 lab=_45812_/Y }
C {sky130_stdcells/nor2_4.sym} 149820 -18800 0 0 {name=X_45812_ }
C {devices/lab_pin.sym} 149760 -18680 0 0 {name=p148989 lab=_76620_/A }
C {devices/lab_pin.sym} 149760 -18640 0 0 {name=p148990 lab=_81548_/Q }
C {devices/lab_pin.sym} 149880 -18660 0 1 {name=p148991 lab=_76633_/A }
C {sky130_stdcells/nand2_4.sym} 149820 -18660 0 0 {name=X_76632_ }
C {devices/lab_pin.sym} 149780 -18530 0 0 {name=p148992 lab=_49580_/A }
C {devices/lab_pin.sym} 149860 -18530 0 1 {name=p148993 lab=_49580_/X }
C {sky130_stdcells/buf_2.sym} 149820 -18530 0 0 {name=X_49580_ }
C {devices/lab_pin.sym} 149780 -18410 0 0 {name=p148994 lab=_72852_/X }
C {devices/lab_pin.sym} 149860 -18410 0 1 {name=p148995 lab=_73873_/B }
C {sky130_stdcells/buf_2.sym} 149820 -18410 0 0 {name=X_73844_ }
C {devices/lab_pin.sym} 149760 -18320 0 0 {name=p148996 lab=_46784_/A }
C {devices/lab_pin.sym} 149760 -18280 0 0 {name=p148997 lab=_46784_/B }
C {devices/lab_pin.sym} 149760 -18240 0 0 {name=p148998 lab=_46784_/C }
C {devices/lab_pin.sym} 149760 -18200 0 0 {name=p148999 lab=_46791_/X }
C {devices/lab_pin.sym} 149880 -18260 0 1 {name=p149000 lab=_46792_/X }
C {sky130_stdcells/and4_4.sym} 149820 -18260 0 0 {name=X_46792_ }
C {devices/lab_pin.sym} 149740 -18140 0 0 {name=p149001 lab=_58769_/Y }
C {devices/lab_pin.sym} 149740 -18100 0 0 {name=p149002 lab=_58739_/X }
C {devices/lab_pin.sym} 149740 -18060 0 0 {name=p149003 lab=_58774_/X }
C {devices/lab_pin.sym} 149740 -18020 0 0 {name=p149004 lab=_58777_/X }
C {devices/lab_pin.sym} 149900 -18080 0 1 {name=p149005 lab=_84801_/D }
C {sky130_stdcells/a22oi_4.sym} 149820 -18080 0 0 {name=X_58778_ }
C {devices/lab_pin.sym} 149740 -17950 0 0 {name=p149006 lab=_40585_/A }
C {devices/lab_pin.sym} 149740 -17910 0 0 {name=p149007 lab=_48529_/Y }
C {devices/lab_pin.sym} 149740 -17870 0 0 {name=p149008 lab=_48530_/Y }
C {devices/lab_pin.sym} 149900 -17910 0 1 {name=p149009 lab=_52175_/A }
C {sky130_stdcells/a21o_4.sym} 149820 -17910 0 0 {name=X_48531_ }
C {devices/lab_pin.sym} 149760 -17780 0 0 {name=p149010 lab=_84802_/Q }
C {devices/lab_pin.sym} 149760 -17740 0 0 {name=p149011 lab=_84122_/Q }
C {devices/lab_pin.sym} 149880 -17760 0 1 {name=p149012 lab=_79351_/X }
C {sky130_stdcells/xor2_4.sym} 149820 -17760 0 0 {name=X_79351_ }
C {devices/lab_pin.sym} 149740 -17650 0 0 {name=p149013 lab=_57725_/Y }
C {devices/lab_pin.sym} 149740 -17610 0 0 {name=p149014 lab=_57728_/Y }
C {devices/lab_pin.sym} 149740 -17570 0 0 {name=p149015 lab=_57718_/X }
C {devices/lab_pin.sym} 149900 -17610 0 1 {name=p149016 lab=_57729_/X }
C {sky130_stdcells/a21o_4.sym} 149820 -17610 0 0 {name=X_57729_ }
C {devices/lab_pin.sym} 149780 -17470 0 0 {name=p149017 lab=_45651_/A }
C {devices/lab_pin.sym} 149860 -17470 0 1 {name=p149018 lab=_45743_/X }
C {sky130_stdcells/buf_2.sym} 149820 -17470 0 0 {name=X_45743_ }
C {devices/lab_pin.sym} 149740 -17370 0 0 {name=p149019 lab=_76548_/A }
C {devices/lab_pin.sym} 149740 -17330 0 0 {name=p149020 lab=_76547_/Y }
C {devices/lab_pin.sym} 149740 -17290 0 0 {name=p149021 lab=_76541_/B }
C {devices/lab_pin.sym} 149900 -17330 0 1 {name=p149022 lab=_76563_/X }
C {sky130_stdcells/o21a_4.sym} 149820 -17330 0 0 {name=X_76563_ }
C {devices/lab_pin.sym} 149780 -17190 0 0 {name=p149023 lab=clkbuf_4_9_1_CLK/X }
C {devices/lab_pin.sym} 149860 -17190 0 1 {name=p149024 lab=clkbuf_6_37_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 149820 -17190 0 0 {name=Xclkbuf_5_18_0_CLK }
C {devices/lab_pin.sym} 149740 -17110 0 0 {name=p149025 lab=_42944_/X }
C {devices/lab_pin.sym} 149740 -17070 0 0 {name=p149026 lab=_42945_/X }
C {devices/lab_pin.sym} 149740 -17030 0 0 {name=p149027 lab=_40371_/X }
C {devices/lab_pin.sym} 149740 -16990 0 0 {name=p149028 lab=_66616_/B }
C {devices/lab_pin.sym} 149740 -16950 0 0 {name=p149029 lab=_42954_/X }
C {devices/lab_pin.sym} 149900 -17030 0 1 {name=p149030 lab=_42955_/Y }
C {sky130_stdcells/o32ai_4.sym} 149820 -17030 0 0 {name=X_42955_ }
C {devices/lab_pin.sym} 149740 -16890 0 0 {name=p149031 lab=_73771_/X }
C {devices/lab_pin.sym} 149740 -16850 0 0 {name=p149032 lab=_73774_/X }
C {devices/lab_pin.sym} 149740 -16810 0 0 {name=p149033 lab=_73679_/X }
C {devices/lab_pin.sym} 149900 -16850 0 1 {name=p149034 lab=_73792_/B }
C {sky130_stdcells/a21o_4.sym} 149820 -16850 0 0 {name=X_73775_ }
C {devices/lab_pin.sym} 149760 -16730 0 0 {name=p149035 lab=_70976_/A }
C {devices/lab_pin.sym} 149760 -16690 0 0 {name=p149036 lab=_71073_/B }
C {devices/lab_pin.sym} 149760 -16650 0 0 {name=p149037 lab=_70990_/C }
C {devices/lab_pin.sym} 149880 -16690 0 1 {name=p149038 lab=_70987_/Y }
C {sky130_stdcells/nand3_4.sym} 149820 -16690 0 0 {name=X_70987_ }
C {devices/lab_pin.sym} 149760 -16560 0 0 {name=p149039 lab=_78302_/A }
C {devices/lab_pin.sym} 149760 -16520 0 0 {name=p149040 lab=_78302_/B }
C {devices/lab_pin.sym} 149880 -16540 0 1 {name=p149041 lab=_78305_/A }
C {sky130_stdcells/nand2_4.sym} 149820 -16540 0 0 {name=X_78302_ }
C {devices/lab_pin.sym} 149760 -16420 0 0 {name=p149042 lab=_75514_/A }
C {devices/lab_pin.sym} 149760 -16380 0 0 {name=p149043 lab=_75513_/X }
C {devices/lab_pin.sym} 149880 -16400 0 1 {name=p149044 lab=_75514_/X }
C {sky130_stdcells/xor2_4.sym} 149820 -16400 0 0 {name=X_75514_ }
C {devices/lab_pin.sym} 149780 -16270 0 0 {name=p149045 lab=_51584_/A }
C {devices/lab_pin.sym} 149860 -16270 0 1 {name=p149046 lab=_51719_/A }
C {sky130_stdcells/buf_2.sym} 149820 -16270 0 0 {name=X_41906_ }
C {devices/lab_pin.sym} 149760 -16160 0 0 {name=p149047 lab=_48976_/B }
C {devices/lab_pin.sym} 149760 -16120 0 0 {name=p149048 lab=_48485_/B }
C {devices/lab_pin.sym} 149880 -16140 0 1 {name=p149049 lab=_48462_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -16140 0 0 {name=X_48462_ }
C {devices/lab_pin.sym} 149760 -16040 0 0 {name=p149050 lab=_60662_/A }
C {devices/lab_pin.sym} 149760 -16000 0 0 {name=p149051 lab=_60711_/A }
C {devices/lab_pin.sym} 149760 -15960 0 0 {name=p149052 lab=_60632_/X }
C {devices/lab_pin.sym} 149760 -15920 0 0 {name=p149053 lab=_60702_/C }
C {devices/lab_pin.sym} 149880 -15980 0 1 {name=p149054 lab=_63436_/A }
C {sky130_stdcells/nand4_4.sym} 149820 -15980 0 0 {name=X_60740_ }
C {devices/lab_pin.sym} 149780 -15830 0 0 {name=p149055 lab=_72978_/A }
C {devices/lab_pin.sym} 149860 -15830 0 1 {name=p149056 lab=_72795_/A }
C {sky130_stdcells/buf_2.sym} 149820 -15830 0 0 {name=X_72726_ }
C {devices/lab_pin.sym} 149760 -15720 0 0 {name=p149057 lab=_79282_/A }
C {devices/lab_pin.sym} 149760 -15680 0 0 {name=p149058 lab=_79268_/Y }
C {devices/lab_pin.sym} 149880 -15700 0 1 {name=p149059 lab=_79282_/X }
C {sky130_stdcells/or2_4.sym} 149820 -15700 0 0 {name=X_79282_ }
C {devices/lab_pin.sym} 149740 -15600 0 0 {name=p149060 lab=_45672_/Y }
C {devices/lab_pin.sym} 149740 -15560 0 0 {name=p149061 lab=_45596_/X }
C {devices/lab_pin.sym} 149740 -15520 0 0 {name=p149062 lab=_45644_/X }
C {devices/lab_pin.sym} 149740 -15480 0 0 {name=p149063 lab=_45673_/Y }
C {devices/lab_pin.sym} 149900 -15540 0 1 {name=p149064 lab=_45674_/X }
C {sky130_stdcells/a211o_4.sym} 149820 -15540 0 0 {name=X_45674_ }
C {devices/lab_pin.sym} 149780 -15390 0 0 {name=p149065 lab=_76494_/A }
C {devices/lab_pin.sym} 149860 -15390 0 1 {name=p149066 lab=_76494_/Y }
C {sky130_stdcells/inv_2.sym} 149820 -15390 0 0 {name=X_76494_ }
C {devices/lab_pin.sym} 149780 -15270 0 0 {name=p149067 lab=_42820_/X }
C {devices/lab_pin.sym} 149860 -15270 0 1 {name=p149068 lab=_42886_/X }
C {sky130_stdcells/buf_2.sym} 149820 -15270 0 0 {name=X_42886_ }
C {devices/lab_pin.sym} 149740 -15170 0 0 {name=p149069 lab=_86637_/Q }
C {devices/lab_pin.sym} 149740 -15130 0 0 {name=p149070 lab=_47382_/X }
C {devices/lab_pin.sym} 149740 -15090 0 0 {name=p149071 lab=_47412_/Y }
C {devices/lab_pin.sym} 149900 -15130 0 1 {name=p149072 lab=_47413_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -15130 0 0 {name=X_47413_ }
C {devices/lab_pin.sym} 149760 -15000 0 0 {name=p149073 lab=_78225_/A }
C {devices/lab_pin.sym} 149760 -14960 0 0 {name=p149074 lab=_78230_/A }
C {devices/lab_pin.sym} 149880 -14980 0 1 {name=p149075 lab=_78233_/X }
C {sky130_stdcells/and2_4.sym} 149820 -14980 0 0 {name=X_78233_ }
C {devices/lab_pin.sym} 149780 -14850 0 0 {name=p149076 lab=_44714_/A }
C {devices/lab_pin.sym} 149860 -14850 0 1 {name=p149077 lab=_44625_/X }
C {sky130_stdcells/buf_2.sym} 149820 -14850 0 0 {name=X_44625_ }
C {devices/lab_pin.sym} 149780 -14730 0 0 {name=p149078 lab=_75445_/A }
C {devices/lab_pin.sym} 149860 -14730 0 1 {name=p149079 lab=_75445_/Y }
C {sky130_stdcells/inv_2.sym} 149820 -14730 0 0 {name=X_75445_ }
C {devices/lab_pin.sym} 149780 -14610 0 0 {name=p149080 lab=_41837_/A }
C {devices/lab_pin.sym} 149860 -14610 0 1 {name=p149081 lab=_88129_/D }
C {sky130_stdcells/inv_2.sym} 149820 -14610 0 0 {name=X_41837_ }
C {devices/lab_pin.sym} 149760 -14510 0 0 {name=p149082 lab=_60671_/A }
C {devices/lab_pin.sym} 149760 -14470 0 0 {name=p149083 lab=_60671_/B }
C {devices/lab_pin.sym} 149760 -14430 0 0 {name=p149084 lab=_60671_/C }
C {devices/lab_pin.sym} 149880 -14470 0 1 {name=p149085 lab=_60671_/Y }
C {sky130_stdcells/nand3_4.sym} 149820 -14470 0 0 {name=X_60671_ }
C {devices/lab_pin.sym} 149740 -14350 0 0 {name=p149086 lab=_72843_/B }
C {devices/lab_pin.sym} 149740 -14310 0 0 {name=p149087 lab=_48350_/X }
C {devices/lab_pin.sym} 149740 -14270 0 0 {name=p149088 lab=_48392_/Y }
C {devices/lab_pin.sym} 149900 -14310 0 1 {name=p149089 lab=_48393_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -14310 0 0 {name=X_48393_ }
C {devices/lab_pin.sym} 149740 -14190 0 0 {name=p149090 lab=_70198_/C }
C {devices/lab_pin.sym} 149740 -14150 0 0 {name=p149091 lab=_72645_/X }
C {devices/lab_pin.sym} 149740 -14110 0 0 {name=p149092 lab=_72656_/Y }
C {devices/lab_pin.sym} 149900 -14150 0 1 {name=p149093 lab=_83200_/D }
C {sky130_stdcells/a21bo_4.sym} 149820 -14150 0 0 {name=X_72657_ }
C {devices/lab_pin.sym} 149740 -14050 0 0 {name=p149094 lab=_62399_/X }
C {devices/lab_pin.sym} 149740 -14010 0 0 {name=p149095 lab=_62406_/Y }
C {devices/lab_pin.sym} 149740 -13970 0 0 {name=p149096 lab=_62409_/X }
C {devices/lab_pin.sym} 149740 -13930 0 0 {name=p149097 lab=_84740_/Q }
C {devices/lab_pin.sym} 149740 -13890 0 0 {name=p149098 lab=_62367_/X }
C {devices/lab_pin.sym} 149900 -13970 0 1 {name=p149099 lab=_62410_/Y }
C {sky130_stdcells/o32ai_4.sym} 149820 -13970 0 0 {name=X_62410_ }
C {devices/lab_pin.sym} 149780 -13810 0 0 {name=p149100 lab=_47344_/A }
C {devices/lab_pin.sym} 149860 -13810 0 1 {name=p149101 lab=_52995_/B }
C {sky130_stdcells/buf_2.sym} 149820 -13810 0 0 {name=X_47344_ }
C {devices/lab_pin.sym} 149740 -13710 0 0 {name=p149102 lab=_71604_/X }
C {devices/lab_pin.sym} 149740 -13670 0 0 {name=p149103 lab=_83441_/Q }
C {devices/lab_pin.sym} 149740 -13630 0 0 {name=p149104 lab=_71607_/Y }
C {devices/lab_pin.sym} 149900 -13670 0 1 {name=p149105 lab=_83441_/D }
C {sky130_stdcells/a21o_4.sym} 149820 -13670 0 0 {name=X_71608_ }
C {devices/lab_pin.sym} 149760 -13550 0 0 {name=p149106 lab=_78154_/X }
C {devices/lab_pin.sym} 149760 -13510 0 0 {name=p149107 lab=_78145_/A }
C {devices/lab_pin.sym} 149760 -13470 0 0 {name=p149108 lab=_82860_/D }
C {devices/lab_pin.sym} 149880 -13510 0 1 {name=p149109 lab=_78165_/A }
C {sky130_stdcells/nand3_4.sym} 149820 -13510 0 0 {name=X_78164_ }
C {devices/lab_pin.sym} 149780 -13370 0 0 {name=p149110 lab=_44556_/A }
C {devices/lab_pin.sym} 149860 -13370 0 1 {name=p149111 lab=_44556_/Y }
C {sky130_stdcells/inv_2.sym} 149820 -13370 0 0 {name=X_44556_ }
C {devices/lab_pin.sym} 149740 -13290 0 0 {name=p149112 lab=_63368_/X }
C {devices/lab_pin.sym} 149740 -13250 0 0 {name=p149113 lab=_63384_/X }
C {devices/lab_pin.sym} 149740 -13210 0 0 {name=p149114 lab=_63385_/X }
C {devices/lab_pin.sym} 149740 -13170 0 0 {name=p149115 lab=_63388_/X }
C {devices/lab_pin.sym} 149740 -13130 0 0 {name=p149116 lab=_63389_/Y }
C {devices/lab_pin.sym} 149900 -13210 0 1 {name=p149117 lab=_63390_/Y }
C {sky130_stdcells/o41ai_4.sym} 149820 -13210 0 0 {name=X_63390_ }
C {devices/lab_pin.sym} 149760 -13060 0 0 {name=p149118 lab=_75376_/A }
C {devices/lab_pin.sym} 149760 -13020 0 0 {name=p149119 lab=_75376_/B }
C {devices/lab_pin.sym} 149880 -13040 0 1 {name=p149120 lab=_75376_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -13040 0 0 {name=X_75376_ }
C {devices/lab_pin.sym} 149780 -12910 0 0 {name=p149121 lab=_41767_/Y }
C {devices/lab_pin.sym} 149860 -12910 0 1 {name=p149122 lab=_41768_/X }
C {sky130_stdcells/buf_2.sym} 149820 -12910 0 0 {name=X_41768_ }
C {devices/lab_pin.sym} 149740 -12830 0 0 {name=p149123 lab=_72528_/Y }
C {devices/lab_pin.sym} 149740 -12790 0 0 {name=p149124 lab=_72607_/B }
C {devices/lab_pin.sym} 149740 -12750 0 0 {name=p149125 lab=_72597_/C }
C {devices/lab_pin.sym} 149740 -12710 0 0 {name=p149126 lab=_72583_/C }
C {devices/lab_pin.sym} 149740 -12670 0 0 {name=p149127 lab=_72525_/A }
C {devices/lab_pin.sym} 149900 -12750 0 1 {name=p149128 lab=_72588_/Y }
C {sky130_stdcells/a32oi_4.sym} 149820 -12750 0 0 {name=X_72588_ }
C {devices/lab_pin.sym} 149760 -12600 0 0 {name=p149129 lab=_77115_/A }
C {devices/lab_pin.sym} 149760 -12560 0 0 {name=p149130 lab=_77112_/C }
C {devices/lab_pin.sym} 149880 -12580 0 1 {name=p149131 lab=_77115_/X }
C {sky130_stdcells/and2_4.sym} 149820 -12580 0 0 {name=X_77115_ }
C {devices/lab_pin.sym} 149740 -12490 0 0 {name=p149132 lab=_43495_/X }
C {devices/lab_pin.sym} 149740 -12450 0 0 {name=p149133 lab=_43503_/X }
C {devices/lab_pin.sym} 149740 -12410 0 0 {name=p149134 lab=_41762_/X }
C {devices/lab_pin.sym} 149740 -12370 0 0 {name=p149135 lab=_87386_/Q }
C {devices/lab_pin.sym} 149740 -12330 0 0 {name=p149136 lab=_43506_/X }
C {devices/lab_pin.sym} 149900 -12410 0 1 {name=p149137 lab=_43507_/Y }
C {sky130_stdcells/o32ai_4.sym} 149820 -12410 0 0 {name=X_43507_ }
C {devices/lab_pin.sym} 149780 -12250 0 0 {name=p149138 lab=_62179_/X }
C {devices/lab_pin.sym} 149860 -12250 0 1 {name=p149139 lab=_62341_/X }
C {sky130_stdcells/buf_2.sym} 149820 -12250 0 0 {name=X_62341_ }
C {devices/lab_pin.sym} 149780 -12130 0 0 {name=p149140 lab=_72943_/A }
C {devices/lab_pin.sym} 149860 -12130 0 1 {name=p149141 lab=_74327_/X }
C {sky130_stdcells/buf_2.sym} 149820 -12130 0 0 {name=X_74327_ }
C {devices/lab_pin.sym} 149780 -12010 0 0 {name=p149142 lab=_40793_/A }
C {devices/lab_pin.sym} 149860 -12010 0 1 {name=p149143 lab=_40719_/X }
C {sky130_stdcells/buf_2.sym} 149820 -12010 0 0 {name=X_40719_ }
C {devices/lab_pin.sym} 149760 -11920 0 0 {name=p149144 lab=_47246_/X }
C {devices/lab_pin.sym} 149760 -11880 0 0 {name=p149145 lab=_47311_/B }
C {devices/lab_pin.sym} 149760 -11840 0 0 {name=p149146 lab=_47234_/X }
C {devices/lab_pin.sym} 149760 -11800 0 0 {name=p149147 lab=_52954_/D }
C {devices/lab_pin.sym} 149880 -11860 0 1 {name=p149148 lab=_47275_/X }
C {sky130_stdcells/and4_4.sym} 149820 -11860 0 0 {name=X_47275_ }
C {devices/lab_pin.sym} 149760 -11730 0 0 {name=p149149 lab=_70673_/A }
C {devices/lab_pin.sym} 149760 -11690 0 0 {name=p149150 lab=_71622_/D }
C {devices/lab_pin.sym} 149760 -11650 0 0 {name=p149151 lab=_71546_/C }
C {devices/lab_pin.sym} 149880 -11690 0 1 {name=p149152 lab=_71539_/Y }
C {sky130_stdcells/nor3_4.sym} 149820 -11690 0 0 {name=X_71539_ }
C {devices/lab_pin.sym} 149780 -11550 0 0 {name=p149153 lab=_78096_/B }
C {devices/lab_pin.sym} 149860 -11550 0 1 {name=p149154 lab=_78095_/Y }
C {sky130_stdcells/inv_2.sym} 149820 -11550 0 0 {name=X_78095_ }
C {devices/lab_pin.sym} 149740 -11470 0 0 {name=p149155 lab=_44481_/X }
C {devices/lab_pin.sym} 149740 -11430 0 0 {name=p149156 lab=_44482_/X }
C {devices/lab_pin.sym} 149740 -11390 0 0 {name=p149157 lab=_41213_/X }
C {devices/lab_pin.sym} 149740 -11350 0 0 {name=p149158 lab=_87084_/Q }
C {devices/lab_pin.sym} 149740 -11310 0 0 {name=p149159 lab=_44484_/X }
C {devices/lab_pin.sym} 149900 -11390 0 1 {name=p149160 lab=_44488_/A }
C {sky130_stdcells/o32ai_4.sym} 149820 -11390 0 0 {name=X_44487_ }
C {devices/lab_pin.sym} 149760 -11240 0 0 {name=p149161 lab=_40620_/X }
C {devices/lab_pin.sym} 149760 -11200 0 0 {name=p149162 lab=_41699_/B }
C {devices/lab_pin.sym} 149880 -11220 0 1 {name=p149163 lab=_41699_/X }
C {sky130_stdcells/or2_4.sym} 149820 -11220 0 0 {name=X_41699_ }
C {devices/lab_pin.sym} 149780 -11090 0 0 {name=p149164 lab=_83612_/Q }
C {devices/lab_pin.sym} 149860 -11090 0 1 {name=p149165 lab=_53848_/B }
C {sky130_stdcells/inv_2.sym} 149820 -11090 0 0 {name=X_49014_ }
C {devices/lab_pin.sym} 149760 -10990 0 0 {name=p149166 lab=_46222_/Y }
C {devices/lab_pin.sym} 149760 -10950 0 0 {name=p149167 lab=_58151_/A }
C {devices/lab_pin.sym} 149760 -10910 0 0 {name=p149168 lab=_46225_/Y }
C {devices/lab_pin.sym} 149880 -10950 0 1 {name=p149169 lab=_46227_/A }
C {sky130_stdcells/nand3_4.sym} 149820 -10950 0 0 {name=X_46226_ }
C {devices/lab_pin.sym} 149780 -10810 0 0 {name=p149170 lab=_64829_/A }
C {devices/lab_pin.sym} 149860 -10810 0 1 {name=p149171 lab=_65060_/X }
C {sky130_stdcells/buf_2.sym} 149820 -10810 0 0 {name=X_65060_ }
C {sky130_stdcells/decap_3.sym} 149820 -10660 0 0 {name=XPHY_380 }
C {devices/lab_pin.sym} 149760 -10520 0 0 {name=p149172 lab=_81992_/Q }
C {devices/lab_pin.sym} 149760 -10480 0 0 {name=p149173 lab=_82280_/D }
C {devices/lab_pin.sym} 149880 -10500 0 1 {name=p149174 lab=_77047_/B }
C {sky130_stdcells/nand2_4.sym} 149820 -10500 0 0 {name=X_77046_ }
C {devices/lab_pin.sym} 149740 -10410 0 0 {name=p149175 lab=_43422_/X }
C {devices/lab_pin.sym} 149740 -10370 0 0 {name=p149176 lab=_43426_/X }
C {devices/lab_pin.sym} 149740 -10330 0 0 {name=p149177 lab=_41574_/X }
C {devices/lab_pin.sym} 149740 -10290 0 0 {name=p149178 lab=_87421_/Q }
C {devices/lab_pin.sym} 149740 -10250 0 0 {name=p149179 lab=_43434_/X }
C {devices/lab_pin.sym} 149900 -10330 0 1 {name=p149180 lab=_43439_/A }
C {sky130_stdcells/o32ai_4.sym} 149820 -10330 0 0 {name=X_43438_ }
C {devices/lab_pin.sym} 149760 -10200 0 0 {name=p149181 lab=_61378_/A }
C {devices/lab_pin.sym} 149760 -10160 0 0 {name=p149182 lab=_62631_/B }
C {devices/lab_pin.sym} 149760 -10120 0 0 {name=p149183 lab=_62631_/C }
C {devices/lab_pin.sym} 149760 -10080 0 0 {name=p149184 lab=_62225_/X }
C {devices/lab_pin.sym} 149880 -10140 0 1 {name=p149185 lab=_62272_/Y }
C {sky130_stdcells/nand4_4.sym} 149820 -10140 0 0 {name=X_62272_ }
C {devices/lab_pin.sym} 149760 -10000 0 0 {name=p149186 lab=_74258_/A }
C {devices/lab_pin.sym} 149760 -9960 0 0 {name=p149187 lab=_74258_/B }
C {devices/lab_pin.sym} 149880 -9980 0 1 {name=p149188 lab=_74259_/B }
C {sky130_stdcells/nand2_4.sym} 149820 -9980 0 0 {name=X_74258_ }
C {sky130_stdcells/decap_3.sym} 149820 -9820 0 0 {name=XPHY_391 }
C {devices/lab_pin.sym} 149760 -9700 0 0 {name=p149189 lab=_63206_/B }
C {devices/lab_pin.sym} 149760 -9660 0 0 {name=p149190 lab=_63947_/B }
C {devices/lab_pin.sym} 149760 -9620 0 0 {name=p149191 lab=_64040_/C }
C {devices/lab_pin.sym} 149760 -9580 0 0 {name=p149192 lab=_64025_/D }
C {devices/lab_pin.sym} 149880 -9640 0 1 {name=p149193 lab=_64011_/Y }
C {sky130_stdcells/nand4_4.sym} 149820 -9640 0 0 {name=X_64011_ }
C {devices/lab_pin.sym} 149780 -9490 0 0 {name=p149194 lab=_72720_/A }
C {devices/lab_pin.sym} 149860 -9490 0 1 {name=p149195 lab=_73355_/A }
C {sky130_stdcells/buf_2.sym} 149820 -9490 0 0 {name=X_73209_ }
C {devices/lab_pin.sym} 149760 -9390 0 0 {name=p149196 lab=_61234_/A }
C {devices/lab_pin.sym} 149760 -9350 0 0 {name=p149197 lab=_61250_/B }
C {devices/lab_pin.sym} 149760 -9310 0 0 {name=p149198 lab=_61223_/C }
C {devices/lab_pin.sym} 149880 -9350 0 1 {name=p149199 lab=_61223_/Y }
C {sky130_stdcells/nor3_4.sym} 149820 -9350 0 0 {name=X_61223_ }
C {devices/lab_pin.sym} 149760 -9230 0 0 {name=p149200 lab=_46120_/A }
C {devices/lab_pin.sym} 149760 -9190 0 0 {name=p149201 lab=_46120_/B }
C {devices/lab_pin.sym} 149760 -9150 0 0 {name=p149202 lab=_86770_/Q }
C {devices/lab_pin.sym} 149880 -9190 0 1 {name=p149203 lab=_46158_/C }
C {sky130_stdcells/nand3_4.sym} 149820 -9190 0 0 {name=X_46157_ }
C {devices/lab_pin.sym} 149780 -9050 0 0 {name=p149204 lab=_43369_/A }
C {devices/lab_pin.sym} 149860 -9050 0 1 {name=p149205 lab=_87456_/D }
C {sky130_stdcells/inv_2.sym} 149820 -9050 0 0 {name=X_43369_ }
C {devices/lab_pin.sym} 149740 -8950 0 0 {name=p149206 lab=_88344_/Q }
C {devices/lab_pin.sym} 149740 -8910 0 0 {name=p149207 lab=_72865_/X }
C {devices/lab_pin.sym} 149740 -8870 0 0 {name=p149208 lab=_72982_/X }
C {devices/lab_pin.sym} 149900 -8910 0 1 {name=p149209 lab=_74189_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -8910 0 0 {name=X_74189_ }
C {devices/lab_pin.sym} 149760 -8780 0 0 {name=p149210 lab=_45108_/A }
C {devices/lab_pin.sym} 149760 -8740 0 0 {name=p149211 lab=_45067_/B }
C {devices/lab_pin.sym} 149880 -8760 0 1 {name=p149212 lab=_45108_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -8760 0 0 {name=X_45108_ }
C {devices/lab_pin.sym} 149740 -8650 0 0 {name=p149213 lab=_61176_/B }
C {devices/lab_pin.sym} 149740 -8610 0 0 {name=p149214 lab=_61151_/Y }
C {devices/lab_pin.sym} 149740 -8570 0 0 {name=p149215 lab=_61272_/B }
C {devices/lab_pin.sym} 149900 -8610 0 1 {name=p149216 lab=_61154_/X }
C {sky130_stdcells/o21a_4.sym} 149820 -8610 0 0 {name=X_61154_ }
C {devices/lab_pin.sym} 149780 -8470 0 0 {name=p149217 lab=_46188_/A }
C {devices/lab_pin.sym} 149860 -8470 0 1 {name=p149218 lab=_46143_/A }
C {sky130_stdcells/inv_2.sym} 149820 -8470 0 0 {name=X_46088_ }
C {devices/lab_pin.sym} 149760 -8360 0 0 {name=p149219 lab=_78997_/A }
C {devices/lab_pin.sym} 149760 -8320 0 0 {name=p149220 lab=_78997_/B }
C {devices/lab_pin.sym} 149880 -8340 0 1 {name=p149221 lab=_79000_/A }
C {sky130_stdcells/xor2_4.sym} 149820 -8340 0 0 {name=X_78997_ }
C {devices/lab_pin.sym} 149780 -8210 0 0 {name=p149222 lab=_65515_/A }
C {devices/lab_pin.sym} 149860 -8210 0 1 {name=p149223 lab=_60105_/X }
C {sky130_stdcells/buf_2.sym} 149820 -8210 0 0 {name=X_60105_ }
C {devices/lab_pin.sym} 149760 -8120 0 0 {name=p149224 lab=_49904_/A }
C {devices/lab_pin.sym} 149760 -8080 0 0 {name=p149225 lab=_49915_/X }
C {devices/lab_pin.sym} 149760 -8040 0 0 {name=p149226 lab=_49904_/C }
C {devices/lab_pin.sym} 149760 -8000 0 0 {name=p149227 lab=_53129_/D }
C {devices/lab_pin.sym} 149880 -8060 0 1 {name=p149228 lab=_49916_/X }
C {sky130_stdcells/and4_4.sym} 149820 -8060 0 0 {name=X_49916_ }
C {devices/lab_pin.sym} 149740 -7930 0 0 {name=p149229 lab=_56216_/C }
C {devices/lab_pin.sym} 149740 -7890 0 0 {name=p149230 lab=_44998_/X }
C {devices/lab_pin.sym} 149740 -7850 0 0 {name=p149231 lab=_45038_/X }
C {devices/lab_pin.sym} 149900 -7890 0 1 {name=p149232 lab=_45039_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -7890 0 0 {name=X_45039_ }
C {devices/lab_pin.sym} 149760 -7760 0 0 {name=p149233 lab=_68750_/A }
C {devices/lab_pin.sym} 149760 -7720 0 0 {name=p149234 lab=_68750_/B }
C {devices/lab_pin.sym} 149880 -7740 0 1 {name=p149235 lab=_68750_/X }
C {sky130_stdcells/and2_4.sym} 149820 -7740 0 0 {name=X_68750_ }
C {devices/lab_pin.sym} 149740 -7630 0 0 {name=p149236 lab=_65958_/X }
C {devices/lab_pin.sym} 149740 -7590 0 0 {name=p149237 lab=_65960_/X }
C {devices/lab_pin.sym} 149740 -7550 0 0 {name=p149238 lab=_65961_/X }
C {devices/lab_pin.sym} 149900 -7590 0 1 {name=p149239 lab=_65962_/X }
C {sky130_stdcells/a21o_4.sym} 149820 -7590 0 0 {name=X_65962_ }
C {devices/lab_pin.sym} 149740 -7470 0 0 {name=p149240 lab=_82073_/Q }
C {devices/lab_pin.sym} 149740 -7430 0 0 {name=p149241 lab=_77946_/Y }
C {devices/lab_pin.sym} 149740 -7390 0 0 {name=p149242 lab=_77947_/X }
C {devices/lab_pin.sym} 149900 -7430 0 1 {name=p149243 lab=_77948_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -7430 0 0 {name=X_77948_ }
C {devices/lab_pin.sym} 149780 -7290 0 0 {name=p149244 lab=_64249_/A }
C {devices/lab_pin.sym} 149860 -7290 0 1 {name=p149245 lab=_61085_/X }
C {sky130_stdcells/buf_2.sym} 149820 -7290 0 0 {name=X_61085_ }
C {devices/lab_pin.sym} 149740 -7200 0 0 {name=p149246 lab=_87972_/Q }
C {devices/lab_pin.sym} 149740 -7160 0 0 {name=p149247 lab=_67651_/X }
C {devices/lab_pin.sym} 149740 -7120 0 0 {name=p149248 lab=_67625_/X }
C {devices/lab_pin.sym} 149740 -7080 0 0 {name=p149249 lab=_67700_/X }
C {devices/lab_pin.sym} 149900 -7140 0 1 {name=p149250 lab=_67701_/X }
C {sky130_stdcells/a211o_4.sym} 149820 -7140 0 0 {name=X_67701_ }
C {devices/lab_pin.sym} 149760 -7010 0 0 {name=p149251 lab=_64637_/X }
C {devices/lab_pin.sym} 149760 -6970 0 0 {name=p149252 lab=_64913_/B }
C {devices/lab_pin.sym} 149760 -6930 0 0 {name=p149253 lab=_84222_/Q }
C {devices/lab_pin.sym} 149880 -6970 0 1 {name=p149254 lab=_64913_/X }
C {sky130_stdcells/and3_4.sym} 149820 -6970 0 0 {name=X_64913_ }
C {devices/lab_pin.sym} 149780 -6830 0 0 {name=p149255 lab=_60036_/A }
C {devices/lab_pin.sym} 149860 -6830 0 1 {name=p149256 lab=_72564_/A }
C {sky130_stdcells/buf_2.sym} 149820 -6830 0 0 {name=X_60036_ }
C {devices/lab_pin.sym} 149740 -6730 0 0 {name=p149257 lab=_49842_/Y }
C {devices/lab_pin.sym} 149740 -6690 0 0 {name=p149258 lab=_49844_/X }
C {devices/lab_pin.sym} 149740 -6650 0 0 {name=p149259 lab=_49846_/X }
C {devices/lab_pin.sym} 149900 -6690 0 1 {name=p149260 lab=_86313_/D }
C {sky130_stdcells/a21oi_4.sym} 149820 -6690 0 0 {name=X_49847_ }
C {devices/lab_pin.sym} 149760 -6560 0 0 {name=p149261 lab=_68604_/A }
C {devices/lab_pin.sym} 149760 -6520 0 0 {name=p149262 lab=_68681_/B }
C {devices/lab_pin.sym} 149880 -6540 0 1 {name=p149263 lab=_68681_/X }
C {sky130_stdcells/and2_4.sym} 149820 -6540 0 0 {name=X_68681_ }
C {devices/lab_pin.sym} 149740 -6440 0 0 {name=p149264 lab=_65859_/X }
C {devices/lab_pin.sym} 149740 -6400 0 0 {name=p149265 lab=_85570_/Q }
C {devices/lab_pin.sym} 149740 -6360 0 0 {name=p149266 lab=_65860_/X }
C {devices/lab_pin.sym} 149740 -6320 0 0 {name=p149267 lab=_65892_/X }
C {devices/lab_pin.sym} 149900 -6380 0 1 {name=p149268 lab=_65893_/X }
C {sky130_stdcells/a211o_4.sym} 149820 -6380 0 0 {name=X_65893_ }
C {devices/lab_pin.sym} 149760 -6240 0 0 {name=p149269 lab=_77879_/A }
C {devices/lab_pin.sym} 149760 -6200 0 0 {name=p149270 lab=_77878_/Y }
C {devices/lab_pin.sym} 149880 -6220 0 1 {name=p149271 lab=_77880_/B }
C {sky130_stdcells/nand2_4.sym} 149820 -6220 0 0 {name=X_77879_ }
