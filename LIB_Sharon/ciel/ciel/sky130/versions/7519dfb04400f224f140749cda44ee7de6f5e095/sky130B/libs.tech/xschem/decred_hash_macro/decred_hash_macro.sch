C {devices/lab_pin.sym} 76180 -32530 0 0 {name=p75408 lab=_54630_/D }
C {devices/lab_pin.sym} 76260 -32530 0 1 {name=p75409 lab=_52938_/D }
C {sky130_stdcells/buf_2.sym} 76220 -32530 0 0 {name=X_47248_ }
C {devices/lab_pin.sym} 76160 -32420 0 0 {name=p75410 lab=_65763_/A }
C {devices/lab_pin.sym} 76160 -32380 0 0 {name=p75411 lab=_66082_/B }
C {devices/lab_pin.sym} 76280 -32400 0 1 {name=p75412 lab=_66082_/X }
C {sky130_stdcells/and2_4.sym} 76220 -32400 0 0 {name=X_66082_ }
C {devices/lab_pin.sym} 76160 -32280 0 0 {name=p75413 lab=_84573_/Q }
C {devices/lab_pin.sym} 76160 -32240 0 0 {name=p75414 lab=_78068_/B }
C {devices/lab_pin.sym} 76280 -32260 0 1 {name=p75415 lab=_78068_/X }
C {sky130_stdcells/xor2_4.sym} 76220 -32260 0 0 {name=X_78068_ }
C {devices/lab_pin.sym} 76180 -32130 0 0 {name=p75416 lab=_63247_/A }
C {devices/lab_pin.sym} 76260 -32130 0 1 {name=p75417 lab=_63344_/D }
C {sky130_stdcells/buf_2.sym} 76220 -32130 0 0 {name=X_63294_ }
C {devices/lab_pin.sym} 76140 -32040 0 0 {name=p75418 lab=_64999_/X }
C {devices/lab_pin.sym} 76140 -32000 0 0 {name=p75419 lab=_86161_/Q }
C {devices/lab_pin.sym} 76140 -31960 0 0 {name=p75420 lab=_64927_/X }
C {devices/lab_pin.sym} 76140 -31920 0 0 {name=p75421 lab=_65032_/X }
C {devices/lab_pin.sym} 76300 -31980 0 1 {name=p75422 lab=_65033_/X }
C {sky130_stdcells/a211o_4.sym} 76220 -31980 0 0 {name=X_65033_ }
C {devices/lab_pin.sym} 76140 -31850 0 0 {name=p75423 lab=_69907_/X }
C {devices/lab_pin.sym} 76140 -31810 0 0 {name=p75424 lab=_69909_/X }
C {devices/lab_pin.sym} 76140 -31770 0 0 {name=p75425 lab=_66579_/X }
C {devices/lab_pin.sym} 76300 -31810 0 1 {name=p75426 lab=_69910_/X }
C {sky130_stdcells/a21o_4.sym} 76220 -31810 0 0 {name=X_69910_ }
C {devices/lab_pin.sym} 76180 -31670 0 0 {name=p75427 lab=_77019_/A }
C {devices/lab_pin.sym} 76260 -31670 0 1 {name=p75428 lab=_77019_/Y }
C {sky130_stdcells/inv_2.sym} 76220 -31670 0 0 {name=X_77019_ }
C {devices/lab_pin.sym} 76160 -31580 0 0 {name=p75429 lab=_62478_/A }
C {devices/lab_pin.sym} 76160 -31540 0 0 {name=p75430 lab=_59995_/A }
C {devices/lab_pin.sym} 76160 -31500 0 0 {name=p75431 lab=_64235_/B }
C {devices/lab_pin.sym} 76160 -31460 0 0 {name=p75432 lab=_60025_/X }
C {devices/lab_pin.sym} 76280 -31520 0 1 {name=p75433 lab=_62245_/X }
C {sky130_stdcells/and4_4.sym} 76220 -31520 0 0 {name=X_62245_ }
C {devices/lab_pin.sym} 76180 -31370 0 0 {name=p75434 lab=_82374_/Q }
C {devices/lab_pin.sym} 76260 -31370 0 1 {name=p75435 lab=_47180_/A }
C {sky130_stdcells/inv_2.sym} 76220 -31370 0 0 {name=X_47179_ }
C {devices/lab_pin.sym} 76180 -31250 0 0 {name=p75436 lab=_80030_/A }
C {devices/lab_pin.sym} 76260 -31250 0 1 {name=p75437 lab=_80030_/Y }
C {sky130_stdcells/inv_2.sym} 76220 -31250 0 0 {name=X_80030_ }
C {devices/lab_pin.sym} 76180 -31130 0 0 {name=p75438 lab=_69755_/A }
C {devices/lab_pin.sym} 76260 -31130 0 1 {name=p75439 lab=_69900_/A }
C {sky130_stdcells/buf_2.sym} 76220 -31130 0 0 {name=X_69841_ }
C {devices/lab_pin.sym} 76180 -31010 0 0 {name=p75440 lab=_48759_/A }
C {devices/lab_pin.sym} 76260 -31010 0 1 {name=p75441 lab=_51263_/A }
C {sky130_stdcells/buf_2.sym} 76220 -31010 0 0 {name=X_50190_ }
C {devices/lab_pin.sym} 76160 -30920 0 0 {name=p75442 lab=_61715_/A }
C {devices/lab_pin.sym} 76160 -30880 0 0 {name=p75443 lab=_62172_/Y }
C {devices/lab_pin.sym} 76160 -30840 0 0 {name=p75444 lab=_62173_/Y }
C {devices/lab_pin.sym} 76160 -30800 0 0 {name=p75445 lab=_62175_/Y }
C {devices/lab_pin.sym} 76280 -30860 0 1 {name=p75446 lab=_62176_/Y }
C {sky130_stdcells/nand4_4.sym} 76220 -30860 0 0 {name=X_62176_ }
C {devices/lab_pin.sym} 76180 -30710 0 0 {name=p75447 lab=clkbuf_9_335_0_CLK/X }
C {devices/lab_pin.sym} 76260 -30710 0 1 {name=p75448 lab=_88394_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 76220 -30710 0 0 {name=Xclkbuf_10_671_0_CLK }
C {devices/lab_pin.sym} 76140 -30610 0 0 {name=p75449 lab=_61122_/B }
C {devices/lab_pin.sym} 76140 -30570 0 0 {name=p75450 lab=_61122_/C }
C {devices/lab_pin.sym} 76140 -30530 0 0 {name=p75451 lab=_61122_/A }
C {devices/lab_pin.sym} 76300 -30570 0 1 {name=p75452 lab=_61128_/A }
C {sky130_stdcells/a21oi_4.sym} 76220 -30570 0 0 {name=X_61127_ }
C {devices/lab_pin.sym} 76160 -30440 0 0 {name=p75453 lab=_69772_/A }
C {devices/lab_pin.sym} 76160 -30400 0 0 {name=p75454 lab=_69772_/B }
C {devices/lab_pin.sym} 76280 -30420 0 1 {name=p75455 lab=_69772_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -30420 0 0 {name=X_69772_ }
C {devices/lab_pin.sym} 76180 -30290 0 0 {name=p75456 lab=clkbuf_8_81_0_CLK/X }
C {devices/lab_pin.sym} 76260 -30290 0 1 {name=p75457 lab=clkbuf_9_162_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 76220 -30290 0 0 {name=Xclkbuf_9_162_0_CLK }
C {devices/lab_pin.sym} 76180 -30170 0 0 {name=p75458 lab=_66628_/X }
C {devices/lab_pin.sym} 76260 -30170 0 1 {name=p75459 lab=_66984_/X }
C {sky130_stdcells/buf_2.sym} 76220 -30170 0 0 {name=X_66984_ }
C {devices/lab_pin.sym} 76160 -30060 0 0 {name=p75460 lab=_68938_/A }
C {devices/lab_pin.sym} 76160 -30020 0 0 {name=p75461 lab=_68723_/B }
C {devices/lab_pin.sym} 76280 -30040 0 1 {name=p75462 lab=_68723_/X }
C {sky130_stdcells/and2_4.sym} 76220 -30040 0 0 {name=X_68723_ }
C {devices/lab_pin.sym} 76160 -29920 0 0 {name=p75463 lab=_65934_/X }
C {devices/lab_pin.sym} 76160 -29880 0 0 {name=p75464 lab=_65935_/B }
C {devices/lab_pin.sym} 76280 -29900 0 1 {name=p75465 lab=_65935_/X }
C {sky130_stdcells/and2_4.sym} 76220 -29900 0 0 {name=X_65935_ }
C {devices/lab_pin.sym} 76140 -29810 0 0 {name=p75466 lab=_60950_/Y }
C {devices/lab_pin.sym} 76140 -29770 0 0 {name=p75467 lab=_60963_/X }
C {devices/lab_pin.sym} 76140 -29730 0 0 {name=p75468 lab=_60935_/X }
C {devices/lab_pin.sym} 76140 -29690 0 0 {name=p75469 lab=_61025_/X }
C {devices/lab_pin.sym} 76140 -29650 0 0 {name=p75470 lab=_61057_/X }
C {devices/lab_pin.sym} 76300 -29730 0 1 {name=p75471 lab=_61058_/X }
C {sky130_stdcells/o41a_4.sym} 76220 -29730 0 0 {name=X_61058_ }
C {devices/lab_pin.sym} 76130 -29570 0 0 {name=p75472 lab=_83906_/CLK }
C {devices/lab_pin.sym} 76130 -29550 0 0 {name=p75473 lab=_81981_/D }
C {devices/lab_pin.sym} 76310 -29570 0 1 {name=p75474 lab=_81981_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -29560 0 0 {name=X_81981_ }
C {devices/lab_pin.sym} 76160 -29460 0 0 {name=p75475 lab=_52895_/A }
C {devices/lab_pin.sym} 76160 -29420 0 0 {name=p75476 lab=_52879_/B }
C {devices/lab_pin.sym} 76160 -29380 0 0 {name=p75477 lab=_52900_/C }
C {devices/lab_pin.sym} 76160 -29340 0 0 {name=p75478 lab=_52900_/D }
C {devices/lab_pin.sym} 76280 -29400 0 1 {name=p75479 lab=_52900_/X }
C {sky130_stdcells/and4_4.sym} 76220 -29400 0 0 {name=X_52900_ }
C {devices/lab_pin.sym} 76160 -29260 0 0 {name=p75480 lab=_59938_/Y }
C {devices/lab_pin.sym} 76160 -29220 0 0 {name=p75481 lab=_60079_/B }
C {devices/lab_pin.sym} 76280 -29240 0 1 {name=p75482 lab=_60009_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -29240 0 0 {name=X_60009_ }
C {devices/lab_pin.sym} 76130 -29110 0 0 {name=p75483 lab=_85439_/CLK }
C {devices/lab_pin.sym} 76130 -29090 0 0 {name=p75484 lab=_70711_/Y }
C {devices/lab_pin.sym} 76310 -29110 0 1 {name=p75485 lab=_46928_/A }
C {sky130_stdcells/dfxtp_4.sym} 76220 -29100 0 0 {name=X_83720_ }
C {devices/lab_pin.sym} 76180 -28970 0 0 {name=p75486 lab=clkbuf_9_343_0_CLK/X }
C {devices/lab_pin.sym} 76260 -28970 0 1 {name=p75487 lab=_87708_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 76220 -28970 0 0 {name=Xclkbuf_10_686_0_CLK }
C {devices/lab_pin.sym} 76160 -28860 0 0 {name=p75488 lab=_68604_/A }
C {devices/lab_pin.sym} 76160 -28820 0 0 {name=p75489 lab=_87240_/Q }
C {devices/lab_pin.sym} 76280 -28840 0 1 {name=p75490 lab=_68654_/X }
C {sky130_stdcells/and2_4.sym} 76220 -28840 0 0 {name=X_68654_ }
C {devices/lab_pin.sym} 76130 -28710 0 0 {name=p75491 lab=_81933_/CLK }
C {devices/lab_pin.sym} 76130 -28690 0 0 {name=p75492 lab=_80932_/D }
C {devices/lab_pin.sym} 76310 -28710 0 1 {name=p75493 lab=_80932_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -28700 0 0 {name=X_80932_ }
C {devices/lab_pin.sym} 76140 -28590 0 0 {name=p75494 lab=_53878_/Y }
C {devices/lab_pin.sym} 76140 -28550 0 0 {name=p75495 lab=_53862_/X }
C {devices/lab_pin.sym} 76140 -28510 0 0 {name=p75496 lab=_53879_/Y }
C {devices/lab_pin.sym} 76300 -28550 0 1 {name=p75497 lab=_85550_/D }
C {sky130_stdcells/a21boi_4.sym} 76220 -28550 0 0 {name=X_53880_ }
C {devices/lab_pin.sym} 76160 -28420 0 0 {name=p75498 lab=_65812_/A }
C {devices/lab_pin.sym} 76160 -28380 0 0 {name=p75499 lab=_86500_/Q }
C {devices/lab_pin.sym} 76280 -28400 0 1 {name=p75500 lab=_65866_/X }
C {sky130_stdcells/and2_4.sym} 76220 -28400 0 0 {name=X_65866_ }
C {devices/lab_pin.sym} 76160 -28280 0 0 {name=p75501 lab=_67582_/A }
C {devices/lab_pin.sym} 76160 -28240 0 0 {name=p75502 lab=_67605_/B }
C {devices/lab_pin.sym} 76280 -28260 0 1 {name=p75503 lab=_67605_/X }
C {sky130_stdcells/and2_4.sym} 76220 -28260 0 0 {name=X_67605_ }
C {devices/lab_pin.sym} 76160 -28160 0 0 {name=p75504 lab=_52818_/A }
C {devices/lab_pin.sym} 76160 -28120 0 0 {name=p75505 lab=_52831_/B }
C {devices/lab_pin.sym} 76160 -28080 0 0 {name=p75506 lab=_52818_/C }
C {devices/lab_pin.sym} 76160 -28040 0 0 {name=p75507 lab=_52831_/D }
C {devices/lab_pin.sym} 76280 -28100 0 1 {name=p75508 lab=_52831_/X }
C {sky130_stdcells/and4_4.sym} 76220 -28100 0 0 {name=X_52831_ }
C {devices/lab_pin.sym} 76180 -27950 0 0 {name=p75509 lab=_64817_/A }
C {devices/lab_pin.sym} 76260 -27950 0 1 {name=p75510 lab=_64817_/X }
C {sky130_stdcells/buf_2.sym} 76220 -27950 0 0 {name=X_64817_ }
C {devices/lab_pin.sym} 76130 -27830 0 0 {name=p75511 lab=_85822_/CLK }
C {devices/lab_pin.sym} 76130 -27810 0 0 {name=p75512 lab=_70955_/Y }
C {devices/lab_pin.sym} 76310 -27830 0 1 {name=p75513 lab=_83651_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -27820 0 0 {name=X_83651_ }
C {devices/lab_pin.sym} 76180 -27690 0 0 {name=p75514 lab=clkbuf_8_88_0_CLK/X }
C {devices/lab_pin.sym} 76260 -27690 0 1 {name=p75515 lab=clkbuf_9_177_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 76220 -27690 0 0 {name=Xclkbuf_9_177_0_CLK }
C {devices/lab_pin.sym} 76130 -27570 0 0 {name=p75516 lab=_83967_/CLK }
C {devices/lab_pin.sym} 76130 -27550 0 0 {name=p75517 lab=_80895_/Q }
C {devices/lab_pin.sym} 76310 -27570 0 1 {name=p75518 lab=_75062_/B }
C {sky130_stdcells/dfxtp_4.sym} 76220 -27560 0 0 {name=X_80863_ }
C {devices/lab_pin.sym} 76140 -27450 0 0 {name=p75519 lab=_80825_/D }
C {devices/lab_pin.sym} 76140 -27410 0 0 {name=p75520 lab=_68462_/X }
C {devices/lab_pin.sym} 76140 -27370 0 0 {name=p75521 lab=_68584_/X }
C {devices/lab_pin.sym} 76300 -27410 0 1 {name=p75522 lab=_68585_/X }
C {sky130_stdcells/a21bo_4.sym} 76220 -27410 0 0 {name=X_68585_ }
C {devices/lab_pin.sym} 76160 -27280 0 0 {name=p75523 lab=_65812_/A }
C {devices/lab_pin.sym} 76160 -27240 0 0 {name=p75524 lab=_86505_/Q }
C {devices/lab_pin.sym} 76280 -27260 0 1 {name=p75525 lab=_65797_/X }
C {sky130_stdcells/and2_4.sym} 76220 -27260 0 0 {name=X_65797_ }
C {devices/lab_pin.sym} 76130 -27130 0 0 {name=p75526 lab=_82570_/CLK }
C {devices/lab_pin.sym} 76130 -27110 0 0 {name=p75527 lab=_78882_/B }
C {devices/lab_pin.sym} 76310 -27130 0 1 {name=p75528 lab=_82602_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -27120 0 0 {name=X_82602_ }
C {devices/lab_pin.sym} 76140 -27020 0 0 {name=p75529 lab=_45526_/A }
C {devices/lab_pin.sym} 76140 -26980 0 0 {name=p75530 lab=_55505_/X }
C {devices/lab_pin.sym} 76140 -26940 0 0 {name=p75531 lab=_55532_/X }
C {devices/lab_pin.sym} 76140 -26900 0 0 {name=p75532 lab=_55549_/X }
C {devices/lab_pin.sym} 76300 -26960 0 1 {name=p75533 lab=_55550_/X }
C {sky130_stdcells/a211o_4.sym} 76220 -26960 0 0 {name=X_55550_ }
C {devices/lab_pin.sym} 76160 -26820 0 0 {name=p75534 lab=_67513_/A }
C {devices/lab_pin.sym} 76160 -26780 0 0 {name=p75535 lab=_67536_/B }
C {devices/lab_pin.sym} 76280 -26800 0 1 {name=p75536 lab=_67536_/X }
C {sky130_stdcells/and2_4.sym} 76220 -26800 0 0 {name=X_67536_ }
C {devices/lab_pin.sym} 76130 -26670 0 0 {name=p75537 lab=_83660_/CLK }
C {devices/lab_pin.sym} 76130 -26650 0 0 {name=p75538 lab=_86370_/D }
C {devices/lab_pin.sym} 76310 -26670 0 1 {name=p75539 lab=_58957_/B }
C {sky130_stdcells/dfxtp_4.sym} 76220 -26660 0 0 {name=X_86370_ }
C {devices/lab_pin.sym} 76180 -26530 0 0 {name=p75540 lab=_52708_/A }
C {devices/lab_pin.sym} 76260 -26530 0 1 {name=p75541 lab=_52775_/C }
C {sky130_stdcells/buf_2.sym} 76220 -26530 0 0 {name=X_52762_ }
C {devices/lab_pin.sym} 76180 -26410 0 0 {name=p75542 lab=_64602_/A }
C {devices/lab_pin.sym} 76260 -26410 0 1 {name=p75543 lab=_64810_/A }
C {sky130_stdcells/buf_2.sym} 76220 -26410 0 0 {name=X_64748_ }
C {devices/lab_pin.sym} 76130 -26290 0 0 {name=p75544 lab=_86516_/CLK }
C {devices/lab_pin.sym} 76130 -26270 0 0 {name=p75545 lab=_71176_/Y }
C {devices/lab_pin.sym} 76310 -26290 0 1 {name=p75546 lab=_83582_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -26280 0 0 {name=X_83582_ }
C {devices/lab_pin.sym} 76130 -26150 0 0 {name=p75547 lab=_80821_/CLK }
C {devices/lab_pin.sym} 76130 -26130 0 0 {name=p75548 lab=_75786_/X }
C {devices/lab_pin.sym} 76310 -26150 0 1 {name=p75549 lab=_80794_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -26140 0 0 {name=X_80794_ }
C {devices/lab_pin.sym} 76140 -26030 0 0 {name=p75550 lab=_85430_/Q }
C {devices/lab_pin.sym} 76140 -25990 0 0 {name=p75551 lab=_54485_/X }
C {devices/lab_pin.sym} 76140 -25950 0 0 {name=p75552 lab=_54500_/Y }
C {devices/lab_pin.sym} 76300 -25990 0 1 {name=p75553 lab=_54501_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -25990 0 0 {name=X_54501_ }
C {devices/lab_pin.sym} 76130 -25850 0 0 {name=p75554 lab=_85351_/CLK }
C {devices/lab_pin.sym} 76130 -25830 0 0 {name=p75555 lab=_85321_/D }
C {devices/lab_pin.sym} 76310 -25850 0 1 {name=p75556 lab=_85321_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -25840 0 0 {name=X_85321_ }
C {devices/lab_pin.sym} 76140 -25730 0 0 {name=p75557 lab=_85959_/Q }
C {devices/lab_pin.sym} 76140 -25690 0 0 {name=p75558 lab=_51701_/X }
C {devices/lab_pin.sym} 76140 -25650 0 0 {name=p75559 lab=_51712_/Y }
C {devices/lab_pin.sym} 76300 -25690 0 1 {name=p75560 lab=_51713_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -25690 0 0 {name=X_51713_ }
C {devices/lab_pin.sym} 76130 -25550 0 0 {name=p75561 lab=_82532_/CLK }
C {devices/lab_pin.sym} 76130 -25530 0 0 {name=p75562 lab=_83853_/Q }
C {devices/lab_pin.sym} 76310 -25550 0 1 {name=p75563 lab=_82533_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -25540 0 0 {name=X_82533_ }
C {devices/lab_pin.sym} 76160 -25420 0 0 {name=p75564 lab=_55470_/A }
C {devices/lab_pin.sym} 76160 -25380 0 0 {name=p75565 lab=_55481_/B }
C {devices/lab_pin.sym} 76280 -25400 0 1 {name=p75566 lab=_55481_/Y }
C {sky130_stdcells/nor2_4.sym} 76220 -25400 0 0 {name=X_55481_ }
C {devices/lab_pin.sym} 76180 -25270 0 0 {name=p75567 lab=_67466_/X }
C {devices/lab_pin.sym} 76260 -25270 0 1 {name=p75568 lab=_67467_/X }
C {sky130_stdcells/buf_2.sym} 76220 -25270 0 0 {name=X_67467_ }
C {devices/lab_pin.sym} 76140 -25170 0 0 {name=p75569 lab=_85772_/Q }
C {devices/lab_pin.sym} 76140 -25130 0 0 {name=p75570 lab=_52684_/X }
C {devices/lab_pin.sym} 76140 -25090 0 0 {name=p75571 lab=_52692_/Y }
C {devices/lab_pin.sym} 76300 -25130 0 1 {name=p75572 lab=_52693_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -25130 0 0 {name=X_52693_ }
C {devices/lab_pin.sym} 76180 -24990 0 0 {name=p75573 lab=_64679_/A }
C {devices/lab_pin.sym} 76260 -24990 0 1 {name=p75574 lab=_64679_/X }
C {sky130_stdcells/buf_2.sym} 76220 -24990 0 0 {name=X_64679_ }
C {devices/lab_pin.sym} 76180 -24870 0 0 {name=p75575 lab=clkbuf_8_50_0_CLK/X }
C {devices/lab_pin.sym} 76260 -24870 0 1 {name=p75576 lab=clkbuf_9_100_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 76220 -24870 0 0 {name=Xclkbuf_9_100_0_CLK }
C {devices/lab_pin.sym} 76140 -24770 0 0 {name=p75577 lab=_56645_/Y }
C {devices/lab_pin.sym} 76140 -24730 0 0 {name=p75578 lab=_56878_/Y }
C {devices/lab_pin.sym} 76140 -24690 0 0 {name=p75579 lab=_57221_/A }
C {devices/lab_pin.sym} 76300 -24730 0 1 {name=p75580 lab=_57220_/Y }
C {sky130_stdcells/a21oi_4.sym} 76220 -24730 0 0 {name=X_57220_ }
C {devices/lab_pin.sym} 76160 -24600 0 0 {name=p75581 lab=_69755_/A }
C {devices/lab_pin.sym} 76160 -24560 0 0 {name=p75582 lab=_69206_/B }
C {devices/lab_pin.sym} 76280 -24580 0 1 {name=p75583 lab=_69206_/X }
C {sky130_stdcells/and2_4.sym} 76220 -24580 0 0 {name=X_69206_ }
C {devices/lab_pin.sym} 76130 -24450 0 0 {name=p75584 lab=_88044_/CLK }
C {devices/lab_pin.sym} 76130 -24430 0 0 {name=p75585 lab=_88040_/D }
C {devices/lab_pin.sym} 76310 -24450 0 1 {name=p75586 lab=_88040_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -24440 0 0 {name=X_88040_ }
C {devices/lab_pin.sym} 76180 -24310 0 0 {name=p75587 lab=_54322_/A }
C {devices/lab_pin.sym} 76260 -24310 0 1 {name=p75588 lab=_54446_/A }
C {sky130_stdcells/buf_2.sym} 76220 -24310 0 0 {name=X_54432_ }
C {devices/lab_pin.sym} 76140 -24210 0 0 {name=p75589 lab=_66411_/X }
C {devices/lab_pin.sym} 76140 -24170 0 0 {name=p75590 lab=_66061_/Y }
C {devices/lab_pin.sym} 76140 -24130 0 0 {name=p75591 lab=_66417_/Y }
C {devices/lab_pin.sym} 76300 -24170 0 1 {name=p75592 lab=_66418_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -24170 0 0 {name=X_66418_ }
C {devices/lab_pin.sym} 76130 -24030 0 0 {name=p75593 lab=_85156_/CLK }
C {devices/lab_pin.sym} 76130 -24010 0 0 {name=p75594 lab=_56268_/Y }
C {devices/lab_pin.sym} 76310 -24030 0 1 {name=p75595 lab=_56267_/C }
C {sky130_stdcells/dfxtp_4.sym} 76220 -24020 0 0 {name=X_85252_ }
C {devices/lab_pin.sym} 76140 -23910 0 0 {name=p75596 lab=_85972_/Q }
C {devices/lab_pin.sym} 76140 -23870 0 0 {name=p75597 lab=_51621_/X }
C {devices/lab_pin.sym} 76140 -23830 0 0 {name=p75598 lab=_51643_/Y }
C {devices/lab_pin.sym} 76300 -23870 0 1 {name=p75599 lab=_51644_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -23870 0 0 {name=X_51644_ }
C {devices/lab_pin.sym} 76130 -23730 0 0 {name=p75600 lab=_82820_/CLK }
C {devices/lab_pin.sym} 76130 -23710 0 0 {name=p75601 lab=_79156_/X }
C {devices/lab_pin.sym} 76310 -23730 0 1 {name=p75602 lab=_82464_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -23720 0 0 {name=X_82464_ }
C {devices/lab_pin.sym} 76180 -23590 0 0 {name=p75603 lab=_67039_/X }
C {devices/lab_pin.sym} 76260 -23590 0 1 {name=p75604 lab=_67398_/X }
C {sky130_stdcells/buf_2.sym} 76220 -23590 0 0 {name=X_67398_ }
C {devices/lab_pin.sym} 76130 -23470 0 0 {name=p75605 lab=_84194_/CLK }
C {devices/lab_pin.sym} 76130 -23450 0 0 {name=p75606 lab=_84203_/D }
C {devices/lab_pin.sym} 76310 -23470 0 1 {name=p75607 lab=_84203_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -23460 0 0 {name=X_84203_ }
C {devices/lab_pin.sym} 76140 -23350 0 0 {name=p75608 lab=_56727_/X }
C {devices/lab_pin.sym} 76140 -23310 0 0 {name=p75609 lab=_57133_/X }
C {devices/lab_pin.sym} 76140 -23270 0 0 {name=p75610 lab=_57150_/Y }
C {devices/lab_pin.sym} 76300 -23310 0 1 {name=p75611 lab=_57151_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -23310 0 0 {name=X_57151_ }
C {devices/lab_pin.sym} 76130 -23170 0 0 {name=p75612 lab=_81575_/CLK }
C {devices/lab_pin.sym} 76130 -23150 0 0 {name=p75613 lab=_81447_/Q }
C {devices/lab_pin.sym} 76310 -23170 0 1 {name=p75614 lab=_75957_/B }
C {sky130_stdcells/dfxtp_4.sym} 76220 -23160 0 0 {name=X_81415_ }
C {devices/lab_pin.sym} 76140 -23060 0 0 {name=p75615 lab=_87539_/Q }
C {devices/lab_pin.sym} 76140 -23020 0 0 {name=p75616 lab=_69098_/X }
C {devices/lab_pin.sym} 76140 -22980 0 0 {name=p75617 lab=_69124_/X }
C {devices/lab_pin.sym} 76140 -22940 0 0 {name=p75618 lab=_69136_/X }
C {devices/lab_pin.sym} 76300 -23000 0 1 {name=p75619 lab=_69137_/X }
C {sky130_stdcells/a211o_4.sym} 76220 -23000 0 0 {name=X_69137_ }
C {devices/lab_pin.sym} 76140 -22870 0 0 {name=p75620 lab=_54361_/Y }
C {devices/lab_pin.sym} 76140 -22830 0 0 {name=p75621 lab=_54338_/X }
C {devices/lab_pin.sym} 76140 -22790 0 0 {name=p75622 lab=_54362_/X }
C {devices/lab_pin.sym} 76300 -22830 0 1 {name=p75623 lab=_85456_/D }
C {sky130_stdcells/a21oi_4.sym} 76220 -22830 0 0 {name=X_54363_ }
C {devices/lab_pin.sym} 76180 -22690 0 0 {name=p75624 lab=clkbuf_9_312_0_CLK/X }
C {devices/lab_pin.sym} 76260 -22690 0 1 {name=p75625 lab=_83967_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 76220 -22690 0 0 {name=Xclkbuf_10_624_0_CLK }
C {devices/lab_pin.sym} 76180 -22570 0 0 {name=p75626 lab=_65976_/A }
C {devices/lab_pin.sym} 76260 -22570 0 1 {name=p75627 lab=_66349_/X }
C {sky130_stdcells/buf_2.sym} 76220 -22570 0 0 {name=X_66349_ }
C {devices/lab_pin.sym} 76130 -22450 0 0 {name=p75628 lab=_85184_/CLK }
C {devices/lab_pin.sym} 76130 -22430 0 0 {name=p75629 lab=_56473_/Y }
C {devices/lab_pin.sym} 76310 -22450 0 1 {name=p75630 lab=_85183_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -22440 0 0 {name=X_85183_ }
C {devices/lab_pin.sym} 76160 -22340 0 0 {name=p75631 lab=_51580_/A }
C {devices/lab_pin.sym} 76160 -22300 0 0 {name=p75632 lab=_51580_/B }
C {devices/lab_pin.sym} 76160 -22260 0 0 {name=p75633 lab=_51553_/C }
C {devices/lab_pin.sym} 76160 -22220 0 0 {name=p75634 lab=_53103_/D }
C {devices/lab_pin.sym} 76280 -22280 0 1 {name=p75635 lab=_51575_/X }
C {sky130_stdcells/and4_4.sym} 76220 -22280 0 0 {name=X_51575_ }
C {devices/lab_pin.sym} 76130 -22130 0 0 {name=p75636 lab=_82965_/CLK }
C {devices/lab_pin.sym} 76130 -22110 0 0 {name=p75637 lab=_82395_/D }
C {devices/lab_pin.sym} 76310 -22130 0 1 {name=p75638 lab=_82395_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -22120 0 0 {name=X_82395_ }
C {devices/lab_pin.sym} 76160 -22000 0 0 {name=p75639 lab=_55994_/X }
C {devices/lab_pin.sym} 76160 -21960 0 0 {name=p75640 lab=_56102_/B }
C {devices/lab_pin.sym} 76280 -21980 0 1 {name=p75641 lab=_56102_/X }
C {sky130_stdcells/xor2_4.sym} 76220 -21980 0 0 {name=X_56102_ }
C {devices/lab_pin.sym} 76160 -21860 0 0 {name=p75642 lab=_53298_/A }
C {devices/lab_pin.sym} 76160 -21820 0 0 {name=p75643 lab=_47006_/Y }
C {devices/lab_pin.sym} 76280 -21840 0 1 {name=p75644 lab=_53314_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -21840 0 0 {name=X_53314_ }
C {devices/lab_pin.sym} 76130 -21710 0 0 {name=p75645 lab=_84166_/CLK }
C {devices/lab_pin.sym} 76130 -21690 0 0 {name=p75646 lab=_84134_/D }
C {devices/lab_pin.sym} 76310 -21710 0 1 {name=p75647 lab=_84134_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -21700 0 0 {name=X_84134_ }
C {devices/lab_pin.sym} 76160 -21590 0 0 {name=p75648 lab=_48845_/A }
C {devices/lab_pin.sym} 76160 -21550 0 0 {name=p75649 lab=_50526_/B }
C {devices/lab_pin.sym} 76160 -21510 0 0 {name=p75650 lab=_50526_/C }
C {devices/lab_pin.sym} 76280 -21550 0 1 {name=p75651 lab=_50526_/X }
C {sky130_stdcells/and3_4.sym} 76220 -21550 0 0 {name=X_50526_ }
C {devices/lab_pin.sym} 76140 -21440 0 0 {name=p75652 lab=_85091_/Q }
C {devices/lab_pin.sym} 76140 -21400 0 0 {name=p75653 lab=_57084_/A }
C {devices/lab_pin.sym} 76140 -21360 0 0 {name=p75654 lab=_57080_/X }
C {devices/lab_pin.sym} 76140 -21320 0 0 {name=p75655 lab=_57081_/Y }
C {devices/lab_pin.sym} 76300 -21380 0 1 {name=p75656 lab=_85091_/D }
C {sky130_stdcells/a211o_4.sym} 76220 -21380 0 0 {name=X_57082_ }
C {devices/lab_pin.sym} 76130 -21230 0 0 {name=p75657 lab=_81346_/CLK }
C {devices/lab_pin.sym} 76130 -21210 0 0 {name=p75658 lab=_76965_/Y }
C {devices/lab_pin.sym} 76310 -21230 0 1 {name=p75659 lab=_81346_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -21220 0 0 {name=X_81346_ }
C {devices/lab_pin.sym} 76140 -21120 0 0 {name=p75660 lab=_43103_/A }
C {devices/lab_pin.sym} 76140 -21080 0 0 {name=p75661 lab=_68883_/X }
C {devices/lab_pin.sym} 76140 -21040 0 0 {name=p75662 lab=_68741_/X }
C {devices/lab_pin.sym} 76140 -21000 0 0 {name=p75663 lab=_69067_/X }
C {devices/lab_pin.sym} 76300 -21060 0 1 {name=p75664 lab=_69068_/X }
C {sky130_stdcells/a211o_4.sym} 76220 -21060 0 0 {name=X_69068_ }
C {devices/lab_pin.sym} 76180 -20910 0 0 {name=p75665 lab=_54320_/A }
C {devices/lab_pin.sym} 76260 -20910 0 1 {name=p75666 lab=_54294_/X }
C {sky130_stdcells/buf_2.sym} 76220 -20910 0 0 {name=X_54294_ }
C {devices/lab_pin.sym} 76180 -20790 0 0 {name=p75667 lab=clkbuf_8_57_0_CLK/X }
C {devices/lab_pin.sym} 76260 -20790 0 1 {name=p75668 lab=clkbuf_9_115_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 76220 -20790 0 0 {name=Xclkbuf_9_115_0_CLK }
C {devices/lab_pin.sym} 76180 -20670 0 0 {name=p75669 lab=clkbuf_9_43_0_CLK/A }
C {devices/lab_pin.sym} 76260 -20670 0 1 {name=p75670 lab=clkbuf_9_42_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 76220 -20670 0 0 {name=Xclkbuf_9_42_0_CLK }
C {devices/lab_pin.sym} 76140 -20570 0 0 {name=p75671 lab=_56029_/X }
C {devices/lab_pin.sym} 76140 -20530 0 0 {name=p75672 lab=_56031_/X }
C {devices/lab_pin.sym} 76140 -20490 0 0 {name=p75673 lab=_56032_/Y }
C {devices/lab_pin.sym} 76300 -20530 0 1 {name=p75674 lab=_56033_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -20530 0 0 {name=X_56033_ }
C {devices/lab_pin.sym} 76140 -20420 0 0 {name=p75675 lab=_87894_/Q }
C {devices/lab_pin.sym} 76140 -20380 0 0 {name=p75676 lab=_67950_/X }
C {devices/lab_pin.sym} 76140 -20340 0 0 {name=p75677 lab=_67997_/X }
C {devices/lab_pin.sym} 76140 -20300 0 0 {name=p75678 lab=_68018_/X }
C {devices/lab_pin.sym} 76300 -20360 0 1 {name=p75679 lab=_68019_/X }
C {sky130_stdcells/a211o_4.sym} 76220 -20360 0 0 {name=X_68019_ }
C {devices/lab_pin.sym} 76140 -20230 0 0 {name=p75680 lab=_53241_/Y }
C {devices/lab_pin.sym} 76140 -20190 0 0 {name=p75681 lab=_53242_/X }
C {devices/lab_pin.sym} 76140 -20150 0 0 {name=p75682 lab=_53244_/X }
C {devices/lab_pin.sym} 76300 -20190 0 1 {name=p75683 lab=_53245_/Y }
C {sky130_stdcells/a21oi_4.sym} 76220 -20190 0 0 {name=X_53245_ }
C {devices/lab_pin.sym} 76130 -20050 0 0 {name=p75684 lab=_81749_/CLK }
C {devices/lab_pin.sym} 76130 -20030 0 0 {name=p75685 lab=_84065_/D }
C {devices/lab_pin.sym} 76310 -20050 0 1 {name=p75686 lab=_84065_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -20040 0 0 {name=X_84065_ }
C {devices/lab_pin.sym} 76140 -19930 0 0 {name=p75687 lab=_50454_/Y }
C {devices/lab_pin.sym} 76140 -19890 0 0 {name=p75688 lab=_50455_/X }
C {devices/lab_pin.sym} 76140 -19850 0 0 {name=p75689 lab=_50456_/X }
C {devices/lab_pin.sym} 76300 -19890 0 1 {name=p75690 lab=_50457_/Y }
C {sky130_stdcells/a21oi_4.sym} 76220 -19890 0 0 {name=X_50457_ }
C {devices/lab_pin.sym} 76130 -19750 0 0 {name=p75691 lab=_81627_/CLK }
C {devices/lab_pin.sym} 76130 -19730 0 0 {name=p75692 lab=_81277_/D }
C {devices/lab_pin.sym} 76310 -19750 0 1 {name=p75693 lab=_76552_/A }
C {sky130_stdcells/dfxtp_4.sym} 76220 -19740 0 0 {name=X_81277_ }
C {devices/lab_pin.sym} 76160 -19640 0 0 {name=p75694 lab=_71175_/A }
C {devices/lab_pin.sym} 76160 -19600 0 0 {name=p75695 lab=_71030_/B }
C {devices/lab_pin.sym} 76160 -19560 0 0 {name=p75696 lab=_71030_/C }
C {devices/lab_pin.sym} 76160 -19520 0 0 {name=p75697 lab=_71018_/D }
C {devices/lab_pin.sym} 76280 -19580 0 1 {name=p75698 lab=_71030_/Y }
C {sky130_stdcells/nand4_4.sym} 76220 -19580 0 0 {name=X_71030_ }
C {devices/lab_pin.sym} 76130 -19430 0 0 {name=p75699 lab=_83016_/CLK }
C {devices/lab_pin.sym} 76130 -19410 0 0 {name=p75700 lab=_83016_/D }
C {devices/lab_pin.sym} 76310 -19430 0 1 {name=p75701 lab=_45290_/A }
C {sky130_stdcells/dfxtp_4.sym} 76220 -19420 0 0 {name=X_83016_ }
C {devices/lab_pin.sym} 76180 -19290 0 0 {name=p75702 lab=clkbuf_9_319_0_CLK/X }
C {devices/lab_pin.sym} 76260 -19290 0 1 {name=p75703 lab=_82103_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 76220 -19290 0 0 {name=Xclkbuf_10_639_0_CLK }
C {devices/lab_pin.sym} 76160 -19180 0 0 {name=p75704 lab=_80228_/A }
C {devices/lab_pin.sym} 76160 -19140 0 0 {name=p75705 lab=_80227_/Y }
C {devices/lab_pin.sym} 76280 -19160 0 1 {name=p75706 lab=_80228_/X }
C {sky130_stdcells/xor2_4.sym} 76220 -19160 0 0 {name=X_80228_ }
C {devices/lab_pin.sym} 76180 -19030 0 0 {name=p75707 lab=clkbuf_2_0_2_CLK/X }
C {devices/lab_pin.sym} 76260 -19030 0 1 {name=p75708 lab=clkbuf_3_0_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 76220 -19030 0 0 {name=Xclkbuf_3_0_0_CLK }
C {devices/lab_pin.sym} 76140 -18940 0 0 {name=p75709 lab=_41189_/X }
C {devices/lab_pin.sym} 76140 -18900 0 0 {name=p75710 lab=_41181_/X }
C {devices/lab_pin.sym} 76140 -18860 0 0 {name=p75711 lab=_68723_/B }
C {devices/lab_pin.sym} 76140 -18820 0 0 {name=p75712 lab=_41182_/X }
C {devices/lab_pin.sym} 76300 -18880 0 1 {name=p75713 lab=_88261_/D }
C {sky130_stdcells/a2bb2o_4.sym} 76220 -18880 0 0 {name=X_41190_ }
C {devices/lab_pin.sym} 76180 -18730 0 0 {name=p75714 lab=_53097_/X }
C {devices/lab_pin.sym} 76260 -18730 0 1 {name=p75715 lab=_53181_/B }
C {sky130_stdcells/buf_2.sym} 76220 -18730 0 0 {name=X_53176_ }
C {devices/lab_pin.sym} 76180 -18610 0 0 {name=p75716 lab=_50500_/A }
C {devices/lab_pin.sym} 76260 -18610 0 1 {name=p75717 lab=_50481_/A }
C {sky130_stdcells/buf_2.sym} 76220 -18610 0 0 {name=X_50388_ }
C {devices/lab_pin.sym} 76180 -18490 0 0 {name=p75718 lab=_52215_/A }
C {devices/lab_pin.sym} 76260 -18490 0 1 {name=p75719 lab=_52127_/X }
C {sky130_stdcells/buf_2.sym} 76220 -18490 0 0 {name=X_52127_ }
C {devices/lab_pin.sym} 76130 -18370 0 0 {name=p75720 lab=_87824_/CLK }
C {devices/lab_pin.sym} 76130 -18350 0 0 {name=p75721 lab=_42551_/Y }
C {devices/lab_pin.sym} 76310 -18370 0 1 {name=p75722 lab=_42550_/A }
C {sky130_stdcells/dfxtp_4.sym} 76220 -18360 0 0 {name=X_87824_ }
C {devices/lab_pin.sym} 76160 -18240 0 0 {name=p75723 lab=_80145_/Y }
C {devices/lab_pin.sym} 76160 -18200 0 0 {name=p75724 lab=_80142_/X }
C {devices/lab_pin.sym} 76280 -18220 0 1 {name=p75725 lab=_80159_/X }
C {sky130_stdcells/and2_4.sym} 76220 -18220 0 0 {name=X_80159_ }
C {devices/lab_pin.sym} 76140 -18110 0 0 {name=p75726 lab=_57884_/X }
C {devices/lab_pin.sym} 76140 -18070 0 0 {name=p75727 lab=_85486_/Q }
C {devices/lab_pin.sym} 76140 -18030 0 0 {name=p75728 lab=_57923_/X }
C {devices/lab_pin.sym} 76300 -18070 0 1 {name=p75729 lab=_57984_/X }
C {sky130_stdcells/o21a_4.sym} 76220 -18070 0 0 {name=X_57984_ }
C {devices/lab_pin.sym} 76180 -17930 0 0 {name=p75730 lab=clkbuf_9_57_0_CLK/A }
C {devices/lab_pin.sym} 76260 -17930 0 1 {name=p75731 lab=clkbuf_9_57_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 76220 -17930 0 0 {name=Xclkbuf_9_57_0_CLK }
C {devices/lab_pin.sym} 76160 -17820 0 0 {name=p75732 lab=_59721_/X }
C {devices/lab_pin.sym} 76160 -17780 0 0 {name=p75733 lab=_59722_/X }
C {devices/lab_pin.sym} 76280 -17800 0 1 {name=p75734 lab=_59724_/A }
C {sky130_stdcells/and2_4.sym} 76220 -17800 0 0 {name=X_59723_ }
C {devices/lab_pin.sym} 76160 -17680 0 0 {name=p75735 lab=_52058_/A }
C {devices/lab_pin.sym} 76160 -17640 0 0 {name=p75736 lab=_50356_/B }
C {devices/lab_pin.sym} 76280 -17660 0 1 {name=p75737 lab=_52058_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -17660 0 0 {name=X_52058_ }
C {devices/lab_pin.sym} 76180 -17530 0 0 {name=p75738 lab=_56934_/X }
C {devices/lab_pin.sym} 76260 -17530 0 1 {name=p75739 lab=_56935_/X }
C {sky130_stdcells/buf_2.sym} 76220 -17530 0 0 {name=X_56935_ }
C {devices/lab_pin.sym} 76130 -17410 0 0 {name=p75740 lab=_87757_/CLK }
C {devices/lab_pin.sym} 76130 -17390 0 0 {name=p75741 lab=_87755_/D }
C {devices/lab_pin.sym} 76310 -17410 0 1 {name=p75742 lab=_87755_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -17400 0 0 {name=X_87755_ }
C {devices/lab_pin.sym} 76140 -17300 0 0 {name=p75743 lab=_43135_/Y }
C {devices/lab_pin.sym} 76140 -17260 0 0 {name=p75744 lab=_72978_/X }
C {devices/lab_pin.sym} 76140 -17220 0 0 {name=p75745 lab=_72979_/X }
C {devices/lab_pin.sym} 76140 -17180 0 0 {name=p75746 lab=_72980_/Y }
C {devices/lab_pin.sym} 76300 -17240 0 1 {name=p75747 lab=_72981_/X }
C {sky130_stdcells/a211o_4.sym} 76220 -17240 0 0 {name=X_72981_ }
C {devices/lab_pin.sym} 76130 -17090 0 0 {name=p75748 lab=_86535_/CLK }
C {devices/lab_pin.sym} 76130 -17070 0 0 {name=p75749 lab=_57624_/Y }
C {devices/lab_pin.sym} 76310 -17090 0 1 {name=p75750 lab=_84967_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -17080 0 0 {name=X_84967_ }
C {devices/lab_pin.sym} 76140 -16970 0 0 {name=p75751 lab=_86090_/Q }
C {devices/lab_pin.sym} 76140 -16930 0 0 {name=p75752 lab=_50992_/X }
C {devices/lab_pin.sym} 76140 -16890 0 0 {name=p75753 lab=_51008_/Y }
C {devices/lab_pin.sym} 76300 -16930 0 1 {name=p75754 lab=_51009_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -16930 0 0 {name=X_51009_ }
C {devices/lab_pin.sym} 76140 -16830 0 0 {name=p75755 lab=_43895_/X }
C {devices/lab_pin.sym} 76140 -16790 0 0 {name=p75756 lab=_43876_/X }
C {devices/lab_pin.sym} 76140 -16750 0 0 {name=p75757 lab=_41341_/X }
C {devices/lab_pin.sym} 76140 -16710 0 0 {name=p75758 lab=_87209_/Q }
C {devices/lab_pin.sym} 76140 -16670 0 0 {name=p75759 lab=_43897_/X }
C {devices/lab_pin.sym} 76300 -16750 0 1 {name=p75760 lab=_43901_/A }
C {sky130_stdcells/o32ai_4.sym} 76220 -16750 0 0 {name=X_43900_ }
C {devices/lab_pin.sym} 76160 -16620 0 0 {name=p75761 lab=_70620_/D }
C {devices/lab_pin.sym} 76160 -16580 0 0 {name=p75762 lab=_74720_/B }
C {devices/lab_pin.sym} 76160 -16540 0 0 {name=p75763 lab=_74720_/C }
C {devices/lab_pin.sym} 76160 -16500 0 0 {name=p75764 lab=_74804_/D }
C {devices/lab_pin.sym} 76280 -16560 0 1 {name=p75765 lab=_74720_/X }
C {sky130_stdcells/and4_4.sym} 76220 -16560 0 0 {name=X_74720_ }
C {devices/lab_pin.sym} 76130 -16410 0 0 {name=p75766 lab=_86384_/CLK }
C {devices/lab_pin.sym} 76130 -16390 0 0 {name=p75767 lab=_86706_/D }
C {devices/lab_pin.sym} 76310 -16410 0 1 {name=p75768 lab=_86706_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -16400 0 0 {name=X_86706_ }
C {devices/lab_pin.sym} 76180 -16270 0 0 {name=p75769 lab=_71894_/Y }
C {devices/lab_pin.sym} 76260 -16270 0 1 {name=p75770 lab=_71945_/D }
C {sky130_stdcells/buf_2.sym} 76220 -16270 0 0 {name=X_71932_ }
C {devices/lab_pin.sym} 76130 -16150 0 0 {name=p75771 lab=_83918_/CLK }
C {devices/lab_pin.sym} 76130 -16130 0 0 {name=p75772 lab=_83918_/D }
C {devices/lab_pin.sym} 76310 -16150 0 1 {name=p75773 lab=_81382_/D }
C {sky130_stdcells/dfxtp_4.sym} 76220 -16140 0 0 {name=X_83918_ }
C {devices/lab_pin.sym} 76180 -16010 0 0 {name=p75774 lab=_66064_/A }
C {devices/lab_pin.sym} 76260 -16010 0 1 {name=p75775 lab=_59654_/X }
C {sky130_stdcells/buf_2.sym} 76220 -16010 0 0 {name=X_59654_ }
C {devices/lab_pin.sym} 76180 -15890 0 0 {name=p75776 lab=_45827_/B }
C {devices/lab_pin.sym} 76260 -15890 0 1 {name=p75777 lab=_44880_/X }
C {sky130_stdcells/buf_2.sym} 76220 -15890 0 0 {name=X_44880_ }
C {devices/lab_pin.sym} 76160 -15790 0 0 {name=p75778 lab=_56866_/A }
C {devices/lab_pin.sym} 76160 -15750 0 0 {name=p75779 lab=_83334_/Q }
C {devices/lab_pin.sym} 76160 -15710 0 0 {name=p75780 lab=_56859_/X }
C {devices/lab_pin.sym} 76280 -15750 0 1 {name=p75781 lab=_56884_/B }
C {sky130_stdcells/nand3_4.sym} 76220 -15750 0 0 {name=X_56866_ }
C {devices/lab_pin.sym} 76130 -15610 0 0 {name=p75782 lab=_87686_/CLK }
C {devices/lab_pin.sym} 76130 -15590 0 0 {name=p75783 lab=_87686_/D }
C {devices/lab_pin.sym} 76310 -15610 0 1 {name=p75784 lab=_66876_/B }
C {sky130_stdcells/dfxtp_4.sym} 76220 -15600 0 0 {name=X_87686_ }
C {devices/lab_pin.sym} 76130 -15470 0 0 {name=p75785 lab=_84732_/CLK }
C {devices/lab_pin.sym} 76130 -15450 0 0 {name=p75786 lab=_84898_/D }
C {devices/lab_pin.sym} 76310 -15470 0 1 {name=p75787 lab=_84898_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -15460 0 0 {name=X_84898_ }
C {devices/lab_pin.sym} 76180 -15330 0 0 {name=p75788 lab=_58605_/A }
C {devices/lab_pin.sym} 76260 -15330 0 1 {name=p75789 lab=_58605_/X }
C {sky130_stdcells/buf_2.sym} 76220 -15330 0 0 {name=X_58605_ }
C {devices/lab_pin.sym} 76140 -15240 0 0 {name=p75790 lab=_41147_/X }
C {devices/lab_pin.sym} 76140 -15200 0 0 {name=p75791 lab=_43817_/X }
C {devices/lab_pin.sym} 76140 -15160 0 0 {name=p75792 lab=_68530_/B }
C {devices/lab_pin.sym} 76140 -15120 0 0 {name=p75793 lab=_43818_/X }
C {devices/lab_pin.sym} 76300 -15180 0 1 {name=p75794 lab=_87245_/D }
C {sky130_stdcells/a2bb2o_4.sym} 76220 -15180 0 0 {name=X_43831_ }
C {devices/lab_pin.sym} 76160 -15040 0 0 {name=p75795 lab=_55817_/A }
C {devices/lab_pin.sym} 76160 -15000 0 0 {name=p75796 lab=_55817_/B }
C {devices/lab_pin.sym} 76280 -15020 0 1 {name=p75797 lab=_55817_/X }
C {sky130_stdcells/and2_4.sym} 76220 -15020 0 0 {name=X_55817_ }
C {devices/lab_pin.sym} 76140 -14910 0 0 {name=p75798 lab=_56626_/A }
C {devices/lab_pin.sym} 76140 -14870 0 0 {name=p75799 lab=_74641_/X }
C {devices/lab_pin.sym} 76140 -14830 0 0 {name=p75800 lab=_74650_/Y }
C {devices/lab_pin.sym} 76300 -14870 0 1 {name=p75801 lab=_82999_/D }
C {sky130_stdcells/a21boi_4.sym} 76220 -14870 0 0 {name=X_74651_ }
C {devices/lab_pin.sym} 76130 -14730 0 0 {name=p75802 lab=_86637_/CLK }
C {devices/lab_pin.sym} 76130 -14710 0 0 {name=p75803 lab=_86637_/D }
C {devices/lab_pin.sym} 76310 -14730 0 1 {name=p75804 lab=_86637_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -14720 0 0 {name=X_86637_ }
C {devices/lab_pin.sym} 76160 -14620 0 0 {name=p75805 lab=_71863_/A }
C {devices/lab_pin.sym} 76160 -14580 0 0 {name=p75806 lab=_71867_/B }
C {devices/lab_pin.sym} 76160 -14540 0 0 {name=p75807 lab=_70884_/B }
C {devices/lab_pin.sym} 76160 -14500 0 0 {name=p75808 lab=_71711_/A }
C {devices/lab_pin.sym} 76280 -14560 0 1 {name=p75809 lab=_71863_/Y }
C {sky130_stdcells/nor4_4.sym} 76220 -14560 0 0 {name=X_71863_ }
C {devices/lab_pin.sym} 76180 -14410 0 0 {name=p75810 lab=_59585_/A }
C {devices/lab_pin.sym} 76260 -14410 0 1 {name=p75811 lab=_59775_/A }
C {sky130_stdcells/inv_2.sym} 76220 -14410 0 0 {name=X_59585_ }
C {devices/lab_pin.sym} 76130 -14290 0 0 {name=p75812 lab=_83842_/CLK }
C {devices/lab_pin.sym} 76130 -14270 0 0 {name=p75813 lab=_83849_/D }
C {devices/lab_pin.sym} 76310 -14290 0 1 {name=p75814 lab=_83849_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -14280 0 0 {name=X_83849_ }
C {devices/lab_pin.sym} 76160 -14160 0 0 {name=p75815 lab=_56797_/A }
C {devices/lab_pin.sym} 76160 -14120 0 0 {name=p75816 lab=_56796_/Y }
C {devices/lab_pin.sym} 76280 -14140 0 1 {name=p75817 lab=_56798_/A }
C {sky130_stdcells/nand2_4.sym} 76220 -14140 0 0 {name=X_56797_ }
C {devices/lab_pin.sym} 76180 -14010 0 0 {name=p75818 lab=_72861_/X }
C {devices/lab_pin.sym} 76260 -14010 0 1 {name=p75819 lab=_73602_/X }
C {sky130_stdcells/buf_2.sym} 76220 -14010 0 0 {name=X_73602_ }
C {devices/lab_pin.sym} 76160 -13910 0 0 {name=p75820 lab=_70810_/A }
C {devices/lab_pin.sym} 76160 -13870 0 0 {name=p75821 lab=_70947_/B }
C {devices/lab_pin.sym} 76160 -13830 0 0 {name=p75822 lab=_70810_/C }
C {devices/lab_pin.sym} 76280 -13870 0 1 {name=p75823 lab=_70814_/Y }
C {sky130_stdcells/nand3_4.sym} 76220 -13870 0 0 {name=X_70814_ }
C {devices/lab_pin.sym} 76140 -13750 0 0 {name=p75824 lab=_46525_/X }
C {devices/lab_pin.sym} 76140 -13710 0 0 {name=p75825 lab=_49148_/A }
C {devices/lab_pin.sym} 76140 -13670 0 0 {name=p75826 lab=_46549_/X }
C {devices/lab_pin.sym} 76300 -13710 0 1 {name=p75827 lab=_51372_/B }
C {sky130_stdcells/o21ai_4.sym} 76220 -13710 0 0 {name=X_46550_ }
C {devices/lab_pin.sym} 76160 -13580 0 0 {name=p75828 lab=_58535_/Y }
C {devices/lab_pin.sym} 76160 -13540 0 0 {name=p75829 lab=_58498_/B }
C {devices/lab_pin.sym} 76280 -13560 0 1 {name=p75830 lab=_58536_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -13560 0 0 {name=X_58536_ }
C {devices/lab_pin.sym} 76180 -13430 0 0 {name=p75831 lab=_77369_/X }
C {devices/lab_pin.sym} 76260 -13430 0 1 {name=p75832 lab=_77396_/B }
C {sky130_stdcells/inv_2.sym} 76220 -13430 0 0 {name=X_77370_ }
C {devices/lab_pin.sym} 76160 -13320 0 0 {name=p75833 lab=_55794_/A }
C {devices/lab_pin.sym} 76160 -13280 0 0 {name=p75834 lab=_55748_/B }
C {devices/lab_pin.sym} 76280 -13300 0 1 {name=p75835 lab=_55748_/X }
C {sky130_stdcells/and2_4.sym} 76220 -13300 0 0 {name=X_55748_ }
C {devices/lab_pin.sym} 76180 -13170 0 0 {name=p75836 lab=_43762_/A }
C {devices/lab_pin.sym} 76260 -13170 0 1 {name=p75837 lab=_43762_/Y }
C {sky130_stdcells/inv_2.sym} 76220 -13170 0 0 {name=X_43762_ }
C {devices/lab_pin.sym} 76180 -13050 0 0 {name=p75838 lab=_74549_/Y }
C {devices/lab_pin.sym} 76260 -13050 0 1 {name=p75839 lab=_74582_/X }
C {sky130_stdcells/buf_2.sym} 76220 -13050 0 0 {name=X_74582_ }
C {devices/lab_pin.sym} 76130 -12930 0 0 {name=p75840 lab=_85599_/CLK }
C {devices/lab_pin.sym} 76130 -12910 0 0 {name=p75841 lab=_48101_/Y }
C {devices/lab_pin.sym} 76310 -12930 0 1 {name=p75842 lab=_86568_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -12920 0 0 {name=X_86568_ }
C {devices/lab_pin.sym} 76180 -12790 0 0 {name=p75843 lab=_40973_/Y }
C {devices/lab_pin.sym} 76260 -12790 0 1 {name=p75844 lab=_40974_/Y }
C {sky130_stdcells/inv_2.sym} 76220 -12790 0 0 {name=X_40974_ }
C {devices/lab_pin.sym} 76160 -12690 0 0 {name=p75845 lab=_70804_/A }
C {devices/lab_pin.sym} 76160 -12650 0 0 {name=p75846 lab=_71680_/C }
C {devices/lab_pin.sym} 76160 -12610 0 0 {name=p75847 lab=_71785_/X }
C {devices/lab_pin.sym} 76280 -12650 0 1 {name=p75848 lab=_71794_/Y }
C {sky130_stdcells/nand3_4.sym} 76220 -12650 0 0 {name=X_71794_ }
C {devices/lab_pin.sym} 76160 -12520 0 0 {name=p75849 lab=_45501_/A }
C {devices/lab_pin.sym} 76160 -12480 0 0 {name=p75850 lab=_45456_/X }
C {devices/lab_pin.sym} 76280 -12500 0 1 {name=p75851 lab=_45501_/Y }
C {sky130_stdcells/nor2_4.sym} 76220 -12500 0 0 {name=X_45501_ }
C {devices/lab_pin.sym} 76160 -12380 0 0 {name=p75852 lab=_76321_/A }
C {devices/lab_pin.sym} 76160 -12340 0 0 {name=p75853 lab=_76320_/Y }
C {devices/lab_pin.sym} 76280 -12360 0 1 {name=p75854 lab=_76321_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -12360 0 0 {name=X_76321_ }
C {devices/lab_pin.sym} 76130 -12230 0 0 {name=p75855 lab=_87851_/CLK }
C {devices/lab_pin.sym} 76130 -12210 0 0 {name=p75856 lab=_40936_/X }
C {devices/lab_pin.sym} 76310 -12230 0 1 {name=p75857 lab=_88307_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -12220 0 0 {name=X_88307_ }
C {devices/lab_pin.sym} 76140 -12120 0 0 {name=p75858 lab=_41151_/X }
C {devices/lab_pin.sym} 76140 -12080 0 0 {name=p75859 lab=_42710_/X }
C {devices/lab_pin.sym} 76140 -12040 0 0 {name=p75860 lab=_68543_/B }
C {devices/lab_pin.sym} 76140 -12000 0 0 {name=p75861 lab=_42711_/X }
C {devices/lab_pin.sym} 76300 -12060 0 1 {name=p75862 lab=_42713_/X }
C {sky130_stdcells/a2bb2o_4.sym} 76220 -12060 0 0 {name=X_42713_ }
C {devices/lab_pin.sym} 76130 -11910 0 0 {name=p75863 lab=_86127_/CLK }
C {devices/lab_pin.sym} 76130 -11890 0 0 {name=p75864 lab=_54032_/Y }
C {devices/lab_pin.sym} 76310 -11910 0 1 {name=p75865 lab=_85519_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -11900 0 0 {name=X_85519_ }
C {devices/lab_pin.sym} 76140 -11790 0 0 {name=p75866 lab=_69972_/B }
C {devices/lab_pin.sym} 76140 -11750 0 0 {name=p75867 lab=_73026_/X }
C {devices/lab_pin.sym} 76140 -11710 0 0 {name=p75868 lab=_73421_/X }
C {devices/lab_pin.sym} 76300 -11750 0 1 {name=p75869 lab=_73533_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -11750 0 0 {name=X_73533_ }
C {devices/lab_pin.sym} 76180 -11610 0 0 {name=p75870 lab=_48461_/A }
C {devices/lab_pin.sym} 76260 -11610 0 1 {name=p75871 lab=_47915_/B }
C {sky130_stdcells/buf_2.sym} 76220 -11610 0 0 {name=X_46481_ }
C {devices/lab_pin.sym} 76160 -11500 0 0 {name=p75872 lab=_70753_/A }
C {devices/lab_pin.sym} 76160 -11460 0 0 {name=p75873 lab=_70714_/A }
C {devices/lab_pin.sym} 76280 -11480 0 1 {name=p75874 lab=_70745_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -11480 0 0 {name=X_70745_ }
C {devices/lab_pin.sym} 76180 -11350 0 0 {name=p75875 lab=_58341_/A }
C {devices/lab_pin.sym} 76260 -11350 0 1 {name=p75876 lab=_58467_/X }
C {sky130_stdcells/buf_2.sym} 76220 -11350 0 0 {name=X_58467_ }
C {devices/lab_pin.sym} 76140 -11260 0 0 {name=p75877 lab=_40814_/A }
C {devices/lab_pin.sym} 76140 -11220 0 0 {name=p75878 lab=_43659_/X }
C {devices/lab_pin.sym} 76140 -11180 0 0 {name=p75879 lab=_69700_/B }
C {devices/lab_pin.sym} 76140 -11140 0 0 {name=p75880 lab=_43661_/X }
C {devices/lab_pin.sym} 76300 -11200 0 1 {name=p75881 lab=_43693_/X }
C {sky130_stdcells/a2bb2o_4.sym} 76220 -11200 0 0 {name=X_43693_ }
C {devices/lab_pin.sym} 76140 -11070 0 0 {name=p75882 lab=_55669_/A }
C {devices/lab_pin.sym} 76140 -11030 0 0 {name=p75883 lab=_55289_/X }
C {devices/lab_pin.sym} 76140 -10990 0 0 {name=p75884 lab=_55678_/X }
C {devices/lab_pin.sym} 76300 -11030 0 1 {name=p75885 lab=_55680_/B }
C {sky130_stdcells/a21boi_4.sym} 76220 -11030 0 0 {name=X_55679_ }
C {devices/lab_pin.sym} 76130 -10890 0 0 {name=p75886 lab=_86499_/CLK }
C {devices/lab_pin.sym} 76130 -10870 0 0 {name=p75887 lab=_48703_/Y }
C {devices/lab_pin.sym} 76310 -10890 0 1 {name=p75888 lab=_86499_/Q }
C {sky130_stdcells/dfxtp_4.sym} 76220 -10880 0 0 {name=X_86499_ }
C {devices/lab_pin.sym} 76140 -10770 0 0 {name=p75889 lab=_66028_/B }
C {devices/lab_pin.sym} 76140 -10730 0 0 {name=p75890 lab=_48203_/X }
C {devices/lab_pin.sym} 76140 -10690 0 0 {name=p75891 lab=_48219_/Y }
C {devices/lab_pin.sym} 76300 -10730 0 1 {name=p75892 lab=_48220_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -10730 0 0 {name=X_48220_ }
C {devices/lab_pin.sym} 76160 -10600 0 0 {name=p75893 lab=_82828_/Q }
C {devices/lab_pin.sym} 76160 -10560 0 0 {name=p75894 lab=_82540_/Q }
C {devices/lab_pin.sym} 76280 -10580 0 1 {name=p75895 lab=_82524_/D }
C {sky130_stdcells/xor2_4.sym} 76220 -10580 0 0 {name=X_79040_ }
C {devices/lab_pin.sym} 76160 -10460 0 0 {name=p75896 lab=_45431_/Y }
C {devices/lab_pin.sym} 76160 -10420 0 0 {name=p75897 lab=_45590_/B }
C {devices/lab_pin.sym} 76280 -10440 0 1 {name=p75898 lab=_45432_/X }
C {sky130_stdcells/and2_4.sym} 76220 -10440 0 0 {name=X_45432_ }
C {devices/lab_pin.sym} 76180 -10310 0 0 {name=p75899 lab=_57417_/Y }
C {devices/lab_pin.sym} 76260 -10310 0 1 {name=p75900 lab=_85008_/D }
C {sky130_stdcells/inv_2.sym} 76220 -10310 0 0 {name=X_57418_ }
C {devices/lab_pin.sym} 76140 -10210 0 0 {name=p75901 lab=_76230_/Y }
C {devices/lab_pin.sym} 76140 -10170 0 0 {name=p75902 lab=_76232_/A }
C {devices/lab_pin.sym} 76140 -10130 0 0 {name=p75903 lab=_76233_/C }
C {devices/lab_pin.sym} 76300 -10170 0 1 {name=p75904 lab=_76252_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -10170 0 0 {name=X_76252_ }
C {devices/lab_pin.sym} 76130 -10030 0 0 {name=p75905 lab=_87472_/CLK }
C {devices/lab_pin.sym} 76130 -10010 0 0 {name=p75906 lab=_88238_/D }
C {devices/lab_pin.sym} 76310 -10030 0 1 {name=p75907 lab=_67456_/B }
C {sky130_stdcells/dfxtp_4.sym} 76220 -10020 0 0 {name=X_88238_ }
C {devices/lab_pin.sym} 76140 -9920 0 0 {name=p75908 lab=_40968_/X }
C {devices/lab_pin.sym} 76140 -9880 0 0 {name=p75909 lab=_42631_/X }
C {devices/lab_pin.sym} 76140 -9840 0 0 {name=p75910 lab=_69218_/B }
C {devices/lab_pin.sym} 76140 -9800 0 0 {name=p75911 lab=_42634_/X }
C {devices/lab_pin.sym} 76300 -9860 0 1 {name=p75912 lab=_87789_/D }
C {sky130_stdcells/a2bb2o_4.sym} 76220 -9860 0 0 {name=X_42644_ }
C {devices/lab_pin.sym} 76180 -9710 0 0 {name=p75913 lab=_56934_/X }
C {devices/lab_pin.sym} 76260 -9710 0 1 {name=p75914 lab=_73464_/X }
C {sky130_stdcells/buf_2.sym} 76220 -9710 0 0 {name=X_73464_ }
C {devices/lab_pin.sym} 76160 -9610 0 0 {name=p75915 lab=_70676_/A }
C {devices/lab_pin.sym} 76160 -9570 0 0 {name=p75916 lab=_70676_/B }
C {devices/lab_pin.sym} 76160 -9530 0 0 {name=p75917 lab=_70676_/C }
C {devices/lab_pin.sym} 76280 -9570 0 1 {name=p75918 lab=_70676_/Y }
C {sky130_stdcells/nor3_4.sym} 76220 -9570 0 0 {name=X_70676_ }
C {devices/lab_pin.sym} 76140 -9450 0 0 {name=p75919 lab=_58388_/X }
C {devices/lab_pin.sym} 76140 -9410 0 0 {name=p75920 lab=_83347_/Q }
C {devices/lab_pin.sym} 76140 -9370 0 0 {name=p75921 lab=_58397_/Y }
C {devices/lab_pin.sym} 76300 -9410 0 1 {name=p75922 lab=_58398_/X }
C {sky130_stdcells/o21a_4.sym} 76220 -9410 0 0 {name=X_58398_ }
C {devices/lab_pin.sym} 76140 -9290 0 0 {name=p75923 lab=_75186_/A }
C {devices/lab_pin.sym} 76140 -9250 0 0 {name=p75924 lab=_75186_/B }
C {devices/lab_pin.sym} 76140 -9210 0 0 {name=p75925 lab=_75202_/Y }
C {devices/lab_pin.sym} 76300 -9250 0 1 {name=p75926 lab=_75203_/Y }
C {sky130_stdcells/a21boi_4.sym} 76220 -9250 0 0 {name=X_75203_ }
C {devices/lab_pin.sym} 76160 -9120 0 0 {name=p75927 lab=_72414_/X }
C {devices/lab_pin.sym} 76160 -9080 0 0 {name=p75928 lab=_72415_/B }
C {devices/lab_pin.sym} 76280 -9100 0 1 {name=p75929 lab=_72415_/Y }
C {sky130_stdcells/nor2_4.sym} 76220 -9100 0 0 {name=X_72415_ }
C {devices/lab_pin.sym} 76180 -8970 0 0 {name=p75930 lab=_48731_/A }
C {devices/lab_pin.sym} 76260 -8970 0 1 {name=p75931 lab=_48725_/A }
C {sky130_stdcells/buf_2.sym} 76220 -8970 0 0 {name=X_48151_ }
C {devices/lab_pin.sym} 76140 -8870 0 0 {name=p75932 lab=_85283_/Q }
C {devices/lab_pin.sym} 76140 -8830 0 0 {name=p75933 lab=_45343_/X }
C {devices/lab_pin.sym} 76140 -8790 0 0 {name=p75934 lab=_45303_/X }
C {devices/lab_pin.sym} 76300 -8830 0 1 {name=p75935 lab=_45363_/X }
C {sky130_stdcells/o21a_4.sym} 76220 -8830 0 0 {name=X_45363_ }
C {devices/lab_pin.sym} 76160 -8700 0 0 {name=p75936 lab=_56824_/X }
C {devices/lab_pin.sym} 76160 -8660 0 0 {name=p75937 lab=_57349_/B }
C {devices/lab_pin.sym} 76280 -8680 0 1 {name=p75938 lab=_57349_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -8680 0 0 {name=X_57349_ }
C {devices/lab_pin.sym} 76160 -8560 0 0 {name=p75939 lab=_76168_/B }
C {devices/lab_pin.sym} 76160 -8520 0 0 {name=p75940 lab=_76182_/Y }
C {devices/lab_pin.sym} 76280 -8540 0 1 {name=p75941 lab=_76183_/Y }
C {sky130_stdcells/xnor2_4.sym} 76220 -8540 0 0 {name=X_76183_ }
C {devices/lab_pin.sym} 76130 -8410 0 0 {name=p75942 lab=_87188_/CLK }
C {devices/lab_pin.sym} 76130 -8390 0 0 {name=p75943 lab=_41690_/Y }
C {devices/lab_pin.sym} 76310 -8410 0 1 {name=p75944 lab=_67575_/B }
C {sky130_stdcells/dfxtp_4.sym} 76220 -8400 0 0 {name=X_88169_ }
C {devices/lab_pin.sym} 76140 -8310 0 0 {name=p75945 lab=_42573_/X }
C {devices/lab_pin.sym} 76140 -8270 0 0 {name=p75946 lab=_42574_/X }
C {devices/lab_pin.sym} 76140 -8230 0 0 {name=p75947 lab=_40826_/X }
C {devices/lab_pin.sym} 76140 -8190 0 0 {name=p75948 lab=_87815_/Q }
C {devices/lab_pin.sym} 76140 -8150 0 0 {name=p75949 lab=_42540_/X }
C {devices/lab_pin.sym} 76300 -8230 0 1 {name=p75950 lab=_42576_/A }
C {sky130_stdcells/o32ai_4.sym} 76220 -8230 0 0 {name=X_42575_ }
C {devices/lab_pin.sym} 76140 -8100 0 0 {name=p75951 lab=_42047_/Y }
C {devices/lab_pin.sym} 76140 -8060 0 0 {name=p75952 lab=_72974_/X }
C {devices/lab_pin.sym} 76140 -8020 0 0 {name=p75953 lab=_73393_/X }
C {devices/lab_pin.sym} 76140 -7980 0 0 {name=p75954 lab=_73394_/Y }
C {devices/lab_pin.sym} 76300 -8040 0 1 {name=p75955 lab=_73395_/X }
C {sky130_stdcells/a211o_4.sym} 76220 -8040 0 0 {name=X_73395_ }
C {devices/lab_pin.sym} 76180 -7890 0 0 {name=p75956 lab=_46961_/X }
C {devices/lab_pin.sym} 76260 -7890 0 1 {name=p75957 lab=_47113_/A }
C {sky130_stdcells/buf_2.sym} 76220 -7890 0 0 {name=X_47102_ }
C {devices/lab_pin.sym} 76140 -7790 0 0 {name=p75958 lab=_44312_/Y }
C {devices/lab_pin.sym} 76140 -7750 0 0 {name=p75959 lab=_44313_/Y }
C {devices/lab_pin.sym} 76140 -7710 0 0 {name=p75960 lab=_44318_/A }
C {devices/lab_pin.sym} 76300 -7750 0 1 {name=p75961 lab=_44314_/Y }
C {sky130_stdcells/a21oi_4.sym} 76220 -7750 0 0 {name=X_44314_ }
C {devices/lab_pin.sym} 76180 -7610 0 0 {name=p75962 lab=_75120_/B }
C {devices/lab_pin.sym} 76260 -7610 0 1 {name=p75963 lab=_75134_/Y }
C {sky130_stdcells/inv_2.sym} 76220 -7610 0 0 {name=X_75134_ }
C {devices/lab_pin.sym} 76140 -7520 0 0 {name=p75964 lab=_41525_/X }
C {devices/lab_pin.sym} 76140 -7480 0 0 {name=p75965 lab=_41486_/X }
C {devices/lab_pin.sym} 76140 -7440 0 0 {name=p75966 lab=_88198_/Q }
C {devices/lab_pin.sym} 76140 -7400 0 0 {name=p75967 lab=_41487_/X }
C {devices/lab_pin.sym} 76300 -7460 0 1 {name=p75968 lab=_88198_/D }
C {sky130_stdcells/a2bb2o_4.sym} 76220 -7460 0 0 {name=X_41526_ }
C {devices/lab_pin.sym} 76180 -7310 0 0 {name=p75969 lab=_48081_/Y }
C {devices/lab_pin.sym} 76260 -7310 0 1 {name=p75970 lab=_48310_/B }
C {sky130_stdcells/buf_2.sym} 76220 -7310 0 0 {name=X_48082_ }
C {devices/lab_pin.sym} 76160 -7200 0 0 {name=p75971 lab=_60168_/A }
C {devices/lab_pin.sym} 76160 -7160 0 0 {name=p75972 lab=_60177_/X }
C {devices/lab_pin.sym} 76280 -7180 0 1 {name=p75973 lab=_60360_/X }
C {sky130_stdcells/and2_4.sym} 76220 -7180 0 0 {name=X_60360_ }
C {devices/lab_pin.sym} 76140 -7080 0 0 {name=p75974 lab=_83263_/Q }
C {devices/lab_pin.sym} 76140 -7040 0 0 {name=p75975 lab=_72250_/X }
C {devices/lab_pin.sym} 76140 -7000 0 0 {name=p75976 lab=_72338_/X }
C {devices/lab_pin.sym} 76140 -6960 0 0 {name=p75977 lab=_72345_/X }
C {devices/lab_pin.sym} 76300 -7020 0 1 {name=p75978 lab=_83263_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 76220 -7020 0 0 {name=X_72346_ }
C {devices/lab_pin.sym} 76180 -6870 0 0 {name=p75979 lab=_45219_/A }
C {devices/lab_pin.sym} 76260 -6870 0 1 {name=p75980 lab=_45294_/X }
C {sky130_stdcells/buf_2.sym} 76220 -6870 0 0 {name=X_45294_ }
C {devices/lab_pin.sym} 76160 -6760 0 0 {name=p75981 lab=_47008_/A }
C {devices/lab_pin.sym} 76160 -6720 0 0 {name=p75982 lab=_52813_/B }
C {devices/lab_pin.sym} 76280 -6740 0 1 {name=p75983 lab=_47033_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -6740 0 0 {name=X_47033_ }
C {devices/lab_pin.sym} 76160 -6620 0 0 {name=p75984 lab=_59019_/A }
C {devices/lab_pin.sym} 76160 -6580 0 0 {name=p75985 lab=_59008_/B }
C {devices/lab_pin.sym} 76280 -6600 0 1 {name=p75986 lab=_59019_/Y }
C {sky130_stdcells/nor2_4.sym} 76220 -6600 0 0 {name=X_59019_ }
C {devices/lab_pin.sym} 76180 -6470 0 0 {name=p75987 lab=_44245_/A }
C {devices/lab_pin.sym} 76260 -6470 0 1 {name=p75988 lab=_44246_/A }
C {sky130_stdcells/buf_2.sym} 76220 -6470 0 0 {name=X_44245_ }
C {devices/lab_pin.sym} 76160 -6360 0 0 {name=p75989 lab=_75067_/B }
C {devices/lab_pin.sym} 76160 -6320 0 0 {name=p75990 lab=_75067_/A }
C {devices/lab_pin.sym} 76280 -6340 0 1 {name=p75991 lab=_75066_/B }
C {sky130_stdcells/xor2_4.sym} 76220 -6340 0 0 {name=X_75065_ }
C {devices/lab_pin.sym} 76160 -6230 0 0 {name=p75992 lab=_79942_/A }
C {devices/lab_pin.sym} 76160 -6190 0 0 {name=p75993 lab=_79940_/Y }
C {devices/lab_pin.sym} 76160 -6150 0 0 {name=p75994 lab=_79941_/Y }
C {devices/lab_pin.sym} 76280 -6190 0 1 {name=p75995 lab=_79945_/B }
C {sky130_stdcells/nand3_4.sym} 76220 -6190 0 0 {name=X_79942_ }
C {devices/lab_pin.sym} 76180 -6050 0 0 {name=p75996 lab=_41457_/A }
C {devices/lab_pin.sym} 76260 -6050 0 1 {name=p75997 lab=_41457_/X }
C {sky130_stdcells/buf_2.sym} 76220 -6050 0 0 {name=X_41457_ }
C {devices/lab_pin.sym} 76160 -5950 0 0 {name=p75998 lab=_60233_/Y }
C {devices/lab_pin.sym} 76160 -5910 0 0 {name=p75999 lab=_60251_/A }
C {devices/lab_pin.sym} 76160 -5870 0 0 {name=p76000 lab=_60291_/C }
C {devices/lab_pin.sym} 76280 -5910 0 1 {name=p76001 lab=_60292_/A }
C {sky130_stdcells/nand3_4.sym} 76220 -5910 0 0 {name=X_60291_ }
C {devices/lab_pin.sym} 76160 -5780 0 0 {name=p76002 lab=_72277_/A }
C {devices/lab_pin.sym} 76160 -5740 0 0 {name=p76003 lab=_72277_/B }
C {devices/lab_pin.sym} 76280 -5760 0 1 {name=p76004 lab=_72277_/Y }
C {sky130_stdcells/nor2_4.sym} 76220 -5760 0 0 {name=X_72277_ }
C {devices/lab_pin.sym} 76160 -5660 0 0 {name=p76005 lab=_62142_/A }
C {devices/lab_pin.sym} 76160 -5620 0 0 {name=p76006 lab=_62025_/Y }
C {devices/lab_pin.sym} 76160 -5580 0 0 {name=p76007 lab=_62026_/Y }
C {devices/lab_pin.sym} 76160 -5540 0 0 {name=p76008 lab=_62030_/D }
C {devices/lab_pin.sym} 76280 -5600 0 1 {name=p76009 lab=_62030_/Y }
C {sky130_stdcells/nand4_4.sym} 76220 -5600 0 0 {name=X_62030_ }
C {devices/lab_pin.sym} 76180 -5450 0 0 {name=p76010 lab=_73378_/A }
C {devices/lab_pin.sym} 76260 -5450 0 1 {name=p76011 lab=_74016_/X }
C {sky130_stdcells/buf_2.sym} 76220 -5450 0 0 {name=X_74016_ }
C {devices/lab_pin.sym} 76180 -5330 0 0 {name=p76012 lab=_40407_/Y }
C {devices/lab_pin.sym} 76260 -5330 0 1 {name=p76013 lab=_40408_/X }
C {sky130_stdcells/buf_2.sym} 76220 -5330 0 0 {name=X_40408_ }
C {devices/lab_pin.sym} 76160 -5230 0 0 {name=p76014 lab=_71232_/A }
C {devices/lab_pin.sym} 76160 -5190 0 0 {name=p76015 lab=_71228_/B }
C {devices/lab_pin.sym} 76160 -5150 0 0 {name=p76016 lab=_71232_/C }
C {devices/lab_pin.sym} 76280 -5190 0 1 {name=p76017 lab=_71228_/Y }
C {sky130_stdcells/nand3_4.sym} 76220 -5190 0 0 {name=X_71228_ }
C {devices/lab_pin.sym} 76180 -5050 0 0 {name=p76018 lab=_64679_/A }
C {devices/lab_pin.sym} 76260 -5050 0 1 {name=p76019 lab=_58126_/A }
C {sky130_stdcells/buf_2.sym} 76220 -5050 0 0 {name=X_44176_ }
C {devices/lab_pin.sym} 76160 -4940 0 0 {name=p76020 lab=_79871_/X }
C {devices/lab_pin.sym} 76160 -4900 0 0 {name=p76021 lab=_79873_/B }
C {devices/lab_pin.sym} 76280 -4920 0 1 {name=p76022 lab=_79873_/Y }
C {sky130_stdcells/xnor2_4.sym} 76220 -4920 0 0 {name=X_79873_ }
C {devices/lab_pin.sym} 76180 -4790 0 0 {name=p76023 lab=_41235_/X }
C {devices/lab_pin.sym} 76260 -4790 0 1 {name=p76024 lab=_41388_/X }
C {sky130_stdcells/buf_2.sym} 76220 -4790 0 0 {name=X_41388_ }
C {devices/lab_pin.sym} 76180 -4670 0 0 {name=p76025 lab=_43127_/A }
C {devices/lab_pin.sym} 76260 -4670 0 1 {name=p76026 lab=_43127_/X }
C {sky130_stdcells/buf_2.sym} 76220 -4670 0 0 {name=X_43127_ }
C {devices/lab_pin.sym} 76160 -4560 0 0 {name=p76027 lab=_82836_/Q }
C {devices/lab_pin.sym} 76160 -4520 0 0 {name=p76028 lab=_78825_/A }
C {devices/lab_pin.sym} 76280 -4540 0 1 {name=p76029 lab=_78828_/A }
C {sky130_stdcells/or2_4.sym} 76220 -4540 0 0 {name=X_78824_ }
C {devices/lab_pin.sym} 76180 -4410 0 0 {name=p76030 lab=_46259_/A }
C {devices/lab_pin.sym} 76260 -4410 0 1 {name=p76031 lab=_44362_/A }
C {sky130_stdcells/inv_2.sym} 76220 -4410 0 0 {name=X_40339_ }
C {devices/lab_pin.sym} 76180 -4290 0 0 {name=p76032 lab=_71225_/A }
C {devices/lab_pin.sym} 76260 -4290 0 1 {name=p76033 lab=_71173_/B }
C {sky130_stdcells/buf_2.sym} 76220 -4290 0 0 {name=X_71159_ }
C {devices/lab_pin.sym} 76140 -4190 0 0 {name=p76034 lab=_86455_/Q }
C {devices/lab_pin.sym} 76140 -4150 0 0 {name=p76035 lab=_48952_/X }
C {devices/lab_pin.sym} 76140 -4110 0 0 {name=p76036 lab=_48983_/Y }
C {devices/lab_pin.sym} 76300 -4150 0 1 {name=p76037 lab=_48984_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -4150 0 0 {name=X_48984_ }
C {devices/lab_pin.sym} 76160 -4020 0 0 {name=p76038 lab=_82360_/Q }
C {devices/lab_pin.sym} 76160 -3980 0 0 {name=p76039 lab=_47963_/B }
C {devices/lab_pin.sym} 76280 -4000 0 1 {name=p76040 lab=_47935_/X }
C {sky130_stdcells/or2_4.sym} 76220 -4000 0 0 {name=X_47935_ }
C {devices/lab_pin.sym} 76180 -3870 0 0 {name=p76041 lab=_43058_/A }
C {devices/lab_pin.sym} 76260 -3870 0 1 {name=p76042 lab=_43058_/X }
C {sky130_stdcells/buf_2.sym} 76220 -3870 0 0 {name=X_43058_ }
C {devices/lab_pin.sym} 76140 -3770 0 0 {name=p76043 lab=_78732_/A }
C {devices/lab_pin.sym} 76140 -3730 0 0 {name=p76044 lab=_78732_/B }
C {devices/lab_pin.sym} 76140 -3690 0 0 {name=p76045 lab=_78731_/A }
C {devices/lab_pin.sym} 76300 -3730 0 1 {name=p76046 lab=_78755_/X }
C {sky130_stdcells/o21a_4.sym} 76220 -3730 0 0 {name=X_78755_ }
C {devices/lab_pin.sym} 76160 -3600 0 0 {name=p76047 lab=_75976_/A }
C {devices/lab_pin.sym} 76160 -3560 0 0 {name=p76048 lab=_75976_/B }
C {devices/lab_pin.sym} 76280 -3580 0 1 {name=p76049 lab=_75970_/A }
C {sky130_stdcells/xor2_4.sym} 76220 -3580 0 0 {name=X_75967_ }
C {devices/lab_pin.sym} 76160 -3480 0 0 {name=p76050 lab=_64392_/B }
C {devices/lab_pin.sym} 76160 -3440 0 0 {name=p76051 lab=_64029_/B }
C {devices/lab_pin.sym} 76160 -3400 0 0 {name=p76052 lab=_63951_/C }
C {devices/lab_pin.sym} 76160 -3360 0 0 {name=p76053 lab=_64015_/D }
C {devices/lab_pin.sym} 76280 -3420 0 1 {name=p76054 lab=_63981_/Y }
C {sky130_stdcells/nand4_4.sym} 76220 -3420 0 0 {name=X_63981_ }
C {devices/lab_pin.sym} 76180 -3270 0 0 {name=p76055 lab=_42009_/A }
C {devices/lab_pin.sym} 76260 -3270 0 1 {name=p76056 lab=_42009_/Y }
C {sky130_stdcells/inv_2.sym} 76220 -3270 0 0 {name=X_42009_ }
C {devices/lab_pin.sym} 76140 -3180 0 0 {name=p76057 lab=_65717_/X }
C {devices/lab_pin.sym} 76140 -3140 0 0 {name=p76058 lab=_85582_/Q }
C {devices/lab_pin.sym} 76140 -3100 0 0 {name=p76059 lab=_65718_/X }
C {devices/lab_pin.sym} 76140 -3060 0 0 {name=p76060 lab=_65719_/X }
C {devices/lab_pin.sym} 76300 -3120 0 1 {name=p76061 lab=_65720_/X }
C {sky130_stdcells/a211o_4.sym} 76220 -3120 0 0 {name=X_65720_ }
C {devices/lab_pin.sym} 76160 -2980 0 0 {name=p76062 lab=_77703_/Y }
C {devices/lab_pin.sym} 76160 -2940 0 0 {name=p76063 lab=_77710_/A }
C {devices/lab_pin.sym} 76280 -2960 0 1 {name=p76064 lab=_77707_/A }
C {sky130_stdcells/nand2_4.sym} 76220 -2960 0 0 {name=X_77706_ }
C {devices/lab_pin.sym} 76160 -2840 0 0 {name=p76065 lab=_74914_/Y }
C {devices/lab_pin.sym} 76160 -2800 0 0 {name=p76066 lab=_74917_/X }
C {devices/lab_pin.sym} 76280 -2820 0 1 {name=p76067 lab=_74930_/A }
C {sky130_stdcells/nand2_4.sym} 76220 -2820 0 0 {name=X_74918_ }
C {devices/lab_pin.sym} 76180 -2690 0 0 {name=p76068 lab=_60199_/X }
C {devices/lab_pin.sym} 76260 -2690 0 1 {name=p76069 lab=_62979_/D }
C {sky130_stdcells/buf_2.sym} 76220 -2690 0 0 {name=X_62932_ }
C {devices/lab_pin.sym} 76140 -2590 0 0 {name=p76070 lab=_73638_/B }
C {devices/lab_pin.sym} 76140 -2550 0 0 {name=p76071 lab=_47840_/X }
C {devices/lab_pin.sym} 76140 -2510 0 0 {name=p76072 lab=_47865_/Y }
C {devices/lab_pin.sym} 76300 -2550 0 1 {name=p76073 lab=_47866_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -2550 0 0 {name=X_47866_ }
C {devices/lab_pin.sym} 76140 -2430 0 0 {name=p76074 lab=_78675_/B }
C {devices/lab_pin.sym} 76140 -2390 0 0 {name=p76075 lab=_78667_/X }
C {devices/lab_pin.sym} 76140 -2350 0 0 {name=p76076 lab=_78669_/B }
C {devices/lab_pin.sym} 76300 -2390 0 1 {name=p76077 lab=_78686_/Y }
C {sky130_stdcells/a21boi_4.sym} 76220 -2390 0 0 {name=X_78686_ }
C {devices/lab_pin.sym} 76160 -2260 0 0 {name=p76078 lab=_75898_/A }
C {devices/lab_pin.sym} 76160 -2220 0 0 {name=p76079 lab=_62943_/C }
C {devices/lab_pin.sym} 76280 -2240 0 1 {name=p76080 lab=_75898_/X }
C {sky130_stdcells/xor2_4.sym} 76220 -2240 0 0 {name=X_75898_ }
C {devices/lab_pin.sym} 76180 -2110 0 0 {name=p76081 lab=_49002_/A }
C {devices/lab_pin.sym} 76260 -2110 0 1 {name=p76082 lab=_49632_/A }
C {sky130_stdcells/buf_2.sym} 76220 -2110 0 0 {name=X_49605_ }
C {devices/lab_pin.sym} 76160 -2000 0 0 {name=p76083 lab=_46817_/A }
C {devices/lab_pin.sym} 76160 -1960 0 0 {name=p76084 lab=_50998_/B }
C {devices/lab_pin.sym} 76280 -1980 0 1 {name=p76085 lab=_46817_/Y }
C {sky130_stdcells/nand2_4.sym} 76220 -1980 0 0 {name=X_46817_ }
C {devices/lab_pin.sym} 76160 -1870 0 0 {name=p76086 lab=_65634_/A }
C {devices/lab_pin.sym} 76160 -1830 0 0 {name=p76087 lab=_65802_/B }
C {devices/lab_pin.sym} 76160 -1790 0 0 {name=p76088 lab=_65651_/C }
C {devices/lab_pin.sym} 76280 -1830 0 1 {name=p76089 lab=_65651_/Y }
C {sky130_stdcells/nor3_4.sym} 76220 -1830 0 0 {name=X_65651_ }
C {devices/lab_pin.sym} 76140 -1710 0 0 {name=p76090 lab=_77633_/X }
C {devices/lab_pin.sym} 76140 -1670 0 0 {name=p76091 lab=_77634_/Y }
C {devices/lab_pin.sym} 76140 -1630 0 0 {name=p76092 lab=_77636_/Y }
C {devices/lab_pin.sym} 76300 -1670 0 1 {name=p76093 lab=_77666_/B }
C {sky130_stdcells/a21oi_4.sym} 76220 -1670 0 0 {name=X_77637_ }
C {devices/lab_pin.sym} 76140 -1570 0 0 {name=p76094 lab=_62856_/X }
C {devices/lab_pin.sym} 76140 -1530 0 0 {name=p76095 lab=_62831_/X }
C {devices/lab_pin.sym} 76140 -1490 0 0 {name=p76096 lab=_62857_/Y }
C {devices/lab_pin.sym} 76140 -1450 0 0 {name=p76097 lab=_62860_/Y }
C {devices/lab_pin.sym} 76140 -1420 0 0 {name=p76098 lab=_62862_/X }
C {devices/lab_pin.sym} 76300 -1490 0 1 {name=p76099 lab=_62863_/X }
C {sky130_stdcells/a41o_4.sym} 76220 -1490 0 0 {name=X_62863_ }
C {devices/lab_pin.sym} 76160 -1340 0 0 {name=p76100 lab=_80930_/Q }
C {devices/lab_pin.sym} 76160 -1300 0 0 {name=p76101 lab=_74849_/B }
C {devices/lab_pin.sym} 76280 -1320 0 1 {name=p76102 lab=_74849_/X }
C {sky130_stdcells/xor2_4.sym} 76220 -1320 0 0 {name=X_74849_ }
C {devices/lab_pin.sym} 76180 -1190 0 0 {name=p76103 lab=_47797_/A }
C {devices/lab_pin.sym} 76260 -1190 0 1 {name=p76104 lab=_47798_/A }
C {sky130_stdcells/inv_2.sym} 76220 -1190 0 0 {name=X_47797_ }
C {devices/lab_pin.sym} 76180 -1070 0 0 {name=p76105 lab=_64602_/A }
C {devices/lab_pin.sym} 76260 -1070 0 1 {name=p76106 lab=_64684_/A }
C {sky130_stdcells/buf_2.sym} 76220 -1070 0 0 {name=X_64602_ }
C {devices/lab_pin.sym} 76160 -980 0 0 {name=p76107 lab=_61863_/A }
C {devices/lab_pin.sym} 76160 -940 0 0 {name=p76108 lab=_61809_/Y }
C {devices/lab_pin.sym} 76160 -900 0 0 {name=p76109 lab=_61810_/Y }
C {devices/lab_pin.sym} 76160 -860 0 0 {name=p76110 lab=_61813_/Y }
C {devices/lab_pin.sym} 76280 -920 0 1 {name=p76111 lab=_61814_/Y }
C {sky130_stdcells/nand4_4.sym} 76220 -920 0 0 {name=X_61814_ }
C {devices/lab_pin.sym} 76140 -790 0 0 {name=p76112 lab=_86369_/Q }
C {devices/lab_pin.sym} 76140 -750 0 0 {name=p76113 lab=_49524_/X }
C {devices/lab_pin.sym} 76140 -710 0 0 {name=p76114 lab=_49535_/Y }
C {devices/lab_pin.sym} 76300 -750 0 1 {name=p76115 lab=_49536_/Y }
C {sky130_stdcells/o21ai_4.sym} 76220 -750 0 0 {name=X_49536_ }
C {devices/lab_pin.sym} 77100 -42150 0 0 {name=p76116 lab=_68370_/A }
C {devices/lab_pin.sym} 77180 -42150 0 1 {name=p76117 lab=_68370_/X }
C {sky130_stdcells/buf_2.sym} 77140 -42150 0 0 {name=X_68370_ }
C {devices/lab_pin.sym} 77100 -42030 0 0 {name=p76118 lab=_52651_/B }
C {devices/lab_pin.sym} 77180 -42030 0 1 {name=p76119 lab=_50961_/B }
C {sky130_stdcells/buf_2.sym} 77140 -42030 0 0 {name=X_46748_ }
C {devices/lab_pin.sym} 77060 -41930 0 0 {name=p76120 lab=_65579_/X }
C {devices/lab_pin.sym} 77060 -41890 0 0 {name=p76121 lab=_65581_/X }
C {devices/lab_pin.sym} 77060 -41850 0 0 {name=p76122 lab=_65389_/X }
C {devices/lab_pin.sym} 77220 -41890 0 1 {name=p76123 lab=_65582_/X }
C {sky130_stdcells/a21o_4.sym} 77140 -41890 0 0 {name=X_65582_ }
C {devices/lab_pin.sym} 77080 -41760 0 0 {name=p76124 lab=_77568_/A }
C {devices/lab_pin.sym} 77080 -41720 0 0 {name=p76125 lab=_82105_/D }
C {devices/lab_pin.sym} 77200 -41740 0 1 {name=p76126 lab=_77568_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -41740 0 0 {name=X_77568_ }
C {devices/lab_pin.sym} 77080 -41630 0 0 {name=p76127 lab=_62792_/X }
C {devices/lab_pin.sym} 77080 -41590 0 0 {name=p76128 lab=_62839_/B }
C {devices/lab_pin.sym} 77080 -41550 0 0 {name=p76129 lab=_75912_/B }
C {devices/lab_pin.sym} 77200 -41590 0 1 {name=p76130 lab=_62794_/Y }
C {sky130_stdcells/nor3_4.sym} 77140 -41590 0 0 {name=X_62794_ }
C {devices/lab_pin.sym} 77080 -41460 0 0 {name=p76131 lab=_84797_/Q }
C {devices/lab_pin.sym} 77080 -41420 0 0 {name=p76132 lab=_66469_/C }
C {devices/lab_pin.sym} 77200 -41440 0 1 {name=p76133 lab=_79307_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -41440 0 0 {name=X_79307_ }
C {devices/lab_pin.sym} 77060 -41340 0 0 {name=p76134 lab=_87412_/Q }
C {devices/lab_pin.sym} 77060 -41300 0 0 {name=p76135 lab=_67274_/X }
C {devices/lab_pin.sym} 77060 -41260 0 0 {name=p76136 lab=_67226_/X }
C {devices/lab_pin.sym} 77060 -41220 0 0 {name=p76137 lab=_67320_/X }
C {devices/lab_pin.sym} 77220 -41280 0 1 {name=p76138 lab=_67321_/X }
C {sky130_stdcells/a211o_4.sym} 77140 -41280 0 0 {name=X_67321_ }
C {devices/lab_pin.sym} 77080 -41140 0 0 {name=p76139 lab=_58364_/A }
C {devices/lab_pin.sym} 77080 -41100 0 0 {name=p76140 lab=_64521_/X }
C {devices/lab_pin.sym} 77200 -41120 0 1 {name=p76141 lab=_64533_/Y }
C {sky130_stdcells/nor2_4.sym} 77140 -41120 0 0 {name=X_64533_ }
C {devices/lab_pin.sym} 77060 -41010 0 0 {name=p76142 lab=_76501_/Y }
C {devices/lab_pin.sym} 77060 -40970 0 0 {name=p76143 lab=_76502_/Y }
C {devices/lab_pin.sym} 77060 -40930 0 0 {name=p76144 lab=_76503_/Y }
C {devices/lab_pin.sym} 77220 -40970 0 1 {name=p76145 lab=_76519_/X }
C {sky130_stdcells/o21a_4.sym} 77140 -40970 0 0 {name=X_76519_ }
C {devices/lab_pin.sym} 77080 -40860 0 0 {name=p76146 lab=_49467_/A }
C {devices/lab_pin.sym} 77080 -40820 0 0 {name=p76147 lab=_49456_/B }
C {devices/lab_pin.sym} 77080 -40780 0 0 {name=p76148 lab=_49467_/C }
C {devices/lab_pin.sym} 77080 -40740 0 0 {name=p76149 lab=_52681_/D }
C {devices/lab_pin.sym} 77200 -40800 0 1 {name=p76150 lab=_49467_/X }
C {sky130_stdcells/and4_4.sym} 77140 -40800 0 0 {name=X_49467_ }
C {devices/lab_pin.sym} 77100 -40650 0 0 {name=p76151 lab=_61712_/X }
C {devices/lab_pin.sym} 77180 -40650 0 1 {name=p76152 lab=_61749_/B }
C {sky130_stdcells/buf_2.sym} 77140 -40650 0 0 {name=X_61745_ }
C {devices/lab_pin.sym} 77100 -40530 0 0 {name=p76153 lab=_74509_/B }
C {devices/lab_pin.sym} 77180 -40530 0 1 {name=p76154 lab=_46717_/A }
C {sky130_stdcells/buf_2.sym} 77140 -40530 0 0 {name=X_46679_ }
C {devices/lab_pin.sym} 77060 -40430 0 0 {name=p76155 lab=_77446_/A }
C {devices/lab_pin.sym} 77060 -40390 0 0 {name=p76156 lab=_77447_/X }
C {devices/lab_pin.sym} 77060 -40350 0 0 {name=p76157 lab=_77458_/B }
C {devices/lab_pin.sym} 77220 -40390 0 1 {name=p76158 lab=_77499_/X }
C {sky130_stdcells/a21o_4.sym} 77140 -40390 0 0 {name=X_77499_ }
C {devices/lab_pin.sym} 77060 -40270 0 0 {name=p76159 lab=_48413_/Y }
C {devices/lab_pin.sym} 77060 -40230 0 0 {name=p76160 lab=_48403_/X }
C {devices/lab_pin.sym} 77060 -40190 0 0 {name=p76161 lab=_48417_/Y }
C {devices/lab_pin.sym} 77220 -40230 0 1 {name=p76162 lab=_86524_/D }
C {sky130_stdcells/a21boi_4.sym} 77140 -40230 0 0 {name=X_48418_ }
C {devices/lab_pin.sym} 77060 -40110 0 0 {name=p76163 lab=_67249_/X }
C {devices/lab_pin.sym} 77060 -40070 0 0 {name=p76164 lab=_67251_/X }
C {devices/lab_pin.sym} 77060 -40030 0 0 {name=p76165 lab=_67204_/X }
C {devices/lab_pin.sym} 77220 -40070 0 1 {name=p76166 lab=_67252_/X }
C {sky130_stdcells/a21o_4.sym} 77140 -40070 0 0 {name=X_67252_ }
C {devices/lab_pin.sym} 77080 -39940 0 0 {name=p76167 lab=_79238_/A }
C {devices/lab_pin.sym} 77080 -39900 0 0 {name=p76168 lab=_79239_/A }
C {devices/lab_pin.sym} 77200 -39920 0 1 {name=p76169 lab=_79238_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -39920 0 0 {name=X_79238_ }
C {devices/lab_pin.sym} 77080 -39800 0 0 {name=p76170 lab=_58461_/A }
C {devices/lab_pin.sym} 77080 -39760 0 0 {name=p76171 lab=_64511_/B }
C {devices/lab_pin.sym} 77200 -39780 0 1 {name=p76172 lab=_64464_/Y }
C {sky130_stdcells/nor2_4.sym} 77140 -39780 0 0 {name=X_64464_ }
C {devices/lab_pin.sym} 77080 -39680 0 0 {name=p76173 lab=_61676_/A }
C {devices/lab_pin.sym} 77080 -39640 0 0 {name=p76174 lab=_61653_/X }
C {devices/lab_pin.sym} 77080 -39600 0 0 {name=p76175 lab=_61654_/X }
C {devices/lab_pin.sym} 77080 -39560 0 0 {name=p76176 lab=_61639_/X }
C {devices/lab_pin.sym} 77200 -39620 0 1 {name=p76177 lab=_61676_/Y }
C {sky130_stdcells/nand4_4.sym} 77140 -39620 0 0 {name=X_61676_ }
C {devices/lab_pin.sym} 77060 -39490 0 0 {name=p76178 lab=_49395_/Y }
C {devices/lab_pin.sym} 77060 -39450 0 0 {name=p76179 lab=_49378_/X }
C {devices/lab_pin.sym} 77060 -39410 0 0 {name=p76180 lab=_49397_/X }
C {devices/lab_pin.sym} 77220 -39450 0 1 {name=p76181 lab=_86395_/D }
C {sky130_stdcells/a21oi_4.sym} 77140 -39450 0 0 {name=X_49398_ }
C {devices/lab_pin.sym} 77080 -39330 0 0 {name=p76182 lab=_66200_/X }
C {devices/lab_pin.sym} 77080 -39290 0 0 {name=p76183 lab=_64633_/B }
C {devices/lab_pin.sym} 77080 -39250 0 0 {name=p76184 lab=_66203_/C }
C {devices/lab_pin.sym} 77200 -39290 0 1 {name=p76185 lab=_66203_/Y }
C {sky130_stdcells/nand3_4.sym} 77140 -39290 0 0 {name=X_66203_ }
C {devices/lab_pin.sym} 77060 -39180 0 0 {name=p76186 lab=_61375_/B }
C {devices/lab_pin.sym} 77060 -39140 0 0 {name=p76187 lab=_60834_/X }
C {devices/lab_pin.sym} 77060 -39100 0 0 {name=p76188 lab=_63412_/X }
C {devices/lab_pin.sym} 77060 -39060 0 0 {name=p76189 lab=_63414_/X }
C {devices/lab_pin.sym} 77220 -39120 0 1 {name=p76190 lab=_63415_/X }
C {sky130_stdcells/a211o_4.sym} 77140 -39120 0 0 {name=X_63415_ }
C {devices/lab_pin.sym} 77060 -38990 0 0 {name=p76191 lab=_48346_/Y }
C {devices/lab_pin.sym} 77060 -38950 0 0 {name=p76192 lab=_48322_/X }
C {devices/lab_pin.sym} 77060 -38910 0 0 {name=p76193 lab=_48348_/Y }
C {devices/lab_pin.sym} 77220 -38950 0 1 {name=p76194 lab=_86531_/D }
C {sky130_stdcells/a21boi_4.sym} 77140 -38950 0 0 {name=X_48349_ }
C {devices/lab_pin.sym} 77100 -38810 0 0 {name=p76195 lab=_60627_/A }
C {devices/lab_pin.sym} 77180 -38810 0 1 {name=p76196 lab=_60628_/C }
C {sky130_stdcells/inv_2.sym} 77140 -38810 0 0 {name=X_60627_ }
C {devices/lab_pin.sym} 77080 -38700 0 0 {name=p76197 lab=_67183_/A }
C {devices/lab_pin.sym} 77080 -38660 0 0 {name=p76198 lab=_67183_/B }
C {devices/lab_pin.sym} 77200 -38680 0 1 {name=p76199 lab=_67183_/X }
C {sky130_stdcells/and2_4.sym} 77140 -38680 0 0 {name=X_67183_ }
C {devices/lab_pin.sym} 77080 -38560 0 0 {name=p76200 lab=_79169_/A }
C {devices/lab_pin.sym} 77080 -38520 0 0 {name=p76201 lab=_79169_/B }
C {devices/lab_pin.sym} 77200 -38540 0 1 {name=p76202 lab=_79171_/B }
C {sky130_stdcells/nand2_4.sym} 77140 -38540 0 0 {name=X_79169_ }
C {devices/lab_pin.sym} 77060 -38430 0 0 {name=p76203 lab=_58338_/Y }
C {devices/lab_pin.sym} 77060 -38390 0 0 {name=p76204 lab=_64367_/X }
C {devices/lab_pin.sym} 77060 -38350 0 0 {name=p76205 lab=_64394_/Y }
C {devices/lab_pin.sym} 77220 -38390 0 1 {name=p76206 lab=_64395_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -38390 0 0 {name=X_64395_ }
C {devices/lab_pin.sym} 77050 -38250 0 0 {name=p76207 lab=_82284_/CLK }
C {devices/lab_pin.sym} 77050 -38230 0 0 {name=p76208 lab=_74998_/X }
C {devices/lab_pin.sym} 77230 -38250 0 1 {name=p76209 lab=_46446_/A }
C {sky130_stdcells/dfxtp_4.sym} 77140 -38240 0 0 {name=X_81200_ }
C {devices/lab_pin.sym} 77080 -38120 0 0 {name=p76210 lab=_66134_/A }
C {devices/lab_pin.sym} 77080 -38080 0 0 {name=p76211 lab=_66133_/X }
C {devices/lab_pin.sym} 77200 -38100 0 1 {name=p76212 lab=_66134_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -38100 0 0 {name=X_66134_ }
C {devices/lab_pin.sym} 77080 -37980 0 0 {name=p76213 lab=_51306_/X }
C {devices/lab_pin.sym} 77080 -37940 0 0 {name=p76214 lab=_51360_/B }
C {devices/lab_pin.sym} 77200 -37960 0 1 {name=p76215 lab=_51360_/X }
C {sky130_stdcells/and2_4.sym} 77140 -37960 0 0 {name=X_51360_ }
C {devices/lab_pin.sym} 77060 -37850 0 0 {name=p76216 lab=_63338_/Y }
C {devices/lab_pin.sym} 77060 -37810 0 0 {name=p76217 lab=_63310_/X }
C {devices/lab_pin.sym} 77060 -37770 0 0 {name=p76218 lab=_63345_/X }
C {devices/lab_pin.sym} 77220 -37810 0 1 {name=p76219 lab=_63346_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -37810 0 0 {name=X_63346_ }
C {devices/lab_pin.sym} 77050 -37670 0 0 {name=p76220 lab=_84951_/CLK }
C {devices/lab_pin.sym} 77050 -37650 0 0 {name=p76221 lab=_82180_/D }
C {devices/lab_pin.sym} 77230 -37670 0 1 {name=p76222 lab=_82180_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -37660 0 0 {name=X_82180_ }
C {devices/lab_pin.sym} 77100 -37530 0 0 {name=p76223 lab=_65515_/A }
C {devices/lab_pin.sym} 77180 -37530 0 1 {name=p76224 lab=_60558_/X }
C {sky130_stdcells/buf_2.sym} 77140 -37530 0 0 {name=X_60558_ }
C {devices/lab_pin.sym} 77060 -37430 0 0 {name=p76225 lab=_86225_/Q }
C {devices/lab_pin.sym} 77060 -37390 0 0 {name=p76226 lab=_50238_/X }
C {devices/lab_pin.sym} 77060 -37350 0 0 {name=p76227 lab=_50310_/Y }
C {devices/lab_pin.sym} 77220 -37390 0 1 {name=p76228 lab=_50311_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -37390 0 0 {name=X_50311_ }
C {devices/lab_pin.sym} 77050 -37250 0 0 {name=p76229 lab=_80792_/CLK }
C {devices/lab_pin.sym} 77050 -37230 0 0 {name=p76230 lab=_81131_/D }
C {devices/lab_pin.sym} 77230 -37250 0 1 {name=p76231 lab=_40710_/A }
C {sky130_stdcells/dfxtp_4.sym} 77140 -37240 0 0 {name=X_81131_ }
C {devices/lab_pin.sym} 77100 -37110 0 0 {name=p76232 lab=_66065_/A }
C {devices/lab_pin.sym} 77180 -37110 0 1 {name=p76233 lab=_66065_/X }
C {sky130_stdcells/buf_2.sym} 77140 -37110 0 0 {name=X_66065_ }
C {devices/lab_pin.sym} 77060 -37010 0 0 {name=p76234 lab=_51288_/Y }
C {devices/lab_pin.sym} 77060 -36970 0 0 {name=p76235 lab=_51289_/X }
C {devices/lab_pin.sym} 77060 -36930 0 0 {name=p76236 lab=_51290_/X }
C {devices/lab_pin.sym} 77220 -36970 0 1 {name=p76237 lab=_86039_/D }
C {sky130_stdcells/a21oi_4.sym} 77140 -36970 0 0 {name=X_51291_ }
C {devices/lab_pin.sym} 77060 -36850 0 0 {name=p76238 lab=_63275_/X }
C {devices/lab_pin.sym} 77060 -36810 0 0 {name=p76239 lab=_62987_/X }
C {devices/lab_pin.sym} 77060 -36770 0 0 {name=p76240 lab=_63276_/Y }
C {devices/lab_pin.sym} 77220 -36810 0 1 {name=p76241 lab=_84338_/D }
C {sky130_stdcells/a21oi_4.sym} 77140 -36810 0 0 {name=X_63277_ }
C {devices/lab_pin.sym} 77100 -36670 0 0 {name=p76242 lab=_60588_/A }
C {devices/lab_pin.sym} 77180 -36670 0 1 {name=p76243 lab=_60489_/X }
C {sky130_stdcells/buf_2.sym} 77140 -36670 0 0 {name=X_60489_ }
C {devices/lab_pin.sym} 77080 -36560 0 0 {name=p76244 lab=_64836_/A }
C {devices/lab_pin.sym} 77080 -36520 0 0 {name=p76245 lab=_86450_/Q }
C {devices/lab_pin.sym} 77200 -36540 0 1 {name=p76246 lab=_65016_/X }
C {sky130_stdcells/and2_4.sym} 77140 -36540 0 0 {name=X_65016_ }
C {devices/lab_pin.sym} 77100 -36410 0 0 {name=p76247 lab=_53112_/A }
C {devices/lab_pin.sym} 77180 -36410 0 1 {name=p76248 lab=_53048_/A }
C {sky130_stdcells/buf_2.sym} 77140 -36410 0 0 {name=X_53030_ }
C {devices/lab_pin.sym} 77100 -36290 0 0 {name=p76249 lab=_50473_/A }
C {devices/lab_pin.sym} 77180 -36290 0 1 {name=p76250 lab=_50768_/A }
C {sky130_stdcells/buf_2.sym} 77140 -36290 0 0 {name=X_50242_ }
C {devices/lab_pin.sym} 77100 -36170 0 0 {name=p76251 lab=_62532_/A }
C {devices/lab_pin.sym} 77180 -36170 0 1 {name=p76252 lab=_62319_/C }
C {sky130_stdcells/buf_2.sym} 77140 -36170 0 0 {name=X_62228_ }
C {devices/lab_pin.sym} 77050 -36050 0 0 {name=p76253 lab=_81061_/CLK }
C {devices/lab_pin.sym} 77050 -36030 0 0 {name=p76254 lab=_81094_/Q }
C {devices/lab_pin.sym} 77230 -36050 0 1 {name=p76255 lab=_81062_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -36040 0 0 {name=X_81062_ }
C {devices/lab_pin.sym} 77060 -35930 0 0 {name=p76256 lab=_80011_/Y }
C {devices/lab_pin.sym} 77060 -35890 0 0 {name=p76257 lab=_79992_/Y }
C {devices/lab_pin.sym} 77060 -35850 0 0 {name=p76258 lab=_80012_/X }
C {devices/lab_pin.sym} 77220 -35890 0 1 {name=p76259 lab=_80013_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -35890 0 0 {name=X_80013_ }
C {devices/lab_pin.sym} 77060 -35780 0 0 {name=p76260 lab=_73252_/A }
C {devices/lab_pin.sym} 77060 -35740 0 0 {name=p76261 lab=_68377_/X }
C {devices/lab_pin.sym} 77060 -35700 0 0 {name=p76262 lab=_66574_/X }
C {devices/lab_pin.sym} 77060 -35660 0 0 {name=p76263 lab=_69823_/Y }
C {devices/lab_pin.sym} 77220 -35720 0 1 {name=p76264 lab=_69824_/X }
C {sky130_stdcells/a211o_4.sym} 77140 -35720 0 0 {name=X_69824_ }
C {devices/lab_pin.sym} 77080 -35580 0 0 {name=p76265 lab=_50169_/A }
C {devices/lab_pin.sym} 77080 -35540 0 0 {name=p76266 lab=_49125_/X }
C {devices/lab_pin.sym} 77200 -35560 0 1 {name=p76267 lab=_50173_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -35560 0 0 {name=X_50173_ }
C {devices/lab_pin.sym} 77060 -35470 0 0 {name=p76268 lab=_58207_/A }
C {devices/lab_pin.sym} 77060 -35430 0 0 {name=p76269 lab=_62105_/X }
C {devices/lab_pin.sym} 77060 -35390 0 0 {name=p76270 lab=_62065_/D }
C {devices/lab_pin.sym} 77060 -35350 0 0 {name=p76271 lab=_62055_/A }
C {devices/lab_pin.sym} 77060 -35320 0 0 {name=p76272 lab=_62158_/X }
C {devices/lab_pin.sym} 77220 -35390 0 1 {name=p76273 lab=_62159_/X }
C {sky130_stdcells/a41o_4.sym} 77140 -35390 0 0 {name=X_62159_ }
C {devices/lab_pin.sym} 77050 -35230 0 0 {name=p76274 lab=_86500_/CLK }
C {devices/lab_pin.sym} 77050 -35210 0 0 {name=p76275 lab=_85870_/D }
C {devices/lab_pin.sym} 77230 -35230 0 1 {name=p76276 lab=_85870_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -35220 0 0 {name=X_85870_ }
C {devices/lab_pin.sym} 77050 -35090 0 0 {name=p76277 lab=_84823_/CLK }
C {devices/lab_pin.sym} 77050 -35070 0 0 {name=p76278 lab=_84821_/D }
C {devices/lab_pin.sym} 77230 -35090 0 1 {name=p76279 lab=_84821_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -35080 0 0 {name=X_84821_ }
C {devices/lab_pin.sym} 77100 -34950 0 0 {name=p76280 lab=_69755_/A }
C {devices/lab_pin.sym} 77180 -34950 0 1 {name=p76281 lab=_69770_/A }
C {sky130_stdcells/buf_2.sym} 77140 -34950 0 0 {name=X_69755_ }
C {devices/lab_pin.sym} 77080 -34840 0 0 {name=p76282 lab=_54985_/A }
C {devices/lab_pin.sym} 77080 -34800 0 0 {name=p76283 lab=_47561_/Y }
C {devices/lab_pin.sym} 77200 -34820 0 1 {name=p76284 lab=_54981_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -34820 0 0 {name=X_54981_ }
C {devices/lab_pin.sym} 77060 -34720 0 0 {name=p76285 lab=_87119_/Q }
C {devices/lab_pin.sym} 77060 -34680 0 0 {name=p76286 lab=_66868_/X }
C {devices/lab_pin.sym} 77060 -34640 0 0 {name=p76287 lab=_66919_/X }
C {devices/lab_pin.sym} 77060 -34600 0 0 {name=p76288 lab=_66966_/X }
C {devices/lab_pin.sym} 77220 -34660 0 1 {name=p76289 lab=_66967_/X }
C {sky130_stdcells/a211o_4.sym} 77140 -34660 0 0 {name=X_66967_ }
C {devices/lab_pin.sym} 77100 -34510 0 0 {name=p76290 lab=_56682_/X }
C {devices/lab_pin.sym} 77180 -34510 0 1 {name=p76291 lab=_56721_/A }
C {sky130_stdcells/inv_2.sym} 77140 -34510 0 0 {name=X_56720_ }
C {devices/lab_pin.sym} 77060 -34410 0 0 {name=p76292 lab=_68703_/X }
C {devices/lab_pin.sym} 77060 -34370 0 0 {name=p76293 lab=_68705_/X }
C {devices/lab_pin.sym} 77060 -34330 0 0 {name=p76294 lab=_68684_/X }
C {devices/lab_pin.sym} 77220 -34370 0 1 {name=p76295 lab=_68706_/X }
C {sky130_stdcells/a21o_4.sym} 77140 -34370 0 0 {name=X_68706_ }
C {devices/lab_pin.sym} 77050 -34230 0 0 {name=p76296 lab=_87824_/CLK }
C {devices/lab_pin.sym} 77050 -34210 0 0 {name=p76297 lab=_43204_/Y }
C {devices/lab_pin.sym} 77230 -34230 0 1 {name=p76298 lab=_87540_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -34220 0 0 {name=X_87540_ }
C {devices/lab_pin.sym} 77080 -34100 0 0 {name=p76299 lab=_53951_/A }
C {devices/lab_pin.sym} 77080 -34060 0 0 {name=p76300 lab=_53932_/B }
C {devices/lab_pin.sym} 77200 -34080 0 1 {name=p76301 lab=_53932_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -34080 0 0 {name=X_53932_ }
C {devices/lab_pin.sym} 77080 -33970 0 0 {name=p76302 lab=_65446_/A }
C {devices/lab_pin.sym} 77080 -33930 0 0 {name=p76303 lab=_66195_/B }
C {devices/lab_pin.sym} 77080 -33890 0 0 {name=p76304 lab=_65445_/X }
C {devices/lab_pin.sym} 77200 -33930 0 1 {name=p76305 lab=_65928_/A }
C {sky130_stdcells/nand3_4.sym} 77140 -33930 0 0 {name=X_65918_ }
C {devices/lab_pin.sym} 77050 -33790 0 0 {name=p76306 lab=_86665_/CLK }
C {devices/lab_pin.sym} 77050 -33770 0 0 {name=p76307 lab=_84752_/D }
C {devices/lab_pin.sym} 77230 -33790 0 1 {name=p76308 lab=_84752_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -33780 0 0 {name=X_84752_ }
C {devices/lab_pin.sym} 77060 -33680 0 0 {name=p76309 lab=_43137_/A }
C {devices/lab_pin.sym} 77060 -33640 0 0 {name=p76310 lab=_69645_/X }
C {devices/lab_pin.sym} 77060 -33600 0 0 {name=p76311 lab=_68613_/X }
C {devices/lab_pin.sym} 77060 -33560 0 0 {name=p76312 lab=_69685_/X }
C {devices/lab_pin.sym} 77220 -33620 0 1 {name=p76313 lab=_69686_/X }
C {sky130_stdcells/a211o_4.sym} 77140 -33620 0 0 {name=X_69686_ }
C {devices/lab_pin.sym} 77050 -33470 0 0 {name=p76314 lab=_87345_/CLK }
C {devices/lab_pin.sym} 77050 -33450 0 0 {name=p76315 lab=_81964_/D }
C {devices/lab_pin.sym} 77230 -33470 0 1 {name=p76316 lab=_81964_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -33460 0 0 {name=X_81964_ }
C {devices/lab_pin.sym} 77100 -33330 0 0 {name=p76317 lab=_69156_/A }
C {devices/lab_pin.sym} 77180 -33330 0 1 {name=p76318 lab=_66898_/X }
C {sky130_stdcells/buf_2.sym} 77140 -33330 0 0 {name=X_66898_ }
C {devices/lab_pin.sym} 77050 -33210 0 0 {name=p76319 lab=_83703_/CLK }
C {devices/lab_pin.sym} 77050 -33190 0 0 {name=p76320 lab=_70776_/Y }
C {devices/lab_pin.sym} 77230 -33210 0 1 {name=p76321 lab=_47087_/A }
C {sky130_stdcells/dfxtp_4.sym} 77140 -33200 0 0 {name=X_83703_ }
C {devices/lab_pin.sym} 77080 -33080 0 0 {name=p76322 lab=_83337_/Q }
C {devices/lab_pin.sym} 77080 -33040 0 0 {name=p76323 lab=_83336_/Q }
C {devices/lab_pin.sym} 77200 -33060 0 1 {name=p76324 lab=_56651_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -33060 0 0 {name=X_56651_ }
C {devices/lab_pin.sym} 77050 -32930 0 0 {name=p76325 lab=_81507_/CLK }
C {devices/lab_pin.sym} 77050 -32910 0 0 {name=p76326 lab=_80915_/D }
C {devices/lab_pin.sym} 77230 -32930 0 1 {name=p76327 lab=_80915_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -32920 0 0 {name=X_80915_ }
C {devices/lab_pin.sym} 77100 -32790 0 0 {name=p76328 lab=_68637_/A }
C {devices/lab_pin.sym} 77180 -32790 0 1 {name=p76329 lab=_69086_/A }
C {sky130_stdcells/buf_2.sym} 77140 -32790 0 0 {name=X_68637_ }
C {devices/lab_pin.sym} 77050 -32670 0 0 {name=p76330 lab=_87471_/CLK }
C {devices/lab_pin.sym} 77050 -32650 0 0 {name=p76331 lab=_43340_/X }
C {devices/lab_pin.sym} 77230 -32670 0 1 {name=p76332 lab=_87471_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -32660 0 0 {name=X_87471_ }
C {devices/lab_pin.sym} 77080 -32540 0 0 {name=p76333 lab=_53863_/A }
C {devices/lab_pin.sym} 77080 -32500 0 0 {name=p76334 lab=_53821_/B }
C {devices/lab_pin.sym} 77200 -32520 0 1 {name=p76335 lab=_53863_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -32520 0 0 {name=X_53863_ }
C {devices/lab_pin.sym} 77060 -32420 0 0 {name=p76336 lab=_65717_/X }
C {devices/lab_pin.sym} 77060 -32380 0 0 {name=p76337 lab=_85573_/Q }
C {devices/lab_pin.sym} 77060 -32340 0 0 {name=p76338 lab=_65718_/X }
C {devices/lab_pin.sym} 77060 -32300 0 0 {name=p76339 lab=_65848_/X }
C {devices/lab_pin.sym} 77220 -32360 0 1 {name=p76340 lab=_65849_/X }
C {sky130_stdcells/a211o_4.sym} 77140 -32360 0 0 {name=X_65849_ }
C {devices/lab_pin.sym} 77050 -32210 0 0 {name=p76341 lab=_84713_/CLK }
C {devices/lab_pin.sym} 77050 -32190 0 0 {name=p76342 lab=_59871_/Y }
C {devices/lab_pin.sym} 77230 -32210 0 1 {name=p76343 lab=_80277_/B }
C {sky130_stdcells/dfxtp_4.sym} 77140 -32200 0 0 {name=X_84683_ }
C {devices/lab_pin.sym} 77050 -32070 0 0 {name=p76344 lab=_82015_/CLK }
C {devices/lab_pin.sym} 77050 -32050 0 0 {name=p76345 lab=_81895_/D }
C {devices/lab_pin.sym} 77230 -32070 0 1 {name=p76346 lab=_77217_/B }
C {sky130_stdcells/dfxtp_4.sym} 77140 -32060 0 0 {name=X_81895_ }
C {devices/lab_pin.sym} 77100 -31930 0 0 {name=p76347 lab=_55601_/X }
C {devices/lab_pin.sym} 77180 -31930 0 1 {name=p76348 lab=_72641_/C }
C {sky130_stdcells/buf_2.sym} 77140 -31930 0 0 {name=X_55602_ }
C {devices/lab_pin.sym} 77050 -31810 0 0 {name=p76349 lab=_86422_/CLK }
C {devices/lab_pin.sym} 77050 -31790 0 0 {name=p76350 lab=_49264_/Y }
C {devices/lab_pin.sym} 77230 -31810 0 1 {name=p76351 lab=_86422_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -31800 0 0 {name=X_86422_ }
C {devices/lab_pin.sym} 77060 -31690 0 0 {name=p76352 lab=_85749_/Q }
C {devices/lab_pin.sym} 77060 -31650 0 0 {name=p76353 lab=_52792_/X }
C {devices/lab_pin.sym} 77060 -31610 0 0 {name=p76354 lab=_52813_/Y }
C {devices/lab_pin.sym} 77220 -31650 0 1 {name=p76355 lab=_52814_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -31650 0 0 {name=X_52814_ }
C {devices/lab_pin.sym} 77060 -31530 0 0 {name=p76356 lab=_59368_/X }
C {devices/lab_pin.sym} 77060 -31490 0 0 {name=p76357 lab=_86051_/Q }
C {devices/lab_pin.sym} 77060 -31450 0 0 {name=p76358 lab=_59369_/X }
C {devices/lab_pin.sym} 77220 -31490 0 1 {name=p76359 lab=_59370_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -31490 0 0 {name=X_59370_ }
C {devices/lab_pin.sym} 77050 -31350 0 0 {name=p76360 lab=_85514_/CLK }
C {devices/lab_pin.sym} 77050 -31330 0 0 {name=p76361 lab=_71009_/Y }
C {devices/lab_pin.sym} 77230 -31350 0 1 {name=p76362 lab=_83634_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -31340 0 0 {name=X_83634_ }
C {devices/lab_pin.sym} 77080 -31240 0 0 {name=p76363 lab=_56582_/A }
C {devices/lab_pin.sym} 77080 -31200 0 0 {name=p76364 lab=_55552_/X }
C {devices/lab_pin.sym} 77080 -31160 0 0 {name=p76365 lab=_55570_/D }
C {devices/lab_pin.sym} 77080 -31120 0 0 {name=p76366 lab=_72648_/C }
C {devices/lab_pin.sym} 77200 -31180 0 1 {name=p76367 lab=_56583_/B }
C {sky130_stdcells/nand4_4.sym} 77140 -31180 0 0 {name=X_56582_ }
C {devices/lab_pin.sym} 77050 -31030 0 0 {name=p76368 lab=_80792_/CLK }
C {devices/lab_pin.sym} 77050 -31010 0 0 {name=p76369 lab=_80878_/Q }
C {devices/lab_pin.sym} 77230 -31030 0 1 {name=p76370 lab=_74928_/B }
C {sky130_stdcells/dfxtp_4.sym} 77140 -31020 0 0 {name=X_80846_ }
C {devices/lab_pin.sym} 77060 -30920 0 0 {name=p76371 lab=_41914_/A }
C {devices/lab_pin.sym} 77060 -30880 0 0 {name=p76372 lab=_68069_/X }
C {devices/lab_pin.sym} 77060 -30840 0 0 {name=p76373 lab=_68439_/X }
C {devices/lab_pin.sym} 77060 -30800 0 0 {name=p76374 lab=_68567_/Y }
C {devices/lab_pin.sym} 77220 -30860 0 1 {name=p76375 lab=_68568_/X }
C {sky130_stdcells/a211o_4.sym} 77140 -30860 0 0 {name=X_68568_ }
C {devices/lab_pin.sym} 77080 -30720 0 0 {name=p76376 lab=_53825_/A }
C {devices/lab_pin.sym} 77080 -30680 0 0 {name=p76377 lab=_71970_/B }
C {devices/lab_pin.sym} 77200 -30700 0 1 {name=p76378 lab=_53794_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -30700 0 0 {name=X_53794_ }
C {devices/lab_pin.sym} 77060 -30590 0 0 {name=p76379 lab=_58310_/X }
C {devices/lab_pin.sym} 77060 -30550 0 0 {name=p76380 lab=_83455_/Q }
C {devices/lab_pin.sym} 77060 -30510 0 0 {name=p76381 lab=_58320_/Y }
C {devices/lab_pin.sym} 77220 -30550 0 1 {name=p76382 lab=_84879_/D }
C {sky130_stdcells/o21a_4.sym} 77140 -30550 0 0 {name=X_58321_ }
C {devices/lab_pin.sym} 77100 -30410 0 0 {name=p76383 lab=_55532_/X }
C {devices/lab_pin.sym} 77180 -30410 0 1 {name=p76384 lab=_55533_/X }
C {sky130_stdcells/buf_2.sym} 77140 -30410 0 0 {name=X_55533_ }
C {devices/lab_pin.sym} 77060 -30310 0 0 {name=p76385 lab=_67515_/X }
C {devices/lab_pin.sym} 77060 -30270 0 0 {name=p76386 lab=_67518_/X }
C {devices/lab_pin.sym} 77060 -30230 0 0 {name=p76387 lab=_67401_/X }
C {devices/lab_pin.sym} 77220 -30270 0 1 {name=p76388 lab=_67519_/Y }
C {sky130_stdcells/a21oi_4.sym} 77140 -30270 0 0 {name=X_67519_ }
C {devices/lab_pin.sym} 77050 -30130 0 0 {name=p76389 lab=_86353_/CLK }
C {devices/lab_pin.sym} 77050 -30110 0 0 {name=p76390 lab=_86353_/D }
C {devices/lab_pin.sym} 77230 -30130 0 1 {name=p76391 lab=_86353_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -30120 0 0 {name=X_86353_ }
C {devices/lab_pin.sym} 77060 -30010 0 0 {name=p76392 lab=_85762_/Q }
C {devices/lab_pin.sym} 77060 -29970 0 0 {name=p76393 lab=_52737_/X }
C {devices/lab_pin.sym} 77060 -29930 0 0 {name=p76394 lab=_52744_/Y }
C {devices/lab_pin.sym} 77220 -29970 0 1 {name=p76395 lab=_52745_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -29970 0 0 {name=X_52745_ }
C {devices/lab_pin.sym} 77050 -29830 0 0 {name=p76396 lab=_83311_/CLK }
C {devices/lab_pin.sym} 77050 -29810 0 0 {name=p76397 lab=_71229_/Y }
C {devices/lab_pin.sym} 77230 -29830 0 1 {name=p76398 lab=_48671_/A }
C {sky130_stdcells/dfxtp_4.sym} 77140 -29820 0 0 {name=X_83565_ }
C {devices/lab_pin.sym} 77050 -29690 0 0 {name=p76399 lab=_80776_/CLK }
C {devices/lab_pin.sym} 77050 -29670 0 0 {name=p76400 lab=_75629_/X }
C {devices/lab_pin.sym} 77230 -29690 0 1 {name=p76401 lab=_80777_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -29680 0 0 {name=X_80777_ }
C {devices/lab_pin.sym} 77060 -29580 0 0 {name=p76402 lab=_87002_/Q }
C {devices/lab_pin.sym} 77060 -29540 0 0 {name=p76403 lab=_68394_/X }
C {devices/lab_pin.sym} 77060 -29500 0 0 {name=p76404 lab=_68421_/X }
C {devices/lab_pin.sym} 77060 -29460 0 0 {name=p76405 lab=_68498_/X }
C {devices/lab_pin.sym} 77220 -29520 0 1 {name=p76406 lab=_68499_/X }
C {sky130_stdcells/a211o_4.sym} 77140 -29520 0 0 {name=X_68499_ }
C {devices/lab_pin.sym} 77050 -29370 0 0 {name=p76407 lab=_85241_/CLK }
C {devices/lab_pin.sym} 77050 -29350 0 0 {name=p76408 lab=_56057_/Y }
C {devices/lab_pin.sym} 77230 -29370 0 1 {name=p76409 lab=_55915_/B }
C {sky130_stdcells/dfxtp_4.sym} 77140 -29360 0 0 {name=X_85304_ }
C {devices/lab_pin.sym} 77080 -29250 0 0 {name=p76410 lab=_71823_/A }
C {devices/lab_pin.sym} 77080 -29210 0 0 {name=p76411 lab=_70700_/A }
C {devices/lab_pin.sym} 77080 -29170 0 0 {name=p76412 lab=_70700_/B }
C {devices/lab_pin.sym} 77200 -29210 0 1 {name=p76413 lab=_70530_/Y }
C {sky130_stdcells/nand3_4.sym} 77140 -29210 0 0 {name=X_70530_ }
C {devices/lab_pin.sym} 77060 -29090 0 0 {name=p76414 lab=_58171_/X }
C {devices/lab_pin.sym} 77060 -29050 0 0 {name=p76415 lab=_83449_/Q }
C {devices/lab_pin.sym} 77060 -29010 0 0 {name=p76416 lab=_58251_/Y }
C {devices/lab_pin.sym} 77220 -29050 0 1 {name=p76417 lab=_58252_/X }
C {sky130_stdcells/o21a_4.sym} 77140 -29050 0 0 {name=X_58252_ }
C {devices/lab_pin.sym} 77050 -28910 0 0 {name=p76418 lab=_82532_/CLK }
C {devices/lab_pin.sym} 77050 -28890 0 0 {name=p76419 lab=_82516_/D }
C {devices/lab_pin.sym} 77230 -28910 0 1 {name=p76420 lab=_78582_/A }
C {sky130_stdcells/dfxtp_4.sym} 77140 -28900 0 0 {name=X_82516_ }
C {devices/lab_pin.sym} 77080 -28780 0 0 {name=p76421 lab=_55826_/A }
C {devices/lab_pin.sym} 77080 -28740 0 0 {name=p76422 lab=_85140_/Q }
C {devices/lab_pin.sym} 77200 -28760 0 1 {name=p76423 lab=_55464_/X }
C {sky130_stdcells/and2_4.sym} 77140 -28760 0 0 {name=X_55464_ }
C {devices/lab_pin.sym} 77050 -28630 0 0 {name=p76424 lab=_86282_/CLK }
C {devices/lab_pin.sym} 77050 -28610 0 0 {name=p76425 lab=_86284_/D }
C {devices/lab_pin.sym} 77230 -28630 0 1 {name=p76426 lab=_72377_/B }
C {sky130_stdcells/dfxtp_4.sym} 77140 -28620 0 0 {name=X_86284_ }
C {devices/lab_pin.sym} 77100 -28490 0 0 {name=p76427 lab=clkbuf_9_281_0_CLK/X }
C {devices/lab_pin.sym} 77180 -28490 0 1 {name=p76428 lab=_88121_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 77140 -28490 0 0 {name=Xclkbuf_10_563_0_CLK }
C {devices/lab_pin.sym} 77060 -28390 0 0 {name=p76429 lab=_40577_/X }
C {devices/lab_pin.sym} 77060 -28350 0 0 {name=p76430 lab=_82863_/Q }
C {devices/lab_pin.sym} 77060 -28310 0 0 {name=p76431 lab=_40689_/X }
C {devices/lab_pin.sym} 77220 -28350 0 1 {name=p76432 lab=_40691_/A }
C {sky130_stdcells/o21a_4.sym} 77140 -28350 0 0 {name=X_40690_ }
C {devices/lab_pin.sym} 77060 -28230 0 0 {name=p76433 lab=_52672_/Y }
C {devices/lab_pin.sym} 77060 -28190 0 0 {name=p76434 lab=_52673_/X }
C {devices/lab_pin.sym} 77060 -28150 0 0 {name=p76435 lab=_52675_/X }
C {devices/lab_pin.sym} 77220 -28190 0 1 {name=p76436 lab=_52676_/Y }
C {sky130_stdcells/a21oi_4.sym} 77140 -28190 0 0 {name=X_52676_ }
C {devices/lab_pin.sym} 77050 -28050 0 0 {name=p76437 lab=_83495_/CLK }
C {devices/lab_pin.sym} 77050 -28030 0 0 {name=p76438 lab=_83496_/D }
C {devices/lab_pin.sym} 77230 -28050 0 1 {name=p76439 lab=_58151_/B }
C {sky130_stdcells/dfxtp_4.sym} 77140 -28040 0 0 {name=X_83496_ }
C {devices/lab_pin.sym} 77100 -27910 0 0 {name=p76440 lab=clkbuf_6_55_0_CLK/A }
C {devices/lab_pin.sym} 77180 -27910 0 1 {name=p76441 lab=clkbuf_6_54_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 77140 -27910 0 0 {name=Xclkbuf_6_54_0_CLK }
C {devices/lab_pin.sym} 77100 -27790 0 0 {name=p76442 lab=_57203_/A }
C {devices/lab_pin.sym} 77180 -27790 0 1 {name=p76443 lab=_85064_/D }
C {sky130_stdcells/inv_2.sym} 77140 -27790 0 0 {name=X_57203_ }
C {devices/lab_pin.sym} 77050 -27670 0 0 {name=p76444 lab=_87273_/CLK }
C {devices/lab_pin.sym} 77050 -27650 0 0 {name=p76445 lab=_42127_/X }
C {devices/lab_pin.sym} 77230 -27670 0 1 {name=p76446 lab=_88023_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -27660 0 0 {name=X_88023_ }
C {devices/lab_pin.sym} 77080 -27540 0 0 {name=p76447 lab=_54425_/A }
C {devices/lab_pin.sym} 77080 -27500 0 0 {name=p76448 lab=_52722_/B }
C {devices/lab_pin.sym} 77200 -27520 0 1 {name=p76449 lab=_54415_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -27520 0 0 {name=X_54415_ }
C {devices/lab_pin.sym} 77050 -27390 0 0 {name=p76450 lab=_85168_/CLK }
C {devices/lab_pin.sym} 77050 -27370 0 0 {name=p76451 lab=_85235_/D }
C {devices/lab_pin.sym} 77230 -27390 0 1 {name=p76452 lab=_55855_/B }
C {sky130_stdcells/dfxtp_4.sym} 77140 -27380 0 0 {name=X_85235_ }
C {devices/lab_pin.sym} 77080 -27260 0 0 {name=p76453 lab=_51627_/A }
C {devices/lab_pin.sym} 77080 -27220 0 0 {name=p76454 lab=_53153_/B }
C {devices/lab_pin.sym} 77200 -27240 0 1 {name=p76455 lab=_51627_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -27240 0 0 {name=X_51627_ }
C {devices/lab_pin.sym} 77100 -27110 0 0 {name=p76456 lab=_71462_/B }
C {devices/lab_pin.sym} 77180 -27110 0 1 {name=p76457 lab=_71483_/B }
C {sky130_stdcells/buf_2.sym} 77140 -27110 0 0 {name=X_70461_ }
C {devices/lab_pin.sym} 77100 -26990 0 0 {name=p76458 lab=_57665_/A }
C {devices/lab_pin.sym} 77180 -26990 0 1 {name=p76459 lab=_58184_/B }
C {sky130_stdcells/buf_2.sym} 77140 -26990 0 0 {name=X_58183_ }
C {devices/lab_pin.sym} 77050 -26870 0 0 {name=p76460 lab=_82822_/CLK }
C {devices/lab_pin.sym} 77050 -26850 0 0 {name=p76461 lab=_79139_/X }
C {devices/lab_pin.sym} 77230 -26870 0 1 {name=p76462 lab=_82447_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -26860 0 0 {name=X_82447_ }
C {devices/lab_pin.sym} 77080 -26760 0 0 {name=p76463 lab=_55296_/A }
C {devices/lab_pin.sym} 77080 -26720 0 0 {name=p76464 lab=_55293_/X }
C {devices/lab_pin.sym} 77080 -26680 0 0 {name=p76465 lab=_55162_/Y }
C {devices/lab_pin.sym} 77080 -26640 0 0 {name=p76466 lab=_55296_/B }
C {devices/lab_pin.sym} 77200 -26700 0 1 {name=p76467 lab=_55396_/B }
C {sky130_stdcells/and4_4.sym} 77140 -26700 0 0 {name=X_55395_ }
C {devices/lab_pin.sym} 77060 -26570 0 0 {name=p76468 lab=_59381_/X }
C {devices/lab_pin.sym} 77060 -26530 0 0 {name=p76469 lab=_85979_/Q }
C {devices/lab_pin.sym} 77060 -26490 0 0 {name=p76470 lab=_72199_/X }
C {devices/lab_pin.sym} 77220 -26530 0 1 {name=p76471 lab=_72200_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -26530 0 0 {name=X_72200_ }
C {devices/lab_pin.sym} 77100 -26390 0 0 {name=p76472 lab=_57133_/X }
C {devices/lab_pin.sym} 77180 -26390 0 1 {name=p76473 lab=_57134_/Y }
C {sky130_stdcells/inv_2.sym} 77140 -26390 0 0 {name=X_57134_ }
C {devices/lab_pin.sym} 77100 -26270 0 0 {name=p76474 lab=_42360_/A }
C {devices/lab_pin.sym} 77180 -26270 0 1 {name=p76475 lab=_42360_/Y }
C {sky130_stdcells/inv_2.sym} 77140 -26270 0 0 {name=X_42360_ }
C {devices/lab_pin.sym} 77100 -26150 0 0 {name=p76476 lab=_54317_/A }
C {devices/lab_pin.sym} 77180 -26150 0 1 {name=p76477 lab=_54362_/C }
C {sky130_stdcells/buf_2.sym} 77140 -26150 0 0 {name=X_54346_ }
C {devices/lab_pin.sym} 77060 -26050 0 0 {name=p76478 lab=_73173_/Y }
C {devices/lab_pin.sym} 77060 -26010 0 0 {name=p76479 lab=_73174_/Y }
C {devices/lab_pin.sym} 77060 -25970 0 0 {name=p76480 lab=_73179_/X }
C {devices/lab_pin.sym} 77220 -26010 0 1 {name=p76481 lab=_73180_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -26010 0 0 {name=X_73180_ }
C {devices/lab_pin.sym} 77050 -25870 0 0 {name=p76482 lab=_85198_/CLK }
C {devices/lab_pin.sym} 77050 -25850 0 0 {name=p76483 lab=_85166_/D }
C {devices/lab_pin.sym} 77230 -25870 0 1 {name=p76484 lab=_55814_/B }
C {sky130_stdcells/dfxtp_4.sym} 77140 -25860 0 0 {name=X_85166_ }
C {devices/lab_pin.sym} 77100 -25730 0 0 {name=p76485 lab=_51504_/A }
C {devices/lab_pin.sym} 77180 -25730 0 1 {name=p76486 lab=_51580_/B }
C {sky130_stdcells/buf_2.sym} 77140 -25730 0 0 {name=X_51558_ }
C {devices/lab_pin.sym} 77100 -25610 0 0 {name=p76487 lab=_70944_/A }
C {devices/lab_pin.sym} 77180 -25610 0 1 {name=p76488 lab=_70942_/A }
C {sky130_stdcells/buf_2.sym} 77140 -25610 0 0 {name=X_70392_ }
C {devices/lab_pin.sym} 77050 -25490 0 0 {name=p76489 lab=_86054_/CLK }
C {devices/lab_pin.sym} 77050 -25470 0 0 {name=p76490 lab=_82186_/Q }
C {devices/lab_pin.sym} 77230 -25490 0 1 {name=p76491 lab=_82378_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -25480 0 0 {name=X_82378_ }
C {devices/lab_pin.sym} 77060 -25370 0 0 {name=p76492 lab=_41290_/X }
C {devices/lab_pin.sym} 77060 -25330 0 0 {name=p76493 lab=_82908_/Q }
C {devices/lab_pin.sym} 77060 -25290 0 0 {name=p76494 lab=_41310_/X }
C {devices/lab_pin.sym} 77220 -25330 0 1 {name=p76495 lab=_41311_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -25330 0 0 {name=X_41311_ }
C {devices/lab_pin.sym} 77060 -25210 0 0 {name=p76496 lab=_59346_/X }
C {devices/lab_pin.sym} 77060 -25170 0 0 {name=p76497 lab=_85344_/Q }
C {devices/lab_pin.sym} 77060 -25130 0 0 {name=p76498 lab=_72120_/X }
C {devices/lab_pin.sym} 77220 -25170 0 1 {name=p76499 lab=_72131_/X }
C {sky130_stdcells/o21a_4.sym} 77140 -25170 0 0 {name=X_72131_ }
C {devices/lab_pin.sym} 77050 -25030 0 0 {name=p76500 lab=_84111_/CLK }
C {devices/lab_pin.sym} 77050 -25010 0 0 {name=p76501 lab=_84117_/D }
C {devices/lab_pin.sym} 77230 -25030 0 1 {name=p76502 lab=_66469_/C }
C {sky130_stdcells/dfxtp_4.sym} 77140 -25020 0 0 {name=X_84117_ }
C {devices/lab_pin.sym} 77060 -24910 0 0 {name=p76503 lab=_86187_/Q }
C {devices/lab_pin.sym} 77060 -24870 0 0 {name=p76504 lab=_50506_/X }
C {devices/lab_pin.sym} 77060 -24830 0 0 {name=p76505 lab=_50508_/Y }
C {devices/lab_pin.sym} 77220 -24870 0 1 {name=p76506 lab=_50509_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -24870 0 0 {name=X_50509_ }
C {devices/lab_pin.sym} 77100 -24730 0 0 {name=p76507 lab=clkbuf_9_289_0_CLK/X }
C {devices/lab_pin.sym} 77180 -24730 0 1 {name=p76508 lab=_80754_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 77140 -24730 0 0 {name=Xclkbuf_10_578_0_CLK }
C {devices/lab_pin.sym} 77050 -24610 0 0 {name=p76509 lab=_81492_/CLK }
C {devices/lab_pin.sym} 77050 -24590 0 0 {name=p76510 lab=_76375_/X }
C {devices/lab_pin.sym} 77230 -24610 0 1 {name=p76511 lab=_75976_/A }
C {sky130_stdcells/dfxtp_4.sym} 77140 -24600 0 0 {name=X_81329_ }
C {devices/lab_pin.sym} 77060 -24490 0 0 {name=p76512 lab=_56966_/X }
C {devices/lab_pin.sym} 77060 -24450 0 0 {name=p76513 lab=_57063_/Y }
C {devices/lab_pin.sym} 77060 -24410 0 0 {name=p76514 lab=_57064_/Y }
C {devices/lab_pin.sym} 77220 -24450 0 1 {name=p76515 lab=_57065_/X }
C {sky130_stdcells/a21o_4.sym} 77140 -24450 0 0 {name=X_57065_ }
C {devices/lab_pin.sym} 77100 -24310 0 0 {name=p76516 lab=_42259_/A }
C {devices/lab_pin.sym} 77180 -24310 0 1 {name=p76517 lab=_42291_/X }
C {sky130_stdcells/buf_2.sym} 77140 -24310 0 0 {name=X_42291_ }
C {devices/lab_pin.sym} 77080 -24200 0 0 {name=p76518 lab=_54288_/A }
C {devices/lab_pin.sym} 77080 -24160 0 0 {name=p76519 lab=_54277_/B }
C {devices/lab_pin.sym} 77200 -24180 0 1 {name=p76520 lab=_54277_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -24180 0 0 {name=X_54277_ }
C {devices/lab_pin.sym} 77050 -24050 0 0 {name=p76521 lab=_85096_/CLK }
C {devices/lab_pin.sym} 77050 -24030 0 0 {name=p76522 lab=_85097_/D }
C {devices/lab_pin.sym} 77230 -24050 0 1 {name=p76523 lab=_57039_/A }
C {sky130_stdcells/dfxtp_4.sym} 77140 -24040 0 0 {name=X_85097_ }
C {devices/lab_pin.sym} 77080 -23940 0 0 {name=p76524 lab=_51473_/A }
C {devices/lab_pin.sym} 77080 -23900 0 0 {name=p76525 lab=_51494_/B }
C {devices/lab_pin.sym} 77080 -23860 0 0 {name=p76526 lab=_51494_/C }
C {devices/lab_pin.sym} 77080 -23820 0 0 {name=p76527 lab=_53015_/D }
C {devices/lab_pin.sym} 77200 -23880 0 1 {name=p76528 lab=_51489_/X }
C {sky130_stdcells/and4_4.sym} 77140 -23880 0 0 {name=X_51489_ }
C {devices/lab_pin.sym} 77100 -23730 0 0 {name=p76529 lab=_57848_/A }
C {devices/lab_pin.sym} 77180 -23730 0 1 {name=p76530 lab=_72255_/A }
C {sky130_stdcells/buf_2.sym} 77140 -23730 0 0 {name=X_44030_ }
C {devices/lab_pin.sym} 77100 -23610 0 0 {name=p76531 lab=_56016_/A }
C {devices/lab_pin.sym} 77180 -23610 0 1 {name=p76532 lab=_56016_/X }
C {sky130_stdcells/buf_2.sym} 77140 -23610 0 0 {name=X_56016_ }
C {devices/lab_pin.sym} 77100 -23490 0 0 {name=p76533 lab=_41072_/X }
C {devices/lab_pin.sym} 77180 -23490 0 1 {name=p76534 lab=_41242_/X }
C {sky130_stdcells/buf_2.sym} 77140 -23490 0 0 {name=X_41242_ }
C {devices/lab_pin.sym} 77060 -23390 0 0 {name=p76535 lab=_85673_/Q }
C {devices/lab_pin.sym} 77060 -23350 0 0 {name=p76536 lab=_53225_/X }
C {devices/lab_pin.sym} 77060 -23310 0 0 {name=p76537 lab=_53227_/Y }
C {devices/lab_pin.sym} 77220 -23350 0 1 {name=p76538 lab=_53228_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -23350 0 0 {name=X_53228_ }
C {devices/lab_pin.sym} 77080 -23220 0 0 {name=p76539 lab=_72040_/A }
C {devices/lab_pin.sym} 77080 -23180 0 0 {name=p76540 lab=_53886_/B }
C {devices/lab_pin.sym} 77200 -23200 0 1 {name=p76541 lab=_72062_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -23200 0 0 {name=X_72062_ }
C {devices/lab_pin.sym} 77050 -23070 0 0 {name=p76542 lab=_88116_/CLK }
C {devices/lab_pin.sym} 77050 -23050 0 0 {name=p76543 lab=_67947_/X }
C {devices/lab_pin.sym} 77230 -23070 0 1 {name=p76544 lab=_84048_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -23060 0 0 {name=X_84048_ }
C {devices/lab_pin.sym} 77100 -22930 0 0 {name=p76545 lab=_71013_/A }
C {devices/lab_pin.sym} 77180 -22930 0 1 {name=p76546 lab=_71013_/X }
C {sky130_stdcells/buf_2.sym} 77140 -22930 0 0 {name=X_71013_ }
C {devices/lab_pin.sym} 77080 -22840 0 0 {name=p76547 lab=_53139_/A }
C {devices/lab_pin.sym} 77080 -22800 0 0 {name=p76548 lab=_53159_/B }
C {devices/lab_pin.sym} 77080 -22760 0 0 {name=p76549 lab=_53143_/X }
C {devices/lab_pin.sym} 77080 -22720 0 0 {name=p76550 lab=_53159_/D }
C {devices/lab_pin.sym} 77200 -22780 0 1 {name=p76551 lab=_53159_/X }
C {sky130_stdcells/and4_4.sym} 77140 -22780 0 0 {name=X_53159_ }
C {devices/lab_pin.sym} 77060 -22650 0 0 {name=p76552 lab=_41136_/X }
C {devices/lab_pin.sym} 77060 -22610 0 0 {name=p76553 lab=_40654_/A }
C {devices/lab_pin.sym} 77060 -22570 0 0 {name=p76554 lab=_41172_/X }
C {devices/lab_pin.sym} 77220 -22610 0 1 {name=p76555 lab=_41173_/X }
C {sky130_stdcells/o21a_4.sym} 77140 -22610 0 0 {name=X_41173_ }
C {devices/lab_pin.sym} 77060 -22490 0 0 {name=p76556 lab=_76866_/Y }
C {devices/lab_pin.sym} 77060 -22450 0 0 {name=p76557 lab=_76854_/B }
C {devices/lab_pin.sym} 77060 -22410 0 0 {name=p76558 lab=_76869_/Y }
C {devices/lab_pin.sym} 77220 -22450 0 1 {name=p76559 lab=_76870_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -22450 0 0 {name=X_76870_ }
C {devices/lab_pin.sym} 77100 -22310 0 0 {name=p76560 lab=clkbuf_9_250_0_CLK/X }
C {devices/lab_pin.sym} 77180 -22310 0 1 {name=p76561 lab=_85778_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 77140 -22310 0 0 {name=Xclkbuf_10_501_0_CLK }
C {devices/lab_pin.sym} 77080 -22200 0 0 {name=p76562 lab=_75821_/A }
C {devices/lab_pin.sym} 77080 -22160 0 0 {name=p76563 lab=_75821_/B }
C {devices/lab_pin.sym} 77200 -22180 0 1 {name=p76564 lab=_75823_/C }
C {sky130_stdcells/nor2_4.sym} 77140 -22180 0 0 {name=X_75821_ }
C {devices/lab_pin.sym} 77050 -22050 0 0 {name=p76565 lab=_87553_/CLK }
C {devices/lab_pin.sym} 77050 -22030 0 0 {name=p76566 lab=_42599_/Y }
C {devices/lab_pin.sym} 77230 -22050 0 1 {name=p76567 lab=_87807_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -22040 0 0 {name=X_87807_ }
C {devices/lab_pin.sym} 77100 -21910 0 0 {name=p76568 lab=_43756_/A }
C {devices/lab_pin.sym} 77180 -21910 0 1 {name=p76569 lab=_45981_/X }
C {sky130_stdcells/buf_2.sym} 77140 -21910 0 0 {name=X_45981_ }
C {devices/lab_pin.sym} 77060 -21810 0 0 {name=p76570 lab=_57966_/X }
C {devices/lab_pin.sym} 77060 -21770 0 0 {name=p76571 lab=_85712_/Q }
C {devices/lab_pin.sym} 77060 -21730 0 0 {name=p76572 lab=_57878_/X }
C {devices/lab_pin.sym} 77220 -21770 0 1 {name=p76573 lab=_57967_/X }
C {sky130_stdcells/o21a_4.sym} 77140 -21770 0 0 {name=X_57967_ }
C {devices/lab_pin.sym} 77050 -21630 0 0 {name=p76574 lab=_85712_/CLK }
C {devices/lab_pin.sym} 77050 -21610 0 0 {name=p76575 lab=_85999_/D }
C {devices/lab_pin.sym} 77230 -21630 0 1 {name=p76576 lab=_85999_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -21620 0 0 {name=X_85999_ }
C {devices/lab_pin.sym} 77100 -21490 0 0 {name=p76577 lab=_49379_/A }
C {devices/lab_pin.sym} 77180 -21490 0 1 {name=p76578 lab=_47758_/A }
C {sky130_stdcells/buf_2.sym} 77140 -21490 0 0 {name=X_47720_ }
C {devices/lab_pin.sym} 77100 -21370 0 0 {name=p76579 lab=_59705_/X }
C {devices/lab_pin.sym} 77180 -21370 0 1 {name=p76580 lab=_63001_/A }
C {sky130_stdcells/buf_2.sym} 77140 -21370 0 0 {name=X_59706_ }
C {devices/lab_pin.sym} 77060 -21270 0 0 {name=p76581 lab=_78503_/Y }
C {devices/lab_pin.sym} 77060 -21230 0 0 {name=p76582 lab=_78505_/X }
C {devices/lab_pin.sym} 77060 -21190 0 0 {name=p76583 lab=_78528_/X }
C {devices/lab_pin.sym} 77220 -21230 0 1 {name=p76584 lab=_78540_/X }
C {sky130_stdcells/a21bo_4.sym} 77140 -21230 0 0 {name=X_78540_ }
C {devices/lab_pin.sym} 77100 -21090 0 0 {name=p76585 lab=_44932_/A }
C {devices/lab_pin.sym} 77180 -21090 0 1 {name=p76586 lab=_45252_/A }
C {sky130_stdcells/buf_2.sym} 77140 -21090 0 0 {name=X_44932_ }
C {devices/lab_pin.sym} 77100 -20970 0 0 {name=p76587 lab=_56877_/X }
C {devices/lab_pin.sym} 77180 -20970 0 1 {name=p76588 lab=_57193_/D }
C {sky130_stdcells/buf_2.sym} 77140 -20970 0 0 {name=X_56918_ }
C {devices/lab_pin.sym} 77080 -20860 0 0 {name=p76589 lab=_75735_/A }
C {devices/lab_pin.sym} 77080 -20820 0 0 {name=p76590 lab=_75747_/A }
C {devices/lab_pin.sym} 77200 -20840 0 1 {name=p76591 lab=_75752_/X }
C {sky130_stdcells/and2_4.sym} 77140 -20840 0 0 {name=X_75752_ }
C {devices/lab_pin.sym} 77050 -20710 0 0 {name=p76592 lab=_88002_/CLK }
C {devices/lab_pin.sym} 77050 -20690 0 0 {name=p76593 lab=_42753_/X }
C {devices/lab_pin.sym} 77230 -20710 0 1 {name=p76594 lab=_68977_/B }
C {sky130_stdcells/dfxtp_4.sym} 77140 -20700 0 0 {name=X_87738_ }
C {devices/lab_pin.sym} 77080 -20580 0 0 {name=p76595 lab=_72816_/X }
C {devices/lab_pin.sym} 77080 -20540 0 0 {name=p76596 lab=_86522_/Q }
C {devices/lab_pin.sym} 77200 -20560 0 1 {name=p76597 lab=_72964_/X }
C {sky130_stdcells/and2_4.sym} 77140 -20560 0 0 {name=X_72964_ }
C {devices/lab_pin.sym} 77080 -20440 0 0 {name=p76598 lab=_86645_/Q }
C {devices/lab_pin.sym} 77080 -20400 0 0 {name=p76599 lab=_57845_/X }
C {devices/lab_pin.sym} 77200 -20420 0 1 {name=p76600 lab=_57898_/Y }
C {sky130_stdcells/nor2_4.sym} 77140 -20420 0 0 {name=X_57898_ }
C {devices/lab_pin.sym} 77060 -20310 0 0 {name=p76601 lab=_74642_/X }
C {devices/lab_pin.sym} 77060 -20270 0 0 {name=p76602 lab=_56917_/A }
C {devices/lab_pin.sym} 77060 -20230 0 0 {name=p76603 lab=_74702_/Y }
C {devices/lab_pin.sym} 77220 -20270 0 1 {name=p76604 lab=_74704_/A }
C {sky130_stdcells/o21ai_4.sym} 77140 -20270 0 0 {name=X_74703_ }
C {devices/lab_pin.sym} 77100 -20130 0 0 {name=p76605 lab=_47745_/A }
C {devices/lab_pin.sym} 77180 -20130 0 1 {name=p76606 lab=_47651_/X }
C {sky130_stdcells/buf_2.sym} 77140 -20130 0 0 {name=X_47651_ }
C {devices/lab_pin.sym} 77060 -20030 0 0 {name=p76607 lab=_71912_/Y }
C {devices/lab_pin.sym} 77060 -19990 0 0 {name=p76608 lab=_56922_/X }
C {devices/lab_pin.sym} 77060 -19950 0 0 {name=p76609 lab=_71914_/Y }
C {devices/lab_pin.sym} 77220 -19990 0 1 {name=p76610 lab=_71915_/X }
C {sky130_stdcells/a21o_4.sym} 77140 -19990 0 0 {name=X_71915_ }
C {devices/lab_pin.sym} 77080 -19870 0 0 {name=p76611 lab=_59637_/A }
C {devices/lab_pin.sym} 77080 -19830 0 0 {name=p76612 lab=_59648_/A }
C {devices/lab_pin.sym} 77080 -19790 0 0 {name=p76613 lab=_59806_/A }
C {devices/lab_pin.sym} 77200 -19830 0 1 {name=p76614 lab=_59638_/A }
C {sky130_stdcells/nor3_4.sym} 77140 -19830 0 0 {name=X_59637_ }
C {devices/lab_pin.sym} 77100 -19690 0 0 {name=p76615 lab=clkbuf_9_258_0_CLK/X }
C {devices/lab_pin.sym} 77180 -19690 0 1 {name=p76616 lab=_83926_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 77140 -19690 0 0 {name=Xclkbuf_10_516_0_CLK }
C {devices/lab_pin.sym} 77100 -19570 0 0 {name=p76617 lab=_82798_/Q }
C {devices/lab_pin.sym} 77180 -19570 0 1 {name=p76618 lab=_78473_/A }
C {sky130_stdcells/inv_2.sym} 77140 -19570 0 0 {name=X_78471_ }
C {devices/lab_pin.sym} 77060 -19490 0 0 {name=p76619 lab=_44857_/X }
C {devices/lab_pin.sym} 77060 -19450 0 0 {name=p76620 lab=_44844_/X }
C {devices/lab_pin.sym} 77060 -19410 0 0 {name=p76621 lab=_41785_/X }
C {devices/lab_pin.sym} 77060 -19370 0 0 {name=p76622 lab=_68054_/B }
C {devices/lab_pin.sym} 77060 -19330 0 0 {name=p76623 lab=_44858_/X }
C {devices/lab_pin.sym} 77220 -19410 0 1 {name=p76624 lab=_44863_/Y }
C {sky130_stdcells/o32ai_4.sym} 77140 -19410 0 0 {name=X_44863_ }
C {devices/lab_pin.sym} 77100 -19250 0 0 {name=p76625 lab=_56676_/Y }
C {devices/lab_pin.sym} 77180 -19250 0 1 {name=p76626 lab=_56849_/X }
C {sky130_stdcells/buf_2.sym} 77140 -19250 0 0 {name=X_56849_ }
C {devices/lab_pin.sym} 77060 -19150 0 0 {name=p76627 lab=_80909_/Q }
C {devices/lab_pin.sym} 77060 -19110 0 0 {name=p76628 lab=_80781_/D }
C {devices/lab_pin.sym} 77060 -19070 0 0 {name=p76629 lab=_75682_/X }
C {devices/lab_pin.sym} 77220 -19110 0 1 {name=p76630 lab=_75684_/B }
C {sky130_stdcells/o21ai_4.sym} 77140 -19110 0 0 {name=X_75683_ }
C {devices/lab_pin.sym} 77050 -18970 0 0 {name=p76631 lab=_87671_/CLK }
C {devices/lab_pin.sym} 77050 -18950 0 0 {name=p76632 lab=_87669_/D }
C {devices/lab_pin.sym} 77230 -18970 0 1 {name=p76633 lab=_67294_/B }
C {sky130_stdcells/dfxtp_4.sym} 77140 -18960 0 0 {name=X_87669_ }
C {devices/lab_pin.sym} 77100 -18830 0 0 {name=p76634 lab=_72894_/X }
C {devices/lab_pin.sym} 77180 -18830 0 1 {name=p76635 lab=_72895_/X }
C {sky130_stdcells/buf_2.sym} 77140 -18830 0 0 {name=X_72895_ }
C {devices/lab_pin.sym} 77100 -18710 0 0 {name=p76636 lab=_54091_/A }
C {devices/lab_pin.sym} 77180 -18710 0 1 {name=p76637 lab=_51396_/A }
C {sky130_stdcells/buf_2.sym} 77140 -18710 0 0 {name=X_46602_ }
C {devices/lab_pin.sym} 77100 -18590 0 0 {name=p76638 lab=_77422_/A }
C {devices/lab_pin.sym} 77180 -18590 0 1 {name=p76639 lab=_77422_/Y }
C {sky130_stdcells/inv_2.sym} 77140 -18590 0 0 {name=X_77422_ }
C {devices/lab_pin.sym} 77060 -18500 0 0 {name=p76640 lab=_41093_/X }
C {devices/lab_pin.sym} 77060 -18460 0 0 {name=p76641 lab=_43801_/X }
C {devices/lab_pin.sym} 77060 -18420 0 0 {name=p76642 lab=_69523_/B }
C {devices/lab_pin.sym} 77060 -18380 0 0 {name=p76643 lab=_43802_/X }
C {devices/lab_pin.sym} 77220 -18440 0 1 {name=p76644 lab=_87255_/D }
C {sky130_stdcells/a2bb2o_4.sym} 77140 -18440 0 0 {name=X_43814_ }
C {devices/lab_pin.sym} 77060 -18320 0 0 {name=p76645 lab=_45952_/X }
C {devices/lab_pin.sym} 77060 -18280 0 0 {name=p76646 lab=_56570_/Y }
C {devices/lab_pin.sym} 77060 -18240 0 0 {name=p76647 lab=_45416_/A }
C {devices/lab_pin.sym} 77060 -18200 0 0 {name=p76648 lab=_74633_/X }
C {devices/lab_pin.sym} 77220 -18260 0 1 {name=p76649 lab=_83008_/D }
C {sky130_stdcells/a2bb2o_4.sym} 77140 -18260 0 0 {name=X_74634_ }
C {devices/lab_pin.sym} 77100 -18110 0 0 {name=p76650 lab=_47582_/A }
C {devices/lab_pin.sym} 77180 -18110 0 1 {name=p76651 lab=_53131_/B }
C {sky130_stdcells/buf_2.sym} 77140 -18110 0 0 {name=X_47582_ }
C {devices/lab_pin.sym} 77080 -18010 0 0 {name=p76652 lab=_71846_/A }
C {devices/lab_pin.sym} 77080 -17970 0 0 {name=p76653 lab=_70882_/Y }
C {devices/lab_pin.sym} 77080 -17930 0 0 {name=p76654 lab=_70500_/D }
C {devices/lab_pin.sym} 77200 -17970 0 1 {name=p76655 lab=_71846_/Y }
C {sky130_stdcells/nor3_4.sym} 77140 -17970 0 0 {name=X_71846_ }
C {devices/lab_pin.sym} 77080 -17850 0 0 {name=p76656 lab=_59546_/A }
C {devices/lab_pin.sym} 77080 -17810 0 0 {name=p76657 lab=_43998_/A }
C {devices/lab_pin.sym} 77080 -17770 0 0 {name=p76658 lab=_59560_/A }
C {devices/lab_pin.sym} 77200 -17810 0 1 {name=p76659 lab=_59568_/X }
C {sky130_stdcells/and3_4.sym} 77140 -17810 0 0 {name=X_59568_ }
C {devices/lab_pin.sym} 77100 -17670 0 0 {name=p76660 lab=_44794_/A }
C {devices/lab_pin.sym} 77180 -17670 0 1 {name=p76661 lab=_86952_/D }
C {sky130_stdcells/inv_2.sym} 77140 -17670 0 0 {name=X_44794_ }
C {devices/lab_pin.sym} 77060 -17570 0 0 {name=p76662 lab=_86410_/Q }
C {devices/lab_pin.sym} 77060 -17530 0 0 {name=p76663 lab=_49285_/X }
C {devices/lab_pin.sym} 77060 -17490 0 0 {name=p76664 lab=_49320_/Y }
C {devices/lab_pin.sym} 77220 -17530 0 1 {name=p76665 lab=_49321_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -17530 0 0 {name=X_49321_ }
C {devices/lab_pin.sym} 77100 -17390 0 0 {name=p76666 lab=_83784_/Q }
C {devices/lab_pin.sym} 77180 -17390 0 1 {name=p76667 lab=_52545_/B }
C {sky130_stdcells/inv_2.sym} 77140 -17390 0 0 {name=X_46533_ }
C {devices/lab_pin.sym} 77100 -17270 0 0 {name=p76668 lab=_84829_/Q }
C {devices/lab_pin.sym} 77180 -17270 0 1 {name=p76669 lab=_58520_/A }
C {sky130_stdcells/buf_2.sym} 77140 -17270 0 0 {name=X_58519_ }
C {devices/lab_pin.sym} 77080 -17160 0 0 {name=p76670 lab=_77353_/A }
C {devices/lab_pin.sym} 77080 -17120 0 0 {name=p76671 lab=_82091_/D }
C {devices/lab_pin.sym} 77200 -17140 0 1 {name=p76672 lab=_77354_/B }
C {sky130_stdcells/xor2_4.sym} 77140 -17140 0 0 {name=X_77353_ }
C {devices/lab_pin.sym} 77060 -17040 0 0 {name=p76673 lab=_40913_/X }
C {devices/lab_pin.sym} 77060 -17000 0 0 {name=p76674 lab=_47846_/A }
C {devices/lab_pin.sym} 77060 -16960 0 0 {name=p76675 lab=_69932_/B }
C {devices/lab_pin.sym} 77060 -16920 0 0 {name=p76676 lab=_43607_/A }
C {devices/lab_pin.sym} 77220 -16980 0 1 {name=p76677 lab=_43745_/X }
C {sky130_stdcells/a2bb2o_4.sym} 77140 -16980 0 0 {name=X_43745_ }
C {devices/lab_pin.sym} 77060 -16850 0 0 {name=p76678 lab=_56050_/X }
C {devices/lab_pin.sym} 77060 -16810 0 0 {name=p76679 lab=_74625_/A }
C {devices/lab_pin.sym} 77060 -16770 0 0 {name=p76680 lab=_74564_/Y }
C {devices/lab_pin.sym} 77220 -16810 0 1 {name=p76681 lab=_83033_/D }
C {sky130_stdcells/a21boi_4.sym} 77140 -16810 0 0 {name=X_74565_ }
C {devices/lab_pin.sym} 77080 -16680 0 0 {name=p76682 lab=_82301_/Q }
C {devices/lab_pin.sym} 77080 -16640 0 0 {name=p76683 lab=_40970_/B }
C {devices/lab_pin.sym} 77200 -16660 0 1 {name=p76684 lab=_40957_/X }
C {sky130_stdcells/or2_4.sym} 77140 -16660 0 0 {name=X_40957_ }
C {devices/lab_pin.sym} 77080 -16550 0 0 {name=p76685 lab=_71779_/A }
C {devices/lab_pin.sym} 77080 -16510 0 0 {name=p76686 lab=_71777_/B }
C {devices/lab_pin.sym} 77080 -16470 0 0 {name=p76687 lab=_70986_/A }
C {devices/lab_pin.sym} 77200 -16510 0 1 {name=p76688 lab=_71777_/X }
C {sky130_stdcells/and3_4.sym} 77140 -16510 0 0 {name=X_71777_ }
C {devices/lab_pin.sym} 77060 -16390 0 0 {name=p76689 lab=_46179_/X }
C {devices/lab_pin.sym} 77060 -16350 0 0 {name=p76690 lab=_63424_/B }
C {devices/lab_pin.sym} 77060 -16310 0 0 {name=p76691 lab=_59498_/Y }
C {devices/lab_pin.sym} 77220 -16350 0 1 {name=p76692 lab=_84716_/D }
C {sky130_stdcells/o21a_4.sym} 77140 -16350 0 0 {name=X_59499_ }
C {devices/lab_pin.sym} 77080 -16230 0 0 {name=p76693 lab=_76300_/Y }
C {devices/lab_pin.sym} 77080 -16190 0 0 {name=p76694 lab=_76301_/Y }
C {devices/lab_pin.sym} 77080 -16150 0 0 {name=p76695 lab=_76303_/Y }
C {devices/lab_pin.sym} 77200 -16190 0 1 {name=p76696 lab=_76306_/A }
C {sky130_stdcells/or3_4.sym} 77140 -16190 0 0 {name=X_76304_ }
C {devices/lab_pin.sym} 77100 -16050 0 0 {name=p76697 lab=_61317_/A }
C {devices/lab_pin.sym} 77180 -16050 0 1 {name=p76698 lab=_61563_/C }
C {sky130_stdcells/buf_2.sym} 77140 -16050 0 0 {name=X_61530_ }
C {devices/lab_pin.sym} 77060 -15950 0 0 {name=p76699 lab=_86424_/Q }
C {devices/lab_pin.sym} 77060 -15910 0 0 {name=p76700 lab=_49222_/X }
C {devices/lab_pin.sym} 77060 -15870 0 0 {name=p76701 lab=_49251_/Y }
C {devices/lab_pin.sym} 77220 -15910 0 1 {name=p76702 lab=_49252_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -15910 0 0 {name=X_49252_ }
C {devices/lab_pin.sym} 77080 -15780 0 0 {name=p76703 lab=_73516_/A }
C {devices/lab_pin.sym} 77080 -15740 0 0 {name=p76704 lab=_86467_/Q }
C {devices/lab_pin.sym} 77200 -15760 0 1 {name=p76705 lab=_73516_/X }
C {sky130_stdcells/and2_4.sym} 77140 -15760 0 0 {name=X_73516_ }
C {devices/lab_pin.sym} 77060 -15650 0 0 {name=p76706 lab=_52787_/B }
C {devices/lab_pin.sym} 77060 -15610 0 0 {name=p76707 lab=_70699_/A }
C {devices/lab_pin.sym} 77060 -15570 0 0 {name=p76708 lab=_70727_/Y }
C {devices/lab_pin.sym} 77220 -15610 0 1 {name=p76709 lab=_70728_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -15610 0 0 {name=X_70728_ }
C {devices/lab_pin.sym} 77100 -15470 0 0 {name=p76710 lab=_83638_/Q }
C {devices/lab_pin.sym} 77180 -15470 0 1 {name=p76711 lab=_46464_/Y }
C {sky130_stdcells/inv_2.sym} 77140 -15470 0 0 {name=X_46464_ }
C {devices/lab_pin.sym} 77060 -15370 0 0 {name=p76712 lab=_77280_/X }
C {devices/lab_pin.sym} 77060 -15330 0 0 {name=p76713 lab=_77285_/C }
C {devices/lab_pin.sym} 77060 -15290 0 0 {name=p76714 lab=_77285_/A }
C {devices/lab_pin.sym} 77220 -15330 0 1 {name=p76715 lab=_77287_/A }
C {sky130_stdcells/a21oi_4.sym} 77140 -15330 0 0 {name=X_77284_ }
C {devices/lab_pin.sym} 77060 -15220 0 0 {name=p76716 lab=_40762_/A }
C {devices/lab_pin.sym} 77060 -15180 0 0 {name=p76717 lab=_43659_/X }
C {devices/lab_pin.sym} 77060 -15140 0 0 {name=p76718 lab=_69114_/B }
C {devices/lab_pin.sym} 77060 -15100 0 0 {name=p76719 lab=_43661_/X }
C {devices/lab_pin.sym} 77220 -15160 0 1 {name=p76720 lab=_43677_/A }
C {sky130_stdcells/a2bb2o_4.sym} 77140 -15160 0 0 {name=X_43676_ }
C {devices/lab_pin.sym} 77060 -15030 0 0 {name=p76721 lab=_83054_/Q }
C {devices/lab_pin.sym} 77060 -14990 0 0 {name=p76722 lab=_74474_/X }
C {devices/lab_pin.sym} 77060 -14950 0 0 {name=p76723 lab=_74495_/Y }
C {devices/lab_pin.sym} 77220 -14990 0 1 {name=p76724 lab=_74496_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -14990 0 0 {name=X_74496_ }
C {devices/lab_pin.sym} 77080 -14860 0 0 {name=p76725 lab=_40888_/A }
C {devices/lab_pin.sym} 77080 -14820 0 0 {name=p76726 lab=_40623_/X }
C {devices/lab_pin.sym} 77200 -14840 0 1 {name=p76727 lab=_40888_/X }
C {sky130_stdcells/or2_4.sym} 77140 -14840 0 0 {name=X_40888_ }
C {devices/lab_pin.sym} 77100 -14710 0 0 {name=p76728 lab=_48169_/X }
C {devices/lab_pin.sym} 77180 -14710 0 1 {name=p76729 lab=_48203_/X }
C {sky130_stdcells/buf_2.sym} 77140 -14710 0 0 {name=X_48203_ }
C {devices/lab_pin.sym} 77100 -14590 0 0 {name=p76730 lab=_79014_/B }
C {devices/lab_pin.sym} 77180 -14590 0 1 {name=p76731 lab=_79023_/Y }
C {sky130_stdcells/inv_2.sym} 77140 -14590 0 0 {name=X_79023_ }
C {devices/lab_pin.sym} 77060 -14490 0 0 {name=p76732 lab=_45410_/X }
C {devices/lab_pin.sym} 77060 -14450 0 0 {name=p76733 lab=_45414_/X }
C {devices/lab_pin.sym} 77060 -14410 0 0 {name=p76734 lab=_45361_/X }
C {devices/lab_pin.sym} 77220 -14450 0 1 {name=p76735 lab=_45415_/X }
C {sky130_stdcells/a21o_4.sym} 77140 -14450 0 0 {name=X_45415_ }
C {devices/lab_pin.sym} 77060 -14330 0 0 {name=p76736 lab=_76234_/Y }
C {devices/lab_pin.sym} 77060 -14290 0 0 {name=p76737 lab=_76215_/A }
C {devices/lab_pin.sym} 77060 -14250 0 0 {name=p76738 lab=_76216_/Y }
C {devices/lab_pin.sym} 77220 -14290 0 1 {name=p76739 lab=_76235_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -14290 0 0 {name=X_76235_ }
C {devices/lab_pin.sym} 77100 -14150 0 0 {name=p76740 lab=_42626_/X }
C {devices/lab_pin.sym} 77180 -14150 0 1 {name=p76741 lab=_52274_/A }
C {sky130_stdcells/buf_2.sym} 77140 -14150 0 0 {name=X_42627_ }
C {devices/lab_pin.sym} 77060 -14050 0 0 {name=p76742 lab=_49178_/Y }
C {devices/lab_pin.sym} 77060 -14010 0 0 {name=p76743 lab=_49138_/X }
C {devices/lab_pin.sym} 77060 -13970 0 0 {name=p76744 lab=_49182_/X }
C {devices/lab_pin.sym} 77220 -14010 0 1 {name=p76745 lab=_49183_/Y }
C {sky130_stdcells/a21oi_4.sym} 77140 -14010 0 0 {name=X_49183_ }
C {devices/lab_pin.sym} 77100 -13870 0 0 {name=p76746 lab=_58546_/A }
C {devices/lab_pin.sym} 77180 -13870 0 1 {name=p76747 lab=_61461_/X }
C {sky130_stdcells/buf_2.sym} 77140 -13870 0 0 {name=X_61461_ }
C {devices/lab_pin.sym} 77080 -13760 0 0 {name=p76748 lab=_73495_/A }
C {devices/lab_pin.sym} 77080 -13720 0 0 {name=p76749 lab=_85862_/Q }
C {devices/lab_pin.sym} 77200 -13740 0 1 {name=p76750 lab=_73447_/X }
C {sky130_stdcells/and2_4.sym} 77140 -13740 0 0 {name=X_73447_ }
C {devices/lab_pin.sym} 77100 -13610 0 0 {name=p76751 lab=_52484_/B }
C {devices/lab_pin.sym} 77180 -13610 0 1 {name=p76752 lab=_46396_/B }
C {sky130_stdcells/buf_2.sym} 77140 -13610 0 0 {name=X_46395_ }
C {devices/lab_pin.sym} 77060 -13510 0 0 {name=p76753 lab=_53050_/B }
C {devices/lab_pin.sym} 77060 -13470 0 0 {name=p76754 lab=_70631_/X }
C {devices/lab_pin.sym} 77060 -13430 0 0 {name=p76755 lab=_70658_/Y }
C {devices/lab_pin.sym} 77220 -13470 0 1 {name=p76756 lab=_70659_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -13470 0 0 {name=X_70659_ }
C {devices/lab_pin.sym} 77060 -13350 0 0 {name=p76757 lab=_79343_/A }
C {devices/lab_pin.sym} 77060 -13310 0 0 {name=p76758 lab=_63189_/X }
C {devices/lab_pin.sym} 77060 -13270 0 0 {name=p76759 lab=_63199_/Y }
C {devices/lab_pin.sym} 77220 -13310 0 1 {name=p76760 lab=_63200_/X }
C {sky130_stdcells/a21o_4.sym} 77140 -13310 0 0 {name=X_63200_ }
C {devices/lab_pin.sym} 77100 -13170 0 0 {name=p76761 lab=_48914_/A }
C {devices/lab_pin.sym} 77180 -13170 0 1 {name=p76762 lab=_48134_/X }
C {sky130_stdcells/buf_2.sym} 77140 -13170 0 0 {name=X_48134_ }
C {devices/lab_pin.sym} 77100 -13050 0 0 {name=p76763 lab=_63060_/A }
C {devices/lab_pin.sym} 77180 -13050 0 1 {name=p76764 lab=_60412_/X }
C {sky130_stdcells/buf_2.sym} 77140 -13050 0 0 {name=X_60412_ }
C {devices/lab_pin.sym} 77100 -12930 0 0 {name=p76765 lab=_45272_/A }
C {devices/lab_pin.sym} 77180 -12930 0 1 {name=p76766 lab=_45381_/B }
C {sky130_stdcells/buf_2.sym} 77140 -12930 0 0 {name=X_45346_ }
C {devices/lab_pin.sym} 77080 -12840 0 0 {name=p76767 lab=_58210_/X }
C {devices/lab_pin.sym} 77080 -12800 0 0 {name=p76768 lab=_64192_/C }
C {devices/lab_pin.sym} 77080 -12760 0 0 {name=p76769 lab=_64180_/C }
C {devices/lab_pin.sym} 77080 -12720 0 0 {name=p76770 lab=_64192_/D }
C {devices/lab_pin.sym} 77200 -12780 0 1 {name=p76771 lab=_64181_/D }
C {sky130_stdcells/nand4_4.sym} 77140 -12780 0 0 {name=X_64180_ }
C {devices/lab_pin.sym} 77060 -12650 0 0 {name=p76772 lab=_76160_/X }
C {devices/lab_pin.sym} 77060 -12610 0 0 {name=p76773 lab=_76161_/Y }
C {devices/lab_pin.sym} 77060 -12570 0 0 {name=p76774 lab=_76165_/X }
C {devices/lab_pin.sym} 77220 -12610 0 1 {name=p76775 lab=_76166_/X }
C {sky130_stdcells/a21o_4.sym} 77140 -12610 0 0 {name=X_76166_ }
C {devices/lab_pin.sym} 77100 -12470 0 0 {name=p76776 lab=_61392_/A }
C {devices/lab_pin.sym} 77180 -12470 0 1 {name=p76777 lab=_61392_/Y }
C {sky130_stdcells/inv_2.sym} 77140 -12470 0 0 {name=X_61392_ }
C {devices/lab_pin.sym} 77100 -12350 0 0 {name=p76778 lab=_87821_/Q }
C {devices/lab_pin.sym} 77180 -12350 0 1 {name=p76779 lab=_42558_/Y }
C {sky130_stdcells/inv_2.sym} 77140 -12350 0 0 {name=X_42558_ }
C {devices/lab_pin.sym} 77100 -12230 0 0 {name=p76780 lab=_73378_/A }
C {devices/lab_pin.sym} 77180 -12230 0 1 {name=p76781 lab=_73378_/X }
C {sky130_stdcells/buf_2.sym} 77140 -12230 0 0 {name=X_73378_ }
C {devices/lab_pin.sym} 77100 -12110 0 0 {name=p76782 lab=_63010_/A }
C {devices/lab_pin.sym} 77180 -12110 0 1 {name=p76783 lab=_63131_/X }
C {sky130_stdcells/buf_2.sym} 77140 -12110 0 0 {name=X_63131_ }
C {devices/lab_pin.sym} 77080 -12010 0 0 {name=p76784 lab=_75117_/A }
C {devices/lab_pin.sym} 77080 -11970 0 0 {name=p76785 lab=_75117_/B }
C {devices/lab_pin.sym} 77080 -11930 0 0 {name=p76786 lab=_75117_/C }
C {devices/lab_pin.sym} 77200 -11970 0 1 {name=p76787 lab=_75120_/B }
C {sky130_stdcells/nand3_4.sym} 77140 -11970 0 0 {name=X_75117_ }
C {devices/lab_pin.sym} 77080 -11840 0 0 {name=p76788 lab=_81175_/Q }
C {devices/lab_pin.sym} 77080 -11800 0 0 {name=p76789 lab=_41523_/B }
C {devices/lab_pin.sym} 77200 -11820 0 1 {name=p76790 lab=_41509_/X }
C {sky130_stdcells/or2_4.sym} 77140 -11820 0 0 {name=X_41509_ }
C {devices/lab_pin.sym} 77060 -11710 0 0 {name=p76791 lab=_72327_/X }
C {devices/lab_pin.sym} 77060 -11670 0 0 {name=p76792 lab=_85968_/Q }
C {devices/lab_pin.sym} 77060 -11630 0 0 {name=p76793 lab=_72328_/X }
C {devices/lab_pin.sym} 77220 -11670 0 1 {name=p76794 lab=_72329_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -11670 0 0 {name=X_72329_ }
C {devices/lab_pin.sym} 77080 -11540 0 0 {name=p76795 lab=_48065_/A }
C {devices/lab_pin.sym} 77080 -11500 0 0 {name=p76796 lab=_47915_/B }
C {devices/lab_pin.sym} 77200 -11520 0 1 {name=p76797 lab=_48065_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -11520 0 0 {name=X_48065_ }
C {devices/lab_pin.sym} 77080 -11410 0 0 {name=p76798 lab=_60344_/A }
C {devices/lab_pin.sym} 77080 -11370 0 0 {name=p76799 lab=_60331_/B }
C {devices/lab_pin.sym} 77080 -11330 0 0 {name=p76800 lab=_60268_/A }
C {devices/lab_pin.sym} 77200 -11370 0 1 {name=p76801 lab=_60343_/Y }
C {sky130_stdcells/nand3_4.sym} 77140 -11370 0 0 {name=X_60343_ }
C {devices/lab_pin.sym} 77100 -11230 0 0 {name=p76802 lab=_45350_/A }
C {devices/lab_pin.sym} 77180 -11230 0 1 {name=p76803 lab=_45277_/X }
C {sky130_stdcells/buf_2.sym} 77140 -11230 0 0 {name=X_45277_ }
C {devices/lab_pin.sym} 77080 -11120 0 0 {name=p76804 lab=_76096_/Y }
C {devices/lab_pin.sym} 77080 -11080 0 0 {name=p76805 lab=_76097_/B }
C {devices/lab_pin.sym} 77200 -11100 0 1 {name=p76806 lab=_76097_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -11100 0 0 {name=X_76097_ }
C {devices/lab_pin.sym} 77100 -10970 0 0 {name=p76807 lab=_42556_/A }
C {devices/lab_pin.sym} 77180 -10970 0 1 {name=p76808 lab=_42489_/X }
C {sky130_stdcells/buf_2.sym} 77140 -10970 0 0 {name=X_42489_ }
C {devices/lab_pin.sym} 77100 -10850 0 0 {name=p76809 lab=_47016_/A }
C {devices/lab_pin.sym} 77180 -10850 0 1 {name=p76810 lab=_52803_/B }
C {sky130_stdcells/buf_2.sym} 77140 -10850 0 0 {name=X_47016_ }
C {devices/lab_pin.sym} 77100 -10730 0 0 {name=p76811 lab=_44010_/A }
C {devices/lab_pin.sym} 77180 -10730 0 1 {name=p76812 lab=_44228_/X }
C {sky130_stdcells/buf_2.sym} 77140 -10730 0 0 {name=X_44228_ }
C {devices/lab_pin.sym} 77100 -10610 0 0 {name=p76813 lab=_60607_/A }
C {devices/lab_pin.sym} 77180 -10610 0 1 {name=p76814 lab=_63085_/D }
C {sky130_stdcells/buf_2.sym} 77140 -10610 0 0 {name=X_63062_ }
C {devices/lab_pin.sym} 77080 -10510 0 0 {name=p76815 lab=_75047_/A }
C {devices/lab_pin.sym} 77080 -10470 0 0 {name=p76816 lab=_75039_/X }
C {devices/lab_pin.sym} 77080 -10430 0 0 {name=p76817 lab=_75051_/B }
C {devices/lab_pin.sym} 77200 -10470 0 1 {name=p76818 lab=_75048_/Y }
C {sky130_stdcells/nand3_4.sym} 77140 -10470 0 0 {name=X_75048_ }
C {devices/lab_pin.sym} 77080 -10340 0 0 {name=p76819 lab=_79924_/B }
C {devices/lab_pin.sym} 77080 -10300 0 0 {name=p76820 lab=_79924_/C }
C {devices/lab_pin.sym} 77200 -10320 0 1 {name=p76821 lab=_79926_/A }
C {sky130_stdcells/nand2_4.sym} 77140 -10320 0 0 {name=X_79925_ }
C {devices/lab_pin.sym} 77100 -10190 0 0 {name=p76822 lab=_60239_/A }
C {devices/lab_pin.sym} 77180 -10190 0 1 {name=p76823 lab=_60274_/X }
C {sky130_stdcells/buf_2.sym} 77140 -10190 0 0 {name=X_60274_ }
C {devices/lab_pin.sym} 77100 -10070 0 0 {name=p76824 lab=_58258_/A }
C {devices/lab_pin.sym} 77180 -10070 0 1 {name=p76825 lab=_63585_/B }
C {sky130_stdcells/buf_2.sym} 77140 -10070 0 0 {name=X_62013_ }
C {devices/lab_pin.sym} 77060 -9980 0 0 {name=p76826 lab=_87389_/Q }
C {devices/lab_pin.sym} 77060 -9940 0 0 {name=p76827 lab=_67868_/X }
C {devices/lab_pin.sym} 77060 -9900 0 0 {name=p76828 lab=_67821_/X }
C {devices/lab_pin.sym} 77060 -9860 0 0 {name=p76829 lab=_67869_/X }
C {devices/lab_pin.sym} 77220 -9920 0 1 {name=p76830 lab=_67870_/X }
C {sky130_stdcells/a211o_4.sym} 77140 -9920 0 0 {name=X_67870_ }
C {devices/lab_pin.sym} 77080 -9800 0 0 {name=p76831 lab=_44151_/X }
C {devices/lab_pin.sym} 77080 -9760 0 0 {name=p76832 lab=_44153_/X }
C {devices/lab_pin.sym} 77080 -9720 0 0 {name=p76833 lab=_44157_/Y }
C {devices/lab_pin.sym} 77080 -9680 0 0 {name=p76834 lab=_44158_/Y }
C {devices/lab_pin.sym} 77200 -9740 0 1 {name=p76835 lab=_44159_/X }
C {sky130_stdcells/or4_4.sym} 77140 -9740 0 0 {name=X_44159_ }
C {devices/lab_pin.sym} 77080 -9610 0 0 {name=p76836 lab=_79853_/X }
C {devices/lab_pin.sym} 77080 -9570 0 0 {name=p76837 lab=_79856_/B }
C {devices/lab_pin.sym} 77080 -9530 0 0 {name=p76838 lab=_79855_/X }
C {devices/lab_pin.sym} 77200 -9570 0 1 {name=p76839 lab=_79856_/X }
C {sky130_stdcells/and3_4.sym} 77140 -9570 0 0 {name=X_79856_ }
C {devices/lab_pin.sym} 77060 -9450 0 0 {name=p76840 lab=_66818_/X }
C {devices/lab_pin.sym} 77060 -9410 0 0 {name=p76841 lab=_66820_/X }
C {devices/lab_pin.sym} 77060 -9370 0 0 {name=p76842 lab=_66726_/X }
C {devices/lab_pin.sym} 77220 -9410 0 1 {name=p76843 lab=_66821_/X }
C {sky130_stdcells/a21o_4.sym} 77140 -9410 0 0 {name=X_66821_ }
C {devices/lab_pin.sym} 77080 -9280 0 0 {name=p76844 lab=_78807_/A }
C {devices/lab_pin.sym} 77080 -9240 0 0 {name=p76845 lab=_82834_/Q }
C {devices/lab_pin.sym} 77200 -9260 0 1 {name=p76846 lab=_78807_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -9260 0 0 {name=X_78807_ }
C {devices/lab_pin.sym} 77080 -9140 0 0 {name=p76847 lab=_48967_/A }
C {devices/lab_pin.sym} 77080 -9100 0 0 {name=p76848 lab=_49009_/B }
C {devices/lab_pin.sym} 77200 -9120 0 1 {name=p76849 lab=_48967_/Y }
C {sky130_stdcells/nor2_4.sym} 77140 -9120 0 0 {name=X_48967_ }
C {devices/lab_pin.sym} 77100 -8990 0 0 {name=p76850 lab=_79786_/X }
C {devices/lab_pin.sym} 77180 -8990 0 1 {name=p76851 lab=_79793_/A }
C {sky130_stdcells/inv_2.sym} 77140 -8990 0 0 {name=X_79787_ }
C {devices/lab_pin.sym} 77080 -8880 0 0 {name=p76852 lab=_76999_/A }
C {devices/lab_pin.sym} 77080 -8840 0 0 {name=p76853 lab=_62254_/C }
C {devices/lab_pin.sym} 77200 -8860 0 1 {name=p76854 lab=_76999_/X }
C {sky130_stdcells/xor2_4.sym} 77140 -8860 0 0 {name=X_76999_ }
C {devices/lab_pin.sym} 77060 -8760 0 0 {name=p76855 lab=_69505_/X }
C {devices/lab_pin.sym} 77060 -8720 0 0 {name=p76856 lab=_69340_/X }
C {devices/lab_pin.sym} 77060 -8680 0 0 {name=p76857 lab=_69538_/Y }
C {devices/lab_pin.sym} 77060 -8640 0 0 {name=p76858 lab=_69539_/Y }
C {devices/lab_pin.sym} 77220 -8700 0 1 {name=p76859 lab=_69540_/X }
C {sky130_stdcells/a211o_4.sym} 77140 -8700 0 0 {name=X_69540_ }
C {devices/lab_pin.sym} 77100 -8550 0 0 {name=p76860 lab=_47918_/A }
C {devices/lab_pin.sym} 77180 -8550 0 1 {name=p76861 lab=_48790_/A }
C {sky130_stdcells/buf_2.sym} 77140 -8550 0 0 {name=X_47918_ }
C {devices/lab_pin.sym} 77080 -8440 0 0 {name=p76862 lab=_66728_/A }
C {devices/lab_pin.sym} 77080 -8400 0 0 {name=p76863 lab=_66752_/B }
C {devices/lab_pin.sym} 77200 -8420 0 1 {name=p76864 lab=_66752_/X }
C {sky130_stdcells/and2_4.sym} 77140 -8420 0 0 {name=X_66752_ }
C {devices/lab_pin.sym} 77080 -8300 0 0 {name=p76865 lab=_78770_/A }
C {devices/lab_pin.sym} 77080 -8260 0 0 {name=p76866 lab=_78737_/Y }
C {devices/lab_pin.sym} 77200 -8280 0 1 {name=p76867 lab=_78739_/A }
C {sky130_stdcells/and2_4.sym} 77140 -8280 0 0 {name=X_78738_ }
C {devices/lab_pin.sym} 77080 -8180 0 0 {name=p76868 lab=_64378_/B }
C {devices/lab_pin.sym} 77080 -8140 0 0 {name=p76869 lab=_64179_/B }
C {devices/lab_pin.sym} 77080 -8100 0 0 {name=p76870 lab=_64081_/C }
C {devices/lab_pin.sym} 77080 -8060 0 0 {name=p76871 lab=_60889_/X }
C {devices/lab_pin.sym} 77200 -8120 0 1 {name=p76872 lab=_63964_/Y }
C {sky130_stdcells/nand4_4.sym} 77140 -8120 0 0 {name=X_63964_ }
C {devices/lab_pin.sym} 77100 -7970 0 0 {name=p76873 lab=_48898_/A }
C {devices/lab_pin.sym} 77180 -7970 0 1 {name=p76874 lab=_48901_/A }
C {sky130_stdcells/buf_2.sym} 77140 -7970 0 0 {name=X_48898_ }
C {devices/lab_pin.sym} 77060 -7880 0 0 {name=p76875 lab=_65685_/X }
C {devices/lab_pin.sym} 77060 -7840 0 0 {name=p76876 lab=_86191_/Q }
C {devices/lab_pin.sym} 77060 -7800 0 0 {name=p76877 lab=_65701_/X }
C {devices/lab_pin.sym} 77060 -7760 0 0 {name=p76878 lab=_65702_/X }
C {devices/lab_pin.sym} 77220 -7820 0 1 {name=p76879 lab=_65703_/X }
C {sky130_stdcells/a211o_4.sym} 77140 -7820 0 0 {name=X_65703_ }
C {devices/lab_pin.sym} 77060 -7710 0 0 {name=p76880 lab=_60257_/X }
C {devices/lab_pin.sym} 77060 -7670 0 0 {name=p76881 lab=_61609_/X }
C {devices/lab_pin.sym} 77060 -7630 0 0 {name=p76882 lab=_62679_/X }
C {devices/lab_pin.sym} 77060 -7590 0 0 {name=p76883 lab=_60281_/A }
C {devices/lab_pin.sym} 77060 -7550 0 0 {name=p76884 lab=_84890_/Q }
C {devices/lab_pin.sym} 77220 -7630 0 1 {name=p76885 lab=_62916_/A }
C {sky130_stdcells/a32o_4.sym} 77140 -7630 0 0 {name=X_62915_ }
C {devices/lab_pin.sym} 77060 -7490 0 0 {name=p76886 lab=_69467_/X }
C {devices/lab_pin.sym} 77060 -7450 0 0 {name=p76887 lab=_69470_/X }
C {devices/lab_pin.sym} 77060 -7410 0 0 {name=p76888 lab=_69346_/X }
C {devices/lab_pin.sym} 77220 -7450 0 1 {name=p76889 lab=_69471_/X }
C {sky130_stdcells/a21o_4.sym} 77140 -7450 0 0 {name=X_69471_ }
C {devices/lab_pin.sym} 77080 -7320 0 0 {name=p76890 lab=_82368_/Q }
C {devices/lab_pin.sym} 77080 -7280 0 0 {name=p76891 lab=_46579_/X }
C {devices/lab_pin.sym} 77200 -7300 0 1 {name=p76892 lab=_47849_/X }
C {sky130_stdcells/or2_4.sym} 77140 -7300 0 0 {name=X_47849_ }
C {devices/lab_pin.sym} 77080 -7180 0 0 {name=p76893 lab=_78667_/X }
C {devices/lab_pin.sym} 77080 -7140 0 0 {name=p76894 lab=_78669_/B }
C {devices/lab_pin.sym} 77200 -7160 0 1 {name=p76895 lab=_78669_/X }
C {sky130_stdcells/and2_4.sym} 77140 -7160 0 0 {name=X_78669_ }
C {devices/lab_pin.sym} 77080 -7040 0 0 {name=p76896 lab=_66683_/A }
C {devices/lab_pin.sym} 77080 -7000 0 0 {name=p76897 lab=_66683_/B }
C {devices/lab_pin.sym} 77200 -7020 0 1 {name=p76898 lab=_66683_/X }
C {sky130_stdcells/and2_4.sym} 77140 -7020 0 0 {name=X_66683_ }
C {devices/lab_pin.sym} 77080 -6910 0 0 {name=p76899 lab=_63831_/A }
C {devices/lab_pin.sym} 77080 -6870 0 0 {name=p76900 lab=_59392_/A }
C {devices/lab_pin.sym} 77080 -6830 0 0 {name=p76901 lab=_63862_/C }
C {devices/lab_pin.sym} 77200 -6870 0 1 {name=p76902 lab=_63895_/X }
C {sky130_stdcells/and3_4.sym} 77140 -6870 0 0 {name=X_63895_ }
C {devices/lab_pin.sym} 77050 -6730 0 0 {name=p76903 lab=_81084_/CLK }
C {devices/lab_pin.sym} 77050 -6710 0 0 {name=p76904 lab=_80732_/Q }
C {devices/lab_pin.sym} 77230 -6730 0 1 {name=p76905 lab=_80700_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -6720 0 0 {name=X_80700_ }
C {devices/lab_pin.sym} 77080 -6600 0 0 {name=p76906 lab=_69877_/A }
C {devices/lab_pin.sym} 77080 -6560 0 0 {name=p76907 lab=_88369_/Q }
C {devices/lab_pin.sym} 77200 -6580 0 1 {name=p76908 lab=_68422_/X }
C {sky130_stdcells/and2_4.sym} 77140 -6580 0 0 {name=X_68422_ }
C {devices/lab_pin.sym} 77080 -6470 0 0 {name=p76909 lab=_65634_/A }
C {devices/lab_pin.sym} 77080 -6430 0 0 {name=p76910 lab=_65397_/B }
C {devices/lab_pin.sym} 77080 -6390 0 0 {name=p76911 lab=_65634_/C }
C {devices/lab_pin.sym} 77200 -6430 0 1 {name=p76912 lab=_65634_/Y }
C {sky130_stdcells/nor3_4.sym} 77140 -6430 0 0 {name=X_65634_ }
C {devices/lab_pin.sym} 77080 -6300 0 0 {name=p76913 lab=_50845_/A }
C {devices/lab_pin.sym} 77080 -6260 0 0 {name=p76914 lab=_54071_/B }
C {devices/lab_pin.sym} 77200 -6280 0 1 {name=p76915 lab=_50860_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -6280 0 0 {name=X_50860_ }
C {devices/lab_pin.sym} 77080 -6180 0 0 {name=p76916 lab=_61522_/X }
C {devices/lab_pin.sym} 77080 -6140 0 0 {name=p76917 lab=_62834_/B }
C {devices/lab_pin.sym} 77080 -6100 0 0 {name=p76918 lab=_62801_/X }
C {devices/lab_pin.sym} 77080 -6060 0 0 {name=p76919 lab=_62889_/D }
C {devices/lab_pin.sym} 77200 -6120 0 1 {name=p76920 lab=_62846_/Y }
C {sky130_stdcells/nand4_4.sym} 77140 -6120 0 0 {name=X_62846_ }
C {devices/lab_pin.sym} 77050 -5970 0 0 {name=p76921 lab=_81680_/CLK }
C {devices/lab_pin.sym} 77050 -5950 0 0 {name=p76922 lab=_80078_/X }
C {devices/lab_pin.sym} 77230 -5970 0 1 {name=p76923 lab=_81680_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -5960 0 0 {name=X_81680_ }
C {devices/lab_pin.sym} 77060 -5850 0 0 {name=p76924 lab=_86372_/Q }
C {devices/lab_pin.sym} 77060 -5810 0 0 {name=p76925 lab=_49496_/X }
C {devices/lab_pin.sym} 77060 -5770 0 0 {name=p76926 lab=_49518_/Y }
C {devices/lab_pin.sym} 77220 -5810 0 1 {name=p76927 lab=_49519_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -5810 0 0 {name=X_49519_ }
C {devices/lab_pin.sym} 77100 -5670 0 0 {name=p76928 lab=_80633_/C }
C {devices/lab_pin.sym} 77180 -5670 0 1 {name=p76929 lab=_80632_/B }
C {sky130_stdcells/inv_2.sym} 77140 -5670 0 0 {name=X_80631_ }
C {devices/lab_pin.sym} 77100 -5550 0 0 {name=p76930 lab=_69182_/A }
C {devices/lab_pin.sym} 77180 -5550 0 1 {name=p76931 lab=_68353_/X }
C {sky130_stdcells/buf_2.sym} 77140 -5550 0 0 {name=X_68353_ }
C {devices/lab_pin.sym} 77060 -5460 0 0 {name=p76932 lab=_65362_/X }
C {devices/lab_pin.sym} 77060 -5420 0 0 {name=p76933 lab=_85592_/Q }
C {devices/lab_pin.sym} 77060 -5380 0 0 {name=p76934 lab=_65363_/X }
C {devices/lab_pin.sym} 77060 -5340 0 0 {name=p76935 lab=_65564_/X }
C {devices/lab_pin.sym} 77220 -5400 0 1 {name=p76936 lab=_65565_/X }
C {sky130_stdcells/a211o_4.sym} 77140 -5400 0 0 {name=X_65565_ }
C {devices/lab_pin.sym} 77060 -5270 0 0 {name=p76937 lab=_86132_/Q }
C {devices/lab_pin.sym} 77060 -5230 0 0 {name=p76938 lab=_50775_/X }
C {devices/lab_pin.sym} 77060 -5190 0 0 {name=p76939 lab=_50790_/Y }
C {devices/lab_pin.sym} 77220 -5230 0 1 {name=p76940 lab=_50791_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -5230 0 0 {name=X_50791_ }
C {devices/lab_pin.sym} 77080 -5120 0 0 {name=p76941 lab=_62731_/A }
C {devices/lab_pin.sym} 77080 -5080 0 0 {name=p76942 lab=_63127_/A }
C {devices/lab_pin.sym} 77080 -5040 0 0 {name=p76943 lab=_62744_/X }
C {devices/lab_pin.sym} 77080 -5000 0 0 {name=p76944 lab=_62789_/D }
C {devices/lab_pin.sym} 77200 -5060 0 1 {name=p76945 lab=_62777_/X }
C {sky130_stdcells/and4_4.sym} 77140 -5060 0 0 {name=X_62777_ }
C {devices/lab_pin.sym} 77060 -4930 0 0 {name=p76946 lab=_80899_/D }
C {devices/lab_pin.sym} 77060 -4890 0 0 {name=p76947 lab=_67211_/X }
C {devices/lab_pin.sym} 77060 -4850 0 0 {name=p76948 lab=_67303_/X }
C {devices/lab_pin.sym} 77220 -4890 0 1 {name=p76949 lab=_84075_/D }
C {sky130_stdcells/a21bo_4.sym} 77140 -4890 0 0 {name=X_67304_ }
C {devices/lab_pin.sym} 77080 -4760 0 0 {name=p76950 lab=_52518_/A }
C {devices/lab_pin.sym} 77080 -4720 0 0 {name=p76951 lab=_46500_/Y }
C {devices/lab_pin.sym} 77200 -4740 0 1 {name=p76952 lab=_52530_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -4740 0 0 {name=X_52530_ }
C {devices/lab_pin.sym} 77060 -4630 0 0 {name=p76953 lab=_58978_/Y }
C {devices/lab_pin.sym} 77060 -4590 0 0 {name=p76954 lab=_64249_/A }
C {devices/lab_pin.sym} 77060 -4550 0 0 {name=p76955 lab=_64515_/Y }
C {devices/lab_pin.sym} 77220 -4590 0 1 {name=p76956 lab=_64516_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -4590 0 0 {name=X_64516_ }
C {devices/lab_pin.sym} 77050 -4450 0 0 {name=p76957 lab=_83480_/CLK }
C {devices/lab_pin.sym} 77050 -4430 0 0 {name=p76958 lab=_83350_/D }
C {devices/lab_pin.sym} 77230 -4450 0 1 {name=p76959 lab=_83350_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -4440 0 0 {name=X_83350_ }
C {devices/lab_pin.sym} 77100 -4310 0 0 {name=p76960 lab=_61728_/A }
C {devices/lab_pin.sym} 77180 -4310 0 1 {name=p76961 lab=_61728_/X }
C {sky130_stdcells/buf_2.sym} 77140 -4310 0 0 {name=X_61728_ }
C {devices/lab_pin.sym} 77080 -4200 0 0 {name=p76962 lab=_80554_/Y }
C {devices/lab_pin.sym} 77080 -4160 0 0 {name=p76963 lab=_80562_/B }
C {devices/lab_pin.sym} 77200 -4180 0 1 {name=p76964 lab=_80562_/Y }
C {sky130_stdcells/nand2_4.sym} 77140 -4180 0 0 {name=X_80562_ }
C {devices/lab_pin.sym} 77060 -4070 0 0 {name=p76965 lab=_67754_/X }
C {devices/lab_pin.sym} 77060 -4030 0 0 {name=p76966 lab=_67757_/X }
C {devices/lab_pin.sym} 77060 -3990 0 0 {name=p76967 lab=_68283_/X }
C {devices/lab_pin.sym} 77220 -4030 0 1 {name=p76968 lab=_68284_/Y }
C {sky130_stdcells/a21oi_4.sym} 77140 -4030 0 0 {name=X_68284_ }
C {devices/lab_pin.sym} 77060 -3910 0 0 {name=p76969 lab=_65399_/X }
C {devices/lab_pin.sym} 77060 -3870 0 0 {name=p76970 lab=_65494_/Y }
C {devices/lab_pin.sym} 77060 -3830 0 0 {name=p76971 lab=_65495_/Y }
C {devices/lab_pin.sym} 77220 -3870 0 1 {name=p76972 lab=_65496_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -3870 0 0 {name=X_65496_ }
C {sky130_stdcells/decap_3.sym} 77140 -3700 0 0 {name=XPHY_109 }
C {devices/lab_pin.sym} 77050 -3550 0 0 {name=p76973 lab=_82301_/CLK }
C {devices/lab_pin.sym} 77050 -3530 0 0 {name=p76974 lab=_77194_/B }
C {devices/lab_pin.sym} 77230 -3550 0 1 {name=p76975 lab=_82301_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -3540 0 0 {name=X_82301_ }
C {devices/lab_pin.sym} 77060 -3430 0 0 {name=p76976 lab=_84078_/Q }
C {devices/lab_pin.sym} 77060 -3390 0 0 {name=p76977 lab=_67211_/X }
C {devices/lab_pin.sym} 77060 -3350 0 0 {name=p76978 lab=_67234_/X }
C {devices/lab_pin.sym} 77220 -3390 0 1 {name=p76979 lab=_67235_/X }
C {sky130_stdcells/a21bo_4.sym} 77140 -3390 0 0 {name=X_67235_ }
C {devices/lab_pin.sym} 77060 -3270 0 0 {name=p76980 lab=_85817_/Q }
C {devices/lab_pin.sym} 77060 -3230 0 0 {name=p76981 lab=_52438_/X }
C {devices/lab_pin.sym} 77060 -3190 0 0 {name=p76982 lab=_52460_/Y }
C {devices/lab_pin.sym} 77220 -3230 0 1 {name=p76983 lab=_52461_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -3230 0 0 {name=X_52461_ }
C {devices/lab_pin.sym} 77080 -3110 0 0 {name=p76984 lab=_64494_/A }
C {devices/lab_pin.sym} 77080 -3070 0 0 {name=p76985 lab=_63238_/B }
C {devices/lab_pin.sym} 77080 -3030 0 0 {name=p76986 lab=_64207_/A }
C {devices/lab_pin.sym} 77200 -3070 0 1 {name=p76987 lab=_64447_/X }
C {sky130_stdcells/and3_4.sym} 77140 -3070 0 0 {name=X_64447_ }
C {devices/lab_pin.sym} 77050 -2930 0 0 {name=p76988 lab=_86303_/CLK }
C {devices/lab_pin.sym} 77050 -2910 0 0 {name=p76989 lab=_72127_/Y }
C {devices/lab_pin.sym} 77230 -2930 0 1 {name=p76990 lab=_83281_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -2920 0 0 {name=X_83281_ }
C {devices/lab_pin.sym} 77100 -2790 0 0 {name=p76991 lab=_61413_/A }
C {devices/lab_pin.sym} 77180 -2790 0 1 {name=p76992 lab=_61690_/A }
C {sky130_stdcells/buf_2.sym} 77140 -2790 0 0 {name=X_61659_ }
C {devices/lab_pin.sym} 77080 -2680 0 0 {name=p76993 lab=_80487_/Y }
C {devices/lab_pin.sym} 77080 -2640 0 0 {name=p76994 lab=_80492_/Y }
C {devices/lab_pin.sym} 77200 -2660 0 1 {name=p76995 lab=_80493_/X }
C {sky130_stdcells/xor2_4.sym} 77140 -2660 0 0 {name=X_80493_ }
C {devices/lab_pin.sym} 77060 -2550 0 0 {name=p76996 lab=_54196_/Y }
C {devices/lab_pin.sym} 77060 -2510 0 0 {name=p76997 lab=_54197_/X }
C {devices/lab_pin.sym} 77060 -2470 0 0 {name=p76998 lab=_54199_/X }
C {devices/lab_pin.sym} 77220 -2510 0 1 {name=p76999 lab=_54200_/Y }
C {sky130_stdcells/a21oi_4.sym} 77140 -2510 0 0 {name=X_54200_ }
C {devices/lab_pin.sym} 77050 -2370 0 0 {name=p77000 lab=_85050_/CLK }
C {devices/lab_pin.sym} 77050 -2350 0 0 {name=p77001 lab=_85020_/D }
C {devices/lab_pin.sym} 77230 -2370 0 1 {name=p77002 lab=_85020_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -2360 0 0 {name=X_85020_ }
C {devices/lab_pin.sym} 77060 -2250 0 0 {name=p77003 lab=_51409_/Y }
C {devices/lab_pin.sym} 77060 -2210 0 0 {name=p77004 lab=_51229_/X }
C {devices/lab_pin.sym} 77060 -2170 0 0 {name=p77005 lab=_51411_/X }
C {devices/lab_pin.sym} 77220 -2210 0 1 {name=p77006 lab=_86015_/D }
C {sky130_stdcells/a21oi_4.sym} 77140 -2210 0 0 {name=X_51412_ }
C {devices/lab_pin.sym} 77050 -2070 0 0 {name=p77007 lab=_81928_/CLK }
C {devices/lab_pin.sym} 77050 -2050 0 0 {name=p77008 lab=_82264_/Q }
C {devices/lab_pin.sym} 77230 -2070 0 1 {name=p77009 lab=_77549_/A }
C {sky130_stdcells/dfxtp_4.sym} 77140 -2060 0 0 {name=X_82232_ }
C {devices/lab_pin.sym} 77080 -1950 0 0 {name=p77010 lab=_55171_/X }
C {devices/lab_pin.sym} 77080 -1910 0 0 {name=p77011 lab=_83748_/Q }
C {devices/lab_pin.sym} 77080 -1870 0 0 {name=p77012 lab=_55178_/X }
C {devices/lab_pin.sym} 77200 -1910 0 1 {name=p77013 lab=_55181_/B }
C {sky130_stdcells/nand3_4.sym} 77140 -1910 0 0 {name=X_55180_ }
C {devices/lab_pin.sym} 77100 -1770 0 0 {name=p77014 lab=_66898_/X }
C {devices/lab_pin.sym} 77180 -1770 0 1 {name=p77015 lab=_67166_/X }
C {sky130_stdcells/buf_2.sym} 77140 -1770 0 0 {name=X_67166_ }
C {devices/lab_pin.sym} 77060 -1670 0 0 {name=p77016 lab=_52388_/Y }
C {devices/lab_pin.sym} 77060 -1630 0 0 {name=p77017 lab=_52390_/X }
C {devices/lab_pin.sym} 77060 -1590 0 0 {name=p77018 lab=_52391_/X }
C {devices/lab_pin.sym} 77220 -1630 0 1 {name=p77019 lab=_52392_/Y }
C {sky130_stdcells/a21oi_4.sym} 77140 -1630 0 0 {name=X_52392_ }
C {devices/lab_pin.sym} 77080 -1510 0 0 {name=p77020 lab=_64377_/X }
C {devices/lab_pin.sym} 77080 -1470 0 0 {name=p77021 lab=_64378_/B }
C {devices/lab_pin.sym} 77080 -1430 0 0 {name=p77022 lab=_64333_/X }
C {devices/lab_pin.sym} 77200 -1470 0 1 {name=p77023 lab=_64378_/X }
C {sky130_stdcells/and3_4.sym} 77140 -1470 0 0 {name=X_64378_ }
C {devices/lab_pin.sym} 77060 -1350 0 0 {name=p77024 lab=_85498_/Q }
C {devices/lab_pin.sym} 77060 -1310 0 0 {name=p77025 lab=_54113_/X }
C {devices/lab_pin.sym} 77060 -1270 0 0 {name=p77026 lab=_54130_/Y }
C {devices/lab_pin.sym} 77220 -1310 0 1 {name=p77027 lab=_54131_/Y }
C {sky130_stdcells/o21ai_4.sym} 77140 -1310 0 0 {name=X_54131_ }
C {devices/lab_pin.sym} 77100 -1170 0 0 {name=p77028 lab=_65595_/X }
C {devices/lab_pin.sym} 77180 -1170 0 1 {name=p77029 lab=_66117_/X }
C {sky130_stdcells/buf_2.sym} 77140 -1170 0 0 {name=X_66117_ }
C {devices/lab_pin.sym} 77080 -1070 0 0 {name=p77030 lab=_52524_/A }
C {devices/lab_pin.sym} 77080 -1030 0 0 {name=p77031 lab=_51266_/B }
C {devices/lab_pin.sym} 77080 -990 0 0 {name=p77032 lab=_51352_/C }
C {devices/lab_pin.sym} 77200 -1030 0 1 {name=p77033 lab=_51343_/X }
C {sky130_stdcells/and3_4.sym} 77140 -1030 0 0 {name=X_51343_ }
C {devices/lab_pin.sym} 77100 -890 0 0 {name=p77034 lab=_79183_/B }
C {devices/lab_pin.sym} 77180 -890 0 1 {name=p77035 lab=_79184_/A }
C {sky130_stdcells/inv_2.sym} 77140 -890 0 0 {name=X_63329_ }
C {devices/lab_pin.sym} 77050 -770 0 0 {name=p77036 lab=_84161_/CLK }
C {devices/lab_pin.sym} 77050 -750 0 0 {name=p77037 lab=_80481_/B }
C {devices/lab_pin.sym} 77230 -770 0 1 {name=p77038 lab=_82163_/Q }
C {sky130_stdcells/dfxtp_4.sym} 77140 -760 0 0 {name=X_82163_ }
C {devices/lab_pin.sym} 78000 -42160 0 0 {name=p77039 lab=_67023_/A }
C {devices/lab_pin.sym} 78000 -42120 0 0 {name=p77040 lab=_86784_/Q }
C {devices/lab_pin.sym} 78120 -42140 0 1 {name=p77041 lab=_67097_/X }
C {sky130_stdcells/and2_4.sym} 78060 -42140 0 0 {name=X_67097_ }
C {devices/lab_pin.sym} 77970 -42010 0 0 {name=p77042 lab=_81082_/CLK }
C {devices/lab_pin.sym} 77970 -41990 0 0 {name=p77043 lab=_79813_/X }
C {devices/lab_pin.sym} 78150 -42010 0 1 {name=p77044 lab=_75637_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -42000 0 0 {name=X_81114_ }
C {devices/lab_pin.sym} 77980 -41890 0 0 {name=p77045 lab=_54059_/Y }
C {devices/lab_pin.sym} 77980 -41850 0 0 {name=p77046 lab=_54060_/X }
C {devices/lab_pin.sym} 77980 -41810 0 0 {name=p77047 lab=_54061_/Y }
C {devices/lab_pin.sym} 78140 -41850 0 1 {name=p77048 lab=_54062_/Y }
C {sky130_stdcells/a21boi_4.sym} 78060 -41850 0 0 {name=X_54062_ }
C {devices/lab_pin.sym} 78000 -41730 0 0 {name=p77049 lab=_66164_/A }
C {devices/lab_pin.sym} 78000 -41690 0 0 {name=p77050 lab=_65888_/B }
C {devices/lab_pin.sym} 78000 -41650 0 0 {name=p77051 lab=_66048_/C }
C {devices/lab_pin.sym} 78120 -41690 0 1 {name=p77052 lab=_66048_/Y }
C {sky130_stdcells/nor3_4.sym} 78060 -41690 0 0 {name=X_66048_ }
C {devices/lab_pin.sym} 78000 -41560 0 0 {name=p77053 lab=_51278_/A }
C {devices/lab_pin.sym} 78000 -41520 0 0 {name=p77054 lab=_46339_/A }
C {devices/lab_pin.sym} 78120 -41540 0 1 {name=p77055 lab=_51274_/X }
C {sky130_stdcells/and2_4.sym} 78060 -41540 0 0 {name=X_51274_ }
C {devices/lab_pin.sym} 77970 -41410 0 0 {name=p77056 lab=_87473_/CLK }
C {devices/lab_pin.sym} 77970 -41390 0 0 {name=p77057 lab=_44757_/X }
C {devices/lab_pin.sym} 78150 -41410 0 1 {name=p77058 lab=_86971_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -41400 0 0 {name=X_86971_ }
C {devices/lab_pin.sym} 77970 -41270 0 0 {name=p77059 lab=_82139_/CLK }
C {devices/lab_pin.sym} 77970 -41250 0 0 {name=p77060 lab=_82094_/D }
C {devices/lab_pin.sym} 78150 -41270 0 1 {name=p77061 lab=_82094_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -41260 0 0 {name=X_82094_ }
C {devices/lab_pin.sym} 77980 -41150 0 0 {name=p77062 lab=_85713_/Q }
C {devices/lab_pin.sym} 77980 -41110 0 0 {name=p77063 lab=_53010_/X }
C {devices/lab_pin.sym} 77980 -41070 0 0 {name=p77064 lab=_53012_/Y }
C {devices/lab_pin.sym} 78140 -41110 0 1 {name=p77065 lab=_53013_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -41110 0 0 {name=X_53013_ }
C {devices/lab_pin.sym} 77980 -40990 0 0 {name=p77066 lab=_86240_/Q }
C {devices/lab_pin.sym} 77980 -40950 0 0 {name=p77067 lab=_50220_/X }
C {devices/lab_pin.sym} 77980 -40910 0 0 {name=p77068 lab=_50224_/Y }
C {devices/lab_pin.sym} 78140 -40950 0 1 {name=p77069 lab=_50225_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -40950 0 0 {name=X_50225_ }
C {devices/lab_pin.sym} 77970 -40810 0 0 {name=p77070 lab=_85444_/CLK }
C {devices/lab_pin.sym} 77970 -40790 0 0 {name=p77071 lab=_51920_/Y }
C {devices/lab_pin.sym} 78150 -40810 0 1 {name=p77072 lab=_85922_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -40800 0 0 {name=X_85922_ }
C {devices/lab_pin.sym} 77970 -40670 0 0 {name=p77073 lab=_81117_/CLK }
C {devices/lab_pin.sym} 77970 -40650 0 0 {name=p77074 lab=_75357_/Y }
C {devices/lab_pin.sym} 78150 -40670 0 1 {name=p77075 lab=_81045_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -40660 0 0 {name=X_81045_ }
C {devices/lab_pin.sym} 77980 -40560 0 0 {name=p77076 lab=_58856_/Y }
C {devices/lab_pin.sym} 77980 -40520 0 0 {name=p77077 lab=_58857_/X }
C {devices/lab_pin.sym} 77980 -40480 0 0 {name=p77078 lab=_58863_/X }
C {devices/lab_pin.sym} 77980 -40440 0 0 {name=p77079 lab=_58869_/X }
C {devices/lab_pin.sym} 78140 -40500 0 1 {name=p77080 lab=_84794_/D }
C {sky130_stdcells/a22oi_4.sym} 78060 -40500 0 0 {name=X_58870_ }
C {devices/lab_pin.sym} 78000 -40360 0 0 {name=p77081 lab=_86651_/Q }
C {devices/lab_pin.sym} 78000 -40320 0 0 {name=p77082 lab=_57833_/B }
C {devices/lab_pin.sym} 78120 -40340 0 1 {name=p77083 lab=_57821_/Y }
C {sky130_stdcells/nor2_4.sym} 78060 -40340 0 0 {name=X_57821_ }
C {devices/lab_pin.sym} 78020 -40210 0 0 {name=p77084 lab=_44148_/A }
C {devices/lab_pin.sym} 78100 -40210 0 1 {name=p77085 lab=_69897_/A }
C {sky130_stdcells/buf_2.sym} 78060 -40210 0 0 {name=X_69807_ }
C {devices/lab_pin.sym} 78000 -40110 0 0 {name=p77086 lab=_52365_/A }
C {devices/lab_pin.sym} 78000 -40070 0 0 {name=p77087 lab=_51256_/B }
C {devices/lab_pin.sym} 78000 -40030 0 0 {name=p77088 lab=_50147_/C }
C {devices/lab_pin.sym} 78120 -40070 0 1 {name=p77089 lab=_50156_/X }
C {sky130_stdcells/and3_4.sym} 78060 -40070 0 0 {name=X_50156_ }
C {devices/lab_pin.sym} 77970 -39930 0 0 {name=p77090 lab=_83623_/CLK }
C {devices/lab_pin.sym} 77970 -39910 0 0 {name=p77091 lab=_85853_/D }
C {devices/lab_pin.sym} 78150 -39930 0 1 {name=p77092 lab=_64719_/B }
C {sky130_stdcells/dfxtp_4.sym} 78060 -39920 0 0 {name=X_85853_ }
C {devices/lab_pin.sym} 77980 -39820 0 0 {name=p77093 lab=_87959_/Q }
C {devices/lab_pin.sym} 77980 -39780 0 0 {name=p77094 lab=_67950_/X }
C {devices/lab_pin.sym} 77980 -39740 0 0 {name=p77095 lab=_67997_/X }
C {devices/lab_pin.sym} 77980 -39700 0 0 {name=p77096 lab=_67998_/X }
C {devices/lab_pin.sym} 78140 -39760 0 1 {name=p77097 lab=_67999_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -39760 0 0 {name=X_67999_ }
C {devices/lab_pin.sym} 77970 -39610 0 0 {name=p77098 lab=_86713_/CLK }
C {devices/lab_pin.sym} 77970 -39590 0 0 {name=p77099 lab=_84804_/D }
C {devices/lab_pin.sym} 78150 -39610 0 1 {name=p77100 lab=_84804_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -39600 0 0 {name=X_84804_ }
C {devices/lab_pin.sym} 77980 -39500 0 0 {name=p77101 lab=_84950_/Q }
C {devices/lab_pin.sym} 77980 -39460 0 0 {name=p77102 lab=_57691_/X }
C {devices/lab_pin.sym} 77980 -39420 0 0 {name=p77103 lab=_57746_/X }
C {devices/lab_pin.sym} 77980 -39380 0 0 {name=p77104 lab=_57751_/X }
C {devices/lab_pin.sym} 78140 -39440 0 1 {name=p77105 lab=_84950_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 78060 -39440 0 0 {name=X_57752_ }
C {devices/lab_pin.sym} 77980 -39320 0 0 {name=p77106 lab=_73108_/A }
C {devices/lab_pin.sym} 77980 -39280 0 0 {name=p77107 lab=_68467_/X }
C {devices/lab_pin.sym} 77980 -39240 0 0 {name=p77108 lab=_69371_/X }
C {devices/lab_pin.sym} 77980 -39200 0 0 {name=p77109 lab=_69737_/Y }
C {devices/lab_pin.sym} 78140 -39260 0 1 {name=p77110 lab=_69738_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -39260 0 0 {name=X_69738_ }
C {devices/lab_pin.sym} 78000 -39140 0 0 {name=p77111 lab=_54964_/A }
C {devices/lab_pin.sym} 78000 -39100 0 0 {name=p77112 lab=_54955_/B }
C {devices/lab_pin.sym} 78000 -39060 0 0 {name=p77113 lab=_54255_/C }
C {devices/lab_pin.sym} 78000 -39020 0 0 {name=p77114 lab=_47540_/A }
C {devices/lab_pin.sym} 78120 -39080 0 1 {name=p77115 lab=_54964_/X }
C {sky130_stdcells/and4_4.sym} 78060 -39080 0 0 {name=X_54964_ }
C {devices/lab_pin.sym} 77980 -38950 0 0 {name=p77116 lab=_50085_/Y }
C {devices/lab_pin.sym} 77980 -38910 0 0 {name=p77117 lab=_50068_/X }
C {devices/lab_pin.sym} 77980 -38870 0 0 {name=p77118 lab=_50086_/X }
C {devices/lab_pin.sym} 78140 -38910 0 1 {name=p77119 lab=_86267_/D }
C {sky130_stdcells/a21oi_4.sym} 78060 -38910 0 0 {name=X_50087_ }
C {devices/lab_pin.sym} 77970 -38770 0 0 {name=p77120 lab=_82769_/CLK }
C {devices/lab_pin.sym} 77970 -38750 0 0 {name=p77121 lab=_85784_/D }
C {devices/lab_pin.sym} 78150 -38770 0 1 {name=p77122 lab=_85784_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -38760 0 0 {name=X_85784_ }
C {devices/lab_pin.sym} 77970 -38630 0 0 {name=p77123 lab=_85013_/CLK }
C {devices/lab_pin.sym} 77970 -38610 0 0 {name=p77124 lab=_74654_/X }
C {devices/lab_pin.sym} 78150 -38630 0 1 {name=p77125 lab=_45604_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -38620 0 0 {name=X_82996_ }
C {devices/lab_pin.sym} 78020 -38490 0 0 {name=p77126 lab=_44253_/X }
C {devices/lab_pin.sym} 78100 -38490 0 1 {name=p77127 lab=_56703_/X }
C {sky130_stdcells/buf_2.sym} 78060 -38490 0 0 {name=X_56703_ }
C {devices/lab_pin.sym} 77970 -38370 0 0 {name=p77128 lab=_88034_/CLK }
C {devices/lab_pin.sym} 77970 -38350 0 0 {name=p77129 lab=_87523_/D }
C {devices/lab_pin.sym} 78150 -38370 0 1 {name=p77130 lab=_87523_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -38360 0 0 {name=X_87523_ }
C {devices/lab_pin.sym} 78000 -38240 0 0 {name=p77131 lab=_53902_/A }
C {devices/lab_pin.sym} 78000 -38200 0 0 {name=p77132 lab=_50183_/B }
C {devices/lab_pin.sym} 78120 -38220 0 1 {name=p77133 lab=_53915_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -38220 0 0 {name=X_53915_ }
C {devices/lab_pin.sym} 77970 -38090 0 0 {name=p77134 lab=_83402_/CLK }
C {devices/lab_pin.sym} 77970 -38070 0 0 {name=p77135 lab=_84735_/D }
C {devices/lab_pin.sym} 78150 -38090 0 1 {name=p77136 lab=_59430_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -38080 0 0 {name=X_84735_ }
C {devices/lab_pin.sym} 77970 -37950 0 0 {name=p77137 lab=_82009_/CLK }
C {devices/lab_pin.sym} 77970 -37930 0 0 {name=p77138 lab=_78042_/Y }
C {devices/lab_pin.sym} 78150 -37950 0 1 {name=p77139 lab=_77609_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -37940 0 0 {name=X_81947_ }
C {devices/lab_pin.sym} 78020 -37810 0 0 {name=p77140 lab=_84954_/Q }
C {devices/lab_pin.sym} 78100 -37810 0 1 {name=p77141 lab=_57683_/X }
C {sky130_stdcells/buf_2.sym} 78060 -37810 0 0 {name=X_57683_ }
C {devices/lab_pin.sym} 77980 -37710 0 0 {name=p77142 lab=_69238_/X }
C {devices/lab_pin.sym} 77980 -37670 0 0 {name=p77143 lab=_69241_/X }
C {devices/lab_pin.sym} 77980 -37630 0 0 {name=p77144 lab=_69575_/X }
C {devices/lab_pin.sym} 78140 -37670 0 1 {name=p77145 lab=_69669_/Y }
C {sky130_stdcells/a21oi_4.sym} 78060 -37670 0 0 {name=X_69669_ }
C {devices/lab_pin.sym} 77980 -37550 0 0 {name=p77146 lab=_85358_/Q }
C {devices/lab_pin.sym} 77980 -37510 0 0 {name=p77147 lab=_54892_/X }
C {devices/lab_pin.sym} 77980 -37470 0 0 {name=p77148 lab=_54894_/Y }
C {devices/lab_pin.sym} 78140 -37510 0 1 {name=p77149 lab=_54895_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -37510 0 0 {name=X_54895_ }
C {devices/lab_pin.sym} 78000 -37390 0 0 {name=p77150 lab=_71338_/A }
C {devices/lab_pin.sym} 78000 -37350 0 0 {name=p77151 lab=_71685_/X }
C {devices/lab_pin.sym} 78000 -37310 0 0 {name=p77152 lab=_70476_/X }
C {devices/lab_pin.sym} 78120 -37350 0 1 {name=p77153 lab=_71700_/Y }
C {sky130_stdcells/nand3_4.sym} 78060 -37350 0 0 {name=X_71700_ }
C {devices/lab_pin.sym} 77980 -37230 0 0 {name=p77154 lab=_59417_/X }
C {devices/lab_pin.sym} 77980 -37190 0 0 {name=p77155 lab=_83482_/Q }
C {devices/lab_pin.sym} 77980 -37150 0 0 {name=p77156 lab=_59421_/Y }
C {devices/lab_pin.sym} 78140 -37190 0 1 {name=p77157 lab=_84738_/D }
C {sky130_stdcells/o21a_4.sym} 78060 -37190 0 0 {name=X_59422_ }
C {devices/lab_pin.sym} 78020 -37050 0 0 {name=p77158 lab=_56633_/X }
C {devices/lab_pin.sym} 78100 -37050 0 1 {name=p77159 lab=_56634_/X }
C {sky130_stdcells/buf_2.sym} 78060 -37050 0 0 {name=X_56634_ }
C {devices/lab_pin.sym} 77980 -36960 0 0 {name=p77160 lab=_40548_/X }
C {devices/lab_pin.sym} 77980 -36920 0 0 {name=p77161 lab=_48226_/A }
C {devices/lab_pin.sym} 77980 -36880 0 0 {name=p77162 lab=_88116_/Q }
C {devices/lab_pin.sym} 77980 -36840 0 0 {name=p77163 lab=_40599_/A }
C {devices/lab_pin.sym} 78140 -36900 0 1 {name=p77164 lab=_88116_/D }
C {sky130_stdcells/a2bb2o_4.sym} 78060 -36900 0 0 {name=X_41860_ }
C {devices/lab_pin.sym} 77970 -36750 0 0 {name=p77165 lab=_87708_/CLK }
C {devices/lab_pin.sym} 77970 -36730 0 0 {name=p77166 lab=_43374_/X }
C {devices/lab_pin.sym} 78150 -36750 0 1 {name=p77167 lab=_87454_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -36740 0 0 {name=X_87454_ }
C {devices/lab_pin.sym} 78020 -36610 0 0 {name=p77168 lab=_53846_/A }
C {devices/lab_pin.sym} 78100 -36610 0 1 {name=p77169 lab=_53846_/X }
C {sky130_stdcells/buf_2.sym} 78060 -36610 0 0 {name=X_53846_ }
C {devices/lab_pin.sym} 77980 -36510 0 0 {name=p77170 lab=_70221_/C }
C {devices/lab_pin.sym} 77980 -36470 0 0 {name=p77171 lab=_72672_/X }
C {devices/lab_pin.sym} 77980 -36430 0 0 {name=p77172 lab=_72679_/Y }
C {devices/lab_pin.sym} 78140 -36470 0 1 {name=p77173 lab=_72680_/X }
C {sky130_stdcells/a21bo_4.sym} 78060 -36470 0 0 {name=X_72680_ }
C {devices/lab_pin.sym} 77970 -36330 0 0 {name=p77174 lab=_84503_/CLK }
C {devices/lab_pin.sym} 77970 -36310 0 0 {name=p77175 lab=_84666_/D }
C {devices/lab_pin.sym} 78150 -36330 0 1 {name=p77176 lab=_80091_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -36320 0 0 {name=X_84666_ }
C {devices/lab_pin.sym} 77970 -36190 0 0 {name=p77177 lab=_81883_/CLK }
C {devices/lab_pin.sym} 77970 -36170 0 0 {name=p77178 lab=_78069_/X }
C {devices/lab_pin.sym} 78150 -36190 0 1 {name=p77179 lab=_81846_/D }
C {sky130_stdcells/dfxtp_4.sym} 78060 -36180 0 0 {name=X_81878_ }
C {devices/lab_pin.sym} 77970 -36050 0 0 {name=p77180 lab=_83783_/CLK }
C {devices/lab_pin.sym} 77970 -36030 0 0 {name=p77181 lab=_86405_/D }
C {devices/lab_pin.sym} 78150 -36050 0 1 {name=p77182 lab=_65343_/B }
C {sky130_stdcells/dfxtp_4.sym} 78060 -36040 0 0 {name=X_86405_ }
C {devices/lab_pin.sym} 77980 -35940 0 0 {name=p77183 lab=_40810_/X }
C {devices/lab_pin.sym} 77980 -35900 0 0 {name=p77184 lab=_40793_/X }
C {devices/lab_pin.sym} 77980 -35860 0 0 {name=p77185 lab=_88330_/Q }
C {devices/lab_pin.sym} 77980 -35820 0 0 {name=p77186 lab=_40794_/X }
C {devices/lab_pin.sym} 78140 -35880 0 1 {name=p77187 lab=_40811_/X }
C {sky130_stdcells/a2bb2o_4.sym} 78060 -35880 0 0 {name=X_40811_ }
C {devices/lab_pin.sym} 77980 -35760 0 0 {name=p77188 lab=_84749_/Q }
C {devices/lab_pin.sym} 77980 -35720 0 0 {name=p77189 lab=_59339_/X }
C {devices/lab_pin.sym} 77980 -35680 0 0 {name=p77190 lab=_59343_/X }
C {devices/lab_pin.sym} 77980 -35640 0 0 {name=p77191 lab=_59352_/X }
C {devices/lab_pin.sym} 78140 -35700 0 1 {name=p77192 lab=_84749_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 78060 -35700 0 0 {name=X_59353_ }
C {devices/lab_pin.sym} 78020 -35550 0 0 {name=p77193 lab=_71641_/A }
C {devices/lab_pin.sym} 78100 -35550 0 1 {name=p77194 lab=_71637_/C }
C {sky130_stdcells/buf_2.sym} 78060 -35550 0 0 {name=X_71631_ }
C {devices/lab_pin.sym} 77970 -35430 0 0 {name=p77195 lab=_85562_/CLK }
C {devices/lab_pin.sym} 77970 -35410 0 0 {name=p77196 lab=_71074_/Y }
C {devices/lab_pin.sym} 78150 -35430 0 1 {name=p77197 lab=_48962_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -35420 0 0 {name=X_83617_ }
C {devices/lab_pin.sym} 78000 -35310 0 0 {name=p77198 lab=_56561_/X }
C {devices/lab_pin.sym} 78000 -35270 0 0 {name=p77199 lab=_56798_/B }
C {devices/lab_pin.sym} 78000 -35230 0 0 {name=p77200 lab=_56931_/A }
C {devices/lab_pin.sym} 78120 -35270 0 1 {name=p77201 lab=_56565_/Y }
C {sky130_stdcells/nand3_4.sym} 78060 -35270 0 0 {name=X_56565_ }
C {devices/lab_pin.sym} 77970 -35130 0 0 {name=p77202 lab=_81065_/CLK }
C {devices/lab_pin.sym} 77970 -35110 0 0 {name=p77203 lab=_83973_/Q }
C {devices/lab_pin.sym} 78150 -35130 0 1 {name=p77204 lab=_75669_/B }
C {sky130_stdcells/dfxtp_4.sym} 78060 -35120 0 0 {name=X_80829_ }
C {devices/lab_pin.sym} 77970 -34990 0 0 {name=p77205 lab=_87189_/CLK }
C {devices/lab_pin.sym} 77970 -34970 0 0 {name=p77206 lab=_43509_/X }
C {devices/lab_pin.sym} 78150 -34990 0 1 {name=p77207 lab=_87385_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -34980 0 0 {name=X_87385_ }
C {devices/lab_pin.sym} 78020 -34850 0 0 {name=p77208 lab=_41790_/X }
C {devices/lab_pin.sym} 78100 -34850 0 1 {name=p77209 lab=_41791_/X }
C {sky130_stdcells/buf_2.sym} 78060 -34850 0 0 {name=X_41791_ }
C {devices/lab_pin.sym} 77980 -34750 0 0 {name=p77210 lab=_85570_/Q }
C {devices/lab_pin.sym} 77980 -34710 0 0 {name=p77211 lab=_53722_/X }
C {devices/lab_pin.sym} 77980 -34670 0 0 {name=p77212 lab=_53776_/Y }
C {devices/lab_pin.sym} 78140 -34710 0 1 {name=p77213 lab=_53777_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -34710 0 0 {name=X_53777_ }
C {devices/lab_pin.sym} 77970 -34570 0 0 {name=p77214 lab=_84333_/CLK }
C {devices/lab_pin.sym} 77970 -34550 0 0 {name=p77215 lab=_60575_/X }
C {devices/lab_pin.sym} 78150 -34570 0 1 {name=p77216 lab=_79137_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -34560 0 0 {name=X_84597_ }
C {devices/lab_pin.sym} 78000 -34460 0 0 {name=p77217 lab=_50973_/X }
C {devices/lab_pin.sym} 78000 -34420 0 0 {name=p77218 lab=_50985_/B }
C {devices/lab_pin.sym} 78000 -34380 0 0 {name=p77219 lab=_50985_/C }
C {devices/lab_pin.sym} 78000 -34340 0 0 {name=p77220 lab=_52681_/D }
C {devices/lab_pin.sym} 78120 -34400 0 1 {name=p77221 lab=_50989_/X }
C {sky130_stdcells/and4_4.sym} 78060 -34400 0 0 {name=X_50989_ }
C {devices/lab_pin.sym} 78020 -34250 0 0 {name=p77222 lab=_64546_/C }
C {devices/lab_pin.sym} 78100 -34250 0 1 {name=p77223 lab=_63703_/B }
C {sky130_stdcells/buf_2.sym} 78060 -34250 0 0 {name=X_58304_ }
C {devices/lab_pin.sym} 78020 -34130 0 0 {name=p77224 lab=_43529_/Y }
C {devices/lab_pin.sym} 78100 -34130 0 1 {name=p77225 lab=_87374_/D }
C {sky130_stdcells/inv_2.sym} 78060 -34130 0 0 {name=X_43530_ }
C {devices/lab_pin.sym} 78020 -34010 0 0 {name=p77226 lab=_44112_/X }
C {devices/lab_pin.sym} 78100 -34010 0 1 {name=p77227 lab=_55516_/X }
C {sky130_stdcells/buf_2.sym} 78060 -34010 0 0 {name=X_55516_ }
C {devices/lab_pin.sym} 77970 -33890 0 0 {name=p77228 lab=_86655_/CLK }
C {devices/lab_pin.sym} 77970 -33870 0 0 {name=p77229 lab=_86336_/D }
C {devices/lab_pin.sym} 78150 -33890 0 1 {name=p77230 lab=_57721_/B }
C {sky130_stdcells/dfxtp_4.sym} 78060 -33880 0 0 {name=X_86336_ }
C {devices/lab_pin.sym} 77980 -33770 0 0 {name=p77231 lab=_83088_/Q }
C {devices/lab_pin.sym} 77980 -33730 0 0 {name=p77232 lab=_74340_/X }
C {devices/lab_pin.sym} 77980 -33690 0 0 {name=p77233 lab=_74349_/Y }
C {devices/lab_pin.sym} 78140 -33730 0 1 {name=p77234 lab=_74350_/X }
C {sky130_stdcells/a21bo_4.sym} 78060 -33730 0 0 {name=X_74350_ }
C {devices/lab_pin.sym} 77980 -33610 0 0 {name=p77235 lab=_40698_/X }
C {devices/lab_pin.sym} 77980 -33570 0 0 {name=p77236 lab=_82853_/Q }
C {devices/lab_pin.sym} 77980 -33530 0 0 {name=p77237 lab=_40741_/X }
C {devices/lab_pin.sym} 78140 -33570 0 1 {name=p77238 lab=_40742_/X }
C {sky130_stdcells/o21a_4.sym} 78060 -33570 0 0 {name=X_40742_ }
C {devices/lab_pin.sym} 78020 -33430 0 0 {name=p77239 lab=_52619_/A }
C {devices/lab_pin.sym} 78100 -33430 0 1 {name=p77240 lab=_52728_/X }
C {sky130_stdcells/buf_2.sym} 78060 -33430 0 0 {name=X_52728_ }
C {devices/lab_pin.sym} 77980 -33330 0 0 {name=p77241 lab=_59273_/X }
C {devices/lab_pin.sym} 77980 -33290 0 0 {name=p77242 lab=_85642_/Q }
C {devices/lab_pin.sym} 77980 -33250 0 0 {name=p77243 lab=_59196_/X }
C {devices/lab_pin.sym} 78140 -33290 0 1 {name=p77244 lab=_59284_/X }
C {sky130_stdcells/o21a_4.sym} 78060 -33290 0 0 {name=X_59284_ }
C {devices/lab_pin.sym} 77980 -33170 0 0 {name=p77245 lab=_71557_/X }
C {devices/lab_pin.sym} 77980 -33130 0 0 {name=p77246 lab=_83456_/Q }
C {devices/lab_pin.sym} 77980 -33090 0 0 {name=p77247 lab=_71561_/Y }
C {devices/lab_pin.sym} 78140 -33130 0 1 {name=p77248 lab=_83456_/D }
C {sky130_stdcells/a21o_4.sym} 78060 -33130 0 0 {name=X_71562_ }
C {devices/lab_pin.sym} 77970 -32990 0 0 {name=p77249 lab=_85354_/CLK }
C {devices/lab_pin.sym} 77970 -32970 0 0 {name=p77250 lab=_83548_/D }
C {devices/lab_pin.sym} 78150 -32990 0 1 {name=p77251 lab=_47725_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -32980 0 0 {name=X_83548_ }
C {devices/lab_pin.sym} 78020 -32850 0 0 {name=p77252 lab=_56448_/X }
C {devices/lab_pin.sym} 78100 -32850 0 1 {name=p77253 lab=_56507_/B }
C {sky130_stdcells/buf_2.sym} 78060 -32850 0 0 {name=X_56496_ }
C {devices/lab_pin.sym} 77980 -32750 0 0 {name=p77254 lab=_73297_/X }
C {devices/lab_pin.sym} 77980 -32710 0 0 {name=p77255 lab=_73300_/X }
C {devices/lab_pin.sym} 77980 -32670 0 0 {name=p77256 lab=_73200_/X }
C {devices/lab_pin.sym} 78140 -32710 0 1 {name=p77257 lab=_73301_/X }
C {sky130_stdcells/a21o_4.sym} 78060 -32710 0 0 {name=X_73301_ }
C {sky130_stdcells/decap_3.sym} 78060 -32540 0 0 {name=XPHY_610 }
C {devices/lab_pin.sym} 78020 -32390 0 0 {name=p77258 lab=_71054_/A }
C {devices/lab_pin.sym} 78100 -32390 0 1 {name=p77259 lab=_70945_/B }
C {sky130_stdcells/buf_2.sym} 78060 -32390 0 0 {name=X_70513_ }
C {devices/lab_pin.sym} 77980 -32290 0 0 {name=p77260 lab=_46179_/X }
C {devices/lab_pin.sym} 77980 -32250 0 0 {name=p77261 lab=_58232_/X }
C {devices/lab_pin.sym} 77980 -32210 0 0 {name=p77262 lab=_58234_/Y }
C {devices/lab_pin.sym} 78140 -32250 0 1 {name=p77263 lab=_58235_/X }
C {sky130_stdcells/o21a_4.sym} 78060 -32250 0 0 {name=X_58235_ }
C {devices/lab_pin.sym} 78020 -32110 0 0 {name=p77264 lab=_43461_/A }
C {devices/lab_pin.sym} 78100 -32110 0 1 {name=p77265 lab=_87411_/D }
C {sky130_stdcells/inv_2.sym} 78060 -32110 0 0 {name=X_43461_ }
C {devices/lab_pin.sym} 77980 -32010 0 0 {name=p77266 lab=_55201_/Y }
C {devices/lab_pin.sym} 77980 -31970 0 0 {name=p77267 lab=_55299_/Y }
C {devices/lab_pin.sym} 77980 -31930 0 0 {name=p77268 lab=_55446_/X }
C {devices/lab_pin.sym} 78140 -31970 0 1 {name=p77269 lab=_55447_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -31970 0 0 {name=X_55447_ }
C {devices/lab_pin.sym} 78000 -31850 0 0 {name=p77270 lab=_74279_/X }
C {devices/lab_pin.sym} 78000 -31810 0 0 {name=p77271 lab=_74268_/X }
C {devices/lab_pin.sym} 78000 -31770 0 0 {name=p77272 lab=_74281_/C }
C {devices/lab_pin.sym} 78120 -31810 0 1 {name=p77273 lab=_74281_/Y }
C {sky130_stdcells/nand3_4.sym} 78060 -31810 0 0 {name=X_74281_ }
C {devices/lab_pin.sym} 77970 -31670 0 0 {name=p77274 lab=_83305_/CLK }
C {devices/lab_pin.sym} 77970 -31650 0 0 {name=p77275 lab=_86267_/D }
C {devices/lab_pin.sym} 78150 -31670 0 1 {name=p77276 lab=_86267_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -31660 0 0 {name=X_86267_ }
C {sky130_stdcells/decap_3.sym} 78060 -31500 0 0 {name=XPHY_621 }
C {devices/lab_pin.sym} 77980 -31370 0 0 {name=p77277 lab=_85778_/Q }
C {devices/lab_pin.sym} 77980 -31330 0 0 {name=p77278 lab=_52656_/X }
C {devices/lab_pin.sym} 77980 -31290 0 0 {name=p77279 lab=_52658_/Y }
C {devices/lab_pin.sym} 78140 -31330 0 1 {name=p77280 lab=_52659_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -31330 0 0 {name=X_52659_ }
C {devices/lab_pin.sym} 78020 -31190 0 0 {name=p77281 lab=_40672_/Y }
C {devices/lab_pin.sym} 78100 -31190 0 1 {name=p77282 lab=_40673_/X }
C {sky130_stdcells/buf_2.sym} 78060 -31190 0 0 {name=X_40673_ }
C {devices/lab_pin.sym} 77980 -31090 0 0 {name=p77283 lab=_71487_/X }
C {devices/lab_pin.sym} 77980 -31050 0 0 {name=p77284 lab=_83480_/Q }
C {devices/lab_pin.sym} 77980 -31010 0 0 {name=p77285 lab=_71492_/X }
C {devices/lab_pin.sym} 78140 -31050 0 1 {name=p77286 lab=_83480_/D }
C {sky130_stdcells/a21o_4.sym} 78060 -31050 0 0 {name=X_71493_ }
C {devices/lab_pin.sym} 77970 -30910 0 0 {name=p77287 lab=_83415_/CLK }
C {devices/lab_pin.sym} 77970 -30890 0 0 {name=p77288 lab=_83479_/D }
C {devices/lab_pin.sym} 78150 -30910 0 1 {name=p77289 lab=_83479_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -30900 0 0 {name=X_83479_ }
C {sky130_stdcells/decap_3.sym} 78060 -30740 0 0 {name=XPHY_632 }
C {sky130_stdcells/decap_3.sym} 78060 -30560 0 0 {name=XPHY_643 }
C {devices/lab_pin.sym} 78020 -30410 0 0 {name=p77290 lab=_44972_/X }
C {devices/lab_pin.sym} 78100 -30410 0 1 {name=p77291 lab=_45200_/X }
C {sky130_stdcells/buf_2.sym} 78060 -30410 0 0 {name=X_45200_ }
C {devices/lab_pin.sym} 78000 -30300 0 0 {name=p77292 lab=_81711_/D }
C {devices/lab_pin.sym} 78000 -30260 0 0 {name=p77293 lab=_76021_/B }
C {devices/lab_pin.sym} 78120 -30280 0 1 {name=p77294 lab=_76020_/Y }
C {sky130_stdcells/nor2_4.sym} 78060 -30280 0 0 {name=X_76020_ }
C {devices/lab_pin.sym} 77970 -30150 0 0 {name=p77295 lab=_88006_/CLK }
C {devices/lab_pin.sym} 77970 -30130 0 0 {name=p77296 lab=_88006_/D }
C {devices/lab_pin.sym} 78150 -30150 0 1 {name=p77297 lab=_88006_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -30140 0 0 {name=X_88006_ }
C {devices/lab_pin.sym} 77980 -30050 0 0 {name=p77298 lab=_42401_/X }
C {devices/lab_pin.sym} 77980 -30010 0 0 {name=p77299 lab=_42410_/X }
C {devices/lab_pin.sym} 77980 -29970 0 0 {name=p77300 lab=_40459_/X }
C {devices/lab_pin.sym} 77980 -29930 0 0 {name=p77301 lab=_87876_/Q }
C {devices/lab_pin.sym} 77980 -29890 0 0 {name=p77302 lab=_42411_/X }
C {devices/lab_pin.sym} 78140 -29970 0 1 {name=p77303 lab=_42412_/Y }
C {sky130_stdcells/o32ai_4.sym} 78060 -29970 0 0 {name=X_42412_ }
C {sky130_stdcells/decap_3.sym} 78060 -29780 0 0 {name=XPHY_654 }
C {devices/lab_pin.sym} 77980 -29650 0 0 {name=p77304 lab=_87053_/Q }
C {devices/lab_pin.sym} 77980 -29610 0 0 {name=p77305 lab=_73129_/X }
C {devices/lab_pin.sym} 77980 -29570 0 0 {name=p77306 lab=_73231_/X }
C {devices/lab_pin.sym} 78140 -29610 0 1 {name=p77307 lab=_73232_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -29610 0 0 {name=X_73232_ }
C {devices/lab_pin.sym} 77970 -29470 0 0 {name=p77308 lab=_85250_/CLK }
C {devices/lab_pin.sym} 77970 -29450 0 0 {name=p77309 lab=_85218_/D }
C {devices/lab_pin.sym} 78150 -29470 0 1 {name=p77310 lab=_55736_/B }
C {sky130_stdcells/dfxtp_4.sym} 78060 -29460 0 0 {name=X_85218_ }
C {devices/lab_pin.sym} 78020 -29330 0 0 {name=p77311 lab=_70426_/A }
C {devices/lab_pin.sym} 78100 -29330 0 1 {name=p77312 lab=_71650_/A }
C {sky130_stdcells/buf_2.sym} 78060 -29330 0 0 {name=X_70444_ }
C {devices/lab_pin.sym} 77980 -29250 0 0 {name=p77313 lab=_46120_/B }
C {devices/lab_pin.sym} 77980 -29210 0 0 {name=p77314 lab=_72527_/A }
C {devices/lab_pin.sym} 77980 -29170 0 0 {name=p77315 lab=_46179_/X }
C {devices/lab_pin.sym} 77980 -29130 0 0 {name=p77316 lab=_46112_/A }
C {devices/lab_pin.sym} 77980 -29090 0 0 {name=p77317 lab=_46111_/X }
C {devices/lab_pin.sym} 78140 -29170 0 1 {name=p77318 lab=_46180_/Y }
C {sky130_stdcells/a2111oi_4.sym} 78060 -29170 0 0 {name=X_46180_ }
C {devices/lab_pin.sym} 78020 -29010 0 0 {name=p77319 lab=_58166_/A }
C {devices/lab_pin.sym} 78100 -29010 0 1 {name=p77320 lab=_63069_/A }
C {sky130_stdcells/inv_2.sym} 78060 -29010 0 0 {name=X_58166_ }
C {sky130_stdcells/decap_3.sym} 78060 -28860 0 0 {name=XPHY_665 }
C {devices/lab_pin.sym} 77980 -28740 0 0 {name=p77321 lab=_41447_/X }
C {devices/lab_pin.sym} 77980 -28700 0 0 {name=p77322 lab=_43386_/X }
C {devices/lab_pin.sym} 77980 -28660 0 0 {name=p77323 lab=_87445_/Q }
C {devices/lab_pin.sym} 77980 -28620 0 0 {name=p77324 lab=_43388_/X }
C {devices/lab_pin.sym} 78140 -28680 0 1 {name=p77325 lab=_87445_/D }
C {sky130_stdcells/a2bb2o_4.sym} 78060 -28680 0 0 {name=X_43392_ }
C {devices/lab_pin.sym} 78000 -28540 0 0 {name=p77326 lab=_55322_/X }
C {devices/lab_pin.sym} 78000 -28500 0 0 {name=p77327 lab=_55324_/X }
C {devices/lab_pin.sym} 78120 -28520 0 1 {name=p77328 lab=_55378_/X }
C {sky130_stdcells/and2_4.sym} 78060 -28520 0 0 {name=X_55378_ }
C {devices/lab_pin.sym} 77970 -28390 0 0 {name=p77329 lab=_86196_/CLK }
C {devices/lab_pin.sym} 77970 -28370 0 0 {name=p77330 lab=_50452_/Y }
C {devices/lab_pin.sym} 78150 -28390 0 1 {name=p77331 lab=_86198_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -28380 0 0 {name=X_86198_ }
C {sky130_stdcells/decap_3.sym} 78060 -28220 0 0 {name=XPHY_676 }
C {sky130_stdcells/decap_3.sym} 78060 -28040 0 0 {name=XPHY_687 }
C {sky130_stdcells/decap_3.sym} 78060 -27860 0 0 {name=XPHY_698 }
C {devices/lab_pin.sym} 78020 -27710 0 0 {name=p77332 lab=_45197_/A }
C {devices/lab_pin.sym} 78100 -27710 0 1 {name=p77333 lab=_45131_/X }
C {sky130_stdcells/buf_2.sym} 78060 -27710 0 0 {name=X_45131_ }
C {devices/lab_pin.sym} 77980 -27610 0 0 {name=p77334 lab=_56626_/X }
C {devices/lab_pin.sym} 77980 -27570 0 0 {name=p77335 lab=_57105_/Y }
C {devices/lab_pin.sym} 77980 -27530 0 0 {name=p77336 lab=_57116_/Y }
C {devices/lab_pin.sym} 78140 -27570 0 1 {name=p77337 lab=_85079_/D }
C {sky130_stdcells/a21oi_4.sym} 78060 -27570 0 0 {name=X_57117_ }
C {devices/lab_pin.sym} 78020 -27430 0 0 {name=p77338 lab=_42304_/X }
C {devices/lab_pin.sym} 78100 -27430 0 1 {name=p77339 lab=_42343_/X }
C {sky130_stdcells/buf_2.sym} 78060 -27430 0 0 {name=X_42343_ }
C {devices/lab_pin.sym} 78020 -27310 0 0 {name=p77340 lab=_54329_/A }
C {devices/lab_pin.sym} 78100 -27310 0 1 {name=p77341 lab=_54353_/B }
C {sky130_stdcells/buf_2.sym} 78060 -27310 0 0 {name=X_54329_ }
C {devices/lab_pin.sym} 78020 -27190 0 0 {name=p77342 lab=_73163_/A }
C {devices/lab_pin.sym} 78100 -27190 0 1 {name=p77343 lab=_73163_/X }
C {sky130_stdcells/buf_2.sym} 78060 -27190 0 0 {name=X_73163_ }
C {devices/lab_pin.sym} 77970 -27070 0 0 {name=p77344 lab=_85152_/CLK }
C {devices/lab_pin.sym} 77970 -27050 0 0 {name=p77345 lab=_56585_/X }
C {devices/lab_pin.sym} 78150 -27070 0 1 {name=p77346 lab=_55590_/B }
C {sky130_stdcells/dfxtp_4.sym} 78060 -27060 0 0 {name=X_85149_ }
C {devices/lab_pin.sym} 78000 -26950 0 0 {name=p77347 lab=_70366_/X }
C {devices/lab_pin.sym} 78000 -26910 0 0 {name=p77348 lab=_70374_/X }
C {devices/lab_pin.sym} 78000 -26870 0 0 {name=p77349 lab=_70375_/C }
C {devices/lab_pin.sym} 78120 -26910 0 1 {name=p77350 lab=_70375_/Y }
C {sky130_stdcells/nand3_4.sym} 78060 -26910 0 0 {name=X_70375_ }
C {devices/lab_pin.sym} 78000 -26780 0 0 {name=p77351 lab=_58097_/A }
C {devices/lab_pin.sym} 78000 -26740 0 0 {name=p77352 lab=_58136_/B }
C {devices/lab_pin.sym} 78120 -26760 0 1 {name=p77353 lab=_58097_/Y }
C {sky130_stdcells/nor2_4.sym} 78060 -26760 0 0 {name=X_58097_ }
C {devices/lab_pin.sym} 77980 -26650 0 0 {name=p77354 lab=_72111_/Y }
C {devices/lab_pin.sym} 77980 -26610 0 0 {name=p77355 lab=_72059_/X }
C {devices/lab_pin.sym} 77980 -26570 0 0 {name=p77356 lab=_72113_/X }
C {devices/lab_pin.sym} 78140 -26610 0 1 {name=p77357 lab=_72114_/Y }
C {sky130_stdcells/a21oi_4.sym} 78060 -26610 0 0 {name=X_72114_ }
C {devices/lab_pin.sym} 77980 -26490 0 0 {name=p77358 lab=_85207_/Q }
C {devices/lab_pin.sym} 77980 -26450 0 0 {name=p77359 lab=_45027_/X }
C {devices/lab_pin.sym} 77980 -26410 0 0 {name=p77360 lab=_45061_/X }
C {devices/lab_pin.sym} 78140 -26450 0 1 {name=p77361 lab=_45062_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -26450 0 0 {name=X_45062_ }
C {devices/lab_pin.sym} 78020 -26310 0 0 {name=p77362 lab=_56551_/X }
C {devices/lab_pin.sym} 78100 -26310 0 1 {name=p77363 lab=_57049_/A }
C {sky130_stdcells/buf_2.sym} 78060 -26310 0 0 {name=X_57048_ }
C {devices/lab_pin.sym} 77980 -26220 0 0 {name=p77364 lab=_41511_/X }
C {devices/lab_pin.sym} 77980 -26180 0 0 {name=p77365 lab=_42271_/X }
C {devices/lab_pin.sym} 77980 -26140 0 0 {name=p77366 lab=_87945_/Q }
C {devices/lab_pin.sym} 77980 -26100 0 0 {name=p77367 lab=_42272_/X }
C {devices/lab_pin.sym} 78140 -26160 0 1 {name=p77368 lab=_42274_/X }
C {sky130_stdcells/a2bb2o_4.sym} 78060 -26160 0 0 {name=X_42274_ }
C {devices/lab_pin.sym} 77980 -26040 0 0 {name=p77369 lab=_72959_/X }
C {devices/lab_pin.sym} 77980 -26000 0 0 {name=p77370 lab=_85589_/Q }
C {devices/lab_pin.sym} 77980 -25960 0 0 {name=p77371 lab=_73092_/X }
C {devices/lab_pin.sym} 77980 -25920 0 0 {name=p77372 lab=_73093_/X }
C {devices/lab_pin.sym} 78140 -25980 0 1 {name=p77373 lab=_73094_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -25980 0 0 {name=X_73094_ }
C {devices/lab_pin.sym} 78000 -25840 0 0 {name=p77374 lab=_81948_/D }
C {devices/lab_pin.sym} 78000 -25800 0 0 {name=p77375 lab=_77964_/A }
C {devices/lab_pin.sym} 78120 -25820 0 1 {name=p77376 lab=_77971_/X }
C {sky130_stdcells/and2_4.sym} 78060 -25820 0 0 {name=X_77971_ }
C {devices/lab_pin.sym} 78020 -25690 0 0 {name=p77377 lab=clkbuf_9_220_0_CLK/X }
C {devices/lab_pin.sym} 78100 -25690 0 1 {name=p77378 lab=_84210_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 78060 -25690 0 0 {name=Xclkbuf_10_440_0_CLK }
C {devices/lab_pin.sym} 78020 -25570 0 0 {name=p77379 lab=_64806_/A }
C {devices/lab_pin.sym} 78100 -25570 0 1 {name=p77380 lab=_64629_/A }
C {sky130_stdcells/buf_2.sym} 78060 -25570 0 0 {name=X_44013_ }
C {devices/lab_pin.sym} 78000 -25460 0 0 {name=p77381 lab=_79699_/X }
C {devices/lab_pin.sym} 78000 -25420 0 0 {name=p77382 lab=_79710_/B }
C {devices/lab_pin.sym} 78120 -25440 0 1 {name=p77383 lab=_79710_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -25440 0 0 {name=X_79710_ }
C {devices/lab_pin.sym} 78020 -25310 0 0 {name=p77384 lab=_41224_/X }
C {devices/lab_pin.sym} 78100 -25310 0 1 {name=p77385 lab=_41225_/X }
C {sky130_stdcells/buf_2.sym} 78060 -25310 0 0 {name=X_41225_ }
C {devices/lab_pin.sym} 77980 -25210 0 0 {name=p77386 lab=_72041_/Y }
C {devices/lab_pin.sym} 77980 -25170 0 0 {name=p77387 lab=_71978_/X }
C {devices/lab_pin.sym} 77980 -25130 0 0 {name=p77388 lab=_72044_/X }
C {devices/lab_pin.sym} 78140 -25170 0 1 {name=p77389 lab=_72045_/Y }
C {sky130_stdcells/a21oi_4.sym} 78060 -25170 0 0 {name=X_72045_ }
C {devices/lab_pin.sym} 77980 -25050 0 0 {name=p77390 lab=_76914_/A }
C {devices/lab_pin.sym} 77980 -25010 0 0 {name=p77391 lab=_76914_/B }
C {devices/lab_pin.sym} 77980 -24970 0 0 {name=p77392 lab=_76921_/Y }
C {devices/lab_pin.sym} 78140 -25010 0 1 {name=p77393 lab=_76922_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -25010 0 0 {name=X_76922_ }
C {devices/lab_pin.sym} 78020 -24870 0 0 {name=p77394 lab=_49924_/A }
C {devices/lab_pin.sym} 78100 -24870 0 1 {name=p77395 lab=_49870_/X }
C {sky130_stdcells/buf_2.sym} 78060 -24870 0 0 {name=X_49870_ }
C {devices/lab_pin.sym} 77980 -24770 0 0 {name=p77396 lab=_86476_/Q }
C {devices/lab_pin.sym} 77980 -24730 0 0 {name=p77397 lab=_48809_/X }
C {devices/lab_pin.sym} 77980 -24690 0 0 {name=p77398 lab=_48820_/Y }
C {devices/lab_pin.sym} 78140 -24730 0 1 {name=p77399 lab=_48821_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -24730 0 0 {name=X_48821_ }
C {devices/lab_pin.sym} 78000 -24600 0 0 {name=p77400 lab=_79630_/X }
C {devices/lab_pin.sym} 78000 -24560 0 0 {name=p77401 lab=_79627_/Y }
C {devices/lab_pin.sym} 78120 -24580 0 1 {name=p77402 lab=_79642_/D }
C {sky130_stdcells/nand2_4.sym} 78060 -24580 0 0 {name=X_79641_ }
C {devices/lab_pin.sym} 77980 -24470 0 0 {name=p77403 lab=_41061_/X }
C {devices/lab_pin.sym} 77980 -24430 0 0 {name=p77404 lab=_81721_/Q }
C {devices/lab_pin.sym} 77980 -24390 0 0 {name=p77405 lab=_41155_/X }
C {devices/lab_pin.sym} 78140 -24430 0 1 {name=p77406 lab=_41157_/A }
C {sky130_stdcells/o21ai_4.sym} 78060 -24430 0 0 {name=X_41156_ }
C {devices/lab_pin.sym} 77980 -24310 0 0 {name=p77407 lab=_76837_/B }
C {devices/lab_pin.sym} 77980 -24270 0 0 {name=p77408 lab=_76850_/X }
C {devices/lab_pin.sym} 77980 -24230 0 0 {name=p77409 lab=_76852_/Y }
C {devices/lab_pin.sym} 78140 -24270 0 1 {name=p77410 lab=_76854_/B }
C {sky130_stdcells/a21oi_4.sym} 78060 -24270 0 0 {name=X_76853_ }
C {devices/lab_pin.sym} 77980 -24150 0 0 {name=p77411 lab=_58961_/X }
C {devices/lab_pin.sym} 77980 -24110 0 0 {name=p77412 lab=_85665_/Q }
C {devices/lab_pin.sym} 77980 -24070 0 0 {name=p77413 lab=_58900_/X }
C {devices/lab_pin.sym} 78140 -24110 0 1 {name=p77414 lab=_58999_/X }
C {sky130_stdcells/o21a_4.sym} 78060 -24110 0 0 {name=X_58999_ }
C {devices/lab_pin.sym} 78000 -23990 0 0 {name=p77415 lab=_75803_/C }
C {devices/lab_pin.sym} 78000 -23950 0 0 {name=p77416 lab=_75787_/A }
C {devices/lab_pin.sym} 78000 -23910 0 0 {name=p77417 lab=_75786_/X }
C {devices/lab_pin.sym} 78120 -23950 0 1 {name=p77418 lab=_75804_/Y }
C {sky130_stdcells/nand3_4.sym} 78060 -23950 0 0 {name=X_75804_ }
C {devices/lab_pin.sym} 78000 -23830 0 0 {name=p77419 lab=_48752_/A }
C {devices/lab_pin.sym} 78000 -23790 0 0 {name=p77420 lab=_48766_/B }
C {devices/lab_pin.sym} 78000 -23750 0 0 {name=p77421 lab=_48761_/C }
C {devices/lab_pin.sym} 78120 -23790 0 1 {name=p77422 lab=_48752_/X }
C {sky130_stdcells/and3_4.sym} 78060 -23790 0 0 {name=X_48752_ }
C {devices/lab_pin.sym} 78000 -23660 0 0 {name=p77423 lab=_65348_/C }
C {devices/lab_pin.sym} 78000 -23620 0 0 {name=p77424 lab=_83253_/Q }
C {devices/lab_pin.sym} 78120 -23640 0 1 {name=p77425 lab=_79572_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -23640 0 0 {name=X_79572_ }
C {devices/lab_pin.sym} 78020 -23510 0 0 {name=p77426 lab=_45964_/A }
C {devices/lab_pin.sym} 78100 -23510 0 1 {name=p77427 lab=_45964_/X }
C {sky130_stdcells/buf_2.sym} 78060 -23510 0 0 {name=X_45964_ }
C {devices/lab_pin.sym} 78020 -23390 0 0 {name=p77428 lab=_41086_/X }
C {devices/lab_pin.sym} 78100 -23390 0 1 {name=p77429 lab=_41087_/X }
C {sky130_stdcells/buf_2.sym} 78060 -23390 0 0 {name=X_41087_ }
C {devices/lab_pin.sym} 78020 -23270 0 0 {name=p77430 lab=clkbuf_9_227_0_CLK/X }
C {devices/lab_pin.sym} 78100 -23270 0 1 {name=p77431 lab=_85692_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 78060 -23270 0 0 {name=Xclkbuf_10_455_0_CLK }
C {devices/lab_pin.sym} 78020 -23150 0 0 {name=p77432 lab=_81489_/Q }
C {devices/lab_pin.sym} 78100 -23150 0 1 {name=p77433 lab=_76784_/Y }
C {sky130_stdcells/inv_2.sym} 78060 -23150 0 0 {name=X_76784_ }
C {devices/lab_pin.sym} 77980 -23060 0 0 {name=p77434 lab=_72744_/X }
C {devices/lab_pin.sym} 77980 -23020 0 0 {name=p77435 lab=_85615_/Q }
C {devices/lab_pin.sym} 77980 -22980 0 0 {name=p77436 lab=_72857_/X }
C {devices/lab_pin.sym} 77980 -22940 0 0 {name=p77437 lab=_73995_/X }
C {devices/lab_pin.sym} 78140 -23000 0 1 {name=p77438 lab=_73996_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -23000 0 0 {name=X_73996_ }
C {devices/lab_pin.sym} 77980 -22870 0 0 {name=p77439 lab=_47697_/Y }
C {devices/lab_pin.sym} 77980 -22830 0 0 {name=p77440 lab=_47698_/X }
C {devices/lab_pin.sym} 77980 -22790 0 0 {name=p77441 lab=_47702_/X }
C {devices/lab_pin.sym} 78140 -22830 0 1 {name=p77442 lab=_86607_/D }
C {sky130_stdcells/a21oi_4.sym} 78060 -22830 0 0 {name=X_47703_ }
C {devices/lab_pin.sym} 78000 -22700 0 0 {name=p77443 lab=_78524_/A }
C {devices/lab_pin.sym} 78000 -22660 0 0 {name=p77444 lab=_82673_/D }
C {devices/lab_pin.sym} 78120 -22680 0 1 {name=p77445 lab=_78526_/B }
C {sky130_stdcells/nor2_4.sym} 78060 -22680 0 0 {name=X_78523_ }
C {devices/lab_pin.sym} 77980 -22570 0 0 {name=p77446 lab=_56379_/C }
C {devices/lab_pin.sym} 77980 -22530 0 0 {name=p77447 lab=_44880_/X }
C {devices/lab_pin.sym} 77980 -22490 0 0 {name=p77448 lab=_44914_/X }
C {devices/lab_pin.sym} 78140 -22530 0 1 {name=p77449 lab=_44915_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -22530 0 0 {name=X_44915_ }
C {devices/lab_pin.sym} 78020 -22390 0 0 {name=p77450 lab=_75735_/A }
C {devices/lab_pin.sym} 78100 -22390 0 1 {name=p77451 lab=_75735_/Y }
C {sky130_stdcells/inv_2.sym} 78060 -22390 0 0 {name=X_75735_ }
C {devices/lab_pin.sym} 78020 -22270 0 0 {name=p77452 lab=_48683_/A }
C {devices/lab_pin.sym} 78100 -22270 0 1 {name=p77453 lab=_48684_/B }
C {sky130_stdcells/buf_2.sym} 78060 -22270 0 0 {name=X_48683_ }
C {devices/lab_pin.sym} 78020 -22150 0 0 {name=p77454 lab=_59875_/A }
C {devices/lab_pin.sym} 78100 -22150 0 1 {name=p77455 lab=_60961_/X }
C {sky130_stdcells/buf_2.sym} 78060 -22150 0 0 {name=X_60961_ }
C {devices/lab_pin.sym} 78000 -22040 0 0 {name=p77456 lab=_72947_/A }
C {devices/lab_pin.sym} 78000 -22000 0 0 {name=p77457 lab=_72924_/B }
C {devices/lab_pin.sym} 78120 -22020 0 1 {name=p77458 lab=_72947_/Y }
C {sky130_stdcells/nor2_4.sym} 78060 -22020 0 0 {name=X_72947_ }
C {devices/lab_pin.sym} 78020 -21890 0 0 {name=p77459 lab=_45894_/X }
C {devices/lab_pin.sym} 78100 -21890 0 1 {name=p77460 lab=_86847_/D }
C {sky130_stdcells/inv_2.sym} 78060 -21890 0 0 {name=X_45895_ }
C {devices/lab_pin.sym} 78000 -21800 0 0 {name=p77461 lab=_62658_/A }
C {devices/lab_pin.sym} 78000 -21760 0 0 {name=p77462 lab=_84717_/Q }
C {devices/lab_pin.sym} 78000 -21720 0 0 {name=p77463 lab=_62676_/C }
C {devices/lab_pin.sym} 78000 -21680 0 0 {name=p77464 lab=_62657_/X }
C {devices/lab_pin.sym} 78120 -21740 0 1 {name=p77465 lab=_62700_/X }
C {sky130_stdcells/and4_4.sym} 78060 -21740 0 0 {name=X_62700_ }
C {devices/lab_pin.sym} 77980 -21610 0 0 {name=p77466 lab=_86614_/Q }
C {devices/lab_pin.sym} 77980 -21570 0 0 {name=p77467 lab=_47619_/X }
C {devices/lab_pin.sym} 77980 -21530 0 0 {name=p77468 lab=_47633_/Y }
C {devices/lab_pin.sym} 78140 -21570 0 1 {name=p77469 lab=_47634_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -21570 0 0 {name=X_47634_ }
C {devices/lab_pin.sym} 78000 -21440 0 0 {name=p77470 lab=_82508_/Q }
C {devices/lab_pin.sym} 78000 -21400 0 0 {name=p77471 lab=_82764_/D }
C {devices/lab_pin.sym} 78120 -21420 0 1 {name=p77472 lab=_78454_/X }
C {sky130_stdcells/xor2_4.sym} 78060 -21420 0 0 {name=X_78454_ }
C {devices/lab_pin.sym} 78020 -21290 0 0 {name=p77473 lab=_44846_/A }
C {devices/lab_pin.sym} 78100 -21290 0 1 {name=p77474 lab=_86923_/D }
C {sky130_stdcells/inv_2.sym} 78060 -21290 0 0 {name=X_44846_ }
C {devices/lab_pin.sym} 78000 -21190 0 0 {name=p77475 lab=_63670_/A }
C {devices/lab_pin.sym} 78000 -21150 0 0 {name=p77476 lab=_63670_/B }
C {devices/lab_pin.sym} 78000 -21110 0 0 {name=p77477 lab=_80323_/B }
C {devices/lab_pin.sym} 78120 -21150 0 1 {name=p77478 lab=_63680_/Y }
C {sky130_stdcells/nor3_4.sym} 78060 -21150 0 0 {name=X_63680_ }
C {devices/lab_pin.sym} 78000 -21020 0 0 {name=p77479 lab=_75666_/A }
C {devices/lab_pin.sym} 78000 -20980 0 0 {name=p77480 lab=_75680_/A }
C {devices/lab_pin.sym} 78120 -21000 0 1 {name=p77481 lab=_75667_/B }
C {sky130_stdcells/xor2_4.sym} 78060 -21000 0 0 {name=X_75666_ }
C {devices/lab_pin.sym} 77980 -20900 0 0 {name=p77482 lab=_61293_/A }
C {devices/lab_pin.sym} 77980 -20860 0 0 {name=p77483 lab=_60861_/X }
C {devices/lab_pin.sym} 77980 -20820 0 0 {name=p77484 lab=_60844_/X }
C {devices/lab_pin.sym} 77980 -20780 0 0 {name=p77485 lab=_60857_/D }
C {devices/lab_pin.sym} 78140 -20840 0 1 {name=p77486 lab=_60892_/Y }
C {sky130_stdcells/a22oi_4.sym} 78060 -20840 0 0 {name=X_60892_ }
C {devices/lab_pin.sym} 77980 -20710 0 0 {name=p77487 lab=_72872_/X }
C {devices/lab_pin.sym} 77980 -20670 0 0 {name=p77488 lab=_72875_/X }
C {devices/lab_pin.sym} 77980 -20630 0 0 {name=p77489 lab=_72877_/X }
C {devices/lab_pin.sym} 78140 -20670 0 1 {name=p77490 lab=_72883_/A }
C {sky130_stdcells/a21o_4.sym} 78060 -20670 0 0 {name=X_72878_ }
C {devices/lab_pin.sym} 78000 -20540 0 0 {name=p77491 lab=_77406_/A }
C {devices/lab_pin.sym} 78000 -20500 0 0 {name=p77492 lab=_82094_/D }
C {devices/lab_pin.sym} 78120 -20520 0 1 {name=p77493 lab=_77405_/Y }
C {sky130_stdcells/nor2_4.sym} 78060 -20520 0 0 {name=X_77405_ }
C {devices/lab_pin.sym} 78000 -20420 0 0 {name=p77494 lab=_61695_/A }
C {devices/lab_pin.sym} 78000 -20380 0 0 {name=p77495 lab=_62631_/B }
C {devices/lab_pin.sym} 78000 -20340 0 0 {name=p77496 lab=_62631_/C }
C {devices/lab_pin.sym} 78000 -20300 0 0 {name=p77497 lab=_62631_/D }
C {devices/lab_pin.sym} 78120 -20360 0 1 {name=p77498 lab=_62634_/B }
C {sky130_stdcells/nand4_4.sym} 78060 -20360 0 0 {name=X_62631_ }
C {devices/lab_pin.sym} 77980 -20240 0 0 {name=p77499 lab=_74605_/X }
C {devices/lab_pin.sym} 77980 -20200 0 0 {name=p77500 lab=_74613_/X }
C {devices/lab_pin.sym} 77980 -20160 0 0 {name=p77501 lab=_56152_/Y }
C {devices/lab_pin.sym} 77980 -20120 0 0 {name=p77502 lab=_74614_/X }
C {devices/lab_pin.sym} 78140 -20180 0 1 {name=p77503 lab=_74617_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -20180 0 0 {name=X_74617_ }
C {devices/lab_pin.sym} 78020 -20030 0 0 {name=p77504 lab=_47565_/A }
C {devices/lab_pin.sym} 78100 -20030 0 1 {name=p77505 lab=_47595_/C }
C {sky130_stdcells/buf_2.sym} 78060 -20030 0 0 {name=X_47565_ }
C {devices/lab_pin.sym} 78020 -19910 0 0 {name=p77506 lab=_71068_/B }
C {devices/lab_pin.sym} 78100 -19910 0 1 {name=p77507 lab=_71829_/X }
C {sky130_stdcells/buf_2.sym} 78060 -19910 0 0 {name=X_71829_ }
C {devices/lab_pin.sym} 78000 -19800 0 0 {name=p77508 lab=_78385_/A }
C {devices/lab_pin.sym} 78000 -19760 0 0 {name=p77509 lab=_82664_/D }
C {devices/lab_pin.sym} 78120 -19780 0 1 {name=p77510 lab=_78385_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -19780 0 0 {name=X_78385_ }
C {devices/lab_pin.sym} 77980 -19680 0 0 {name=p77511 lab=_41360_/Y }
C {devices/lab_pin.sym} 77980 -19640 0 0 {name=p77512 lab=_44774_/X }
C {devices/lab_pin.sym} 77980 -19600 0 0 {name=p77513 lab=_86961_/Q }
C {devices/lab_pin.sym} 77980 -19560 0 0 {name=p77514 lab=_44775_/X }
C {devices/lab_pin.sym} 78140 -19620 0 1 {name=p77515 lab=_44777_/X }
C {sky130_stdcells/a2bb2o_4.sym} 78060 -19620 0 0 {name=X_44777_ }
C {devices/lab_pin.sym} 78000 -19480 0 0 {name=p77516 lab=_80996_/Q }
C {devices/lab_pin.sym} 78000 -19440 0 0 {name=p77517 lab=_75597_/B }
C {devices/lab_pin.sym} 78120 -19460 0 1 {name=p77518 lab=_75597_/X }
C {sky130_stdcells/xor2_4.sym} 78060 -19460 0 0 {name=X_75597_ }
C {devices/lab_pin.sym} 77980 -19370 0 0 {name=p77519 lab=_41982_/X }
C {devices/lab_pin.sym} 77980 -19330 0 0 {name=p77520 lab=_41975_/X }
C {devices/lab_pin.sym} 77980 -19290 0 0 {name=p77521 lab=_40781_/X }
C {devices/lab_pin.sym} 77980 -19250 0 0 {name=p77522 lab=_41988_/Y }
C {devices/lab_pin.sym} 77980 -19210 0 0 {name=p77523 lab=_41984_/X }
C {devices/lab_pin.sym} 78140 -19290 0 1 {name=p77524 lab=_88080_/D }
C {sky130_stdcells/o32ai_4.sym} 78060 -19290 0 0 {name=X_41989_ }
C {devices/lab_pin.sym} 78000 -19150 0 0 {name=p77525 lab=_51330_/A }
C {devices/lab_pin.sym} 78000 -19110 0 0 {name=p77526 lab=_49283_/B }
C {devices/lab_pin.sym} 78000 -19070 0 0 {name=p77527 lab=_49234_/X }
C {devices/lab_pin.sym} 78120 -19110 0 1 {name=p77528 lab=_49304_/X }
C {sky130_stdcells/and3_4.sym} 78060 -19110 0 0 {name=X_49304_ }
C {devices/lab_pin.sym} 78020 -18970 0 0 {name=p77529 lab=_51356_/B }
C {devices/lab_pin.sym} 78100 -18970 0 1 {name=p77530 lab=_49322_/B }
C {sky130_stdcells/buf_2.sym} 78060 -18970 0 0 {name=X_46516_ }
C {devices/lab_pin.sym} 78020 -18850 0 0 {name=p77531 lab=_64666_/A }
C {devices/lab_pin.sym} 78100 -18850 0 1 {name=p77532 lab=_65350_/X }
C {sky130_stdcells/buf_2.sym} 78060 -18850 0 0 {name=X_65350_ }
C {devices/lab_pin.sym} 78000 -18740 0 0 {name=p77533 lab=_77334_/Y }
C {devices/lab_pin.sym} 78000 -18700 0 0 {name=p77534 lab=_77335_/Y }
C {devices/lab_pin.sym} 78120 -18720 0 1 {name=p77535 lab=_82185_/D }
C {sky130_stdcells/xnor2_4.sym} 78060 -18720 0 0 {name=X_77336_ }
C {devices/lab_pin.sym} 78020 -18590 0 0 {name=p77536 lab=_87293_/Q }
C {devices/lab_pin.sym} 78100 -18590 0 1 {name=p77537 lab=_69862_/B }
C {sky130_stdcells/inv_2.sym} 78060 -18590 0 0 {name=X_43728_ }
C {devices/lab_pin.sym} 77980 -18510 0 0 {name=p77538 lab=_62556_/X }
C {devices/lab_pin.sym} 77980 -18470 0 0 {name=p77539 lab=_62558_/X }
C {devices/lab_pin.sym} 77980 -18430 0 0 {name=p77540 lab=_62561_/Y }
C {devices/lab_pin.sym} 77980 -18390 0 0 {name=p77541 lab=_58344_/A }
C {devices/lab_pin.sym} 77980 -18350 0 0 {name=p77542 lab=_62511_/X }
C {devices/lab_pin.sym} 78140 -18430 0 1 {name=p77543 lab=_62562_/Y }
C {sky130_stdcells/o32ai_4.sym} 78060 -18430 0 0 {name=X_62562_ }
C {devices/lab_pin.sym} 77980 -18290 0 0 {name=p77544 lab=_56019_/Y }
C {devices/lab_pin.sym} 77980 -18250 0 0 {name=p77545 lab=_74538_/Y }
C {devices/lab_pin.sym} 77980 -18210 0 0 {name=p77546 lab=_74547_/Y }
C {devices/lab_pin.sym} 78140 -18250 0 1 {name=p77547 lab=_74548_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -18250 0 0 {name=X_74548_ }
C {devices/lab_pin.sym} 77980 -18130 0 0 {name=p77548 lab=_47492_/Y }
C {devices/lab_pin.sym} 77980 -18090 0 0 {name=p77549 lab=_47462_/X }
C {devices/lab_pin.sym} 77980 -18050 0 0 {name=p77550 lab=_47495_/X }
C {devices/lab_pin.sym} 78140 -18090 0 1 {name=p77551 lab=_47496_/Y }
C {sky130_stdcells/a21oi_4.sym} 78060 -18090 0 0 {name=X_47496_ }
C {devices/lab_pin.sym} 78000 -17960 0 0 {name=p77552 lab=_59388_/A }
C {devices/lab_pin.sym} 78000 -17920 0 0 {name=p77553 lab=_64301_/B }
C {devices/lab_pin.sym} 78120 -17940 0 1 {name=p77554 lab=_64301_/Y }
C {sky130_stdcells/nor2_4.sym} 78060 -17940 0 0 {name=X_64301_ }
C {devices/lab_pin.sym} 78000 -17830 0 0 {name=p77555 lab=_50755_/A }
C {devices/lab_pin.sym} 78000 -17790 0 0 {name=p77556 lab=_49113_/B }
C {devices/lab_pin.sym} 78000 -17750 0 0 {name=p77557 lab=_49234_/X }
C {devices/lab_pin.sym} 78120 -17790 0 1 {name=p77558 lab=_49235_/X }
C {sky130_stdcells/and3_4.sym} 78060 -17790 0 0 {name=X_49235_ }
C {devices/lab_pin.sym} 78000 -17680 0 0 {name=p77559 lab=_61513_/A }
C {devices/lab_pin.sym} 78000 -17640 0 0 {name=p77560 lab=_61468_/B }
C {devices/lab_pin.sym} 78000 -17600 0 0 {name=p77561 lab=_61467_/X }
C {devices/lab_pin.sym} 78000 -17560 0 0 {name=p77562 lab=_61512_/X }
C {devices/lab_pin.sym} 78120 -17620 0 1 {name=p77563 lab=_61513_/Y }
C {sky130_stdcells/nand4_4.sym} 78060 -17620 0 0 {name=X_61513_ }
C {devices/lab_pin.sym} 78000 -17480 0 0 {name=p77564 lab=_46505_/A }
C {devices/lab_pin.sym} 78000 -17440 0 0 {name=p77565 lab=_46447_/B }
C {devices/lab_pin.sym} 78120 -17460 0 1 {name=p77566 lab=_46447_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -17460 0 0 {name=X_46447_ }
C {devices/lab_pin.sym} 78000 -17340 0 0 {name=p77567 lab=_65281_/A }
C {devices/lab_pin.sym} 78000 -17300 0 0 {name=p77568 lab=_65280_/X }
C {devices/lab_pin.sym} 78120 -17320 0 1 {name=p77569 lab=_65281_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -17320 0 0 {name=X_65281_ }
C {devices/lab_pin.sym} 78000 -17210 0 0 {name=p77570 lab=_77264_/Y }
C {devices/lab_pin.sym} 78000 -17170 0 0 {name=p77571 lab=_82213_/Q }
C {devices/lab_pin.sym} 78000 -17130 0 0 {name=p77572 lab=_77265_/Y }
C {devices/lab_pin.sym} 78120 -17170 0 1 {name=p77573 lab=_77267_/Y }
C {sky130_stdcells/nand3_4.sym} 78060 -17170 0 0 {name=X_77267_ }
C {devices/lab_pin.sym} 78020 -17030 0 0 {name=p77574 lab=_47834_/A }
C {devices/lab_pin.sym} 78100 -17030 0 1 {name=p77575 lab=_43659_/X }
C {sky130_stdcells/buf_2.sym} 78060 -17030 0 0 {name=X_43659_ }
C {devices/lab_pin.sym} 77980 -16930 0 0 {name=p77576 lab=_74477_/Y }
C {devices/lab_pin.sym} 77980 -16890 0 0 {name=p77577 lab=_74463_/X }
C {devices/lab_pin.sym} 77980 -16850 0 0 {name=p77578 lab=_74478_/X }
C {devices/lab_pin.sym} 78140 -16890 0 1 {name=p77579 lab=_74479_/Y }
C {sky130_stdcells/a21oi_4.sym} 78060 -16890 0 0 {name=X_74479_ }
C {devices/lab_pin.sym} 78000 -16780 0 0 {name=p77580 lab=_62493_/A }
C {devices/lab_pin.sym} 78000 -16740 0 0 {name=p77581 lab=_62490_/Y }
C {devices/lab_pin.sym} 78000 -16700 0 0 {name=p77582 lab=_62493_/C }
C {devices/lab_pin.sym} 78000 -16660 0 0 {name=p77583 lab=_62492_/Y }
C {devices/lab_pin.sym} 78120 -16720 0 1 {name=p77584 lab=_62493_/Y }
C {sky130_stdcells/nand4_4.sym} 78060 -16720 0 0 {name=X_62493_ }
C {devices/lab_pin.sym} 77980 -16600 0 0 {name=p77585 lab=_87872_/Q }
C {devices/lab_pin.sym} 77980 -16560 0 0 {name=p77586 lab=_66994_/X }
C {devices/lab_pin.sym} 77980 -16520 0 0 {name=p77587 lab=_66926_/X }
C {devices/lab_pin.sym} 77980 -16480 0 0 {name=p77588 lab=_67019_/X }
C {devices/lab_pin.sym} 78140 -16540 0 1 {name=p77589 lab=_67020_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -16540 0 0 {name=X_67020_ }
C {devices/lab_pin.sym} 78000 -16400 0 0 {name=p77590 lab=_78993_/A }
C {devices/lab_pin.sym} 78000 -16360 0 0 {name=p77591 lab=_79000_/A }
C {devices/lab_pin.sym} 78120 -16380 0 1 {name=p77592 lab=_79006_/X }
C {sky130_stdcells/and2_4.sym} 78060 -16380 0 0 {name=X_79006_ }
C {devices/lab_pin.sym} 77980 -16270 0 0 {name=p77593 lab=_79872_/B }
C {devices/lab_pin.sym} 77980 -16230 0 0 {name=p77594 lab=_63258_/X }
C {devices/lab_pin.sym} 77980 -16190 0 0 {name=p77595 lab=_64231_/X }
C {devices/lab_pin.sym} 78140 -16230 0 1 {name=p77596 lab=_64232_/X }
C {sky130_stdcells/a21o_4.sym} 78060 -16230 0 0 {name=X_64232_ }
C {devices/lab_pin.sym} 78000 -16110 0 0 {name=p77597 lab=_76215_/Y }
C {devices/lab_pin.sym} 78000 -16070 0 0 {name=p77598 lab=_76234_/A }
C {devices/lab_pin.sym} 78000 -16030 0 0 {name=p77599 lab=_76216_/Y }
C {devices/lab_pin.sym} 78120 -16070 0 1 {name=p77600 lab=_76221_/C }
C {sky130_stdcells/nand3_4.sym} 78060 -16070 0 0 {name=X_76218_ }
C {devices/lab_pin.sym} 78020 -15930 0 0 {name=p77601 lab=_83597_/Q }
C {devices/lab_pin.sym} 78100 -15930 0 1 {name=p77602 lab=_49166_/Y }
C {sky130_stdcells/inv_2.sym} 78060 -15930 0 0 {name=X_49166_ }
C {devices/lab_pin.sym} 77980 -15850 0 0 {name=p77603 lab=_61437_/Y }
C {devices/lab_pin.sym} 77980 -15810 0 0 {name=p77604 lab=_61439_/Y }
C {devices/lab_pin.sym} 77980 -15770 0 0 {name=p77605 lab=_61403_/X }
C {devices/lab_pin.sym} 77980 -15730 0 0 {name=p77606 lab=_61440_/Y }
C {devices/lab_pin.sym} 77980 -15700 0 0 {name=p77607 lab=_61443_/Y }
C {devices/lab_pin.sym} 78140 -15770 0 1 {name=p77608 lab=_61444_/X }
C {sky130_stdcells/a41o_4.sym} 78060 -15770 0 0 {name=X_61444_ }
C {devices/lab_pin.sym} 78000 -15620 0 0 {name=p77609 lab=_46387_/A }
C {devices/lab_pin.sym} 78000 -15580 0 0 {name=p77610 lab=_50781_/B }
C {devices/lab_pin.sym} 78120 -15600 0 1 {name=p77611 lab=_46378_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -15600 0 0 {name=X_46378_ }
C {devices/lab_pin.sym} 78000 -15480 0 0 {name=p77612 lab=_77198_/A }
C {devices/lab_pin.sym} 78000 -15440 0 0 {name=p77613 lab=_77198_/B }
C {devices/lab_pin.sym} 78120 -15460 0 1 {name=p77614 lab=_77199_/B }
C {sky130_stdcells/xor2_4.sym} 78060 -15460 0 0 {name=X_77198_ }
C {devices/lab_pin.sym} 77980 -15350 0 0 {name=p77615 lab=_66298_/B }
C {devices/lab_pin.sym} 77980 -15310 0 0 {name=p77616 lab=_48103_/X }
C {devices/lab_pin.sym} 77980 -15270 0 0 {name=p77617 lab=_48116_/Y }
C {devices/lab_pin.sym} 78140 -15310 0 1 {name=p77618 lab=_48117_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -15310 0 0 {name=X_48117_ }
C {devices/lab_pin.sym} 77980 -15190 0 0 {name=p77619 lab=_45325_/Y }
C {devices/lab_pin.sym} 77980 -15150 0 0 {name=p77620 lab=_45328_/Y }
C {devices/lab_pin.sym} 77980 -15110 0 0 {name=p77621 lab=_45287_/X }
C {devices/lab_pin.sym} 78140 -15150 0 1 {name=p77622 lab=_45329_/X }
C {sky130_stdcells/a21o_4.sym} 78060 -15150 0 0 {name=X_45329_ }
C {devices/lab_pin.sym} 77980 -15050 0 0 {name=p77623 lab=_64159_/X }
C {devices/lab_pin.sym} 77980 -15010 0 0 {name=p77624 lab=_63741_/X }
C {devices/lab_pin.sym} 77980 -14970 0 0 {name=p77625 lab=_64160_/Y }
C {devices/lab_pin.sym} 77980 -14930 0 0 {name=p77626 lab=_64161_/Y }
C {devices/lab_pin.sym} 77980 -14900 0 0 {name=p77627 lab=_64162_/X }
C {devices/lab_pin.sym} 78140 -14970 0 1 {name=p77628 lab=_64163_/X }
C {sky130_stdcells/a41o_4.sym} 78060 -14970 0 0 {name=X_64163_ }
C {devices/lab_pin.sym} 78000 -14830 0 0 {name=p77629 lab=_76145_/A }
C {devices/lab_pin.sym} 78000 -14790 0 0 {name=p77630 lab=_76145_/B }
C {devices/lab_pin.sym} 78000 -14750 0 0 {name=p77631 lab=_76149_/C }
C {devices/lab_pin.sym} 78120 -14790 0 1 {name=p77632 lab=_76150_/B }
C {sky130_stdcells/nand3_4.sym} 78060 -14790 0 0 {name=X_76149_ }
C {devices/lab_pin.sym} 78000 -14660 0 0 {name=p77633 lab=_46495_/B }
C {devices/lab_pin.sym} 78000 -14620 0 0 {name=p77634 lab=_46348_/A }
C {devices/lab_pin.sym} 78120 -14640 0 1 {name=p77635 lab=_49097_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -14640 0 0 {name=X_49097_ }
C {devices/lab_pin.sym} 78000 -14530 0 0 {name=p77636 lab=_61375_/A }
C {devices/lab_pin.sym} 78000 -14490 0 0 {name=p77637 lab=_61375_/B }
C {devices/lab_pin.sym} 78000 -14450 0 0 {name=p77638 lab=_61375_/C }
C {devices/lab_pin.sym} 78120 -14490 0 1 {name=p77639 lab=_61375_/Y }
C {sky130_stdcells/nand3_4.sym} 78060 -14490 0 0 {name=X_61375_ }
C {devices/lab_pin.sym} 78020 -14350 0 0 {name=p77640 lab=_63231_/A }
C {devices/lab_pin.sym} 78100 -14350 0 1 {name=p77641 lab=_63114_/X }
C {sky130_stdcells/buf_2.sym} 78060 -14350 0 0 {name=X_63114_ }
C {devices/lab_pin.sym} 77980 -14260 0 0 {name=p77642 lab=_79700_/A }
C {devices/lab_pin.sym} 77980 -14220 0 0 {name=p77643 lab=_60323_/X }
C {devices/lab_pin.sym} 77980 -14180 0 0 {name=p77644 lab=_60306_/Y }
C {devices/lab_pin.sym} 77980 -14140 0 0 {name=p77645 lab=_60325_/Y }
C {devices/lab_pin.sym} 78140 -14200 0 1 {name=p77646 lab=_60326_/X }
C {sky130_stdcells/o22a_4.sym} 78060 -14200 0 0 {name=X_60326_ }
C {devices/lab_pin.sym} 77980 -14070 0 0 {name=p77647 lab=_48042_/Y }
C {devices/lab_pin.sym} 77980 -14030 0 0 {name=p77648 lab=_48007_/X }
C {devices/lab_pin.sym} 77980 -13990 0 0 {name=p77649 lab=_48047_/X }
C {devices/lab_pin.sym} 78140 -14030 0 1 {name=p77650 lab=_86573_/D }
C {sky130_stdcells/a21oi_4.sym} 78060 -14030 0 0 {name=X_48048_ }
C {devices/lab_pin.sym} 78020 -13890 0 0 {name=p77651 lab=clkbuf_9_204_0_CLK/X }
C {devices/lab_pin.sym} 78100 -13890 0 1 {name=p77652 lab=_83515_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 78060 -13890 0 0 {name=Xclkbuf_10_408_0_CLK }
C {devices/lab_pin.sym} 77980 -13800 0 0 {name=p77653 lab=_87079_/Q }
C {devices/lab_pin.sym} 77980 -13760 0 0 {name=p77654 lab=_68948_/X }
C {devices/lab_pin.sym} 77980 -13720 0 0 {name=p77655 lab=_68875_/X }
C {devices/lab_pin.sym} 77980 -13680 0 0 {name=p77656 lab=_68970_/X }
C {devices/lab_pin.sym} 78140 -13740 0 1 {name=p77657 lab=_68971_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -13740 0 0 {name=X_68971_ }
C {devices/lab_pin.sym} 78000 -13620 0 0 {name=p77658 lab=_64090_/Y }
C {devices/lab_pin.sym} 78000 -13580 0 0 {name=p77659 lab=_64094_/B }
C {devices/lab_pin.sym} 78000 -13540 0 0 {name=p77660 lab=_64094_/C }
C {devices/lab_pin.sym} 78000 -13500 0 0 {name=p77661 lab=_64094_/D }
C {devices/lab_pin.sym} 78120 -13560 0 1 {name=p77662 lab=_64094_/X }
C {sky130_stdcells/and4_4.sym} 78060 -13560 0 0 {name=X_64094_ }
C {devices/lab_pin.sym} 77980 -13440 0 0 {name=p77663 lab=_67664_/X }
C {devices/lab_pin.sym} 77980 -13400 0 0 {name=p77664 lab=_67911_/Y }
C {devices/lab_pin.sym} 77980 -13360 0 0 {name=p77665 lab=_67863_/X }
C {devices/lab_pin.sym} 77980 -13320 0 0 {name=p77666 lab=_67921_/Y }
C {devices/lab_pin.sym} 78140 -13380 0 1 {name=p77667 lab=_67922_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -13380 0 0 {name=X_67922_ }
C {devices/lab_pin.sym} 78000 -13240 0 0 {name=p77668 lab=_60148_/C }
C {devices/lab_pin.sym} 78000 -13200 0 0 {name=p77669 lab=_79908_/B }
C {devices/lab_pin.sym} 78120 -13220 0 1 {name=p77670 lab=_79913_/B }
C {sky130_stdcells/nand2_4.sym} 78060 -13220 0 0 {name=X_79908_ }
C {devices/lab_pin.sym} 77980 -13110 0 0 {name=p77671 lab=_63042_/Y }
C {devices/lab_pin.sym} 77980 -13070 0 0 {name=p77672 lab=_63044_/X }
C {devices/lab_pin.sym} 77980 -13030 0 0 {name=p77673 lab=_61194_/X }
C {devices/lab_pin.sym} 78140 -13070 0 1 {name=p77674 lab=_63045_/Y }
C {sky130_stdcells/a21oi_4.sym} 78060 -13070 0 0 {name=X_63045_ }
C {devices/lab_pin.sym} 78000 -12940 0 0 {name=p77675 lab=_60199_/X }
C {devices/lab_pin.sym} 78000 -12900 0 0 {name=p77676 lab=_60179_/Y }
C {devices/lab_pin.sym} 78120 -12920 0 1 {name=p77677 lab=_60257_/X }
C {sky130_stdcells/and2_4.sym} 78060 -12920 0 0 {name=X_60257_ }
C {devices/lab_pin.sym} 78000 -12820 0 0 {name=p77678 lab=_50025_/A }
C {devices/lab_pin.sym} 78000 -12780 0 0 {name=p77679 lab=_49994_/X }
C {devices/lab_pin.sym} 78000 -12740 0 0 {name=p77680 lab=_50025_/C }
C {devices/lab_pin.sym} 78000 -12700 0 0 {name=p77681 lab=_53223_/D }
C {devices/lab_pin.sym} 78120 -12760 0 1 {name=p77682 lab=_50010_/X }
C {sky130_stdcells/and4_4.sym} 78060 -12760 0 0 {name=X_50010_ }
C {devices/lab_pin.sym} 78000 -12620 0 0 {name=p77683 lab=_67901_/A }
C {devices/lab_pin.sym} 78000 -12580 0 0 {name=p77684 lab=_87709_/Q }
C {devices/lab_pin.sym} 78120 -12600 0 1 {name=p77685 lab=_67853_/X }
C {sky130_stdcells/and2_4.sym} 78060 -12600 0 0 {name=X_67853_ }
C {devices/lab_pin.sym} 78000 -12480 0 0 {name=p77686 lab=_79835_/X }
C {devices/lab_pin.sym} 78000 -12440 0 0 {name=p77687 lab=_79854_/B }
C {devices/lab_pin.sym} 78120 -12460 0 1 {name=p77688 lab=_79839_/X }
C {sky130_stdcells/xor2_4.sym} 78060 -12460 0 0 {name=X_79839_ }
C {devices/lab_pin.sym} 78020 -12330 0 0 {name=p77689 lab=_60204_/A }
C {devices/lab_pin.sym} 78100 -12330 0 1 {name=p77690 lab=_60189_/A }
C {sky130_stdcells/buf_2.sym} 78060 -12330 0 0 {name=X_60188_ }
C {devices/lab_pin.sym} 78000 -12240 0 0 {name=p77691 lab=_49995_/A }
C {devices/lab_pin.sym} 78000 -12200 0 0 {name=p77692 lab=_49994_/X }
C {devices/lab_pin.sym} 78000 -12160 0 0 {name=p77693 lab=_50005_/C }
C {devices/lab_pin.sym} 78000 -12120 0 0 {name=p77694 lab=_53211_/D }
C {devices/lab_pin.sym} 78120 -12180 0 1 {name=p77695 lab=_49999_/X }
C {sky130_stdcells/and4_4.sym} 78060 -12180 0 0 {name=X_49999_ }
C {devices/lab_pin.sym} 77980 -12050 0 0 {name=p77696 lab=_66800_/X }
C {devices/lab_pin.sym} 77980 -12010 0 0 {name=p77697 lab=_66803_/X }
C {devices/lab_pin.sym} 77980 -11970 0 0 {name=p77698 lab=_66706_/X }
C {devices/lab_pin.sym} 78140 -12010 0 1 {name=p77699 lab=_66804_/Y }
C {sky130_stdcells/a21oi_4.sym} 78060 -12010 0 0 {name=X_66804_ }
C {devices/lab_pin.sym} 77970 -11870 0 0 {name=p77700 lab=_82563_/CLK }
C {devices/lab_pin.sym} 77970 -11850 0 0 {name=p77701 lab=_78083_/B }
C {devices/lab_pin.sym} 78150 -11870 0 1 {name=p77702 lab=_40927_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -11860 0 0 {name=X_82850_ }
C {devices/lab_pin.sym} 77980 -11760 0 0 {name=p77703 lab=_87904_/Q }
C {devices/lab_pin.sym} 77980 -11720 0 0 {name=p77704 lab=_67713_/X }
C {devices/lab_pin.sym} 77980 -11680 0 0 {name=p77705 lab=_67761_/X }
C {devices/lab_pin.sym} 77980 -11640 0 0 {name=p77706 lab=_67783_/X }
C {devices/lab_pin.sym} 78140 -11700 0 1 {name=p77707 lab=_67784_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -11700 0 0 {name=X_67784_ }
C {devices/lab_pin.sym} 78020 -11550 0 0 {name=p77708 lab=clkbuf_8_83_0_CLK/A }
C {devices/lab_pin.sym} 78100 -11550 0 1 {name=p77709 lab=clkbuf_8_82_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 78060 -11550 0 0 {name=Xclkbuf_8_82_0_CLK }
C {devices/lab_pin.sym} 78020 -11430 0 0 {name=p77710 lab=_84219_/Q }
C {devices/lab_pin.sym} 78100 -11430 0 1 {name=p77711 lab=_64997_/C }
C {sky130_stdcells/inv_2.sym} 78060 -11430 0 0 {name=X_64996_ }
C {devices/lab_pin.sym} 77970 -11310 0 0 {name=p77712 lab=_81801_/CLK }
C {devices/lab_pin.sym} 77970 -11290 0 0 {name=p77713 lab=_81609_/Q }
C {devices/lab_pin.sym} 78150 -11310 0 1 {name=p77714 lab=_81801_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -11300 0 0 {name=X_81801_ }
C {devices/lab_pin.sym} 78000 -11180 0 0 {name=p77715 lab=_69383_/A }
C {devices/lab_pin.sym} 78000 -11140 0 0 {name=p77716 lab=_69523_/B }
C {devices/lab_pin.sym} 78120 -11160 0 1 {name=p77717 lab=_69523_/X }
C {sky130_stdcells/and2_4.sym} 78060 -11160 0 0 {name=X_69523_ }
C {devices/lab_pin.sym} 78020 -11030 0 0 {name=p77718 lab=_66534_/A }
C {devices/lab_pin.sym} 78100 -11030 0 1 {name=p77719 lab=_66760_/A }
C {sky130_stdcells/buf_2.sym} 78060 -11030 0 0 {name=X_66735_ }
C {devices/lab_pin.sym} 78020 -10910 0 0 {name=p77720 lab=_53199_/A }
C {devices/lab_pin.sym} 78100 -10910 0 1 {name=p77721 lab=_51961_/X }
C {sky130_stdcells/buf_2.sym} 78060 -10910 0 0 {name=X_51961_ }
C {devices/lab_pin.sym} 78000 -10820 0 0 {name=p77722 lab=_61492_/A }
C {devices/lab_pin.sym} 78000 -10780 0 0 {name=p77723 lab=_63947_/B }
C {devices/lab_pin.sym} 78000 -10740 0 0 {name=p77724 lab=_63947_/C }
C {devices/lab_pin.sym} 78000 -10700 0 0 {name=p77725 lab=_64025_/D }
C {devices/lab_pin.sym} 78120 -10760 0 1 {name=p77726 lab=_63947_/Y }
C {sky130_stdcells/nand4_4.sym} 78060 -10760 0 0 {name=X_63947_ }
C {devices/lab_pin.sym} 77970 -10610 0 0 {name=p77727 lab=_82973_/CLK }
C {devices/lab_pin.sym} 77970 -10590 0 0 {name=p77728 lab=_78725_/X }
C {devices/lab_pin.sym} 78150 -10610 0 1 {name=p77729 lab=_82781_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -10600 0 0 {name=X_82781_ }
C {devices/lab_pin.sym} 77980 -10490 0 0 {name=p77730 lab=_85585_/Q }
C {devices/lab_pin.sym} 77980 -10450 0 0 {name=p77731 lab=_53687_/X }
C {devices/lab_pin.sym} 77980 -10410 0 0 {name=p77732 lab=_53699_/Y }
C {devices/lab_pin.sym} 78140 -10450 0 1 {name=p77733 lab=_53700_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -10450 0 0 {name=X_53700_ }
C {devices/lab_pin.sym} 77970 -10310 0 0 {name=p77734 lab=_84520_/CLK }
C {devices/lab_pin.sym} 77970 -10290 0 0 {name=p77735 lab=_61106_/Y }
C {devices/lab_pin.sym} 78150 -10310 0 1 {name=p77736 lab=_84520_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -10300 0 0 {name=X_84520_ }
C {devices/lab_pin.sym} 78000 -10180 0 0 {name=p77737 lab=_50932_/A }
C {devices/lab_pin.sym} 78000 -10140 0 0 {name=p77738 lab=_46662_/X }
C {devices/lab_pin.sym} 78120 -10160 0 1 {name=p77739 lab=_50912_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -10160 0 0 {name=X_50912_ }
C {devices/lab_pin.sym} 77970 -10030 0 0 {name=p77740 lab=_81169_/CLK }
C {devices/lab_pin.sym} 77970 -10010 0 0 {name=p77741 lab=_75938_/Y }
C {devices/lab_pin.sym} 78150 -10030 0 1 {name=p77742 lab=_41440_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -10020 0 0 {name=X_81732_ }
C {devices/lab_pin.sym} 78000 -9900 0 0 {name=p77743 lab=_69454_/A }
C {devices/lab_pin.sym} 78000 -9860 0 0 {name=p77744 lab=_87260_/Q }
C {devices/lab_pin.sym} 78120 -9880 0 1 {name=p77745 lab=_69454_/X }
C {sky130_stdcells/and2_4.sym} 78060 -9880 0 0 {name=X_69454_ }
C {devices/lab_pin.sym} 78000 -9780 0 0 {name=p77746 lab=_54674_/A }
C {devices/lab_pin.sym} 78000 -9740 0 0 {name=p77747 lab=_54674_/B }
C {devices/lab_pin.sym} 78000 -9700 0 0 {name=p77748 lab=_54674_/C }
C {devices/lab_pin.sym} 78000 -9660 0 0 {name=p77749 lab=_47329_/A }
C {devices/lab_pin.sym} 78120 -9720 0 1 {name=p77750 lab=_54680_/X }
C {sky130_stdcells/and4_4.sym} 78060 -9720 0 0 {name=X_54680_ }
C {devices/lab_pin.sym} 77980 -9600 0 0 {name=p77751 lab=_87439_/Q }
C {devices/lab_pin.sym} 77980 -9560 0 0 {name=p77752 lab=_66642_/X }
C {devices/lab_pin.sym} 77980 -9520 0 0 {name=p77753 lab=_66643_/X }
C {devices/lab_pin.sym} 77980 -9480 0 0 {name=p77754 lab=_66665_/X }
C {devices/lab_pin.sym} 78140 -9540 0 1 {name=p77755 lab=_66666_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -9540 0 0 {name=X_66666_ }
C {devices/lab_pin.sym} 78020 -9390 0 0 {name=p77756 lab=_52626_/A }
C {devices/lab_pin.sym} 78100 -9390 0 1 {name=p77757 lab=_51893_/C }
C {sky130_stdcells/buf_2.sym} 78060 -9390 0 0 {name=X_51892_ }
C {devices/lab_pin.sym} 78000 -9290 0 0 {name=p77758 lab=_63831_/A }
C {devices/lab_pin.sym} 78000 -9250 0 0 {name=p77759 lab=_59388_/A }
C {devices/lab_pin.sym} 78000 -9210 0 0 {name=p77760 lab=_63862_/C }
C {devices/lab_pin.sym} 78120 -9250 0 1 {name=p77761 lab=_63878_/X }
C {sky130_stdcells/and3_4.sym} 78060 -9250 0 0 {name=X_63878_ }
C {devices/lab_pin.sym} 78000 -9120 0 0 {name=p77762 lab=_68405_/A }
C {devices/lab_pin.sym} 78000 -9080 0 0 {name=p77763 lab=_87250_/Q }
C {devices/lab_pin.sym} 78120 -9100 0 1 {name=p77764 lab=_68405_/X }
C {sky130_stdcells/and2_4.sym} 78060 -9100 0 0 {name=X_68405_ }
C {devices/lab_pin.sym} 77980 -9000 0 0 {name=p77765 lab=_64599_/X }
C {devices/lab_pin.sym} 77980 -8960 0 0 {name=p77766 lab=_83069_/Q }
C {devices/lab_pin.sym} 77980 -8920 0 0 {name=p77767 lab=_65015_/X }
C {devices/lab_pin.sym} 77980 -8880 0 0 {name=p77768 lab=_65616_/X }
C {devices/lab_pin.sym} 78140 -8940 0 1 {name=p77769 lab=_65617_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -8940 0 0 {name=X_65617_ }
C {devices/lab_pin.sym} 78000 -8810 0 0 {name=p77770 lab=_48388_/A }
C {devices/lab_pin.sym} 78000 -8770 0 0 {name=p77771 lab=_53658_/B }
C {devices/lab_pin.sym} 78000 -8730 0 0 {name=p77772 lab=_53620_/C }
C {devices/lab_pin.sym} 78120 -8770 0 1 {name=p77773 lab=_53631_/X }
C {sky130_stdcells/and3_4.sym} 78060 -8770 0 0 {name=X_53631_ }
C {devices/lab_pin.sym} 77970 -8630 0 0 {name=p77774 lab=_84454_/CLK }
C {devices/lab_pin.sym} 77970 -8610 0 0 {name=p77775 lab=_61836_/Y }
C {devices/lab_pin.sym} 78150 -8630 0 1 {name=p77776 lab=_78074_/B }
C {sky130_stdcells/dfxtp_4.sym} 78060 -8620 0 0 {name=X_84451_ }
C {devices/lab_pin.sym} 77980 -8510 0 0 {name=p77777 lab=_86122_/Q }
C {devices/lab_pin.sym} 77980 -8470 0 0 {name=p77778 lab=_50804_/X }
C {devices/lab_pin.sym} 77980 -8430 0 0 {name=p77779 lab=_50842_/Y }
C {devices/lab_pin.sym} 78140 -8470 0 1 {name=p77780 lab=_50843_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -8470 0 0 {name=X_50843_ }
C {devices/lab_pin.sym} 78000 -8360 0 0 {name=p77781 lab=_62971_/A }
C {devices/lab_pin.sym} 78000 -8320 0 0 {name=p77782 lab=_84826_/Q }
C {devices/lab_pin.sym} 78000 -8280 0 0 {name=p77783 lab=_62819_/C }
C {devices/lab_pin.sym} 78000 -8240 0 0 {name=p77784 lab=_62782_/X }
C {devices/lab_pin.sym} 78120 -8300 0 1 {name=p77785 lab=_62829_/X }
C {sky130_stdcells/and4_4.sym} 78060 -8300 0 0 {name=X_62829_ }
C {devices/lab_pin.sym} 78020 -8150 0 0 {name=p77786 lab=clkbuf_8_97_0_CLK/A }
C {devices/lab_pin.sym} 78100 -8150 0 1 {name=p77787 lab=clkbuf_8_97_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 78060 -8150 0 0 {name=Xclkbuf_8_97_0_CLK }
C {devices/lab_pin.sym} 77970 -8030 0 0 {name=p77788 lab=_81269_/CLK }
C {devices/lab_pin.sym} 77970 -8010 0 0 {name=p77789 lab=_81695_/Q }
C {devices/lab_pin.sym} 78150 -8030 0 1 {name=p77790 lab=_76593_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -8020 0 0 {name=X_81663_ }
C {devices/lab_pin.sym} 78020 -7890 0 0 {name=p77791 lab=_69678_/A }
C {devices/lab_pin.sym} 78100 -7890 0 1 {name=p77792 lab=_69385_/X }
C {sky130_stdcells/buf_2.sym} 78060 -7890 0 0 {name=X_69385_ }
C {devices/lab_pin.sym} 78000 -7780 0 0 {name=p77793 lab=_66597_/A }
C {devices/lab_pin.sym} 78000 -7740 0 0 {name=p77794 lab=_66596_/X }
C {devices/lab_pin.sym} 78120 -7760 0 1 {name=p77795 lab=_66597_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -7760 0 0 {name=X_66597_ }
C {devices/lab_pin.sym} 77970 -7630 0 0 {name=p77796 lab=_83402_/CLK }
C {devices/lab_pin.sym} 77970 -7610 0 0 {name=p77797 lab=_83402_/D }
C {devices/lab_pin.sym} 78150 -7630 0 1 {name=p77798 lab=_83402_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -7620 0 0 {name=X_83402_ }
C {devices/lab_pin.sym} 78020 -7490 0 0 {name=p77799 lab=_56350_/A }
C {devices/lab_pin.sym} 78100 -7490 0 1 {name=p77800 lab=_56350_/X }
C {sky130_stdcells/buf_2.sym} 78060 -7490 0 0 {name=X_56350_ }
C {devices/lab_pin.sym} 78000 -7380 0 0 {name=p77801 lab=_80614_/A }
C {devices/lab_pin.sym} 78000 -7340 0 0 {name=p77802 lab=_80614_/B }
C {devices/lab_pin.sym} 78120 -7360 0 1 {name=p77803 lab=_80614_/X }
C {sky130_stdcells/xor2_4.sym} 78060 -7360 0 0 {name=X_80614_ }
C {devices/lab_pin.sym} 77980 -7260 0 0 {name=p77804 lab=_68319_/X }
C {devices/lab_pin.sym} 77980 -7220 0 0 {name=p77805 lab=_68049_/Y }
C {devices/lab_pin.sym} 77980 -7180 0 0 {name=p77806 lab=_68326_/X }
C {devices/lab_pin.sym} 77980 -7140 0 0 {name=p77807 lab=_68335_/Y }
C {devices/lab_pin.sym} 78140 -7200 0 1 {name=p77808 lab=_68336_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -7200 0 0 {name=X_68336_ }
C {devices/lab_pin.sym} 77970 -7050 0 0 {name=p77809 lab=_84534_/CLK }
C {devices/lab_pin.sym} 77970 -7030 0 0 {name=p77810 lab=_44314_/Y }
C {devices/lab_pin.sym} 78150 -7050 0 1 {name=p77811 lab=_44313_/B }
C {sky130_stdcells/dfxtp_4.sym} 78060 -7040 0 0 {name=X_87170_ }
C {devices/lab_pin.sym} 77980 -6930 0 0 {name=p77812 lab=_53559_/Y }
C {devices/lab_pin.sym} 77980 -6890 0 0 {name=p77813 lab=_53537_/X }
C {devices/lab_pin.sym} 77980 -6850 0 0 {name=p77814 lab=_53561_/X }
C {devices/lab_pin.sym} 78140 -6890 0 1 {name=p77815 lab=_85613_/D }
C {sky130_stdcells/a21oi_4.sym} 78060 -6890 0 0 {name=X_53562_ }
C {devices/lab_pin.sym} 78000 -6770 0 0 {name=p77816 lab=_64832_/X }
C {devices/lab_pin.sym} 78000 -6730 0 0 {name=p77817 lab=_65548_/B }
C {devices/lab_pin.sym} 78000 -6690 0 0 {name=p77818 lab=_64837_/X }
C {devices/lab_pin.sym} 78120 -6730 0 1 {name=p77819 lab=_65557_/A }
C {sky130_stdcells/nand3_4.sym} 78060 -6730 0 0 {name=X_65548_ }
C {devices/lab_pin.sym} 77970 -6590 0 0 {name=p77820 lab=_84520_/CLK }
C {devices/lab_pin.sym} 77970 -6570 0 0 {name=p77821 lab=_84382_/D }
C {devices/lab_pin.sym} 78150 -6590 0 1 {name=p77822 lab=_75912_/B }
C {sky130_stdcells/dfxtp_4.sym} 78060 -6580 0 0 {name=X_84382_ }
C {devices/lab_pin.sym} 77980 -6470 0 0 {name=p77823 lab=_50772_/Y }
C {devices/lab_pin.sym} 77980 -6430 0 0 {name=p77824 lab=_50768_/X }
C {devices/lab_pin.sym} 77980 -6390 0 0 {name=p77825 lab=_50773_/Y }
C {devices/lab_pin.sym} 78140 -6430 0 1 {name=p77826 lab=_86136_/D }
C {sky130_stdcells/a21boi_4.sym} 78060 -6430 0 0 {name=X_50774_ }
C {devices/lab_pin.sym} 77970 -6290 0 0 {name=p77827 lab=_81433_/CLK }
C {devices/lab_pin.sym} 77970 -6270 0 0 {name=p77828 lab=_65546_/C }
C {devices/lab_pin.sym} 78150 -6290 0 1 {name=p77829 lab=_76872_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -6280 0 0 {name=X_81594_ }
C {devices/lab_pin.sym} 78020 -6150 0 0 {name=p77830 lab=_55300_/X }
C {devices/lab_pin.sym} 78100 -6150 0 1 {name=p77831 lab=_55301_/X }
C {sky130_stdcells/buf_2.sym} 78060 -6150 0 0 {name=X_55301_ }
C {devices/lab_pin.sym} 77970 -6030 0 0 {name=p77832 lab=_86121_/CLK }
C {devices/lab_pin.sym} 77970 -6010 0 0 {name=p77833 lab=_50851_/Y }
C {devices/lab_pin.sym} 78150 -6030 0 1 {name=p77834 lab=_86121_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -6020 0 0 {name=X_86121_ }
C {devices/lab_pin.sym} 78000 -5900 0 0 {name=p77835 lab=_52487_/X }
C {devices/lab_pin.sym} 78000 -5860 0 0 {name=p77836 lab=_50816_/B }
C {devices/lab_pin.sym} 78120 -5880 0 1 {name=p77837 lab=_52513_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -5880 0 0 {name=X_52513_ }
C {devices/lab_pin.sym} 77970 -5750 0 0 {name=p77838 lab=_83333_/CLK }
C {devices/lab_pin.sym} 77970 -5730 0 0 {name=p77839 lab=_83333_/D }
C {devices/lab_pin.sym} 78150 -5750 0 1 {name=p77840 lab=_83333_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -5740 0 0 {name=X_83333_ }
C {devices/lab_pin.sym} 78000 -5620 0 0 {name=p77841 lab=_84769_/Q }
C {devices/lab_pin.sym} 78000 -5580 0 0 {name=p77842 lab=_84161_/Q }
C {devices/lab_pin.sym} 78120 -5600 0 1 {name=p77843 lab=_80545_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -5600 0 0 {name=X_80545_ }
C {devices/lab_pin.sym} 78000 -5480 0 0 {name=p77844 lab=_56281_/A }
C {devices/lab_pin.sym} 78000 -5440 0 0 {name=p77845 lab=_56280_/Y }
C {devices/lab_pin.sym} 78120 -5460 0 1 {name=p77846 lab=_56281_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -5460 0 0 {name=X_56281_ }
C {devices/lab_pin.sym} 78020 -5330 0 0 {name=p77847 lab=_67388_/X }
C {devices/lab_pin.sym} 78100 -5330 0 1 {name=p77848 lab=_68447_/A }
C {sky130_stdcells/buf_2.sym} 78060 -5330 0 0 {name=X_68267_ }
C {devices/lab_pin.sym} 78000 -5230 0 0 {name=p77849 lab=_50270_/A }
C {devices/lab_pin.sym} 78000 -5190 0 0 {name=p77850 lab=_53474_/B }
C {devices/lab_pin.sym} 78000 -5150 0 0 {name=p77851 lab=_53492_/X }
C {devices/lab_pin.sym} 78120 -5190 0 1 {name=p77852 lab=_53493_/X }
C {sky130_stdcells/and3_4.sym} 78060 -5190 0 0 {name=X_53493_ }
C {devices/lab_pin.sym} 78000 -5070 0 0 {name=p77853 lab=_64682_/X }
C {devices/lab_pin.sym} 78000 -5030 0 0 {name=p77854 lab=_65647_/B }
C {devices/lab_pin.sym} 78000 -4990 0 0 {name=p77855 lab=_64685_/X }
C {devices/lab_pin.sym} 78120 -5030 0 1 {name=p77856 lab=_65479_/Y }
C {sky130_stdcells/nand3_4.sym} 78060 -5030 0 0 {name=X_65479_ }
C {devices/lab_pin.sym} 78020 -4890 0 0 {name=p77857 lab=clkbuf_8_21_0_CLK/A }
C {devices/lab_pin.sym} 78100 -4890 0 1 {name=p77858 lab=clkbuf_8_20_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 78060 -4890 0 0 {name=Xclkbuf_8_20_0_CLK }
C {devices/lab_pin.sym} 78020 -4770 0 0 {name=p77859 lab=_58020_/A }
C {devices/lab_pin.sym} 78100 -4770 0 1 {name=p77860 lab=_58020_/X }
C {sky130_stdcells/buf_2.sym} 78060 -4770 0 0 {name=X_58020_ }
C {devices/lab_pin.sym} 77980 -4680 0 0 {name=p77861 lab=_85028_/Q }
C {devices/lab_pin.sym} 77980 -4640 0 0 {name=p77862 lab=_55142_/A }
C {devices/lab_pin.sym} 77980 -4600 0 0 {name=p77863 lab=_80665_/Q }
C {devices/lab_pin.sym} 77980 -4560 0 0 {name=p77864 lab=_55231_/Y }
C {devices/lab_pin.sym} 78140 -4620 0 1 {name=p77865 lab=_55232_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -4620 0 0 {name=X_55232_ }
C {devices/lab_pin.sym} 78000 -4480 0 0 {name=p77866 lab=_67149_/A }
C {devices/lab_pin.sym} 78000 -4440 0 0 {name=p77867 lab=_67218_/B }
C {devices/lab_pin.sym} 78120 -4460 0 1 {name=p77868 lab=_67218_/X }
C {sky130_stdcells/and2_4.sym} 78060 -4460 0 0 {name=X_67218_ }
C {devices/lab_pin.sym} 77970 -4330 0 0 {name=p77869 lab=_86054_/CLK }
C {devices/lab_pin.sym} 77970 -4310 0 0 {name=p77870 lab=_51221_/Y }
C {devices/lab_pin.sym} 78150 -4330 0 1 {name=p77871 lab=_86052_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -4320 0 0 {name=X_86052_ }
C {devices/lab_pin.sym} 78000 -4200 0 0 {name=p77872 lab=_52448_/A }
C {devices/lab_pin.sym} 78000 -4160 0 0 {name=p77873 lab=_46295_/A }
C {devices/lab_pin.sym} 78120 -4180 0 1 {name=p77874 lab=_52444_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -4180 0 0 {name=X_52444_ }
C {devices/lab_pin.sym} 77970 -4050 0 0 {name=p77875 lab=_81233_/CLK }
C {devices/lab_pin.sym} 77970 -4030 0 0 {name=p77876 lab=_83264_/D }
C {devices/lab_pin.sym} 78150 -4050 0 1 {name=p77877 lab=_72323_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -4040 0 0 {name=X_83264_ }
C {devices/lab_pin.sym} 78000 -3920 0 0 {name=p77878 lab=_80476_/A }
C {devices/lab_pin.sym} 78000 -3880 0 0 {name=p77879 lab=_80476_/B }
C {devices/lab_pin.sym} 78120 -3900 0 1 {name=p77880 lab=_80489_/B }
C {sky130_stdcells/xnor2_4.sym} 78060 -3900 0 0 {name=X_80476_ }
C {devices/lab_pin.sym} 77980 -3800 0 0 {name=p77881 lab=_68196_/X }
C {devices/lab_pin.sym} 77980 -3760 0 0 {name=p77882 lab=_67220_/Y }
C {devices/lab_pin.sym} 77980 -3720 0 0 {name=p77883 lab=_68189_/X }
C {devices/lab_pin.sym} 77980 -3680 0 0 {name=p77884 lab=_68197_/Y }
C {devices/lab_pin.sym} 78140 -3740 0 1 {name=p77885 lab=_68198_/X }
C {sky130_stdcells/a211o_4.sym} 78060 -3740 0 0 {name=X_68198_ }
C {devices/lab_pin.sym} 77970 -3590 0 0 {name=p77886 lab=_85003_/CLK }
C {devices/lab_pin.sym} 77970 -3570 0 0 {name=p77887 lab=_57447_/Y }
C {devices/lab_pin.sym} 78150 -3590 0 1 {name=p77888 lab=_85003_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -3580 0 0 {name=X_85003_ }
C {devices/lab_pin.sym} 77970 -3450 0 0 {name=p77889 lab=_82084_/CLK }
C {devices/lab_pin.sym} 77970 -3430 0 0 {name=p77890 lab=_82247_/Q }
C {devices/lab_pin.sym} 78150 -3450 0 1 {name=p77891 lab=_77312_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -3440 0 0 {name=X_82215_ }
C {devices/lab_pin.sym} 78000 -3320 0 0 {name=p77892 lab=_55296_/B }
C {devices/lab_pin.sym} 78000 -3280 0 0 {name=p77893 lab=_55162_/Y }
C {devices/lab_pin.sym} 78120 -3300 0 1 {name=p77894 lab=_55163_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -3300 0 0 {name=X_55163_ }
C {devices/lab_pin.sym} 78000 -3180 0 0 {name=p77895 lab=_67149_/A }
C {devices/lab_pin.sym} 78000 -3140 0 0 {name=p77896 lab=_88123_/Q }
C {devices/lab_pin.sym} 78120 -3160 0 1 {name=p77897 lab=_67149_/X }
C {sky130_stdcells/and2_4.sym} 78060 -3160 0 0 {name=X_67149_ }
C {devices/lab_pin.sym} 77980 -3050 0 0 {name=p77898 lab=_85835_/Q }
C {devices/lab_pin.sym} 77980 -3010 0 0 {name=p77899 lab=_52372_/X }
C {devices/lab_pin.sym} 77980 -2970 0 0 {name=p77900 lab=_52374_/Y }
C {devices/lab_pin.sym} 78140 -3010 0 1 {name=p77901 lab=_52375_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -3010 0 0 {name=X_52375_ }
C {devices/lab_pin.sym} 77970 -2870 0 0 {name=p77902 lab=_83191_/CLK }
C {devices/lab_pin.sym} 77970 -2850 0 0 {name=p77903 lab=_72671_/X }
C {devices/lab_pin.sym} 78150 -2870 0 1 {name=p77904 lab=_83195_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -2860 0 0 {name=X_83195_ }
C {devices/lab_pin.sym} 78020 -2730 0 0 {name=p77905 lab=_54194_/A }
C {devices/lab_pin.sym} 78100 -2730 0 1 {name=p77906 lab=_54134_/A }
C {sky130_stdcells/buf_2.sym} 78060 -2730 0 0 {name=X_54114_ }
C {devices/lab_pin.sym} 78000 -2620 0 0 {name=p77907 lab=_51306_/X }
C {devices/lab_pin.sym} 78000 -2580 0 0 {name=p77908 lab=_51326_/B }
C {devices/lab_pin.sym} 78120 -2600 0 1 {name=p77909 lab=_51326_/X }
C {sky130_stdcells/and2_4.sym} 78060 -2600 0 0 {name=X_51326_ }
C {devices/lab_pin.sym} 78020 -2470 0 0 {name=p77910 lab=_70348_/A }
C {devices/lab_pin.sym} 78100 -2470 0 1 {name=p77911 lab=_70160_/X }
C {sky130_stdcells/buf_2.sym} 78060 -2470 0 0 {name=X_70160_ }
C {devices/lab_pin.sym} 77970 -2350 0 0 {name=p77912 lab=_82145_/CLK }
C {devices/lab_pin.sym} 77970 -2330 0 0 {name=p77913 lab=_84138_/Q }
C {devices/lab_pin.sym} 78150 -2350 0 1 {name=p77914 lab=_77728_/A }
C {sky130_stdcells/dfxtp_4.sym} 78060 -2340 0 0 {name=X_82146_ }
C {devices/lab_pin.sym} 77980 -2230 0 0 {name=p77915 lab=_85319_/Q }
C {devices/lab_pin.sym} 77980 -2190 0 0 {name=p77916 lab=_55072_/X }
C {devices/lab_pin.sym} 77980 -2150 0 0 {name=p77917 lab=_55093_/Y }
C {devices/lab_pin.sym} 78140 -2190 0 1 {name=p77918 lab=_55094_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -2190 0 0 {name=X_55094_ }
C {devices/lab_pin.sym} 78020 -2050 0 0 {name=p77919 lab=_60042_/A }
C {devices/lab_pin.sym} 78100 -2050 0 1 {name=p77920 lab=_59971_/X }
C {sky130_stdcells/buf_2.sym} 78060 -2050 0 0 {name=X_59971_ }
C {devices/lab_pin.sym} 78020 -1930 0 0 {name=p77921 lab=clkbuf_8_35_0_CLK/A }
C {devices/lab_pin.sym} 78100 -1930 0 1 {name=p77922 lab=clkbuf_9_71_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 78060 -1930 0 0 {name=Xclkbuf_8_35_0_CLK }
C {devices/lab_pin.sym} 78000 -1820 0 0 {name=p77923 lab=_54037_/A }
C {devices/lab_pin.sym} 78000 -1780 0 0 {name=p77924 lab=_52526_/B }
C {devices/lab_pin.sym} 78120 -1800 0 1 {name=p77925 lab=_54045_/Y }
C {sky130_stdcells/nand2_4.sym} 78060 -1800 0 0 {name=X_54045_ }
C {devices/lab_pin.sym} 78020 -1670 0 0 {name=p77926 lab=_58635_/A }
C {devices/lab_pin.sym} 78100 -1670 0 1 {name=p77927 lab=_58923_/A }
C {sky130_stdcells/buf_2.sym} 78060 -1670 0 0 {name=X_58922_ }
C {devices/lab_pin.sym} 77980 -1570 0 0 {name=p77928 lab=_51254_/Y }
C {devices/lab_pin.sym} 77980 -1530 0 0 {name=p77929 lab=_51237_/X }
C {devices/lab_pin.sym} 77980 -1490 0 0 {name=p77930 lab=_51256_/X }
C {devices/lab_pin.sym} 78140 -1530 0 1 {name=p77931 lab=_51257_/Y }
C {sky130_stdcells/a21oi_4.sym} 78060 -1530 0 0 {name=X_51257_ }
C {devices/lab_pin.sym} 77980 -1410 0 0 {name=p77932 lab=_83852_/Q }
C {devices/lab_pin.sym} 77980 -1370 0 0 {name=p77933 lab=_70085_/X }
C {devices/lab_pin.sym} 77980 -1330 0 0 {name=p77934 lab=_70090_/X }
C {devices/lab_pin.sym} 78140 -1370 0 1 {name=p77935 lab=_70091_/X }
C {sky130_stdcells/a21bo_4.sym} 78060 -1370 0 0 {name=X_70091_ }
C {devices/lab_pin.sym} 77970 -1230 0 0 {name=p77936 lab=_88164_/CLK }
C {devices/lab_pin.sym} 77970 -1210 0 0 {name=p77937 lab=_86954_/D }
C {devices/lab_pin.sym} 78150 -1230 0 1 {name=p77938 lab=_86954_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -1220 0 0 {name=X_86954_ }
C {devices/lab_pin.sym} 77970 -1090 0 0 {name=p77939 lab=_81160_/CLK }
C {devices/lab_pin.sym} 77970 -1070 0 0 {name=p77940 lab=_84037_/Q }
C {devices/lab_pin.sym} 78150 -1090 0 1 {name=p77941 lab=_82077_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78060 -1080 0 0 {name=X_82077_ }
C {devices/lab_pin.sym} 77980 -990 0 0 {name=p77942 lab=_40999_/X }
C {devices/lab_pin.sym} 77980 -950 0 0 {name=p77943 lab=_41000_/X }
C {devices/lab_pin.sym} 77980 -910 0 0 {name=p77944 lab=_41009_/X }
C {devices/lab_pin.sym} 77980 -870 0 0 {name=p77945 lab=_88294_/Q }
C {devices/lab_pin.sym} 77980 -830 0 0 {name=p77946 lab=_40995_/X }
C {devices/lab_pin.sym} 78140 -910 0 1 {name=p77947 lab=_41010_/Y }
C {sky130_stdcells/o32ai_4.sym} 78060 -910 0 0 {name=X_41010_ }
C {devices/lab_pin.sym} 77980 -770 0 0 {name=p77948 lab=_86242_/Q }
C {devices/lab_pin.sym} 77980 -730 0 0 {name=p77949 lab=_50185_/X }
C {devices/lab_pin.sym} 77980 -690 0 0 {name=p77950 lab=_50207_/Y }
C {devices/lab_pin.sym} 78140 -730 0 1 {name=p77951 lab=_50208_/Y }
C {sky130_stdcells/o21ai_4.sym} 78060 -730 0 0 {name=X_50208_ }
C {devices/lab_pin.sym} 78890 -42150 0 0 {name=p77952 lab=_86541_/CLK }
C {devices/lab_pin.sym} 78890 -42130 0 0 {name=p77953 lab=_52018_/Y }
C {devices/lab_pin.sym} 79070 -42150 0 1 {name=p77954 lab=_66141_/B }
C {sky130_stdcells/dfxtp_4.sym} 78980 -42140 0 0 {name=X_85905_ }
C {devices/lab_pin.sym} 78890 -42010 0 0 {name=p77955 lab=_81933_/CLK }
C {devices/lab_pin.sym} 78890 -41990 0 0 {name=p77956 lab=_75107_/Y }
C {devices/lab_pin.sym} 79070 -42010 0 1 {name=p77957 lab=_81028_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -42000 0 0 {name=X_81028_ }
C {devices/lab_pin.sym} 78920 -41880 0 0 {name=p77958 lab=_58853_/A }
C {devices/lab_pin.sym} 78920 -41840 0 0 {name=p77959 lab=_59090_/B }
C {devices/lab_pin.sym} 79040 -41860 0 1 {name=p77960 lab=_58853_/Y }
C {sky130_stdcells/nor2_4.sym} 78980 -41860 0 0 {name=X_58853_ }
C {devices/lab_pin.sym} 78900 -41750 0 0 {name=p77961 lab=_51186_/Y }
C {devices/lab_pin.sym} 78900 -41710 0 0 {name=p77962 lab=_51175_/X }
C {devices/lab_pin.sym} 78900 -41670 0 0 {name=p77963 lab=_51187_/X }
C {devices/lab_pin.sym} 79060 -41710 0 1 {name=p77964 lab=_86058_/D }
C {sky130_stdcells/a21oi_4.sym} 78980 -41710 0 0 {name=X_51188_ }
C {devices/lab_pin.sym} 78890 -41570 0 0 {name=p77965 lab=_86873_/CLK }
C {devices/lab_pin.sym} 78890 -41550 0 0 {name=p77966 lab=_45310_/Y }
C {devices/lab_pin.sym} 79070 -41570 0 1 {name=p77967 lab=_45308_/A }
C {sky130_stdcells/dfxtp_4.sym} 78980 -41560 0 0 {name=X_86885_ }
C {devices/lab_pin.sym} 78940 -41430 0 0 {name=p77968 lab=_57804_/A }
C {devices/lab_pin.sym} 79020 -41430 0 1 {name=p77969 lab=_58697_/A }
C {sky130_stdcells/buf_2.sym} 78980 -41430 0 0 {name=X_57804_ }
C {devices/lab_pin.sym} 78920 -41320 0 0 {name=p77970 lab=_50153_/A }
C {devices/lab_pin.sym} 78920 -41280 0 0 {name=p77971 lab=_50649_/B }
C {devices/lab_pin.sym} 79040 -41300 0 1 {name=p77972 lab=_50139_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -41300 0 0 {name=X_50139_ }
C {devices/lab_pin.sym} 78890 -41170 0 0 {name=p77973 lab=_85837_/CLK }
C {devices/lab_pin.sym} 78890 -41150 0 0 {name=p77974 lab=_52371_/Y }
C {devices/lab_pin.sym} 79070 -41170 0 1 {name=p77975 lab=_65155_/B }
C {sky130_stdcells/dfxtp_4.sym} 78980 -41160 0 0 {name=X_85836_ }
C {devices/lab_pin.sym} 78940 -41030 0 0 {name=p77976 lab=_73355_/A }
C {devices/lab_pin.sym} 79020 -41030 0 1 {name=p77977 lab=_73850_/X }
C {sky130_stdcells/buf_2.sym} 78980 -41030 0 0 {name=X_73850_ }
C {devices/lab_pin.sym} 78940 -40910 0 0 {name=p77978 lab=_58784_/A }
C {devices/lab_pin.sym} 79020 -40910 0 1 {name=p77979 lab=_58785_/A }
C {sky130_stdcells/buf_2.sym} 78980 -40910 0 0 {name=X_58784_ }
C {devices/lab_pin.sym} 78920 -40820 0 0 {name=p77980 lab=_55995_/X }
C {devices/lab_pin.sym} 78920 -40780 0 0 {name=p77981 lab=_55863_/X }
C {devices/lab_pin.sym} 78920 -40740 0 0 {name=p77982 lab=_56073_/A }
C {devices/lab_pin.sym} 78920 -40700 0 0 {name=p77983 lab=_74317_/C }
C {devices/lab_pin.sym} 79040 -40760 0 1 {name=p77984 lab=_55996_/X }
C {sky130_stdcells/and4_4.sym} 78980 -40760 0 0 {name=X_55996_ }
C {devices/lab_pin.sym} 78900 -40640 0 0 {name=p77985 lab=_43117_/Y }
C {devices/lab_pin.sym} 78900 -40600 0 0 {name=p77986 lab=_72731_/X }
C {devices/lab_pin.sym} 78900 -40560 0 0 {name=p77987 lab=_72799_/X }
C {devices/lab_pin.sym} 78900 -40520 0 0 {name=p77988 lab=_72800_/Y }
C {devices/lab_pin.sym} 79060 -40580 0 1 {name=p77989 lab=_72801_/X }
C {sky130_stdcells/a211o_4.sym} 78980 -40580 0 0 {name=X_72801_ }
C {devices/lab_pin.sym} 78900 -40470 0 0 {name=p77990 lab=_46213_/X }
C {devices/lab_pin.sym} 78900 -40430 0 0 {name=p77991 lab=_57731_/Y }
C {devices/lab_pin.sym} 78900 -40390 0 0 {name=p77992 lab=_57734_/Y }
C {devices/lab_pin.sym} 78900 -40350 0 0 {name=p77993 lab=_57700_/X }
C {devices/lab_pin.sym} 78900 -40310 0 0 {name=p77994 lab=_57703_/X }
C {devices/lab_pin.sym} 79060 -40390 0 1 {name=p77995 lab=_57735_/X }
C {sky130_stdcells/o32a_4.sym} 78980 -40390 0 0 {name=X_57735_ }
C {devices/lab_pin.sym} 78900 -40260 0 0 {name=p77996 lab=_40400_/X }
C {devices/lab_pin.sym} 78900 -40220 0 0 {name=p77997 lab=_42950_/X }
C {devices/lab_pin.sym} 78900 -40180 0 0 {name=p77998 lab=_87629_/Q }
C {devices/lab_pin.sym} 78900 -40140 0 0 {name=p77999 lab=_42951_/X }
C {devices/lab_pin.sym} 79060 -40200 0 1 {name=p78000 lab=_42961_/X }
C {sky130_stdcells/a2bb2o_4.sym} 78980 -40200 0 0 {name=X_42961_ }
C {devices/lab_pin.sym} 78900 -40070 0 0 {name=p78001 lab=_54945_/Y }
C {devices/lab_pin.sym} 78900 -40030 0 0 {name=p78002 lab=_54936_/X }
C {devices/lab_pin.sym} 78900 -39990 0 0 {name=p78003 lab=_54946_/X }
C {devices/lab_pin.sym} 79060 -40030 0 1 {name=p78004 lab=_85348_/D }
C {sky130_stdcells/a21oi_4.sym} 78980 -40030 0 0 {name=X_54947_ }
C {devices/lab_pin.sym} 78900 -39920 0 0 {name=p78005 lab=_73731_/X }
C {devices/lab_pin.sym} 78900 -39880 0 0 {name=p78006 lab=_86232_/Q }
C {devices/lab_pin.sym} 78900 -39840 0 0 {name=p78007 lab=_73683_/X }
C {devices/lab_pin.sym} 78900 -39800 0 0 {name=p78008 lab=_73780_/X }
C {devices/lab_pin.sym} 79060 -39860 0 1 {name=p78009 lab=_73781_/X }
C {sky130_stdcells/a211o_4.sym} 78980 -39860 0 0 {name=X_73781_ }
C {devices/lab_pin.sym} 78890 -39710 0 0 {name=p78010 lab=_85767_/CLK }
C {devices/lab_pin.sym} 78890 -39690 0 0 {name=p78011 lab=_52721_/Y }
C {devices/lab_pin.sym} 79070 -39710 0 1 {name=p78012 lab=_85767_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -39700 0 0 {name=X_85767_ }
C {devices/lab_pin.sym} 78900 -39590 0 0 {name=p78013 lab=_51324_/B }
C {devices/lab_pin.sym} 78900 -39550 0 0 {name=p78014 lab=_70983_/X }
C {devices/lab_pin.sym} 78900 -39510 0 0 {name=p78015 lab=_70992_/Y }
C {devices/lab_pin.sym} 79060 -39550 0 1 {name=p78016 lab=_83639_/D }
C {sky130_stdcells/o21ai_4.sym} 78980 -39550 0 0 {name=X_70993_ }
C {devices/lab_pin.sym} 78890 -39410 0 0 {name=p78017 lab=_82979_/CLK }
C {devices/lab_pin.sym} 78890 -39390 0 0 {name=p78018 lab=_74704_/Y }
C {devices/lab_pin.sym} 79070 -39410 0 1 {name=p78019 lab=_45861_/A }
C {sky130_stdcells/dfxtp_4.sym} 78980 -39400 0 0 {name=X_82979_ }
C {devices/lab_pin.sym} 78940 -39270 0 0 {name=p78020 lab=_44700_/A }
C {devices/lab_pin.sym} 79020 -39270 0 1 {name=p78021 lab=_44700_/Y }
C {sky130_stdcells/inv_2.sym} 78980 -39270 0 0 {name=X_44700_ }
C {devices/lab_pin.sym} 78900 -39170 0 0 {name=p78022 lab=_75516_/Y }
C {devices/lab_pin.sym} 78900 -39130 0 0 {name=p78023 lab=_75519_/C }
C {devices/lab_pin.sym} 78900 -39090 0 0 {name=p78024 lab=_75519_/A }
C {devices/lab_pin.sym} 79060 -39130 0 1 {name=p78025 lab=_75520_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -39130 0 0 {name=X_75520_ }
C {devices/lab_pin.sym} 78890 -38990 0 0 {name=p78026 lab=_87766_/CLK }
C {devices/lab_pin.sym} 78890 -38970 0 0 {name=p78027 lab=_87506_/D }
C {devices/lab_pin.sym} 79070 -38990 0 1 {name=p78028 lab=_87506_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -38980 0 0 {name=X_87506_ }
C {devices/lab_pin.sym} 78940 -38850 0 0 {name=p78029 lab=_41912_/A }
C {devices/lab_pin.sym} 79020 -38850 0 1 {name=p78030 lab=_41912_/X }
C {sky130_stdcells/buf_2.sym} 78980 -38850 0 0 {name=X_41912_ }
C {devices/lab_pin.sym} 78920 -38740 0 0 {name=p78031 lab=_87315_/Q }
C {devices/lab_pin.sym} 78920 -38700 0 0 {name=p78032 lab=_72732_/B }
C {devices/lab_pin.sym} 79040 -38720 0 1 {name=p78033 lab=_72732_/Y }
C {sky130_stdcells/nor2_4.sym} 78980 -38720 0 0 {name=X_72732_ }
C {devices/lab_pin.sym} 78890 -38590 0 0 {name=p78034 lab=_84727_/CLK }
C {devices/lab_pin.sym} 78890 -38570 0 0 {name=p78035 lab=_59491_/Y }
C {devices/lab_pin.sym} 79070 -38590 0 1 {name=p78036 lab=_64248_/C }
C {sky130_stdcells/dfxtp_4.sym} 78980 -38580 0 0 {name=X_84718_ }
C {devices/lab_pin.sym} 78900 -38470 0 0 {name=p78037 lab=_85135_/Q }
C {devices/lab_pin.sym} 78900 -38430 0 0 {name=p78038 lab=_45556_/X }
C {devices/lab_pin.sym} 78900 -38390 0 0 {name=p78039 lab=_45651_/X }
C {devices/lab_pin.sym} 79060 -38430 0 1 {name=p78040 lab=_45680_/X }
C {sky130_stdcells/o21a_4.sym} 78980 -38430 0 0 {name=X_45680_ }
C {devices/lab_pin.sym} 78920 -38300 0 0 {name=p78041 lab=_57664_/X }
C {devices/lab_pin.sym} 78920 -38260 0 0 {name=p78042 lab=_57666_/B }
C {devices/lab_pin.sym} 79040 -38280 0 1 {name=p78043 lab=_57666_/Y }
C {sky130_stdcells/nor2_4.sym} 78980 -38280 0 0 {name=X_57666_ }
C {devices/lab_pin.sym} 78900 -38180 0 0 {name=p78044 lab=_41643_/X }
C {devices/lab_pin.sym} 78900 -38140 0 0 {name=p78045 lab=_42886_/X }
C {devices/lab_pin.sym} 78900 -38100 0 0 {name=p78046 lab=_67378_/B }
C {devices/lab_pin.sym} 78900 -38060 0 0 {name=p78047 lab=_42887_/X }
C {devices/lab_pin.sym} 79060 -38120 0 1 {name=p78048 lab=_87665_/D }
C {sky130_stdcells/a2bb2o_4.sym} 78980 -38120 0 0 {name=X_42892_ }
C {devices/lab_pin.sym} 78920 -38000 0 0 {name=p78049 lab=_54883_/A }
C {devices/lab_pin.sym} 78920 -37960 0 0 {name=p78050 lab=_54883_/B }
C {devices/lab_pin.sym} 78920 -37920 0 0 {name=p78051 lab=_54883_/C }
C {devices/lab_pin.sym} 78920 -37880 0 0 {name=p78052 lab=_53185_/D }
C {devices/lab_pin.sym} 79040 -37940 0 1 {name=p78053 lab=_54878_/X }
C {sky130_stdcells/and4_4.sym} 78980 -37940 0 0 {name=X_54878_ }
C {devices/lab_pin.sym} 78890 -37790 0 0 {name=p78054 lab=_85697_/CLK }
C {devices/lab_pin.sym} 78890 -37770 0 0 {name=p78055 lab=_85698_/D }
C {devices/lab_pin.sym} 79070 -37790 0 1 {name=p78056 lab=_85698_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -37780 0 0 {name=X_85698_ }
C {devices/lab_pin.sym} 78940 -37650 0 0 {name=p78057 lab=_84741_/Q }
C {devices/lab_pin.sym} 79020 -37650 0 1 {name=p78058 lab=_63150_/A }
C {sky130_stdcells/inv_2.sym} 78980 -37650 0 0 {name=X_59405_ }
C {devices/lab_pin.sym} 78940 -37530 0 0 {name=p78059 lab=_44631_/A }
C {devices/lab_pin.sym} 79020 -37530 0 1 {name=p78060 lab=_44631_/Y }
C {sky130_stdcells/inv_2.sym} 78980 -37530 0 0 {name=X_44631_ }
C {devices/lab_pin.sym} 78940 -37410 0 0 {name=p78061 lab=_56617_/A }
C {devices/lab_pin.sym} 79020 -37410 0 1 {name=p78062 lab=_72656_/C }
C {sky130_stdcells/buf_2.sym} 78980 -37410 0 0 {name=X_56617_ }
C {devices/lab_pin.sym} 78890 -37290 0 0 {name=p78063 lab=_87126_/CLK }
C {devices/lab_pin.sym} 78890 -37270 0 0 {name=p78064 lab=_43406_/Y }
C {devices/lab_pin.sym} 79070 -37290 0 1 {name=p78065 lab=_87437_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -37280 0 0 {name=X_87437_ }
C {devices/lab_pin.sym} 78920 -37160 0 0 {name=p78066 lab=_75466_/A }
C {devices/lab_pin.sym} 78920 -37120 0 0 {name=p78067 lab=_75450_/Y }
C {devices/lab_pin.sym} 79040 -37140 0 1 {name=p78068 lab=_75451_/Y }
C {sky130_stdcells/xnor2_4.sym} 78980 -37140 0 0 {name=X_75451_ }
C {devices/lab_pin.sym} 78940 -37010 0 0 {name=p78069 lab=_41843_/A }
C {devices/lab_pin.sym} 79020 -37010 0 1 {name=p78070 lab=_41843_/Y }
C {sky130_stdcells/inv_2.sym} 78980 -37010 0 0 {name=X_41843_ }
C {devices/lab_pin.sym} 78940 -36890 0 0 {name=p78071 lab=_53773_/A }
C {devices/lab_pin.sym} 79020 -36890 0 1 {name=p78072 lab=_53829_/X }
C {sky130_stdcells/buf_2.sym} 78980 -36890 0 0 {name=X_53829_ }
C {devices/lab_pin.sym} 78900 -36790 0 0 {name=p78073 lab=_83199_/Q }
C {devices/lab_pin.sym} 78900 -36750 0 0 {name=p78074 lab=_72658_/X }
C {devices/lab_pin.sym} 78900 -36710 0 0 {name=p78075 lab=_72662_/Y }
C {devices/lab_pin.sym} 79060 -36750 0 1 {name=p78076 lab=_83199_/D }
C {sky130_stdcells/a21bo_4.sym} 78980 -36750 0 0 {name=X_72663_ }
C {devices/lab_pin.sym} 78890 -36610 0 0 {name=p78077 lab=_84649_/CLK }
C {devices/lab_pin.sym} 78890 -36590 0 0 {name=p78078 lab=_84649_/D }
C {devices/lab_pin.sym} 79070 -36610 0 1 {name=p78079 lab=_60214_/C }
C {sky130_stdcells/dfxtp_4.sym} 78980 -36600 0 0 {name=X_84649_ }
C {devices/lab_pin.sym} 78920 -36480 0 0 {name=p78080 lab=_57597_/A }
C {devices/lab_pin.sym} 78920 -36440 0 0 {name=p78081 lab=_48297_/X }
C {devices/lab_pin.sym} 79040 -36460 0 1 {name=p78082 lab=_57597_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -36460 0 0 {name=X_57597_ }
C {devices/lab_pin.sym} 78900 -36350 0 0 {name=p78083 lab=_74399_/Y }
C {devices/lab_pin.sym} 78900 -36310 0 0 {name=p78084 lab=_74370_/X }
C {devices/lab_pin.sym} 78900 -36270 0 0 {name=p78085 lab=_74401_/X }
C {devices/lab_pin.sym} 79060 -36310 0 1 {name=p78086 lab=_74402_/Y }
C {sky130_stdcells/a21oi_4.sym} 78980 -36310 0 0 {name=X_74402_ }
C {devices/lab_pin.sym} 78900 -36190 0 0 {name=p78087 lab=_47346_/Y }
C {devices/lab_pin.sym} 78900 -36150 0 0 {name=p78088 lab=_47317_/X }
C {devices/lab_pin.sym} 78900 -36110 0 0 {name=p78089 lab=_47349_/X }
C {devices/lab_pin.sym} 79060 -36150 0 1 {name=p78090 lab=_86644_/D }
C {sky130_stdcells/a21oi_4.sym} 78980 -36150 0 0 {name=X_47350_ }
C {devices/lab_pin.sym} 78900 -36030 0 0 {name=p78091 lab=_59286_/X }
C {devices/lab_pin.sym} 78900 -35990 0 0 {name=p78092 lab=_86054_/Q }
C {devices/lab_pin.sym} 78900 -35950 0 0 {name=p78093 lab=_59335_/X }
C {devices/lab_pin.sym} 79060 -35990 0 1 {name=p78094 lab=_59336_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -35990 0 0 {name=X_59336_ }
C {devices/lab_pin.sym} 78920 -35880 0 0 {name=p78095 lab=_71859_/A }
C {devices/lab_pin.sym} 78920 -35840 0 0 {name=p78096 lab=_70573_/B }
C {devices/lab_pin.sym} 78920 -35800 0 0 {name=p78097 lab=_71614_/C }
C {devices/lab_pin.sym} 78920 -35760 0 0 {name=p78098 lab=_71606_/X }
C {devices/lab_pin.sym} 79040 -35820 0 1 {name=p78099 lab=_71614_/Y }
C {sky130_stdcells/nor4_4.sym} 78980 -35820 0 0 {name=X_71614_ }
C {devices/lab_pin.sym} 78920 -35680 0 0 {name=p78100 lab=_78161_/A }
C {devices/lab_pin.sym} 78920 -35640 0 0 {name=p78101 lab=_82862_/D }
C {devices/lab_pin.sym} 79040 -35660 0 1 {name=p78102 lab=_78170_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -35660 0 0 {name=X_78170_ }
C {devices/lab_pin.sym} 78940 -35530 0 0 {name=p78103 lab=_44562_/A }
C {devices/lab_pin.sym} 79020 -35530 0 1 {name=p78104 lab=_44562_/Y }
C {sky130_stdcells/inv_2.sym} 78980 -35530 0 0 {name=X_44562_ }
C {devices/lab_pin.sym} 78940 -35410 0 0 {name=p78105 lab=_56547_/X }
C {devices/lab_pin.sym} 79020 -35410 0 1 {name=p78106 lab=_56548_/X }
C {sky130_stdcells/buf_2.sym} 78980 -35410 0 0 {name=X_56548_ }
C {devices/lab_pin.sym} 78940 -35290 0 0 {name=p78107 lab=_75382_/A }
C {devices/lab_pin.sym} 79020 -35290 0 1 {name=p78108 lab=_75383_/C }
C {sky130_stdcells/inv_2.sym} 78980 -35290 0 0 {name=X_75382_ }
C {devices/lab_pin.sym} 78890 -35170 0 0 {name=p78109 lab=_87373_/CLK }
C {devices/lab_pin.sym} 78890 -35150 0 0 {name=p78110 lab=_87368_/D }
C {devices/lab_pin.sym} 79070 -35170 0 1 {name=p78111 lab=_87368_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -35160 0 0 {name=X_87368_ }
C {devices/lab_pin.sym} 78900 -35070 0 0 {name=p78112 lab=_41753_/X }
C {devices/lab_pin.sym} 78900 -35030 0 0 {name=p78113 lab=_41754_/X }
C {devices/lab_pin.sym} 78900 -34990 0 0 {name=p78114 lab=_41773_/X }
C {devices/lab_pin.sym} 78900 -34950 0 0 {name=p78115 lab=_67992_/B }
C {devices/lab_pin.sym} 78900 -34910 0 0 {name=p78116 lab=_41736_/X }
C {devices/lab_pin.sym} 79060 -34990 0 1 {name=p78117 lab=_41775_/A }
C {sky130_stdcells/o32ai_4.sym} 78980 -34990 0 0 {name=X_41774_ }
C {devices/lab_pin.sym} 78940 -34830 0 0 {name=p78118 lab=_72593_/X }
C {devices/lab_pin.sym} 79020 -34830 0 1 {name=p78119 lab=_72594_/Y }
C {sky130_stdcells/inv_2.sym} 78980 -34830 0 0 {name=X_72594_ }
C {devices/lab_pin.sym} 78940 -34710 0 0 {name=p78120 lab=_40365_/X }
C {devices/lab_pin.sym} 79020 -34710 0 1 {name=p78121 lab=_46301_/X }
C {sky130_stdcells/buf_2.sym} 78980 -34710 0 0 {name=X_46301_ }
C {devices/lab_pin.sym} 78900 -34610 0 0 {name=p78122 lab=_77126_/A }
C {devices/lab_pin.sym} 78900 -34570 0 0 {name=p78123 lab=_77111_/X }
C {devices/lab_pin.sym} 78900 -34530 0 0 {name=p78124 lab=_77120_/Y }
C {devices/lab_pin.sym} 79060 -34570 0 1 {name=p78125 lab=_77121_/Y }
C {sky130_stdcells/a21boi_4.sym} 78980 -34570 0 0 {name=X_77121_ }
C {devices/lab_pin.sym} 78940 -34430 0 0 {name=p78126 lab=_43513_/A }
C {devices/lab_pin.sym} 79020 -34430 0 1 {name=p78127 lab=_43513_/X }
C {sky130_stdcells/buf_2.sym} 78980 -34430 0 0 {name=X_43513_ }
C {devices/lab_pin.sym} 78900 -34330 0 0 {name=p78128 lab=_70318_/A }
C {devices/lab_pin.sym} 78900 -34290 0 0 {name=p78129 lab=_74327_/X }
C {devices/lab_pin.sym} 78900 -34250 0 0 {name=p78130 lab=_74332_/Y }
C {devices/lab_pin.sym} 79060 -34290 0 1 {name=p78131 lab=_74333_/X }
C {sky130_stdcells/a21bo_4.sym} 78980 -34290 0 0 {name=X_74333_ }
C {devices/lab_pin.sym} 78890 -34150 0 0 {name=p78132 lab=_86640_/CLK }
C {devices/lab_pin.sym} 78890 -34130 0 0 {name=p78133 lab=_49812_/Y }
C {devices/lab_pin.sym} 79070 -34150 0 1 {name=p78134 lab=_57971_/B }
C {sky130_stdcells/dfxtp_4.sym} 78980 -34140 0 0 {name=X_86319_ }
C {devices/lab_pin.sym} 78900 -34050 0 0 {name=p78135 lab=_40687_/X }
C {devices/lab_pin.sym} 78900 -34010 0 0 {name=p78136 lab=_40688_/X }
C {devices/lab_pin.sym} 78900 -33970 0 0 {name=p78137 lab=_40724_/X }
C {devices/lab_pin.sym} 78900 -33930 0 0 {name=p78138 lab=_88347_/Q }
C {devices/lab_pin.sym} 78900 -33890 0 0 {name=p78139 lab=_40683_/X }
C {devices/lab_pin.sym} 79060 -33970 0 1 {name=p78140 lab=_40726_/A }
C {sky130_stdcells/o32ai_4.sym} 78980 -33970 0 0 {name=X_40725_ }
C {devices/lab_pin.sym} 78940 -33810 0 0 {name=p78141 lab=_47140_/A }
C {devices/lab_pin.sym} 79020 -33810 0 1 {name=p78142 lab=_47321_/C }
C {sky130_stdcells/buf_2.sym} 78980 -33810 0 0 {name=X_47281_ }
C {devices/lab_pin.sym} 78900 -33710 0 0 {name=p78143 lab=_71531_/X }
C {devices/lab_pin.sym} 78900 -33670 0 0 {name=p78144 lab=_83462_/Q }
C {devices/lab_pin.sym} 78900 -33630 0 0 {name=p78145 lab=_71544_/Y }
C {devices/lab_pin.sym} 79060 -33670 0 1 {name=p78146 lab=_83462_/D }
C {sky130_stdcells/a21o_4.sym} 78980 -33670 0 0 {name=X_71545_ }
C {devices/lab_pin.sym} 78900 -33560 0 0 {name=p78147 lab=_84756_/Q }
C {devices/lab_pin.sym} 78900 -33520 0 0 {name=p78148 lab=_59129_/X }
C {devices/lab_pin.sym} 78900 -33480 0 0 {name=p78149 lab=_59259_/X }
C {devices/lab_pin.sym} 78900 -33440 0 0 {name=p78150 lab=_59266_/X }
C {devices/lab_pin.sym} 79060 -33500 0 1 {name=p78151 lab=_84756_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 78980 -33500 0 0 {name=X_59267_ }
C {devices/lab_pin.sym} 78900 -33380 0 0 {name=p78152 lab=_41230_/A }
C {devices/lab_pin.sym} 78900 -33340 0 0 {name=p78153 lab=_44474_/X }
C {devices/lab_pin.sym} 78900 -33300 0 0 {name=p78154 lab=_87081_/Q }
C {devices/lab_pin.sym} 78900 -33260 0 0 {name=p78155 lab=_44475_/X }
C {devices/lab_pin.sym} 79060 -33320 0 1 {name=p78156 lab=_87081_/D }
C {sky130_stdcells/a2bb2o_4.sym} 78980 -33320 0 0 {name=X_44493_ }
C {devices/lab_pin.sym} 78920 -33190 0 0 {name=p78157 lab=_56474_/X }
C {devices/lab_pin.sym} 78920 -33150 0 0 {name=p78158 lab=_56472_/B }
C {devices/lab_pin.sym} 78920 -33110 0 0 {name=p78159 lab=_85180_/Q }
C {devices/lab_pin.sym} 79040 -33150 0 1 {name=p78160 lab=_56479_/Y }
C {sky130_stdcells/nand3_4.sym} 78980 -33150 0 0 {name=X_56479_ }
C {devices/lab_pin.sym} 78890 -33010 0 0 {name=p78161 lab=_87553_/CLK }
C {devices/lab_pin.sym} 78890 -32990 0 0 {name=p78162 lab=_43712_/Y }
C {devices/lab_pin.sym} 79070 -33010 0 1 {name=p78163 lab=_87299_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -33000 0 0 {name=X_87299_ }
C {devices/lab_pin.sym} 78900 -32890 0 0 {name=p78164 lab=_49018_/X }
C {devices/lab_pin.sym} 78900 -32850 0 0 {name=p78165 lab=_48508_/A }
C {devices/lab_pin.sym} 78900 -32810 0 0 {name=p78166 lab=_49019_/Y }
C {devices/lab_pin.sym} 79060 -32850 0 1 {name=p78167 lab=_49021_/A }
C {sky130_stdcells/a21o_4.sym} 78980 -32850 0 0 {name=X_49020_ }
C {devices/lab_pin.sym} 78900 -32730 0 0 {name=p78168 lab=_46174_/X }
C {devices/lab_pin.sym} 78900 -32690 0 0 {name=p78169 lab=_46175_/Y }
C {devices/lab_pin.sym} 78900 -32650 0 0 {name=p78170 lab=_46158_/B }
C {devices/lab_pin.sym} 79060 -32690 0 1 {name=p78171 lab=_46232_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -32690 0 0 {name=X_46232_ }
C {sky130_stdcells/decap_3.sym} 78980 -32520 0 0 {name=XPHY_440 }
C {devices/lab_pin.sym} 78900 -32390 0 0 {name=p78172 lab=_58171_/X }
C {devices/lab_pin.sym} 78900 -32350 0 0 {name=p78173 lab=_83401_/Q }
C {devices/lab_pin.sym} 78900 -32310 0 0 {name=p78174 lab=_58217_/Y }
C {devices/lab_pin.sym} 79060 -32350 0 1 {name=p78175 lab=_84905_/D }
C {sky130_stdcells/o21a_4.sym} 78980 -32350 0 0 {name=X_58218_ }
C {devices/lab_pin.sym} 78920 -32220 0 0 {name=p78176 lab=_77026_/Y }
C {devices/lab_pin.sym} 78920 -32180 0 0 {name=p78177 lab=_77051_/X }
C {devices/lab_pin.sym} 79040 -32200 0 1 {name=p78178 lab=_77052_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -32200 0 0 {name=X_77052_ }
C {devices/lab_pin.sym} 78940 -32070 0 0 {name=p78179 lab=_43443_/Y }
C {devices/lab_pin.sym} 79020 -32070 0 1 {name=p78180 lab=_43444_/Y }
C {sky130_stdcells/inv_2.sym} 78980 -32070 0 0 {name=X_43444_ }
C {devices/lab_pin.sym} 78920 -31960 0 0 {name=p78181 lab=_88084_/Q }
C {devices/lab_pin.sym} 78920 -31920 0 0 {name=p78182 lab=_73599_/B }
C {devices/lab_pin.sym} 79040 -31940 0 1 {name=p78183 lab=_74264_/Y }
C {sky130_stdcells/nor2_4.sym} 78980 -31940 0 0 {name=X_74264_ }
C {sky130_stdcells/decap_3.sym} 78980 -31780 0 0 {name=XPHY_451 }
C {devices/lab_pin.sym} 78940 -31630 0 0 {name=p78184 lab=_40656_/A }
C {devices/lab_pin.sym} 79020 -31630 0 1 {name=p78185 lab=_40656_/X }
C {sky130_stdcells/buf_2.sym} 78980 -31630 0 0 {name=X_40656_ }
C {devices/lab_pin.sym} 78900 -31530 0 0 {name=p78186 lab=_59121_/X }
C {devices/lab_pin.sym} 78900 -31490 0 0 {name=p78187 lab=_85425_/Q }
C {devices/lab_pin.sym} 78900 -31450 0 0 {name=p78188 lab=_59197_/X }
C {devices/lab_pin.sym} 79060 -31490 0 1 {name=p78189 lab=_59198_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -31490 0 0 {name=X_59198_ }
C {devices/lab_pin.sym} 78920 -31380 0 0 {name=p78190 lab=_71827_/A }
C {devices/lab_pin.sym} 78920 -31340 0 0 {name=p78191 lab=_71479_/B }
C {devices/lab_pin.sym} 78920 -31300 0 0 {name=p78192 lab=_70782_/A }
C {devices/lab_pin.sym} 78920 -31260 0 0 {name=p78193 lab=_71476_/D }
C {devices/lab_pin.sym} 79040 -31320 0 1 {name=p78194 lab=_71476_/X }
C {sky130_stdcells/and4_4.sym} 78980 -31320 0 0 {name=X_71476_ }
C {sky130_stdcells/decap_3.sym} 78980 -31140 0 0 {name=XPHY_462 }
C {sky130_stdcells/decap_3.sym} 78980 -30960 0 0 {name=XPHY_473 }
C {devices/lab_pin.sym} 78920 -30820 0 0 {name=p78195 lab=_81517_/Q }
C {devices/lab_pin.sym} 78920 -30780 0 0 {name=p78196 lab=_81741_/D }
C {devices/lab_pin.sym} 79040 -30800 0 1 {name=p78197 lab=_76003_/X }
C {sky130_stdcells/xor2_4.sym} 78980 -30800 0 0 {name=X_76003_ }
C {devices/lab_pin.sym} 78920 -30680 0 0 {name=p78198 lab=_73239_/A }
C {devices/lab_pin.sym} 78920 -30640 0 0 {name=p78199 lab=_86512_/Q }
C {devices/lab_pin.sym} 79040 -30660 0 1 {name=p78200 lab=_73215_/X }
C {sky130_stdcells/and2_4.sym} 78980 -30660 0 0 {name=X_73215_ }
C {sky130_stdcells/decap_3.sym} 78980 -30500 0 0 {name=XPHY_484 }
C {devices/lab_pin.sym} 78940 -30350 0 0 {name=p78201 lab=_70984_/A }
C {devices/lab_pin.sym} 79020 -30350 0 1 {name=p78202 lab=_70940_/B }
C {sky130_stdcells/buf_2.sym} 78980 -30350 0 0 {name=X_70427_ }
C {devices/lab_pin.sym} 78940 -30230 0 0 {name=p78203 lab=_46162_/X }
C {devices/lab_pin.sym} 79020 -30230 0 1 {name=p78204 lab=_46166_/A }
C {sky130_stdcells/buf_2.sym} 78980 -30230 0 0 {name=X_46163_ }
C {devices/lab_pin.sym} 78940 -30110 0 0 {name=p78205 lab=_58149_/A }
C {devices/lab_pin.sym} 79020 -30110 0 1 {name=p78206 lab=_63022_/A }
C {sky130_stdcells/inv_2.sym} 78980 -30110 0 0 {name=X_58149_ }
C {sky130_stdcells/decap_3.sym} 78980 -29960 0 0 {name=XPHY_495 }
C {devices/lab_pin.sym} 78940 -29810 0 0 {name=p78207 lab=_43305_/A }
C {devices/lab_pin.sym} 79020 -29810 0 1 {name=p78208 lab=_43375_/X }
C {sky130_stdcells/buf_2.sym} 78980 -29810 0 0 {name=X_43375_ }
C {devices/lab_pin.sym} 78900 -29720 0 0 {name=p78209 lab=_74106_/X }
C {devices/lab_pin.sym} 78900 -29680 0 0 {name=p78210 lab=_85606_/Q }
C {devices/lab_pin.sym} 78900 -29640 0 0 {name=p78211 lab=_74107_/X }
C {devices/lab_pin.sym} 78900 -29600 0 0 {name=p78212 lab=_74194_/X }
C {devices/lab_pin.sym} 79060 -29660 0 1 {name=p78213 lab=_74195_/X }
C {sky130_stdcells/a211o_4.sym} 78980 -29660 0 0 {name=X_74195_ }
C {devices/lab_pin.sym} 78940 -29510 0 0 {name=p78214 lab=_40736_/A }
C {devices/lab_pin.sym} 79020 -29510 0 1 {name=p78215 lab=_40588_/B }
C {sky130_stdcells/buf_2.sym} 78980 -29510 0 0 {name=X_40587_ }
C {devices/lab_pin.sym} 78900 -29410 0 0 {name=p78216 lab=_85267_/Q }
C {devices/lab_pin.sym} 78900 -29370 0 0 {name=p78217 lab=_45073_/X }
C {devices/lab_pin.sym} 78900 -29330 0 0 {name=p78218 lab=_45113_/X }
C {devices/lab_pin.sym} 79060 -29370 0 1 {name=p78219 lab=_45114_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -29370 0 0 {name=X_45114_ }
C {devices/lab_pin.sym} 78940 -29230 0 0 {name=p78220 lab=_42304_/X }
C {devices/lab_pin.sym} 79020 -29230 0 1 {name=p78221 lab=_42326_/X }
C {sky130_stdcells/buf_2.sym} 78980 -29230 0 0 {name=X_42326_ }
C {devices/lab_pin.sym} 78900 -29150 0 0 {name=p78222 lab=_61271_/A }
C {devices/lab_pin.sym} 78900 -29110 0 0 {name=p78223 lab=_61230_/C }
C {devices/lab_pin.sym} 78900 -29070 0 0 {name=p78224 lab=_61097_/X }
C {devices/lab_pin.sym} 78900 -29030 0 0 {name=p78225 lab=_64456_/C }
C {devices/lab_pin.sym} 78900 -29000 0 0 {name=p78226 lab=_60620_/Y }
C {devices/lab_pin.sym} 79060 -29070 0 1 {name=p78227 lab=_61160_/Y }
C {sky130_stdcells/a41oi_4.sym} 78980 -29070 0 0 {name=X_61160_ }
C {devices/lab_pin.sym} 78940 -28910 0 0 {name=p78228 lab=_74139_/A }
C {devices/lab_pin.sym} 79020 -28910 0 1 {name=p78229 lab=_73339_/A }
C {sky130_stdcells/buf_2.sym} 78980 -28910 0 0 {name=X_73146_ }
C {devices/lab_pin.sym} 78940 -28790 0 0 {name=p78230 lab=_46094_/A }
C {devices/lab_pin.sym} 79020 -28790 0 1 {name=p78231 lab=_46094_/X }
C {sky130_stdcells/buf_2.sym} 78980 -28790 0 0 {name=X_46094_ }
C {devices/lab_pin.sym} 78940 -28670 0 0 {name=p78232 lab=HASH_ADDR[0] }
C {devices/lab_pin.sym} 79020 -28670 0 1 {name=p78233 lab=_70358_/X }
C {sky130_stdcells/buf_2.sym} 78980 -28670 0 0 {name=X_70358_ }
C {devices/lab_pin.sym} 78940 -28550 0 0 {name=p78234 lab=_65464_/A }
C {devices/lab_pin.sym} 79020 -28550 0 1 {name=p78235 lab=_60111_/X }
C {sky130_stdcells/buf_2.sym} 78980 -28550 0 0 {name=X_60111_ }
C {devices/lab_pin.sym} 78920 -28440 0 0 {name=p78236 lab=_49928_/A }
C {devices/lab_pin.sym} 78920 -28400 0 0 {name=p78237 lab=_53135_/B }
C {devices/lab_pin.sym} 79040 -28420 0 1 {name=p78238 lab=_49922_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -28420 0 0 {name=X_49922_ }
C {devices/lab_pin.sym} 78900 -28310 0 0 {name=p78239 lab=_55915_/B }
C {devices/lab_pin.sym} 78900 -28270 0 0 {name=p78240 lab=_45044_/X }
C {devices/lab_pin.sym} 78900 -28230 0 0 {name=p78241 lab=_45004_/X }
C {devices/lab_pin.sym} 79060 -28270 0 1 {name=p78242 lab=_45045_/X }
C {sky130_stdcells/o21a_4.sym} 78980 -28270 0 0 {name=X_45045_ }
C {devices/lab_pin.sym} 78900 -28160 0 0 {name=p78243 lab=_41461_/X }
C {devices/lab_pin.sym} 78900 -28120 0 0 {name=p78244 lab=_42248_/X }
C {devices/lab_pin.sym} 78900 -28080 0 0 {name=p78245 lab=_87955_/Q }
C {devices/lab_pin.sym} 78900 -28040 0 0 {name=p78246 lab=_42249_/X }
C {devices/lab_pin.sym} 79060 -28100 0 1 {name=p78247 lab=_87955_/D }
C {sky130_stdcells/a2bb2o_4.sym} 78980 -28100 0 0 {name=X_42257_ }
C {devices/lab_pin.sym} 78940 -27950 0 0 {name=p78248 lab=_61091_/A }
C {devices/lab_pin.sym} 79020 -27950 0 1 {name=p78249 lab=_61091_/Y }
C {sky130_stdcells/inv_2.sym} 78980 -27950 0 0 {name=X_61091_ }
C {devices/lab_pin.sym} 78900 -27850 0 0 {name=p78250 lab=_83166_/Q }
C {devices/lab_pin.sym} 78900 -27810 0 0 {name=p78251 lab=_72943_/X }
C {devices/lab_pin.sym} 78900 -27770 0 0 {name=p78252 lab=_73076_/Y }
C {devices/lab_pin.sym} 79060 -27810 0 1 {name=p78253 lab=_73077_/X }
C {sky130_stdcells/a21o_4.sym} 78980 -27810 0 0 {name=X_73077_ }
C {devices/lab_pin.sym} 78920 -27680 0 0 {name=p78254 lab=_77954_/A }
C {devices/lab_pin.sym} 78920 -27640 0 0 {name=p78255 lab=_77954_/B }
C {devices/lab_pin.sym} 79040 -27660 0 1 {name=p78256 lab=_77957_/A }
C {sky130_stdcells/xor2_4.sym} 78980 -27660 0 0 {name=X_77954_ }
C {devices/lab_pin.sym} 78940 -27530 0 0 {name=p78257 lab=_70238_/A }
C {devices/lab_pin.sym} 79020 -27530 0 1 {name=p78258 lab=_70289_/X }
C {sky130_stdcells/buf_2.sym} 78980 -27530 0 0 {name=X_70289_ }
C {devices/lab_pin.sym} 78900 -27430 0 0 {name=p78259 lab=_41136_/X }
C {devices/lab_pin.sym} 78900 -27390 0 0 {name=p78260 lab=_40689_/A }
C {devices/lab_pin.sym} 78900 -27350 0 0 {name=p78261 lab=_41207_/X }
C {devices/lab_pin.sym} 79060 -27390 0 1 {name=p78262 lab=_41209_/A }
C {sky130_stdcells/o21a_4.sym} 78980 -27390 0 0 {name=X_41208_ }
C {devices/lab_pin.sym} 78920 -27280 0 0 {name=p78263 lab=_60042_/A }
C {devices/lab_pin.sym} 78920 -27240 0 0 {name=p78264 lab=_60599_/A }
C {devices/lab_pin.sym} 78920 -27200 0 0 {name=p78265 lab=_60403_/C }
C {devices/lab_pin.sym} 78920 -27160 0 0 {name=p78266 lab=_60042_/D }
C {devices/lab_pin.sym} 79040 -27220 0 1 {name=p78267 lab=_60059_/A }
C {sky130_stdcells/and4_4.sym} 78980 -27220 0 0 {name=X_60042_ }
C {devices/lab_pin.sym} 78900 -27090 0 0 {name=p78268 lab=_83299_/Q }
C {devices/lab_pin.sym} 78900 -27050 0 0 {name=p78269 lab=_72016_/X }
C {devices/lab_pin.sym} 78900 -27010 0 0 {name=p78270 lab=_72027_/Y }
C {devices/lab_pin.sym} 79060 -27050 0 1 {name=p78271 lab=_72028_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -27050 0 0 {name=X_72028_ }
C {devices/lab_pin.sym} 78920 -26920 0 0 {name=p78272 lab=_76905_/A }
C {devices/lab_pin.sym} 78920 -26880 0 0 {name=p78273 lab=_76904_/Y }
C {devices/lab_pin.sym} 79040 -26900 0 1 {name=p78274 lab=_76905_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -26900 0 0 {name=X_76905_ }
C {devices/lab_pin.sym} 78940 -26770 0 0 {name=p78275 lab=_49825_/A }
C {devices/lab_pin.sym} 79020 -26770 0 1 {name=p78276 lab=_49853_/X }
C {sky130_stdcells/buf_2.sym} 78980 -26770 0 0 {name=X_49853_ }
C {devices/lab_pin.sym} 78900 -26690 0 0 {name=p78277 lab=_42173_/X }
C {devices/lab_pin.sym} 78900 -26650 0 0 {name=p78278 lab=_42169_/X }
C {devices/lab_pin.sym} 78900 -26610 0 0 {name=p78279 lab=_41277_/X }
C {devices/lab_pin.sym} 78900 -26570 0 0 {name=p78280 lab=_87989_/Q }
C {devices/lab_pin.sym} 78900 -26530 0 0 {name=p78281 lab=_42170_/X }
C {devices/lab_pin.sym} 79060 -26610 0 1 {name=p78282 lab=_42189_/A }
C {sky130_stdcells/o32ai_4.sym} 78980 -26610 0 0 {name=X_42188_ }
C {devices/lab_pin.sym} 78920 -26460 0 0 {name=p78283 lab=_77885_/A }
C {devices/lab_pin.sym} 78920 -26420 0 0 {name=p78284 lab=_77872_/Y }
C {devices/lab_pin.sym} 79040 -26440 0 1 {name=p78285 lab=_77885_/Y }
C {sky130_stdcells/nor2_4.sym} 78980 -26440 0 0 {name=X_77885_ }
C {devices/lab_pin.sym} 78940 -26310 0 0 {name=p78286 lab=clkbuf_9_197_0_CLK/X }
C {devices/lab_pin.sym} 79020 -26310 0 1 {name=p78287 lab=_84469_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 78980 -26310 0 0 {name=Xclkbuf_10_394_0_CLK }
C {devices/lab_pin.sym} 78900 -26210 0 0 {name=p78288 lab=_86479_/Q }
C {devices/lab_pin.sym} 78900 -26170 0 0 {name=p78289 lab=_48781_/X }
C {devices/lab_pin.sym} 78900 -26130 0 0 {name=p78290 lab=_48803_/Y }
C {devices/lab_pin.sym} 79060 -26170 0 1 {name=p78291 lab=_48804_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -26170 0 0 {name=X_48804_ }
C {devices/lab_pin.sym} 78920 -26040 0 0 {name=p78292 lab=_79624_/A }
C {devices/lab_pin.sym} 78920 -26000 0 0 {name=p78293 lab=_79624_/B }
C {devices/lab_pin.sym} 79040 -26020 0 1 {name=p78294 lab=_79624_/X }
C {sky130_stdcells/xor2_4.sym} 78980 -26020 0 0 {name=X_79624_ }
C {devices/lab_pin.sym} 78940 -25890 0 0 {name=p78295 lab=_41138_/X }
C {devices/lab_pin.sym} 79020 -25890 0 1 {name=p78296 lab=_41139_/X }
C {sky130_stdcells/buf_2.sym} 78980 -25890 0 0 {name=X_41139_ }
C {devices/lab_pin.sym} 78940 -25770 0 0 {name=p78297 lab=_64850_/A }
C {devices/lab_pin.sym} 79020 -25770 0 1 {name=p78298 lab=_64851_/A }
C {sky130_stdcells/buf_2.sym} 78980 -25770 0 0 {name=X_64850_ }
C {devices/lab_pin.sym} 78900 -25670 0 0 {name=p78299 lab=_76831_/Y }
C {devices/lab_pin.sym} 78900 -25630 0 0 {name=p78300 lab=_76818_/B }
C {devices/lab_pin.sym} 78900 -25590 0 0 {name=p78301 lab=_76835_/Y }
C {devices/lab_pin.sym} 79060 -25630 0 1 {name=p78302 lab=_76837_/B }
C {sky130_stdcells/o21ai_4.sym} 78980 -25630 0 0 {name=X_76836_ }
C {devices/lab_pin.sym} 78900 -25510 0 0 {name=p78303 lab=_49782_/Y }
C {devices/lab_pin.sym} 78900 -25470 0 0 {name=p78304 lab=_49759_/X }
C {devices/lab_pin.sym} 78900 -25430 0 0 {name=p78305 lab=_49783_/X }
C {devices/lab_pin.sym} 79060 -25470 0 1 {name=p78306 lab=_49784_/Y }
C {sky130_stdcells/a21oi_4.sym} 78980 -25470 0 0 {name=X_49784_ }
C {devices/lab_pin.sym} 78900 -25350 0 0 {name=p78307 lab=_59094_/A }
C {devices/lab_pin.sym} 78900 -25310 0 0 {name=p78308 lab=_46955_/X }
C {devices/lab_pin.sym} 78900 -25270 0 0 {name=p78309 lab=_46995_/Y }
C {devices/lab_pin.sym} 79060 -25310 0 1 {name=p78310 lab=_46996_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -25310 0 0 {name=X_46996_ }
C {devices/lab_pin.sym} 78900 -25190 0 0 {name=p78311 lab=_63799_/X }
C {devices/lab_pin.sym} 78900 -25150 0 0 {name=p78312 lab=_63744_/X }
C {devices/lab_pin.sym} 78900 -25110 0 0 {name=p78313 lab=_63800_/Y }
C {devices/lab_pin.sym} 79060 -25150 0 1 {name=p78314 lab=_63801_/Y }
C {sky130_stdcells/a21oi_4.sym} 78980 -25150 0 0 {name=X_63801_ }
C {devices/lab_pin.sym} 78920 -25020 0 0 {name=p78315 lab=_48801_/A }
C {devices/lab_pin.sym} 78920 -24980 0 0 {name=p78316 lab=_48407_/A }
C {devices/lab_pin.sym} 79040 -25000 0 1 {name=p78317 lab=_48735_/X }
C {sky130_stdcells/and2_4.sym} 78980 -25000 0 0 {name=X_48735_ }
C {devices/lab_pin.sym} 78920 -24890 0 0 {name=p78318 lab=_79555_/A }
C {devices/lab_pin.sym} 78920 -24850 0 0 {name=p78319 lab=_79555_/B }
C {devices/lab_pin.sym} 78920 -24810 0 0 {name=p78320 lab=_79555_/C }
C {devices/lab_pin.sym} 79040 -24850 0 1 {name=p78321 lab=_79558_/A }
C {sky130_stdcells/nand3_4.sym} 78980 -24850 0 0 {name=X_79555_ }
C {devices/lab_pin.sym} 78920 -24720 0 0 {name=p78322 lab=_66517_/B }
C {devices/lab_pin.sym} 78920 -24680 0 0 {name=p78323 lab=_45947_/B }
C {devices/lab_pin.sym} 79040 -24700 0 1 {name=p78324 lab=_45947_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -24700 0 0 {name=X_45947_ }
C {devices/lab_pin.sym} 78900 -24600 0 0 {name=p78325 lab=_64678_/X }
C {devices/lab_pin.sym} 78900 -24560 0 0 {name=p78326 lab=_85531_/Q }
C {devices/lab_pin.sym} 78900 -24520 0 0 {name=p78327 lab=_64679_/X }
C {devices/lab_pin.sym} 78900 -24480 0 0 {name=p78328 lab=_64780_/X }
C {devices/lab_pin.sym} 79060 -24540 0 1 {name=p78329 lab=_64781_/X }
C {sky130_stdcells/a211o_4.sym} 78980 -24540 0 0 {name=X_64781_ }
C {devices/lab_pin.sym} 78920 -24400 0 0 {name=p78330 lab=_76765_/Y }
C {devices/lab_pin.sym} 78920 -24360 0 0 {name=p78331 lab=_76766_/Y }
C {devices/lab_pin.sym} 79040 -24380 0 1 {name=p78332 lab=_76770_/A }
C {sky130_stdcells/xor2_4.sym} 78980 -24380 0 0 {name=X_76767_ }
C {devices/lab_pin.sym} 78920 -24260 0 0 {name=p78333 lab=_48014_/Y }
C {devices/lab_pin.sym} 78920 -24220 0 0 {name=p78334 lab=_73979_/B }
C {devices/lab_pin.sym} 79040 -24240 0 1 {name=p78335 lab=_73979_/X }
C {sky130_stdcells/xor2_4.sym} 78980 -24240 0 0 {name=X_73979_ }
C {devices/lab_pin.sym} 78900 -24140 0 0 {name=p78336 lab=_63573_/A }
C {devices/lab_pin.sym} 78900 -24100 0 0 {name=p78337 lab=_59841_/X }
C {devices/lab_pin.sym} 78900 -24060 0 0 {name=p78338 lab=_61542_/A }
C {devices/lab_pin.sym} 78900 -24020 0 0 {name=p78339 lab=_61981_/X }
C {devices/lab_pin.sym} 79060 -24080 0 1 {name=p78340 lab=_61993_/X }
C {sky130_stdcells/a2bb2o_4.sym} 78980 -24080 0 0 {name=X_61993_ }
C {devices/lab_pin.sym} 78900 -23950 0 0 {name=p78341 lab=_79165_/B }
C {devices/lab_pin.sym} 78900 -23910 0 0 {name=p78342 lab=_64532_/X }
C {devices/lab_pin.sym} 78900 -23870 0 0 {name=p78343 lab=_66519_/X }
C {devices/lab_pin.sym} 79060 -23910 0 1 {name=p78344 lab=_84107_/D }
C {sky130_stdcells/o21ai_4.sym} 78980 -23910 0 0 {name=X_66520_ }
C {devices/lab_pin.sym} 78900 -23790 0 0 {name=p78345 lab=_78505_/B }
C {devices/lab_pin.sym} 78900 -23750 0 0 {name=p78346 lab=_78505_/C }
C {devices/lab_pin.sym} 78900 -23710 0 0 {name=p78347 lab=_78501_/Y }
C {devices/lab_pin.sym} 79060 -23750 0 1 {name=p78348 lab=_78510_/C }
C {sky130_stdcells/o21ai_4.sym} 78980 -23750 0 0 {name=X_78506_ }
C {devices/lab_pin.sym} 78940 -23610 0 0 {name=p78349 lab=_75707_/Y }
C {devices/lab_pin.sym} 79020 -23610 0 1 {name=p78350 lab=_80785_/D }
C {sky130_stdcells/inv_2.sym} 78980 -23610 0 0 {name=X_75718_ }
C {devices/lab_pin.sym} 78920 -23520 0 0 {name=p78351 lab=_63721_/Y }
C {devices/lab_pin.sym} 78920 -23480 0 0 {name=p78352 lab=_63726_/Y }
C {devices/lab_pin.sym} 78920 -23440 0 0 {name=p78353 lab=_63730_/Y }
C {devices/lab_pin.sym} 78920 -23400 0 0 {name=p78354 lab=_63731_/Y }
C {devices/lab_pin.sym} 79040 -23460 0 1 {name=p78355 lab=_63732_/X }
C {sky130_stdcells/and4_4.sym} 78980 -23460 0 0 {name=X_63732_ }
C {devices/lab_pin.sym} 78940 -23310 0 0 {name=p78356 lab=_48666_/A }
C {devices/lab_pin.sym} 79020 -23310 0 1 {name=p78357 lab=_48667_/A }
C {sky130_stdcells/buf_2.sym} 78980 -23310 0 0 {name=X_48666_ }
C {devices/lab_pin.sym} 78900 -23210 0 0 {name=p78358 lab=_64172_/D }
C {devices/lab_pin.sym} 78900 -23170 0 0 {name=p78359 lab=_60870_/X }
C {devices/lab_pin.sym} 78900 -23130 0 0 {name=p78360 lab=_63781_/B }
C {devices/lab_pin.sym} 79060 -23170 0 1 {name=p78361 lab=_60944_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -23170 0 0 {name=X_60944_ }
C {devices/lab_pin.sym} 78920 -23050 0 0 {name=p78362 lab=_79483_/X }
C {devices/lab_pin.sym} 78920 -23010 0 0 {name=p78363 lab=_79486_/B }
C {devices/lab_pin.sym} 78920 -22970 0 0 {name=p78364 lab=_79486_/C }
C {devices/lab_pin.sym} 79040 -23010 0 1 {name=p78365 lab=_79487_/A }
C {sky130_stdcells/and3_4.sym} 78980 -23010 0 0 {name=X_79486_ }
C {devices/lab_pin.sym} 78940 -22870 0 0 {name=p78366 lab=_64190_/A }
C {devices/lab_pin.sym} 79020 -22870 0 1 {name=p78367 lab=_61695_/A }
C {sky130_stdcells/buf_2.sym} 78980 -22870 0 0 {name=X_45878_ }
C {devices/lab_pin.sym} 78920 -22760 0 0 {name=p78368 lab=_76688_/A }
C {devices/lab_pin.sym} 78920 -22720 0 0 {name=p78369 lab=_76687_/Y }
C {devices/lab_pin.sym} 79040 -22740 0 1 {name=p78370 lab=_76698_/Y }
C {sky130_stdcells/nor2_4.sym} 78980 -22740 0 0 {name=X_76698_ }
C {devices/lab_pin.sym} 78920 -22640 0 0 {name=p78371 lab=_47595_/A }
C {devices/lab_pin.sym} 78920 -22600 0 0 {name=p78372 lab=_47645_/B }
C {devices/lab_pin.sym} 78920 -22560 0 0 {name=p78373 lab=_47614_/X }
C {devices/lab_pin.sym} 78920 -22520 0 0 {name=p78374 lab=_53151_/D }
C {devices/lab_pin.sym} 79040 -22580 0 1 {name=p78375 lab=_47617_/X }
C {sky130_stdcells/and4_4.sym} 78980 -22580 0 0 {name=X_47617_ }
C {devices/lab_pin.sym} 78920 -22450 0 0 {name=p78376 lab=_66445_/A }
C {devices/lab_pin.sym} 78920 -22410 0 0 {name=p78377 lab=_66402_/B }
C {devices/lab_pin.sym} 78920 -22370 0 0 {name=p78378 lab=_66450_/Y }
C {devices/lab_pin.sym} 79040 -22410 0 1 {name=p78379 lab=_66451_/Y }
C {sky130_stdcells/nor3_4.sym} 78980 -22410 0 0 {name=X_66451_ }
C {devices/lab_pin.sym} 78900 -22290 0 0 {name=p78380 lab=_78439_/B }
C {devices/lab_pin.sym} 78900 -22250 0 0 {name=p78381 lab=_78439_/C }
C {devices/lab_pin.sym} 78900 -22210 0 0 {name=p78382 lab=_78436_/Y }
C {devices/lab_pin.sym} 79060 -22250 0 1 {name=p78383 lab=_78450_/A }
C {sky130_stdcells/a21boi_4.sym} 78980 -22250 0 0 {name=X_78437_ }
C {devices/lab_pin.sym} 78900 -22140 0 0 {name=p78384 lab=_41692_/Y }
C {devices/lab_pin.sym} 78900 -22100 0 0 {name=p78385 lab=_44817_/X }
C {devices/lab_pin.sym} 78900 -22060 0 0 {name=p78386 lab=_67605_/B }
C {devices/lab_pin.sym} 78900 -22020 0 0 {name=p78387 lab=_44818_/X }
C {devices/lab_pin.sym} 79060 -22080 0 1 {name=p78388 lab=_86932_/D }
C {sky130_stdcells/a2bb2o_4.sym} 78980 -22080 0 0 {name=X_44829_ }
C {devices/lab_pin.sym} 78920 -21950 0 0 {name=p78389 lab=_63670_/A }
C {devices/lab_pin.sym} 78920 -21910 0 0 {name=p78390 lab=_63670_/B }
C {devices/lab_pin.sym} 78920 -21870 0 0 {name=p78391 lab=_80357_/B }
C {devices/lab_pin.sym} 79040 -21910 0 1 {name=p78392 lab=_63663_/Y }
C {sky130_stdcells/nor3_4.sym} 78980 -21910 0 0 {name=X_63663_ }
C {devices/lab_pin.sym} 78940 -21770 0 0 {name=p78393 lab=_75649_/A }
C {devices/lab_pin.sym} 79020 -21770 0 1 {name=p78394 lab=_75649_/Y }
C {sky130_stdcells/inv_2.sym} 78980 -21770 0 0 {name=X_75649_ }
C {devices/lab_pin.sym} 78920 -21660 0 0 {name=p78395 lab=_81772_/Q }
C {devices/lab_pin.sym} 78920 -21620 0 0 {name=p78396 lab=_48959_/B }
C {devices/lab_pin.sym} 79040 -21640 0 1 {name=p78397 lab=_48597_/X }
C {sky130_stdcells/or2_4.sym} 78980 -21640 0 0 {name=X_48597_ }
C {devices/lab_pin.sym} 78920 -21530 0 0 {name=p78398 lab=_60870_/X }
C {devices/lab_pin.sym} 78920 -21490 0 0 {name=p78399 lab=_64172_/B }
C {devices/lab_pin.sym} 78920 -21450 0 0 {name=p78400 lab=_64172_/D }
C {devices/lab_pin.sym} 79040 -21490 0 1 {name=p78401 lab=_60881_/B }
C {sky130_stdcells/nand3_4.sym} 78980 -21490 0 0 {name=X_60875_ }
C {devices/lab_pin.sym} 78900 -21380 0 0 {name=p78402 lab=_65350_/X }
C {devices/lab_pin.sym} 78900 -21340 0 0 {name=p78403 lab=_86146_/Q }
C {devices/lab_pin.sym} 78900 -21300 0 0 {name=p78404 lab=_65400_/X }
C {devices/lab_pin.sym} 78900 -21260 0 0 {name=p78405 lab=_65401_/X }
C {devices/lab_pin.sym} 79060 -21320 0 1 {name=p78406 lab=_65402_/X }
C {sky130_stdcells/a211o_4.sym} 78980 -21320 0 0 {name=X_65402_ }
C {devices/lab_pin.sym} 78920 -21200 0 0 {name=p78407 lab=_62634_/A }
C {devices/lab_pin.sym} 78920 -21160 0 0 {name=p78408 lab=_62614_/B }
C {devices/lab_pin.sym} 78920 -21120 0 0 {name=p78409 lab=_62612_/Y }
C {devices/lab_pin.sym} 78920 -21080 0 0 {name=p78410 lab=_62613_/Y }
C {devices/lab_pin.sym} 79040 -21140 0 1 {name=p78411 lab=_62614_/Y }
C {sky130_stdcells/nand4_4.sym} 78980 -21140 0 0 {name=X_62614_ }
C {devices/lab_pin.sym} 78900 -21020 0 0 {name=p78412 lab=_87037_/Q }
C {devices/lab_pin.sym} 78900 -20980 0 0 {name=p78413 lab=_69153_/X }
C {devices/lab_pin.sym} 78900 -20940 0 0 {name=p78414 lab=_69168_/X }
C {devices/lab_pin.sym} 78900 -20900 0 0 {name=p78415 lab=_69169_/X }
C {devices/lab_pin.sym} 79060 -20960 0 1 {name=p78416 lab=_69170_/X }
C {sky130_stdcells/a211o_4.sym} 78980 -20960 0 0 {name=X_69170_ }
C {devices/lab_pin.sym} 78920 -20830 0 0 {name=p78417 lab=_64702_/X }
C {devices/lab_pin.sym} 78920 -20790 0 0 {name=p78418 lab=_66423_/B }
C {devices/lab_pin.sym} 78920 -20750 0 0 {name=p78419 lab=_64711_/X }
C {devices/lab_pin.sym} 79040 -20790 0 1 {name=p78420 lab=_66382_/Y }
C {sky130_stdcells/nand3_4.sym} 78980 -20790 0 0 {name=X_66382_ }
C {devices/lab_pin.sym} 78940 -20650 0 0 {name=p78421 lab=_47548_/A }
C {devices/lab_pin.sym} 79020 -20650 0 1 {name=p78422 lab=_53113_/D }
C {sky130_stdcells/buf_2.sym} 78980 -20650 0 0 {name=X_47548_ }
C {devices/lab_pin.sym} 78900 -20550 0 0 {name=p78423 lab=_78353_/A }
C {devices/lab_pin.sym} 78900 -20510 0 0 {name=p78424 lab=_78353_/C }
C {devices/lab_pin.sym} 78900 -20470 0 0 {name=p78425 lab=_78367_/Y }
C {devices/lab_pin.sym} 79060 -20510 0 1 {name=p78426 lab=_78369_/B }
C {sky130_stdcells/a21oi_4.sym} 78980 -20510 0 0 {name=X_78368_ }
C {devices/lab_pin.sym} 78940 -20370 0 0 {name=p78427 lab=_63471_/A }
C {devices/lab_pin.sym} 79020 -20370 0 1 {name=p78428 lab=_63595_/D }
C {sky130_stdcells/buf_2.sym} 78980 -20370 0 0 {name=X_63594_ }
C {devices/lab_pin.sym} 78940 -20250 0 0 {name=p78429 lab=clkbuf_9_166_0_CLK/X }
C {devices/lab_pin.sym} 79020 -20250 0 1 {name=p78430 lab=_84746_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 78980 -20250 0 0 {name=Xclkbuf_10_332_0_CLK }
C {devices/lab_pin.sym} 78940 -20130 0 0 {name=p78431 lab=_67495_/X }
C {devices/lab_pin.sym} 79020 -20130 0 1 {name=p78432 lab=_68121_/X }
C {sky130_stdcells/buf_2.sym} 78980 -20130 0 0 {name=X_68121_ }
C {devices/lab_pin.sym} 78920 -20020 0 0 {name=p78433 lab=_65333_/A }
C {devices/lab_pin.sym} 78920 -19980 0 0 {name=p78434 lab=_65332_/X }
C {devices/lab_pin.sym} 79040 -20000 0 1 {name=p78435 lab=_65333_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -20000 0 0 {name=X_65333_ }
C {devices/lab_pin.sym} 78900 -19890 0 0 {name=p78436 lab=_77286_/A }
C {devices/lab_pin.sym} 78900 -19850 0 0 {name=p78437 lab=_77300_/A }
C {devices/lab_pin.sym} 78900 -19810 0 0 {name=p78438 lab=_77301_/A }
C {devices/lab_pin.sym} 79060 -19850 0 1 {name=p78439 lab=_77319_/X }
C {sky130_stdcells/a21o_4.sym} 78980 -19850 0 0 {name=X_77319_ }
C {devices/lab_pin.sym} 78900 -19740 0 0 {name=p78440 lab=_62544_/Y }
C {devices/lab_pin.sym} 78900 -19700 0 0 {name=p78441 lab=_59951_/C }
C {devices/lab_pin.sym} 78900 -19660 0 0 {name=p78442 lab=_84890_/Q }
C {devices/lab_pin.sym} 78900 -19620 0 0 {name=p78443 lab=_62196_/X }
C {devices/lab_pin.sym} 79060 -19680 0 1 {name=p78444 lab=_62545_/X }
C {sky130_stdcells/a2bb2o_4.sym} 78980 -19680 0 0 {name=X_62545_ }
C {devices/lab_pin.sym} 78940 -19530 0 0 {name=p78445 lab=_47525_/A }
C {devices/lab_pin.sym} 79020 -19530 0 1 {name=p78446 lab=_47517_/A }
C {sky130_stdcells/buf_2.sym} 78980 -19530 0 0 {name=X_47479_ }
C {devices/lab_pin.sym} 78940 -19410 0 0 {name=p78447 lab=clkbuf_9_481_0_CLK/X }
C {devices/lab_pin.sym} 79020 -19410 0 1 {name=p78448 lab=_86238_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 78980 -19410 0 0 {name=Xclkbuf_10_962_0_CLK }
C {devices/lab_pin.sym} 78920 -19300 0 0 {name=p78449 lab=_82688_/Q }
C {devices/lab_pin.sym} 78920 -19260 0 0 {name=p78450 lab=_78299_/B }
C {devices/lab_pin.sym} 79040 -19280 0 1 {name=p78451 lab=_78299_/X }
C {sky130_stdcells/xor2_4.sym} 78980 -19280 0 0 {name=X_78299_ }
C {devices/lab_pin.sym} 78920 -19160 0 0 {name=p78452 lab=_49212_/A }
C {devices/lab_pin.sym} 78920 -19120 0 0 {name=p78453 lab=_50738_/B }
C {devices/lab_pin.sym} 79040 -19140 0 1 {name=p78454 lab=_49218_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -19140 0 0 {name=X_49218_ }
C {devices/lab_pin.sym} 78920 -19030 0 0 {name=p78455 lab=_80324_/A }
C {devices/lab_pin.sym} 78920 -18990 0 0 {name=p78456 lab=_80326_/X }
C {devices/lab_pin.sym} 78920 -18950 0 0 {name=p78457 lab=_80327_/Y }
C {devices/lab_pin.sym} 79040 -18990 0 1 {name=p78458 lab=_80330_/Y }
C {sky130_stdcells/nand3_4.sym} 78980 -18990 0 0 {name=X_80330_ }
C {devices/lab_pin.sym} 78900 -18880 0 0 {name=p78459 lab=_87893_/Q }
C {devices/lab_pin.sym} 78900 -18840 0 0 {name=p78460 lab=_68006_/X }
C {devices/lab_pin.sym} 78900 -18800 0 0 {name=p78461 lab=_67984_/X }
C {devices/lab_pin.sym} 78900 -18760 0 0 {name=p78462 lab=_68051_/X }
C {devices/lab_pin.sym} 79060 -18820 0 1 {name=p78463 lab=_68052_/X }
C {sky130_stdcells/a211o_4.sym} 78980 -18820 0 0 {name=X_68052_ }
C {devices/lab_pin.sym} 78920 -18680 0 0 {name=p78464 lab=_65289_/A }
C {devices/lab_pin.sym} 78920 -18640 0 0 {name=p78465 lab=_86408_/Q }
C {devices/lab_pin.sym} 79040 -18660 0 1 {name=p78466 lab=_65264_/X }
C {sky130_stdcells/and2_4.sym} 78980 -18660 0 0 {name=X_65264_ }
C {devices/lab_pin.sym} 78900 -18550 0 0 {name=p78467 lab=_86190_/Q }
C {devices/lab_pin.sym} 78900 -18510 0 0 {name=p78468 lab=_50464_/X }
C {devices/lab_pin.sym} 78900 -18470 0 0 {name=p78469 lab=_50489_/Y }
C {devices/lab_pin.sym} 79060 -18510 0 1 {name=p78470 lab=_50490_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -18510 0 0 {name=X_50490_ }
C {devices/lab_pin.sym} 78920 -18400 0 0 {name=p78471 lab=_61549_/X }
C {devices/lab_pin.sym} 78920 -18360 0 0 {name=p78472 lab=_62492_/B }
C {devices/lab_pin.sym} 78920 -18320 0 0 {name=p78473 lab=_62449_/X }
C {devices/lab_pin.sym} 78920 -18280 0 0 {name=p78474 lab=_62475_/X }
C {devices/lab_pin.sym} 79040 -18340 0 1 {name=p78475 lab=_62476_/Y }
C {sky130_stdcells/nand4_4.sym} 78980 -18340 0 0 {name=X_62476_ }
C {devices/lab_pin.sym} 78940 -18190 0 0 {name=p78476 lab=clkbuf_8_226_0_CLK/X }
C {devices/lab_pin.sym} 79020 -18190 0 1 {name=p78477 lab=clkbuf_9_453_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 78980 -18190 0 0 {name=Xclkbuf_9_453_0_CLK }
C {devices/lab_pin.sym} 78920 -18080 0 0 {name=p78478 lab=_67028_/A }
C {devices/lab_pin.sym} 78920 -18040 0 0 {name=p78479 lab=_67003_/B }
C {devices/lab_pin.sym} 79040 -18060 0 1 {name=p78480 lab=_67003_/X }
C {sky130_stdcells/and2_4.sym} 78980 -18060 0 0 {name=X_67003_ }
C {devices/lab_pin.sym} 78920 -17950 0 0 {name=p78481 lab=_64490_/A }
C {devices/lab_pin.sym} 78920 -17910 0 0 {name=p78482 lab=_64490_/B }
C {devices/lab_pin.sym} 78920 -17870 0 0 {name=p78483 lab=_79883_/B }
C {devices/lab_pin.sym} 79040 -17910 0 1 {name=p78484 lab=_64215_/Y }
C {sky130_stdcells/nor3_4.sym} 78980 -17910 0 0 {name=X_64215_ }
C {devices/lab_pin.sym} 78920 -17790 0 0 {name=p78485 lab=_61375_/A }
C {devices/lab_pin.sym} 78920 -17750 0 0 {name=p78486 lab=_61427_/B }
C {devices/lab_pin.sym} 78920 -17710 0 0 {name=p78487 lab=_61398_/C }
C {devices/lab_pin.sym} 79040 -17750 0 1 {name=p78488 lab=_61427_/Y }
C {sky130_stdcells/nand3_4.sym} 78980 -17750 0 0 {name=X_61427_ }
C {devices/lab_pin.sym} 78900 -17630 0 0 {name=p78489 lab=_49128_/X }
C {devices/lab_pin.sym} 78900 -17590 0 0 {name=p78490 lab=_48654_/A }
C {devices/lab_pin.sym} 78900 -17550 0 0 {name=p78491 lab=_49148_/Y }
C {devices/lab_pin.sym} 79060 -17590 0 1 {name=p78492 lab=_52395_/B }
C {sky130_stdcells/a21o_4.sym} 78980 -17590 0 0 {name=X_49149_ }
C {devices/lab_pin.sym} 78920 -17460 0 0 {name=p78493 lab=_80261_/A }
C {devices/lab_pin.sym} 78920 -17420 0 0 {name=p78494 lab=_80261_/B }
C {devices/lab_pin.sym} 79040 -17440 0 1 {name=p78495 lab=_80261_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -17440 0 0 {name=X_80261_ }
C {devices/lab_pin.sym} 78940 -17310 0 0 {name=p78496 lab=_65529_/A }
C {devices/lab_pin.sym} 79020 -17310 0 1 {name=p78497 lab=_65195_/X }
C {sky130_stdcells/buf_2.sym} 78980 -17310 0 0 {name=X_65195_ }
C {devices/lab_pin.sym} 78940 -17190 0 0 {name=p78498 lab=clkbuf_9_173_0_CLK/X }
C {devices/lab_pin.sym} 79020 -17190 0 1 {name=p78499 lab=_85428_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 78980 -17190 0 0 {name=Xclkbuf_10_347_0_CLK }
C {devices/lab_pin.sym} 78890 -17070 0 0 {name=p78500 lab=_82103_/CLK }
C {devices/lab_pin.sym} 78890 -17050 0 0 {name=p78501 lab=_82032_/Q }
C {devices/lab_pin.sym} 79070 -17070 0 1 {name=p78502 lab=_77114_/B }
C {sky130_stdcells/dfxtp_4.sym} 78980 -17060 0 0 {name=X_82000_ }
C {devices/lab_pin.sym} 78940 -16930 0 0 {name=p78503 lab=_51956_/X }
C {devices/lab_pin.sym} 79020 -16930 0 1 {name=p78504 lab=_52182_/C }
C {sky130_stdcells/buf_2.sym} 78980 -16930 0 0 {name=X_52160_ }
C {devices/lab_pin.sym} 78940 -16810 0 0 {name=p78505 lab=clkbuf_9_488_0_CLK/X }
C {devices/lab_pin.sym} 79020 -16810 0 1 {name=p78506 lab=_86154_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 78980 -16810 0 0 {name=Xclkbuf_10_977_0_CLK }
C {devices/lab_pin.sym} 78920 -16720 0 0 {name=p78507 lab=_58198_/A }
C {devices/lab_pin.sym} 78920 -16680 0 0 {name=p78508 lab=_64158_/B }
C {devices/lab_pin.sym} 78920 -16640 0 0 {name=p78509 lab=_64158_/C }
C {devices/lab_pin.sym} 78920 -16600 0 0 {name=p78510 lab=_64045_/X }
C {devices/lab_pin.sym} 79040 -16660 0 1 {name=p78511 lab=_64146_/Y }
C {sky130_stdcells/nand4_4.sym} 78980 -16660 0 0 {name=X_64146_ }
C {devices/lab_pin.sym} 78920 -16540 0 0 {name=p78512 lab=_61358_/A }
C {devices/lab_pin.sym} 78920 -16500 0 0 {name=p78513 lab=_61367_/B }
C {devices/lab_pin.sym} 78920 -16460 0 0 {name=p78514 lab=_61367_/C }
C {devices/lab_pin.sym} 78920 -16420 0 0 {name=p78515 lab=_61367_/D }
C {devices/lab_pin.sym} 79040 -16480 0 1 {name=p78516 lab=_61358_/Y }
C {sky130_stdcells/nand4_4.sym} 78980 -16480 0 0 {name=X_61358_ }
C {devices/lab_pin.sym} 78920 -16340 0 0 {name=p78517 lab=_84947_/Q }
C {devices/lab_pin.sym} 78920 -16300 0 0 {name=p78518 lab=_65531_/C }
C {devices/lab_pin.sym} 79040 -16320 0 1 {name=p78519 lab=_80192_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -16320 0 0 {name=X_80192_ }
C {devices/lab_pin.sym} 78900 -16210 0 0 {name=p78520 lab=_51108_/Y }
C {devices/lab_pin.sym} 78900 -16170 0 0 {name=p78521 lab=_51093_/X }
C {devices/lab_pin.sym} 78900 -16130 0 0 {name=p78522 lab=_51110_/X }
C {devices/lab_pin.sym} 79060 -16170 0 1 {name=p78523 lab=_86072_/D }
C {sky130_stdcells/a21oi_4.sym} 78980 -16170 0 0 {name=X_51111_ }
C {devices/lab_pin.sym} 78920 -16060 0 0 {name=p78524 lab=_60170_/A }
C {devices/lab_pin.sym} 78920 -16020 0 0 {name=p78525 lab=_60253_/A }
C {devices/lab_pin.sym} 78920 -15980 0 0 {name=p78526 lab=_60309_/C }
C {devices/lab_pin.sym} 78920 -15940 0 0 {name=p78527 lab=_60309_/D }
C {devices/lab_pin.sym} 79040 -16000 0 1 {name=p78528 lab=_60309_/X }
C {sky130_stdcells/and4_4.sym} 78980 -16000 0 0 {name=X_60309_ }
C {devices/lab_pin.sym} 78920 -15860 0 0 {name=p78529 lab=_52100_/A }
C {devices/lab_pin.sym} 78920 -15820 0 0 {name=p78530 lab=_50389_/B }
C {devices/lab_pin.sym} 79040 -15840 0 1 {name=p78531 lab=_52091_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -15840 0 0 {name=X_52091_ }
C {devices/lab_pin.sym} 78940 -15710 0 0 {name=p78532 lab=_68586_/A }
C {devices/lab_pin.sym} 79020 -15710 0 1 {name=p78533 lab=_68954_/X }
C {sky130_stdcells/buf_2.sym} 78980 -15710 0 0 {name=X_68954_ }
C {devices/lab_pin.sym} 78940 -15590 0 0 {name=p78534 lab=_64076_/Y }
C {devices/lab_pin.sym} 79020 -15590 0 1 {name=p78535 lab=_64077_/Y }
C {sky130_stdcells/inv_2.sym} 78980 -15590 0 0 {name=X_64077_ }
C {devices/lab_pin.sym} 78940 -15470 0 0 {name=p78536 lab=clkbuf_9_469_0_CLK/A }
C {devices/lab_pin.sym} 79020 -15470 0 1 {name=p78537 lab=clkbuf_9_468_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 78980 -15470 0 0 {name=Xclkbuf_9_468_0_CLK }
C {devices/lab_pin.sym} 78920 -15370 0 0 {name=p78538 lab=_72502_/A }
C {devices/lab_pin.sym} 78920 -15330 0 0 {name=p78539 lab=_72507_/A }
C {devices/lab_pin.sym} 78920 -15290 0 0 {name=p78540 lab=_72514_/A }
C {devices/lab_pin.sym} 79040 -15330 0 1 {name=p78541 lab=_61290_/A }
C {sky130_stdcells/and3_4.sym} 78980 -15330 0 0 {name=X_61289_ }
C {devices/lab_pin.sym} 78900 -15210 0 0 {name=p78542 lab=_51038_/Y }
C {devices/lab_pin.sym} 78900 -15170 0 0 {name=p78543 lab=_51039_/X }
C {devices/lab_pin.sym} 78900 -15130 0 0 {name=p78544 lab=_51041_/X }
C {devices/lab_pin.sym} 79060 -15170 0 1 {name=p78545 lab=_86085_/D }
C {sky130_stdcells/a21oi_4.sym} 78980 -15170 0 0 {name=X_51042_ }
C {devices/lab_pin.sym} 78900 -15050 0 0 {name=p78546 lab=_67902_/X }
C {devices/lab_pin.sym} 78900 -15010 0 0 {name=p78547 lab=_67904_/X }
C {devices/lab_pin.sym} 78900 -14970 0 0 {name=p78548 lab=_67858_/X }
C {devices/lab_pin.sym} 79060 -15010 0 1 {name=p78549 lab=_67905_/X }
C {sky130_stdcells/a21o_4.sym} 78980 -15010 0 0 {name=X_67905_ }
C {devices/lab_pin.sym} 78940 -14870 0 0 {name=p78550 lab=_60473_/C }
C {devices/lab_pin.sym} 79020 -14870 0 1 {name=p78551 lab=_63028_/X }
C {sky130_stdcells/buf_2.sym} 78980 -14870 0 0 {name=X_63028_ }
C {devices/lab_pin.sym} 78890 -14750 0 0 {name=p78552 lab=_81134_/CLK }
C {devices/lab_pin.sym} 78890 -14730 0 0 {name=p78553 lab=_83951_/D }
C {devices/lab_pin.sym} 79070 -14750 0 1 {name=p78554 lab=_83951_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -14740 0 0 {name=X_83951_ }
C {devices/lab_pin.sym} 78940 -14610 0 0 {name=p78555 lab=_87838_/Q }
C {devices/lab_pin.sym} 79020 -14610 0 1 {name=p78556 lab=_68886_/B }
C {sky130_stdcells/inv_2.sym} 78980 -14610 0 0 {name=X_68885_ }
C {devices/lab_pin.sym} 78940 -14490 0 0 {name=p78557 lab=clkbuf_9_450_0_CLK/X }
C {devices/lab_pin.sym} 79020 -14490 0 1 {name=p78558 lab=_82536_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 78980 -14490 0 0 {name=Xclkbuf_10_900_0_CLK }
C {devices/lab_pin.sym} 78890 -14370 0 0 {name=p78559 lab=_81154_/CLK }
C {devices/lab_pin.sym} 78890 -14350 0 0 {name=p78560 lab=_78226_/B }
C {devices/lab_pin.sym} 79070 -14370 0 1 {name=p78561 lab=_82902_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -14360 0 0 {name=X_82902_ }
C {devices/lab_pin.sym} 78900 -14250 0 0 {name=p78562 lab=_55847_/X }
C {devices/lab_pin.sym} 78900 -14210 0 0 {name=p78563 lab=_55849_/X }
C {devices/lab_pin.sym} 78900 -14170 0 0 {name=p78564 lab=_44112_/X }
C {devices/lab_pin.sym} 79060 -14210 0 1 {name=p78565 lab=_55850_/X }
C {sky130_stdcells/a21o_4.sym} 78980 -14210 0 0 {name=X_55850_ }
C {devices/lab_pin.sym} 78920 -14080 0 0 {name=p78566 lab=_67739_/X }
C {devices/lab_pin.sym} 78920 -14040 0 0 {name=p78567 lab=_67836_/B }
C {devices/lab_pin.sym} 79040 -14060 0 1 {name=p78568 lab=_67836_/X }
C {sky130_stdcells/and2_4.sym} 78980 -14060 0 0 {name=X_67836_ }
C {devices/lab_pin.sym} 78890 -13930 0 0 {name=p78569 lab=_86351_/CLK }
C {devices/lab_pin.sym} 78890 -13910 0 0 {name=p78570 lab=_86670_/D }
C {devices/lab_pin.sym} 79070 -13930 0 1 {name=p78571 lab=_59240_/A }
C {sky130_stdcells/dfxtp_4.sym} 78980 -13920 0 0 {name=X_86670_ }
C {devices/lab_pin.sym} 78890 -13790 0 0 {name=p78572 lab=_82339_/CLK }
C {devices/lab_pin.sym} 78890 -13770 0 0 {name=p78573 lab=_83882_/D }
C {devices/lab_pin.sym} 79070 -13790 0 1 {name=p78574 lab=_83882_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -13780 0 0 {name=X_83882_ }
C {devices/lab_pin.sym} 78900 -13670 0 0 {name=p78575 lab=_85375_/Q }
C {devices/lab_pin.sym} 78900 -13630 0 0 {name=p78576 lab=_54784_/X }
C {devices/lab_pin.sym} 78900 -13590 0 0 {name=p78577 lab=_54800_/Y }
C {devices/lab_pin.sym} 79060 -13630 0 1 {name=p78578 lab=_54801_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -13630 0 0 {name=X_54801_ }
C {devices/lab_pin.sym} 78890 -13490 0 0 {name=p78579 lab=_86554_/CLK }
C {devices/lab_pin.sym} 78890 -13470 0 0 {name=p78580 lab=_85621_/D }
C {devices/lab_pin.sym} 79070 -13490 0 1 {name=p78581 lab=_85621_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -13480 0 0 {name=X_85621_ }
C {devices/lab_pin.sym} 78890 -13350 0 0 {name=p78582 lab=_82833_/CLK }
C {devices/lab_pin.sym} 78890 -13330 0 0 {name=p78583 lab=_79348_/X }
C {devices/lab_pin.sym} 79070 -13350 0 1 {name=p78584 lab=_82833_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -13340 0 0 {name=X_82833_ }
C {devices/lab_pin.sym} 78920 -13220 0 0 {name=p78585 lab=_67790_/A }
C {devices/lab_pin.sym} 78920 -13180 0 0 {name=p78586 lab=_67767_/B }
C {devices/lab_pin.sym} 79040 -13200 0 1 {name=p78587 lab=_67767_/X }
C {sky130_stdcells/and2_4.sym} 78980 -13200 0 0 {name=X_67767_ }
C {devices/lab_pin.sym} 78920 -13080 0 0 {name=p78588 lab=_55778_/X }
C {devices/lab_pin.sym} 78920 -13040 0 0 {name=p78589 lab=_55780_/X }
C {devices/lab_pin.sym} 79040 -13060 0 1 {name=p78590 lab=_55781_/X }
C {sky130_stdcells/and2_4.sym} 78980 -13060 0 0 {name=X_55781_ }
C {devices/lab_pin.sym} 78920 -12960 0 0 {name=p78591 lab=_52997_/A }
C {devices/lab_pin.sym} 78920 -12920 0 0 {name=p78592 lab=_52997_/B }
C {devices/lab_pin.sym} 78920 -12880 0 0 {name=p78593 lab=_52997_/C }
C {devices/lab_pin.sym} 78920 -12840 0 0 {name=p78594 lab=_52993_/D }
C {devices/lab_pin.sym} 79040 -12900 0 1 {name=p78595 lab=_52993_/X }
C {sky130_stdcells/and4_4.sym} 78980 -12900 0 0 {name=X_52993_ }
C {devices/lab_pin.sym} 78940 -12750 0 0 {name=p78596 lab=_65607_/A }
C {devices/lab_pin.sym} 79020 -12750 0 1 {name=p78597 lab=_65056_/B }
C {sky130_stdcells/buf_2.sym} 78980 -12750 0 0 {name=X_64979_ }
C {devices/lab_pin.sym} 78940 -12630 0 0 {name=p78598 lab=_46401_/A }
C {devices/lab_pin.sym} 79020 -12630 0 1 {name=p78599 lab=_57531_/A }
C {sky130_stdcells/buf_2.sym} 78980 -12630 0 0 {name=X_57520_ }
C {devices/lab_pin.sym} 78940 -12510 0 0 {name=p78600 lab=_69315_/A }
C {devices/lab_pin.sym} 79020 -12510 0 1 {name=p78601 lab=_69506_/X }
C {sky130_stdcells/buf_2.sym} 78980 -12510 0 0 {name=X_69506_ }
C {devices/lab_pin.sym} 78890 -12390 0 0 {name=p78602 lab=_88327_/CLK }
C {devices/lab_pin.sym} 78890 -12370 0 0 {name=p78603 lab=_88340_/D }
C {devices/lab_pin.sym} 79070 -12390 0 1 {name=p78604 lab=_88340_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -12380 0 0 {name=X_88340_ }
C {devices/lab_pin.sym} 78920 -12260 0 0 {name=p78605 lab=_54731_/X }
C {devices/lab_pin.sym} 78920 -12220 0 0 {name=p78606 lab=_47420_/Y }
C {devices/lab_pin.sym} 79040 -12240 0 1 {name=p78607 lab=_54732_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -12240 0 0 {name=X_54732_ }
C {devices/lab_pin.sym} 78890 -12110 0 0 {name=p78608 lab=_83305_/CLK }
C {devices/lab_pin.sym} 78890 -12090 0 0 {name=p78609 lab=_53868_/Y }
C {devices/lab_pin.sym} 79070 -12110 0 1 {name=p78610 lab=_85552_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -12100 0 0 {name=X_85552_ }
C {devices/lab_pin.sym} 78920 -11980 0 0 {name=p78611 lab=_66669_/A }
C {devices/lab_pin.sym} 78920 -11940 0 0 {name=p78612 lab=_66718_/B }
C {devices/lab_pin.sym} 79040 -11960 0 1 {name=p78613 lab=_66718_/X }
C {sky130_stdcells/and2_4.sym} 78980 -11960 0 0 {name=X_66718_ }
C {devices/lab_pin.sym} 78940 -11830 0 0 {name=p78614 lab=clkbuf_9_457_0_CLK/X }
C {devices/lab_pin.sym} 79020 -11830 0 1 {name=p78615 lab=_83141_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 78980 -11830 0 0 {name=Xclkbuf_10_915_0_CLK }
C {devices/lab_pin.sym} 78940 -11710 0 0 {name=p78616 lab=_52177_/A }
C {devices/lab_pin.sym} 79020 -11710 0 1 {name=p78617 lab=_52152_/A }
C {sky130_stdcells/buf_2.sym} 78980 -11710 0 0 {name=X_51944_ }
C {devices/lab_pin.sym} 78890 -11590 0 0 {name=p78618 lab=_82956_/CLK }
C {devices/lab_pin.sym} 78890 -11570 0 0 {name=p78619 lab=_82764_/D }
C {devices/lab_pin.sym} 79070 -11590 0 1 {name=p78620 lab=_82956_/D }
C {sky130_stdcells/dfxtp_4.sym} 78980 -11580 0 0 {name=X_82764_ }
C {devices/lab_pin.sym} 78920 -11460 0 0 {name=p78621 lab=_67698_/A }
C {devices/lab_pin.sym} 78920 -11420 0 0 {name=p78622 lab=_67698_/B }
C {devices/lab_pin.sym} 79040 -11440 0 1 {name=p78623 lab=_67698_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -11440 0 0 {name=X_67698_ }
C {devices/lab_pin.sym} 78940 -11310 0 0 {name=p78624 lab=clkbuf_9_2_0_CLK/X }
C {devices/lab_pin.sym} 79020 -11310 0 1 {name=p78625 lab=_85168_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 78980 -11310 0 0 {name=Xclkbuf_10_4_0_CLK }
C {devices/lab_pin.sym} 78890 -11190 0 0 {name=p78626 lab=_84503_/CLK }
C {devices/lab_pin.sym} 78890 -11170 0 0 {name=p78627 lab=_84503_/D }
C {devices/lab_pin.sym} 79070 -11190 0 1 {name=p78628 lab=_84503_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -11180 0 0 {name=X_84503_ }
C {devices/lab_pin.sym} 78900 -11070 0 0 {name=p78629 lab=_57440_/X }
C {devices/lab_pin.sym} 78900 -11030 0 0 {name=p78630 lab=_57449_/X }
C {devices/lab_pin.sym} 78900 -10990 0 0 {name=p78631 lab=_57450_/Y }
C {devices/lab_pin.sym} 79060 -11030 0 1 {name=p78632 lab=_57452_/A }
C {sky130_stdcells/o21ai_4.sym} 78980 -11030 0 0 {name=X_57451_ }
C {devices/lab_pin.sym} 78890 -10890 0 0 {name=p78633 lab=_81514_/CLK }
C {devices/lab_pin.sym} 78890 -10870 0 0 {name=p78634 lab=_81339_/Q }
C {devices/lab_pin.sym} 79070 -10890 0 1 {name=p78635 lab=_81715_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -10880 0 0 {name=X_81715_ }
C {devices/lab_pin.sym} 78900 -10770 0 0 {name=p78636 lab=_81388_/D }
C {devices/lab_pin.sym} 78900 -10730 0 0 {name=p78637 lab=_69367_/X }
C {devices/lab_pin.sym} 78900 -10690 0 0 {name=p78638 lab=_69436_/X }
C {devices/lab_pin.sym} 79060 -10730 0 1 {name=p78639 lab=_83924_/D }
C {sky130_stdcells/a21bo_4.sym} 78980 -10730 0 0 {name=X_69437_ }
C {devices/lab_pin.sym} 78890 -10590 0 0 {name=p78640 lab=_88272_/CLK }
C {devices/lab_pin.sym} 78890 -10570 0 0 {name=p78641 lab=_41135_/X }
C {devices/lab_pin.sym} 79070 -10590 0 1 {name=p78642 lab=_68485_/B }
C {sky130_stdcells/dfxtp_4.sym} 78980 -10580 0 0 {name=X_88271_ }
C {devices/lab_pin.sym} 78900 -10470 0 0 {name=p78643 lab=_54661_/Y }
C {devices/lab_pin.sym} 78900 -10430 0 0 {name=p78644 lab=_54638_/X }
C {devices/lab_pin.sym} 78900 -10390 0 0 {name=p78645 lab=_54662_/X }
C {devices/lab_pin.sym} 79060 -10430 0 1 {name=p78646 lab=_85401_/D }
C {sky130_stdcells/a21oi_4.sym} 78980 -10430 0 0 {name=X_54663_ }
C {devices/lab_pin.sym} 78900 -10320 0 0 {name=p78647 lab=_88400_/Q }
C {devices/lab_pin.sym} 78900 -10280 0 0 {name=p78648 lab=_66593_/X }
C {devices/lab_pin.sym} 78900 -10240 0 0 {name=p78649 lab=_66594_/X }
C {devices/lab_pin.sym} 78900 -10200 0 0 {name=p78650 lab=_66648_/X }
C {devices/lab_pin.sym} 79060 -10260 0 1 {name=p78651 lab=_66649_/X }
C {sky130_stdcells/a211o_4.sym} 78980 -10260 0 0 {name=X_66649_ }
C {devices/lab_pin.sym} 78890 -10110 0 0 {name=p78652 lab=_84930_/CLK }
C {devices/lab_pin.sym} 78890 -10090 0 0 {name=p78653 lab=_85483_/D }
C {devices/lab_pin.sym} 79070 -10110 0 1 {name=p78654 lab=_85483_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -10100 0 0 {name=X_85483_ }
C {devices/lab_pin.sym} 78920 -9980 0 0 {name=p78655 lab=_51875_/A }
C {devices/lab_pin.sym} 78920 -9940 0 0 {name=p78656 lab=_51008_/B }
C {devices/lab_pin.sym} 79040 -9960 0 1 {name=p78657 lab=_51875_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -9960 0 0 {name=X_51875_ }
C {devices/lab_pin.sym} 78940 -9830 0 0 {name=p78658 lab=clkbuf_9_407_0_CLK/A }
C {devices/lab_pin.sym} 79020 -9830 0 1 {name=p78659 lab=clkbuf_9_406_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 78980 -9830 0 0 {name=Xclkbuf_9_406_0_CLK }
C {devices/lab_pin.sym} 78890 -9710 0 0 {name=p78660 lab=_82933_/CLK }
C {devices/lab_pin.sym} 78890 -9690 0 0 {name=p78661 lab=_78851_/X }
C {devices/lab_pin.sym} 79070 -9710 0 1 {name=p78662 lab=_78680_/B }
C {sky130_stdcells/dfxtp_4.sym} 78980 -9700 0 0 {name=X_82695_ }
C {devices/lab_pin.sym} 78900 -9590 0 0 {name=p78663 lab=_56055_/X }
C {devices/lab_pin.sym} 78900 -9550 0 0 {name=p78664 lab=_56394_/X }
C {devices/lab_pin.sym} 78900 -9510 0 0 {name=p78665 lab=_56401_/Y }
C {devices/lab_pin.sym} 79060 -9550 0 1 {name=p78666 lab=_85208_/D }
C {sky130_stdcells/o21ai_4.sym} 78980 -9550 0 0 {name=X_56402_ }
C {devices/lab_pin.sym} 78890 -9410 0 0 {name=p78667 lab=_87225_/CLK }
C {devices/lab_pin.sym} 78890 -9390 0 0 {name=p78668 lab=_87222_/D }
C {devices/lab_pin.sym} 79070 -9410 0 1 {name=p78669 lab=_87222_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -9400 0 0 {name=X_87222_ }
C {devices/lab_pin.sym} 78920 -9290 0 0 {name=p78670 lab=_50391_/A }
C {devices/lab_pin.sym} 78920 -9250 0 0 {name=p78671 lab=_53697_/B }
C {devices/lab_pin.sym} 78920 -9210 0 0 {name=p78672 lab=_53697_/C }
C {devices/lab_pin.sym} 79040 -9250 0 1 {name=p78673 lab=_53614_/Y }
C {sky130_stdcells/nand3_4.sym} 78980 -9250 0 0 {name=X_53614_ }
C {devices/lab_pin.sym} 78890 -9110 0 0 {name=p78674 lab=_81859_/CLK }
C {devices/lab_pin.sym} 78890 -9090 0 0 {name=p78675 lab=_62091_/Y }
C {devices/lab_pin.sym} 79070 -9110 0 1 {name=p78676 lab=_78057_/B }
C {sky130_stdcells/dfxtp_4.sym} 78980 -9100 0 0 {name=X_84434_ }
C {devices/lab_pin.sym} 78900 -8990 0 0 {name=p78677 lab=_50823_/Y }
C {devices/lab_pin.sym} 78900 -8950 0 0 {name=p78678 lab=_50801_/X }
C {devices/lab_pin.sym} 78900 -8910 0 0 {name=p78679 lab=_50825_/X }
C {devices/lab_pin.sym} 79060 -8950 0 1 {name=p78680 lab=_86126_/D }
C {sky130_stdcells/a21oi_4.sym} 78980 -8950 0 0 {name=X_50826_ }
C {devices/lab_pin.sym} 78890 -8810 0 0 {name=p78681 lab=_81296_/CLK }
C {devices/lab_pin.sym} 78890 -8790 0 0 {name=p78682 lab=_76907_/A }
C {devices/lab_pin.sym} 79070 -8810 0 1 {name=p78683 lab=_76314_/A }
C {sky130_stdcells/dfxtp_4.sym} 78980 -8800 0 0 {name=X_81646_ }
C {devices/lab_pin.sym} 78940 -8670 0 0 {name=p78684 lab=_44308_/X }
C {devices/lab_pin.sym} 79020 -8670 0 1 {name=p78685 lab=_57465_/A }
C {sky130_stdcells/inv_2.sym} 78980 -8670 0 0 {name=X_57382_ }
C {devices/lab_pin.sym} 78940 -8550 0 0 {name=p78686 lab=_69645_/A }
C {devices/lab_pin.sym} 79020 -8550 0 1 {name=p78687 lab=_69368_/X }
C {sky130_stdcells/buf_2.sym} 78980 -8550 0 0 {name=X_69368_ }
C {devices/lab_pin.sym} 78940 -8430 0 0 {name=p78688 lab=_54321_/A }
C {devices/lab_pin.sym} 79020 -8430 0 1 {name=p78689 lab=_54594_/X }
C {sky130_stdcells/buf_2.sym} 78980 -8430 0 0 {name=X_54594_ }
C {devices/lab_pin.sym} 78940 -8310 0 0 {name=p78690 lab=_59033_/A }
C {devices/lab_pin.sym} 79020 -8310 0 1 {name=p78691 lab=_59121_/X }
C {sky130_stdcells/buf_2.sym} 78980 -8310 0 0 {name=X_59121_ }
C {devices/lab_pin.sym} 78900 -8210 0 0 {name=p78692 lab=_56099_/X }
C {devices/lab_pin.sym} 78900 -8170 0 0 {name=p78693 lab=_56321_/X }
C {devices/lab_pin.sym} 78900 -8130 0 0 {name=p78694 lab=_56332_/Y }
C {devices/lab_pin.sym} 79060 -8170 0 1 {name=p78695 lab=_56333_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -8170 0 0 {name=X_56333_ }
C {devices/lab_pin.sym} 78940 -8030 0 0 {name=p78696 lab=_68376_/A }
C {devices/lab_pin.sym} 79020 -8030 0 1 {name=p78697 lab=_68319_/X }
C {sky130_stdcells/buf_2.sym} 78980 -8030 0 0 {name=X_68319_ }
C {devices/lab_pin.sym} 78890 -7910 0 0 {name=p78698 lab=_87653_/CLK }
C {devices/lab_pin.sym} 78890 -7890 0 0 {name=p78699 lab=_87153_/D }
C {devices/lab_pin.sym} 79070 -7910 0 1 {name=p78700 lab=_87153_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -7900 0 0 {name=X_87153_ }
C {devices/lab_pin.sym} 78940 -7770 0 0 {name=p78701 lab=_53793_/A }
C {devices/lab_pin.sym} 79020 -7770 0 1 {name=p78702 lab=_53565_/A }
C {sky130_stdcells/buf_2.sym} 78980 -7770 0 0 {name=X_53545_ }
C {devices/lab_pin.sym} 78890 -7650 0 0 {name=p78703 lab=_84559_/CLK }
C {devices/lab_pin.sym} 78890 -7630 0 0 {name=p78704 lab=_62970_/Y }
C {devices/lab_pin.sym} 79070 -7650 0 1 {name=p78705 lab=_84365_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -7640 0 0 {name=X_84365_ }
C {devices/lab_pin.sym} 78920 -7520 0 0 {name=p78706 lab=_50771_/A }
C {devices/lab_pin.sym} 78920 -7480 0 0 {name=p78707 lab=_50757_/B }
C {devices/lab_pin.sym} 79040 -7500 0 1 {name=p78708 lab=_50757_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -7500 0 0 {name=X_50757_ }
C {devices/lab_pin.sym} 78890 -7370 0 0 {name=p78709 lab=_81344_/CLK }
C {devices/lab_pin.sym} 78890 -7350 0 0 {name=p78710 lab=_84177_/Q }
C {devices/lab_pin.sym} 79070 -7370 0 1 {name=p78711 lab=_76713_/A }
C {sky130_stdcells/dfxtp_4.sym} 78980 -7360 0 0 {name=X_81577_ }
C {devices/lab_pin.sym} 78940 -7230 0 0 {name=p78712 lab=_69065_/X }
C {devices/lab_pin.sym} 79020 -7230 0 1 {name=p78713 lab=_69299_/X }
C {sky130_stdcells/buf_2.sym} 78980 -7230 0 0 {name=X_69299_ }
C {devices/lab_pin.sym} 78890 -7110 0 0 {name=p78714 lab=_86104_/CLK }
C {devices/lab_pin.sym} 78890 -7090 0 0 {name=p78715 lab=_50935_/Y }
C {devices/lab_pin.sym} 79070 -7110 0 1 {name=p78716 lab=_86104_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -7100 0 0 {name=X_86104_ }
C {devices/lab_pin.sym} 78940 -6970 0 0 {name=p78717 lab=_40509_/X }
C {devices/lab_pin.sym} 79020 -6970 0 1 {name=p78718 lab=_40510_/X }
C {sky130_stdcells/buf_2.sym} 78980 -6970 0 0 {name=X_40510_ }
C {devices/lab_pin.sym} 78900 -6870 0 0 {name=p78719 lab=_59001_/X }
C {devices/lab_pin.sym} 78900 -6830 0 0 {name=p78720 lab=_86077_/Q }
C {devices/lab_pin.sym} 78900 -6790 0 0 {name=p78721 lab=_59051_/X }
C {devices/lab_pin.sym} 79060 -6830 0 1 {name=p78722 lab=_59052_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -6830 0 0 {name=X_59052_ }
C {devices/lab_pin.sym} 78900 -6710 0 0 {name=p78723 lab=_50370_/B }
C {devices/lab_pin.sym} 78900 -6670 0 0 {name=p78724 lab=_71320_/X }
C {devices/lab_pin.sym} 78900 -6630 0 0 {name=p78725 lab=_71329_/Y }
C {devices/lab_pin.sym} 79060 -6670 0 1 {name=p78726 lab=_83534_/D }
C {sky130_stdcells/o21ai_4.sym} 78980 -6670 0 0 {name=X_71330_ }
C {devices/lab_pin.sym} 78890 -6530 0 0 {name=p78727 lab=_83316_/CLK }
C {devices/lab_pin.sym} 78890 -6510 0 0 {name=p78728 lab=_83316_/D }
C {devices/lab_pin.sym} 79070 -6530 0 1 {name=p78729 lab=_83316_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -6520 0 0 {name=X_83316_ }
C {devices/lab_pin.sym} 78900 -6410 0 0 {name=p78730 lab=_56153_/X }
C {devices/lab_pin.sym} 78900 -6370 0 0 {name=p78731 lab=_56255_/X }
C {devices/lab_pin.sym} 78900 -6330 0 0 {name=p78732 lab=_56263_/Y }
C {devices/lab_pin.sym} 79060 -6370 0 1 {name=p78733 lab=_85254_/D }
C {sky130_stdcells/o21ai_4.sym} 78980 -6370 0 0 {name=X_56264_ }
C {devices/lab_pin.sym} 78920 -6240 0 0 {name=p78734 lab=_80542_/A }
C {devices/lab_pin.sym} 78920 -6200 0 0 {name=p78735 lab=_80527_/Y }
C {devices/lab_pin.sym} 79040 -6220 0 1 {name=p78736 lab=_80551_/A }
C {sky130_stdcells/xor2_4.sym} 78980 -6220 0 0 {name=X_80528_ }
C {devices/lab_pin.sym} 78890 -6090 0 0 {name=p78737 lab=_88263_/CLK }
C {devices/lab_pin.sym} 78890 -6070 0 0 {name=p78738 lab=_44488_/Y }
C {devices/lab_pin.sym} 79070 -6090 0 1 {name=p78739 lab=_87084_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -6080 0 0 {name=X_87084_ }
C {devices/lab_pin.sym} 78940 -5950 0 0 {name=p78740 lab=_53448_/X }
C {devices/lab_pin.sym} 79020 -5950 0 1 {name=p78741 lab=_53476_/X }
C {sky130_stdcells/buf_2.sym} 78980 -5950 0 0 {name=X_53476_ }
C {devices/lab_pin.sym} 78940 -5830 0 0 {name=p78742 lab=_41490_/A }
C {devices/lab_pin.sym} 79020 -5830 0 1 {name=p78743 lab=_41490_/X }
C {sky130_stdcells/buf_2.sym} 78980 -5830 0 0 {name=X_41490_ }
C {devices/lab_pin.sym} 78890 -5710 0 0 {name=p78744 lab=_84671_/CLK }
C {devices/lab_pin.sym} 78890 -5690 0 0 {name=p78745 lab=_84296_/D }
C {devices/lab_pin.sym} 79070 -5710 0 1 {name=p78746 lab=_80241_/B }
C {sky130_stdcells/dfxtp_4.sym} 78980 -5700 0 0 {name=X_84296_ }
C {devices/lab_pin.sym} 78920 -5580 0 0 {name=p78747 lab=_50640_/A }
C {devices/lab_pin.sym} 78920 -5540 0 0 {name=p78748 lab=_72079_/B }
C {devices/lab_pin.sym} 79040 -5560 0 1 {name=p78749 lab=_50688_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -5560 0 0 {name=X_50688_ }
C {devices/lab_pin.sym} 78940 -5430 0 0 {name=p78750 lab=_58939_/A }
C {devices/lab_pin.sym} 79020 -5430 0 1 {name=p78751 lab=_58003_/X }
C {sky130_stdcells/buf_2.sym} 78980 -5430 0 0 {name=X_58003_ }
C {devices/lab_pin.sym} 78900 -5330 0 0 {name=p78752 lab=_55212_/X }
C {devices/lab_pin.sym} 78900 -5290 0 0 {name=p78753 lab=_55214_/X }
C {devices/lab_pin.sym} 78900 -5250 0 0 {name=p78754 lab=_55138_/A }
C {devices/lab_pin.sym} 79060 -5290 0 1 {name=p78755 lab=_72718_/C }
C {sky130_stdcells/a21o_4.sym} 78980 -5290 0 0 {name=X_55215_ }
C {devices/lab_pin.sym} 78890 -5150 0 0 {name=p78756 lab=_86424_/CLK }
C {devices/lab_pin.sym} 78890 -5130 0 0 {name=p78757 lab=_86035_/D }
C {devices/lab_pin.sym} 79070 -5150 0 1 {name=p78758 lab=_86035_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -5140 0 0 {name=X_86035_ }
C {devices/lab_pin.sym} 78900 -5050 0 0 {name=p78759 lab=_40437_/X }
C {devices/lab_pin.sym} 78900 -5010 0 0 {name=p78760 lab=_40364_/X }
C {devices/lab_pin.sym} 78900 -4970 0 0 {name=p78761 lab=_40440_/X }
C {devices/lab_pin.sym} 78900 -4930 0 0 {name=p78762 lab=_88391_/Q }
C {devices/lab_pin.sym} 78900 -4890 0 0 {name=p78763 lab=_40375_/X }
C {devices/lab_pin.sym} 79060 -4970 0 1 {name=p78764 lab=_40441_/Y }
C {sky130_stdcells/o32ai_4.sym} 78980 -4970 0 0 {name=X_40441_ }
C {devices/lab_pin.sym} 78900 -4830 0 0 {name=p78765 lab=_52425_/Y }
C {devices/lab_pin.sym} 78900 -4790 0 0 {name=p78766 lab=_52415_/X }
C {devices/lab_pin.sym} 78900 -4750 0 0 {name=p78767 lab=_52426_/Y }
C {devices/lab_pin.sym} 79060 -4790 0 1 {name=p78768 lab=_85825_/D }
C {sky130_stdcells/a21oi_4.sym} 78980 -4790 0 0 {name=X_52427_ }
C {devices/lab_pin.sym} 78920 -4670 0 0 {name=p78769 lab=_71258_/A }
C {devices/lab_pin.sym} 78920 -4630 0 0 {name=p78770 lab=_71261_/B }
C {devices/lab_pin.sym} 78920 -4590 0 0 {name=p78771 lab=_71141_/B }
C {devices/lab_pin.sym} 79040 -4630 0 1 {name=p78772 lab=_71261_/Y }
C {sky130_stdcells/nand3_4.sym} 78980 -4630 0 0 {name=X_71261_ }
C {devices/lab_pin.sym} 78890 -4490 0 0 {name=p78773 lab=_84835_/CLK }
C {devices/lab_pin.sym} 78890 -4470 0 0 {name=p78774 lab=_83247_/D }
C {devices/lab_pin.sym} 79070 -4490 0 1 {name=p78775 lab=_62005_/A }
C {sky130_stdcells/dfxtp_4.sym} 78980 -4480 0 0 {name=X_83247_ }
C {devices/lab_pin.sym} 78900 -4370 0 0 {name=p78776 lab=_80445_/Y }
C {devices/lab_pin.sym} 78900 -4330 0 0 {name=p78777 lab=_80451_/B }
C {devices/lab_pin.sym} 78900 -4290 0 0 {name=p78778 lab=_80458_/X }
C {devices/lab_pin.sym} 79060 -4330 0 1 {name=p78779 lab=_80460_/B }
C {sky130_stdcells/o21ai_4.sym} 78980 -4330 0 0 {name=X_80459_ }
C {devices/lab_pin.sym} 78940 -4190 0 0 {name=p78780 lab=_56194_/X }
C {devices/lab_pin.sym} 79020 -4190 0 1 {name=p78781 lab=_56195_/X }
C {sky130_stdcells/buf_2.sym} 78980 -4190 0 0 {name=X_56195_ }
C {devices/lab_pin.sym} 78920 -4080 0 0 {name=p78782 lab=_87818_/Q }
C {devices/lab_pin.sym} 78920 -4040 0 0 {name=p78783 lab=_73000_/B }
C {devices/lab_pin.sym} 79040 -4060 0 1 {name=p78784 lab=_73000_/Y }
C {sky130_stdcells/nor2_4.sym} 78980 -4060 0 0 {name=X_73000_ }
C {devices/lab_pin.sym} 78920 -3960 0 0 {name=p78785 lab=_70214_/A }
C {devices/lab_pin.sym} 78920 -3920 0 0 {name=p78786 lab=_70214_/B }
C {devices/lab_pin.sym} 78920 -3880 0 0 {name=p78787 lab=_83195_/Q }
C {devices/lab_pin.sym} 78920 -3840 0 0 {name=p78788 lab=_70204_/X }
C {devices/lab_pin.sym} 79040 -3900 0 1 {name=p78789 lab=_70212_/X }
C {sky130_stdcells/and4_4.sym} 78980 -3900 0 0 {name=X_70212_ }
C {devices/lab_pin.sym} 78940 -3750 0 0 {name=p78790 lab=clkbuf_6_7_0_CLK/A }
C {devices/lab_pin.sym} 79020 -3750 0 1 {name=p78791 lab=clkbuf_6_6_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 78980 -3750 0 0 {name=Xclkbuf_6_6_0_CLK }
C {devices/lab_pin.sym} 78940 -3630 0 0 {name=p78792 lab=_43160_/A }
C {devices/lab_pin.sym} 79020 -3630 0 1 {name=p78793 lab=_43160_/Y }
C {sky130_stdcells/inv_2.sym} 78980 -3630 0 0 {name=X_43160_ }
C {devices/lab_pin.sym} 78900 -3540 0 0 {name=p78794 lab=_45745_/A }
C {devices/lab_pin.sym} 78900 -3500 0 0 {name=p78795 lab=_44059_/A }
C {devices/lab_pin.sym} 78900 -3460 0 0 {name=p78796 lab=_55140_/X }
C {devices/lab_pin.sym} 78900 -3420 0 0 {name=p78797 lab=_55145_/Y }
C {devices/lab_pin.sym} 79060 -3480 0 1 {name=p78798 lab=_55146_/X }
C {sky130_stdcells/a211o_4.sym} 78980 -3480 0 0 {name=X_55146_ }
C {devices/lab_pin.sym} 78900 -3350 0 0 {name=p78799 lab=_40344_/A }
C {devices/lab_pin.sym} 78900 -3310 0 0 {name=p78800 lab=_40361_/A }
C {devices/lab_pin.sym} 78900 -3270 0 0 {name=p78801 lab=_40372_/B1 }
C {devices/lab_pin.sym} 79060 -3310 0 1 {name=p78802 lab=_44624_/A }
C {sky130_stdcells/a21o_4.sym} 78980 -3310 0 0 {name=X_40372_ }
C {devices/lab_pin.sym} 78900 -3190 0 0 {name=p78803 lab=_65094_/B }
C {devices/lab_pin.sym} 78900 -3150 0 0 {name=p78804 lab=_52347_/X }
C {devices/lab_pin.sym} 78900 -3110 0 0 {name=p78805 lab=_52357_/Y }
C {devices/lab_pin.sym} 79060 -3150 0 1 {name=p78806 lab=_52358_/Y }
C {sky130_stdcells/o21ai_4.sym} 78980 -3150 0 0 {name=X_52358_ }
C {devices/lab_pin.sym} 78940 -3010 0 0 {name=p78807 lab=_71211_/A }
C {devices/lab_pin.sym} 79020 -3010 0 1 {name=p78808 lab=_71197_/A }
C {sky130_stdcells/buf_2.sym} 78980 -3010 0 0 {name=X_71192_ }
C {devices/lab_pin.sym} 78890 -2890 0 0 {name=p78809 lab=_81696_/CLK }
C {devices/lab_pin.sym} 78890 -2870 0 0 {name=p78810 lab=_72719_/X }
C {devices/lab_pin.sym} 79070 -2890 0 1 {name=p78811 lab=_83178_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -2880 0 0 {name=X_83178_ }
C {devices/lab_pin.sym} 78900 -2790 0 0 {name=p78812 lab=_42099_/X }
C {devices/lab_pin.sym} 78900 -2750 0 0 {name=p78813 lab=_42094_/X }
C {devices/lab_pin.sym} 78900 -2710 0 0 {name=p78814 lab=_41054_/X }
C {devices/lab_pin.sym} 78900 -2670 0 0 {name=p78815 lab=_88030_/Q }
C {devices/lab_pin.sym} 78900 -2630 0 0 {name=p78816 lab=_42096_/X }
C {devices/lab_pin.sym} 79060 -2710 0 1 {name=p78817 lab=_42112_/A }
C {sky130_stdcells/o32ai_4.sym} 78980 -2710 0 0 {name=X_42111_ }
C {devices/lab_pin.sym} 78940 -2550 0 0 {name=p78818 lab=_51259_/A }
C {devices/lab_pin.sym} 79020 -2550 0 1 {name=p78819 lab=_51309_/X }
C {sky130_stdcells/buf_2.sym} 78980 -2550 0 0 {name=X_51309_ }
C {devices/lab_pin.sym} 78900 -2460 0 0 {name=p78820 lab=_83516_/Q }
C {devices/lab_pin.sym} 78900 -2420 0 0 {name=p78821 lab=_83164_/Q }
C {devices/lab_pin.sym} 78900 -2380 0 0 {name=p78822 lab=_83513_/Q }
C {devices/lab_pin.sym} 78900 -2340 0 0 {name=p78823 lab=_83161_/Q }
C {devices/lab_pin.sym} 79060 -2400 0 1 {name=p78824 lab=_70144_/D }
C {sky130_stdcells/a22oi_4.sym} 78980 -2400 0 0 {name=X_70143_ }
C {devices/lab_pin.sym} 78890 -2250 0 0 {name=p78825 lab=_81989_/CLK }
C {devices/lab_pin.sym} 78890 -2230 0 0 {name=p78826 lab=_82129_/D }
C {devices/lab_pin.sym} 79070 -2250 0 1 {name=p78827 lab=_77265_/B }
C {sky130_stdcells/dfxtp_4.sym} 78980 -2240 0 0 {name=X_82129_ }
C {devices/lab_pin.sym} 78940 -2110 0 0 {name=p78828 lab=_60422_/A }
C {devices/lab_pin.sym} 79020 -2110 0 1 {name=p78829 lab=_61587_/B }
C {sky130_stdcells/buf_2.sym} 78980 -2110 0 0 {name=X_59954_ }
C {devices/lab_pin.sym} 78900 -2030 0 0 {name=p78830 lab=_43085_/X }
C {devices/lab_pin.sym} 78900 -1990 0 0 {name=p78831 lab=_43086_/X }
C {devices/lab_pin.sym} 78900 -1950 0 0 {name=p78832 lab=_40716_/X }
C {devices/lab_pin.sym} 78900 -1910 0 0 {name=p78833 lab=_43089_/Y }
C {devices/lab_pin.sym} 78900 -1870 0 0 {name=p78834 lab=_43090_/X }
C {devices/lab_pin.sym} 79060 -1950 0 1 {name=p78835 lab=_87580_/D }
C {sky130_stdcells/o32ai_4.sym} 78980 -1950 0 0 {name=X_43091_ }
C {devices/lab_pin.sym} 78940 -1790 0 0 {name=p78836 lab=_54973_/A }
C {devices/lab_pin.sym} 79020 -1790 0 1 {name=p78837 lab=_55083_/C }
C {sky130_stdcells/buf_2.sym} 78980 -1790 0 0 {name=X_55077_ }
C {devices/lab_pin.sym} 78940 -1670 0 0 {name=p78838 lab=_52262_/A }
C {devices/lab_pin.sym} 79020 -1670 0 1 {name=p78839 lab=_52289_/X }
C {sky130_stdcells/buf_2.sym} 78980 -1670 0 0 {name=X_52289_ }
C {devices/lab_pin.sym} 78890 -1550 0 0 {name=p78840 lab=_82906_/CLK }
C {devices/lab_pin.sym} 78890 -1530 0 0 {name=p78841 lab=_87986_/D }
C {devices/lab_pin.sym} 79070 -1550 0 1 {name=p78842 lab=_87986_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -1540 0 0 {name=X_87986_ }
C {devices/lab_pin.sym} 78900 -1450 0 0 {name=p78843 lab=_42035_/X }
C {devices/lab_pin.sym} 78900 -1410 0 0 {name=p78844 lab=_42010_/X }
C {devices/lab_pin.sym} 78900 -1370 0 0 {name=p78845 lab=_40890_/X }
C {devices/lab_pin.sym} 78900 -1330 0 0 {name=p78846 lab=_42041_/Y }
C {devices/lab_pin.sym} 78900 -1290 0 0 {name=p78847 lab=_42037_/X }
C {devices/lab_pin.sym} 79060 -1370 0 1 {name=p78848 lab=_88060_/D }
C {sky130_stdcells/o32ai_4.sym} 78980 -1370 0 0 {name=X_42042_ }
C {devices/lab_pin.sym} 78900 -1230 0 0 {name=p78849 lab=_58904_/X }
C {devices/lab_pin.sym} 78900 -1190 0 0 {name=p78850 lab=_85767_/Q }
C {devices/lab_pin.sym} 78900 -1150 0 0 {name=p78851 lab=_58838_/X }
C {devices/lab_pin.sym} 79060 -1190 0 1 {name=p78852 lab=_58905_/X }
C {sky130_stdcells/o21a_4.sym} 78980 -1190 0 0 {name=X_58905_ }
C {devices/lab_pin.sym} 78920 -1060 0 0 {name=p78853 lab=_54020_/A }
C {devices/lab_pin.sym} 78920 -1020 0 0 {name=p78854 lab=_46455_/Y }
C {devices/lab_pin.sym} 79040 -1040 0 1 {name=p78855 lab=_54028_/Y }
C {sky130_stdcells/nand2_4.sym} 78980 -1040 0 0 {name=X_54028_ }
C {devices/lab_pin.sym} 78890 -910 0 0 {name=p78856 lab=_87471_/CLK }
C {devices/lab_pin.sym} 78890 -890 0 0 {name=p78857 lab=_86937_/D }
C {devices/lab_pin.sym} 79070 -910 0 1 {name=p78858 lab=_86937_/Q }
C {sky130_stdcells/dfxtp_4.sym} 78980 -900 0 0 {name=X_86937_ }
C {devices/lab_pin.sym} 78920 -780 0 0 {name=p78859 lab=_81137_/D }
C {devices/lab_pin.sym} 78920 -740 0 0 {name=p78860 lab=_80849_/Q }
C {devices/lab_pin.sym} 79040 -760 0 1 {name=p78861 lab=_74961_/B }
C {sky130_stdcells/nand2_4.sym} 78980 -760 0 0 {name=X_74951_ }
C {devices/lab_pin.sym} 79820 -42170 0 0 {name=p78862 lab=_68992_/X }
C {devices/lab_pin.sym} 79820 -42130 0 0 {name=p78863 lab=_68995_/X }
C {devices/lab_pin.sym} 79820 -42090 0 0 {name=p78864 lab=_69156_/X }
C {devices/lab_pin.sym} 79980 -42130 0 1 {name=p78865 lab=_70074_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -42130 0 0 {name=X_70074_ }
C {devices/lab_pin.sym} 79840 -42010 0 0 {name=p78866 lab=_59532_/A }
C {devices/lab_pin.sym} 79840 -41970 0 0 {name=p78867 lab=_59520_/A }
C {devices/lab_pin.sym} 79840 -41930 0 0 {name=p78868 lab=_59535_/A }
C {devices/lab_pin.sym} 79960 -41970 0 1 {name=p78869 lab=_59885_/Y }
C {sky130_stdcells/nand3_4.sym} 79900 -41970 0 0 {name=X_59885_ }
C {devices/lab_pin.sym} 79820 -41860 0 0 {name=p78870 lab=_73850_/X }
C {devices/lab_pin.sym} 79820 -41820 0 0 {name=p78871 lab=_86227_/Q }
C {devices/lab_pin.sym} 79820 -41780 0 0 {name=p78872 lab=_73804_/X }
C {devices/lab_pin.sym} 79820 -41740 0 0 {name=p78873 lab=_73901_/X }
C {devices/lab_pin.sym} 79980 -41800 0 1 {name=p78874 lab=_73902_/X }
C {sky130_stdcells/a211o_4.sym} 79900 -41800 0 0 {name=X_73902_ }
C {devices/lab_pin.sym} 79860 -41650 0 0 {name=p78875 lab=_46850_/A }
C {devices/lab_pin.sym} 79940 -41650 0 1 {name=p78876 lab=_52713_/B }
C {sky130_stdcells/inv_2.sym} 79900 -41650 0 0 {name=X_46850_ }
C {devices/lab_pin.sym} 79820 -41550 0 0 {name=p78877 lab=_58730_/X }
C {devices/lab_pin.sym} 79820 -41510 0 0 {name=p78878 lab=_85932_/Q }
C {devices/lab_pin.sym} 79820 -41470 0 0 {name=p78879 lab=_58810_/X }
C {devices/lab_pin.sym} 79980 -41510 0 1 {name=p78880 lab=_58836_/X }
C {sky130_stdcells/o21a_4.sym} 79900 -41510 0 0 {name=X_58836_ }
C {devices/lab_pin.sym} 79840 -41380 0 0 {name=p78881 lab=_77662_/Y }
C {devices/lab_pin.sym} 79840 -41340 0 0 {name=p78882 lab=_77695_/B }
C {devices/lab_pin.sym} 79960 -41360 0 1 {name=p78883 lab=_82206_/D }
C {sky130_stdcells/xor2_4.sym} 79900 -41360 0 0 {name=X_77670_ }
C {devices/lab_pin.sym} 79840 -41240 0 0 {name=p78884 lab=_81127_/D }
C {devices/lab_pin.sym} 79840 -41200 0 0 {name=p78885 lab=_74875_/B }
C {devices/lab_pin.sym} 79960 -41220 0 1 {name=p78886 lab=_74882_/Y }
C {sky130_stdcells/nor2_4.sym} 79900 -41220 0 0 {name=X_74882_ }
C {devices/lab_pin.sym} 79810 -41090 0 0 {name=p78887 lab=_84408_/CLK }
C {devices/lab_pin.sym} 79810 -41070 0 0 {name=p78888 lab=_86868_/D }
C {devices/lab_pin.sym} 79990 -41090 0 1 {name=p78889 lab=_63137_/B }
C {sky130_stdcells/dfxtp_4.sym} 79900 -41080 0 0 {name=X_86868_ }
C {devices/lab_pin.sym} 79860 -40950 0 0 {name=p78890 lab=_45801_/A }
C {devices/lab_pin.sym} 79940 -40950 0 1 {name=p78891 lab=_45832_/B }
C {sky130_stdcells/buf_2.sym} 79900 -40950 0 0 {name=X_45801_ }
C {devices/lab_pin.sym} 79840 -40840 0 0 {name=p78892 lab=_76619_/Y }
C {devices/lab_pin.sym} 79840 -40800 0 0 {name=p78893 lab=_76620_/X }
C {devices/lab_pin.sym} 79960 -40820 0 1 {name=p78894 lab=_76621_/X }
C {sky130_stdcells/xor2_4.sym} 79900 -40820 0 0 {name=X_76621_ }
C {devices/lab_pin.sym} 79840 -40700 0 0 {name=p78895 lab=_73742_/A }
C {devices/lab_pin.sym} 79840 -40660 0 0 {name=p78896 lab=_73833_/B }
C {devices/lab_pin.sym} 79960 -40680 0 1 {name=p78897 lab=_73833_/X }
C {sky130_stdcells/and2_4.sym} 79900 -40680 0 0 {name=X_73833_ }
C {devices/lab_pin.sym} 79810 -40550 0 0 {name=p78898 lab=_85822_/CLK }
C {devices/lab_pin.sym} 79810 -40530 0 0 {name=p78899 lab=_52455_/Y }
C {devices/lab_pin.sym} 79990 -40550 0 1 {name=p78900 lab=_85819_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -40540 0 0 {name=X_85819_ }
C {devices/lab_pin.sym} 79820 -40430 0 0 {name=p78901 lab=_86704_/Q }
C {devices/lab_pin.sym} 79820 -40390 0 0 {name=p78902 lab=_46767_/X }
C {devices/lab_pin.sym} 79820 -40350 0 0 {name=p78903 lab=_46780_/Y }
C {devices/lab_pin.sym} 79980 -40390 0 1 {name=p78904 lab=_46781_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -40390 0 0 {name=X_46781_ }
C {devices/lab_pin.sym} 79820 -40290 0 0 {name=p78905 lab=_58748_/X }
C {devices/lab_pin.sym} 79820 -40250 0 0 {name=p78906 lab=_58763_/Y }
C {devices/lab_pin.sym} 79820 -40210 0 0 {name=p78907 lab=_58764_/Y }
C {devices/lab_pin.sym} 79820 -40170 0 0 {name=p78908 lab=_58766_/X }
C {devices/lab_pin.sym} 79820 -40130 0 0 {name=p78909 lab=_58752_/X }
C {devices/lab_pin.sym} 79980 -40210 0 1 {name=p78910 lab=_58767_/X }
C {sky130_stdcells/o32a_4.sym} 79900 -40210 0 0 {name=X_58767_ }
C {devices/lab_pin.sym} 79820 -40070 0 0 {name=p78911 lab=_43989_/Y }
C {devices/lab_pin.sym} 79820 -40030 0 0 {name=p78912 lab=_43955_/Y }
C {devices/lab_pin.sym} 79820 -39990 0 0 {name=p78913 lab=_43992_/Y }
C {devices/lab_pin.sym} 79980 -40030 0 1 {name=p78914 lab=_43994_/A }
C {sky130_stdcells/a21oi_4.sym} 79900 -40030 0 0 {name=X_43993_ }
C {devices/lab_pin.sym} 79820 -39920 0 0 {name=p78915 lab=_56379_/C }
C {devices/lab_pin.sym} 79820 -39880 0 0 {name=p78916 lab=_55690_/A }
C {devices/lab_pin.sym} 79820 -39840 0 0 {name=p78917 lab=_55611_/X }
C {devices/lab_pin.sym} 79820 -39800 0 0 {name=p78918 lab=_55978_/X }
C {devices/lab_pin.sym} 79980 -39860 0 1 {name=p78919 lab=_55979_/X }
C {sky130_stdcells/a211o_4.sym} 79900 -39860 0 0 {name=X_55979_ }
C {devices/lab_pin.sym} 79810 -39710 0 0 {name=p78920 lab=_87990_/CLK }
C {devices/lab_pin.sym} 79810 -39690 0 0 {name=p78921 lab=_86799_/D }
C {devices/lab_pin.sym} 79990 -39710 0 1 {name=p78922 lab=_86799_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -39700 0 0 {name=X_86799_ }
C {devices/lab_pin.sym} 79840 -39580 0 0 {name=p78923 lab=_48520_/A }
C {devices/lab_pin.sym} 79840 -39540 0 0 {name=p78924 lab=_48565_/B }
C {devices/lab_pin.sym} 79960 -39560 0 1 {name=p78925 lab=_48520_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -39560 0 0 {name=X_48520_ }
C {devices/lab_pin.sym} 79840 -39440 0 0 {name=p78926 lab=_84800_/Q }
C {devices/lab_pin.sym} 79840 -39400 0 0 {name=p78927 lab=_84120_/Q }
C {devices/lab_pin.sym} 79960 -39420 0 1 {name=p78928 lab=_79340_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -39420 0 0 {name=X_79340_ }
C {devices/lab_pin.sym} 79820 -39310 0 0 {name=p78929 lab=_45725_/X }
C {devices/lab_pin.sym} 79820 -39270 0 0 {name=p78930 lab=_45729_/Y }
C {devices/lab_pin.sym} 79820 -39230 0 0 {name=p78931 lab=_45731_/Y }
C {devices/lab_pin.sym} 79980 -39270 0 1 {name=p78932 lab=_45732_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -39270 0 0 {name=X_45732_ }
C {devices/lab_pin.sym} 79860 -39130 0 0 {name=p78933 lab=_57718_/A }
C {devices/lab_pin.sym} 79940 -39130 0 1 {name=p78934 lab=_57718_/X }
C {sky130_stdcells/buf_2.sym} 79900 -39130 0 0 {name=X_57718_ }
C {devices/lab_pin.sym} 79840 -39020 0 0 {name=p78935 lab=_76552_/A }
C {devices/lab_pin.sym} 79840 -38980 0 0 {name=p78936 lab=_81545_/Q }
C {devices/lab_pin.sym} 79960 -39000 0 1 {name=p78937 lab=_76552_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -39000 0 0 {name=X_76552_ }
C {devices/lab_pin.sym} 79860 -38870 0 0 {name=p78938 lab=_42846_/X }
C {devices/lab_pin.sym} 79940 -38870 0 1 {name=p78939 lab=_42944_/X }
C {sky130_stdcells/buf_2.sym} 79900 -38870 0 0 {name=X_42944_ }
C {devices/lab_pin.sym} 79840 -38760 0 0 {name=p78940 lab=_73764_/A }
C {devices/lab_pin.sym} 79840 -38720 0 0 {name=p78941 lab=_73764_/B }
C {devices/lab_pin.sym} 79960 -38740 0 1 {name=p78942 lab=_73765_/B }
C {sky130_stdcells/nand2_4.sym} 79900 -38740 0 0 {name=X_73764_ }
C {devices/lab_pin.sym} 79840 -38630 0 0 {name=p78943 lab=_70976_/A }
C {devices/lab_pin.sym} 79840 -38590 0 0 {name=p78944 lab=_70954_/B }
C {devices/lab_pin.sym} 79840 -38550 0 0 {name=p78945 lab=_70969_/C }
C {devices/lab_pin.sym} 79960 -38590 0 1 {name=p78946 lab=_70976_/Y }
C {sky130_stdcells/nand3_4.sym} 79900 -38590 0 0 {name=X_70976_ }
C {devices/lab_pin.sym} 79860 -38450 0 0 {name=p78947 lab=_58698_/A }
C {devices/lab_pin.sym} 79940 -38450 0 1 {name=p78948 lab=_58699_/A }
C {sky130_stdcells/buf_2.sym} 79900 -38450 0 0 {name=X_58698_ }
C {devices/lab_pin.sym} 79840 -38350 0 0 {name=p78949 lab=_75503_/A }
C {devices/lab_pin.sym} 79840 -38310 0 0 {name=p78950 lab=_75503_/B }
C {devices/lab_pin.sym} 79840 -38270 0 0 {name=p78951 lab=_75503_/C }
C {devices/lab_pin.sym} 79960 -38310 0 1 {name=p78952 lab=_75503_/Y }
C {sky130_stdcells/nand3_4.sym} 79900 -38310 0 0 {name=X_75503_ }
C {devices/lab_pin.sym} 79860 -38170 0 0 {name=p78953 lab=_74406_/A }
C {devices/lab_pin.sym} 79940 -38170 0 1 {name=p78954 lab=_48752_/A }
C {sky130_stdcells/buf_2.sym} 79900 -38170 0 0 {name=X_48451_ }
C {devices/lab_pin.sym} 79820 -38070 0 0 {name=p78955 lab=_83180_/Q }
C {devices/lab_pin.sym} 79820 -38030 0 0 {name=p78956 lab=_72702_/X }
C {devices/lab_pin.sym} 79820 -37990 0 0 {name=p78957 lab=_72714_/Y }
C {devices/lab_pin.sym} 79980 -38030 0 1 {name=p78958 lab=_83180_/D }
C {sky130_stdcells/a21bo_4.sym} 79900 -38030 0 0 {name=X_72715_ }
C {devices/lab_pin.sym} 79840 -37900 0 0 {name=p78959 lab=_79270_/B }
C {devices/lab_pin.sym} 79840 -37860 0 0 {name=p78960 lab=_79257_/Y }
C {devices/lab_pin.sym} 79960 -37880 0 1 {name=p78961 lab=_79271_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -37880 0 0 {name=X_79271_ }
C {devices/lab_pin.sym} 79820 -37770 0 0 {name=p78962 lab=_57647_/Y }
C {devices/lab_pin.sym} 79820 -37730 0 0 {name=p78963 lab=_57627_/X }
C {devices/lab_pin.sym} 79820 -37690 0 0 {name=p78964 lab=_57648_/Y }
C {devices/lab_pin.sym} 79980 -37730 0 1 {name=p78965 lab=_84962_/D }
C {sky130_stdcells/a21boi_4.sym} 79900 -37730 0 0 {name=X_57649_ }
C {devices/lab_pin.sym} 79820 -37610 0 0 {name=p78966 lab=_57283_/B }
C {devices/lab_pin.sym} 79820 -37570 0 0 {name=p78967 lab=_45326_/X }
C {devices/lab_pin.sym} 79820 -37530 0 0 {name=p78968 lab=_45662_/X }
C {devices/lab_pin.sym} 79980 -37570 0 1 {name=p78969 lab=_45663_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -37570 0 0 {name=X_45663_ }
C {devices/lab_pin.sym} 79820 -37450 0 0 {name=p78970 lab=_76482_/A }
C {devices/lab_pin.sym} 79820 -37410 0 0 {name=p78971 lab=_76463_/X }
C {devices/lab_pin.sym} 79820 -37370 0 0 {name=p78972 lab=_76461_/X }
C {devices/lab_pin.sym} 79980 -37410 0 1 {name=p78973 lab=_76483_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -37410 0 0 {name=X_76483_ }
C {devices/lab_pin.sym} 79860 -37270 0 0 {name=p78974 lab=_42945_/A }
C {devices/lab_pin.sym} 79940 -37270 0 1 {name=p78975 lab=_42875_/X }
C {sky130_stdcells/buf_2.sym} 79900 -37270 0 0 {name=X_42875_ }
C {devices/lab_pin.sym} 79820 -37170 0 0 {name=p78976 lab=_73693_/X }
C {devices/lab_pin.sym} 79820 -37130 0 0 {name=p78977 lab=_73694_/Y }
C {devices/lab_pin.sym} 79820 -37090 0 0 {name=p78978 lab=_73546_/X }
C {devices/lab_pin.sym} 79980 -37130 0 1 {name=p78979 lab=_73695_/X }
C {sky130_stdcells/a21o_4.sym} 79900 -37130 0 0 {name=X_73695_ }
C {devices/lab_pin.sym} 79860 -36990 0 0 {name=p78980 lab=_83734_/Q }
C {devices/lab_pin.sym} 79940 -36990 0 1 {name=p78981 lab=_47403_/A }
C {sky130_stdcells/inv_2.sym} 79900 -36990 0 0 {name=X_47402_ }
C {devices/lab_pin.sym} 79840 -36890 0 0 {name=p78982 lab=_78220_/B }
C {devices/lab_pin.sym} 79840 -36850 0 0 {name=p78983 lab=_78203_/A }
C {devices/lab_pin.sym} 79840 -36810 0 0 {name=p78984 lab=_82492_/Q }
C {devices/lab_pin.sym} 79960 -36850 0 1 {name=p78985 lab=_78222_/Y }
C {sky130_stdcells/nand3_4.sym} 79900 -36850 0 0 {name=X_78222_ }
C {devices/lab_pin.sym} 79860 -36710 0 0 {name=p78986 lab=_44613_/Y }
C {devices/lab_pin.sym} 79940 -36710 0 1 {name=p78987 lab=_87032_/D }
C {sky130_stdcells/inv_2.sym} 79900 -36710 0 0 {name=X_44614_ }
C {devices/lab_pin.sym} 79860 -36590 0 0 {name=p78988 lab=_75433_/X }
C {devices/lab_pin.sym} 79940 -36590 0 1 {name=p78989 lab=_75466_/B }
C {sky130_stdcells/buf_2.sym} 79900 -36590 0 0 {name=X_75434_ }
C {devices/lab_pin.sym} 79820 -36510 0 0 {name=p78990 lab=_41824_/X }
C {devices/lab_pin.sym} 79820 -36470 0 0 {name=p78991 lab=_41825_/X }
C {devices/lab_pin.sym} 79820 -36430 0 0 {name=p78992 lab=_40446_/X }
C {devices/lab_pin.sym} 79820 -36390 0 0 {name=p78993 lab=_66892_/B }
C {devices/lab_pin.sym} 79820 -36350 0 0 {name=p78994 lab=_41821_/X }
C {devices/lab_pin.sym} 79980 -36430 0 1 {name=p78995 lab=_41826_/Y }
C {sky130_stdcells/o32ai_4.sym} 79900 -36430 0 0 {name=X_41826_ }
C {devices/lab_pin.sym} 79820 -36290 0 0 {name=p78996 lab=_72817_/B }
C {devices/lab_pin.sym} 79820 -36250 0 0 {name=p78997 lab=_48350_/X }
C {devices/lab_pin.sym} 79820 -36210 0 0 {name=p78998 lab=_48381_/Y }
C {devices/lab_pin.sym} 79980 -36250 0 1 {name=p78999 lab=_48382_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -36250 0 0 {name=X_48382_ }
C {devices/lab_pin.sym} 79860 -36110 0 0 {name=p79000 lab=_60660_/A }
C {devices/lab_pin.sym} 79940 -36110 0 1 {name=p79001 lab=_60660_/X }
C {sky130_stdcells/buf_2.sym} 79900 -36110 0 0 {name=X_60660_ }
C {devices/lab_pin.sym} 79860 -35990 0 0 {name=p79002 lab=_72687_/A }
C {devices/lab_pin.sym} 79940 -35990 0 1 {name=p79003 lab=_72656_/A }
C {sky130_stdcells/buf_2.sym} 79900 -35990 0 0 {name=X_72646_ }
C {devices/lab_pin.sym} 79820 -35890 0 0 {name=p79004 lab=_45587_/X }
C {devices/lab_pin.sym} 79820 -35850 0 0 {name=p79005 lab=_45590_/X }
C {devices/lab_pin.sym} 79820 -35810 0 0 {name=p79006 lab=_45593_/Y }
C {devices/lab_pin.sym} 79980 -35850 0 1 {name=p79007 lab=_45594_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -35850 0 0 {name=X_45594_ }
C {devices/lab_pin.sym} 79860 -35710 0 0 {name=p79008 lab=_47147_/A }
C {devices/lab_pin.sym} 79940 -35710 0 1 {name=p79009 lab=_47333_/X }
C {sky130_stdcells/buf_2.sym} 79900 -35710 0 0 {name=X_47333_ }
C {devices/lab_pin.sym} 79820 -35610 0 0 {name=p79010 lab=_59273_/X }
C {devices/lab_pin.sym} 79820 -35570 0 0 {name=p79011 lab=_85639_/Q }
C {devices/lab_pin.sym} 79820 -35530 0 0 {name=p79012 lab=_59308_/X }
C {devices/lab_pin.sym} 79980 -35570 0 1 {name=p79013 lab=_59319_/X }
C {sky130_stdcells/o21a_4.sym} 79900 -35570 0 0 {name=X_59319_ }
C {devices/lab_pin.sym} 79840 -35440 0 0 {name=p79014 lab=_82668_/Q }
C {devices/lab_pin.sym} 79840 -35400 0 0 {name=p79015 lab=_78153_/B }
C {devices/lab_pin.sym} 79960 -35420 0 1 {name=p79016 lab=_78153_/X }
C {sky130_stdcells/xor2_4.sym} 79900 -35420 0 0 {name=X_78153_ }
C {devices/lab_pin.sym} 79820 -35330 0 0 {name=p79017 lab=_44496_/X }
C {devices/lab_pin.sym} 79820 -35290 0 0 {name=p79018 lab=_44497_/X }
C {devices/lab_pin.sym} 79820 -35250 0 0 {name=p79019 lab=_40826_/X }
C {devices/lab_pin.sym} 79820 -35210 0 0 {name=p79020 lab=_87059_/Q }
C {devices/lab_pin.sym} 79820 -35170 0 0 {name=p79021 lab=_44498_/X }
C {devices/lab_pin.sym} 79980 -35250 0 1 {name=p79022 lab=_44545_/Y }
C {sky130_stdcells/o32ai_4.sym} 79900 -35250 0 0 {name=X_44545_ }
C {devices/lab_pin.sym} 79860 -35090 0 0 {name=p79023 lab=_75364_/Y }
C {devices/lab_pin.sym} 79940 -35090 0 1 {name=p79024 lab=_75365_/Y }
C {sky130_stdcells/inv_2.sym} 79900 -35090 0 0 {name=X_75365_ }
C {devices/lab_pin.sym} 79860 -34970 0 0 {name=p79025 lab=_41756_/X }
C {devices/lab_pin.sym} 79940 -34970 0 1 {name=p79026 lab=_41757_/X }
C {sky130_stdcells/buf_2.sym} 79900 -34970 0 0 {name=X_41757_ }
C {devices/lab_pin.sym} 79820 -34880 0 0 {name=p79027 lab=_79132_/A }
C {devices/lab_pin.sym} 79820 -34840 0 0 {name=p79028 lab=_60132_/X }
C {devices/lab_pin.sym} 79820 -34800 0 0 {name=p79029 lab=_60551_/X }
C {devices/lab_pin.sym} 79820 -34760 0 0 {name=p79030 lab=_60590_/Y }
C {devices/lab_pin.sym} 79980 -34820 0 1 {name=p79031 lab=_60591_/X }
C {sky130_stdcells/a2bb2o_4.sym} 79900 -34820 0 0 {name=X_60591_ }
C {devices/lab_pin.sym} 79840 -34690 0 0 {name=p79032 lab=_72576_/Y }
C {devices/lab_pin.sym} 79840 -34650 0 0 {name=p79033 lab=_72577_/B }
C {devices/lab_pin.sym} 79840 -34610 0 0 {name=p79034 lab=_72569_/A }
C {devices/lab_pin.sym} 79960 -34650 0 1 {name=p79035 lab=_72577_/Y }
C {sky130_stdcells/nand3_4.sym} 79900 -34650 0 0 {name=X_72577_ }
C {devices/lab_pin.sym} 79840 -34520 0 0 {name=p79036 lab=_77105_/A }
C {devices/lab_pin.sym} 79840 -34480 0 0 {name=p79037 lab=_81913_/Q }
C {devices/lab_pin.sym} 79960 -34500 0 1 {name=p79038 lab=_77106_/A }
C {sky130_stdcells/or2_4.sym} 79900 -34500 0 0 {name=X_77104_ }
C {devices/lab_pin.sym} 79840 -34400 0 0 {name=p79039 lab=_62304_/A }
C {devices/lab_pin.sym} 79840 -34360 0 0 {name=p79040 lab=_57652_/X }
C {devices/lab_pin.sym} 79840 -34320 0 0 {name=p79041 lab=_62315_/C }
C {devices/lab_pin.sym} 79840 -34280 0 0 {name=p79042 lab=_62286_/X }
C {devices/lab_pin.sym} 79960 -34340 0 1 {name=p79043 lab=_62330_/X }
C {sky130_stdcells/and4_4.sym} 79900 -34340 0 0 {name=X_62330_ }
C {devices/lab_pin.sym} 79860 -34190 0 0 {name=p79044 lab=_74342_/A }
C {devices/lab_pin.sym} 79940 -34190 0 1 {name=p79045 lab=_74325_/B }
C {sky130_stdcells/buf_2.sym} 79900 -34190 0 0 {name=X_74316_ }
C {devices/lab_pin.sym} 79820 -34110 0 0 {name=p79046 lab=_40687_/X }
C {devices/lab_pin.sym} 79820 -34070 0 0 {name=p79047 lab=_40688_/X }
C {devices/lab_pin.sym} 79820 -34030 0 0 {name=p79048 lab=_40707_/X }
C {devices/lab_pin.sym} 79820 -33990 0 0 {name=p79049 lab=_68892_/B }
C {devices/lab_pin.sym} 79820 -33950 0 0 {name=p79050 lab=_40683_/X }
C {devices/lab_pin.sym} 79980 -34030 0 1 {name=p79051 lab=_40709_/A }
C {sky130_stdcells/o32ai_4.sym} 79900 -34030 0 0 {name=X_40708_ }
C {devices/lab_pin.sym} 79860 -33870 0 0 {name=p79052 lab=_47264_/A }
C {devices/lab_pin.sym} 79940 -33870 0 1 {name=p79053 lab=_52948_/D }
C {sky130_stdcells/buf_2.sym} 79900 -33870 0 0 {name=X_47264_ }
C {devices/lab_pin.sym} 79860 -33750 0 0 {name=p79054 lab=_71527_/Y }
C {devices/lab_pin.sym} 79940 -33750 0 1 {name=p79055 lab=_71528_/X }
C {sky130_stdcells/buf_2.sym} 79900 -33750 0 0 {name=X_71528_ }
C {devices/lab_pin.sym} 79840 -33640 0 0 {name=p79056 lab=_82563_/Q }
C {devices/lab_pin.sym} 79840 -33600 0 0 {name=p79057 lab=_78091_/B }
C {devices/lab_pin.sym} 79960 -33620 0 1 {name=p79058 lab=_78084_/X }
C {sky130_stdcells/xor2_4.sym} 79900 -33620 0 0 {name=X_78084_ }
C {devices/lab_pin.sym} 79820 -33520 0 0 {name=p79059 lab=_41189_/A }
C {devices/lab_pin.sym} 79820 -33480 0 0 {name=p79060 lab=_44474_/X }
C {devices/lab_pin.sym} 79820 -33440 0 0 {name=p79061 lab=_87089_/Q }
C {devices/lab_pin.sym} 79820 -33400 0 0 {name=p79062 lab=_44475_/X }
C {devices/lab_pin.sym} 79980 -33460 0 1 {name=p79063 lab=_44476_/X }
C {sky130_stdcells/a2bb2o_4.sym} 79900 -33460 0 0 {name=X_44476_ }
C {devices/lab_pin.sym} 79840 -33320 0 0 {name=p79064 lab=_75294_/Y }
C {devices/lab_pin.sym} 79840 -33280 0 0 {name=p79065 lab=_75295_/X }
C {devices/lab_pin.sym} 79960 -33300 0 1 {name=p79066 lab=_81041_/D }
C {sky130_stdcells/xnor2_4.sym} 79900 -33300 0 0 {name=X_75296_ }
C {devices/lab_pin.sym} 79860 -33170 0 0 {name=p79067 lab=_41687_/X }
C {devices/lab_pin.sym} 79940 -33170 0 1 {name=p79068 lab=_41688_/X }
C {sky130_stdcells/buf_2.sym} 79900 -33170 0 0 {name=X_41688_ }
C {devices/lab_pin.sym} 79860 -33050 0 0 {name=p79069 lab=_49052_/A }
C {devices/lab_pin.sym} 79940 -33050 0 1 {name=p79070 lab=_49003_/X }
C {sky130_stdcells/buf_2.sym} 79900 -33050 0 0 {name=X_49003_ }
C {devices/lab_pin.sym} 79840 -32950 0 0 {name=p79071 lab=_46207_/Y }
C {devices/lab_pin.sym} 79840 -32910 0 0 {name=p79072 lab=_46215_/B }
C {devices/lab_pin.sym} 79840 -32870 0 0 {name=p79073 lab=_46215_/C }
C {devices/lab_pin.sym} 79960 -32910 0 1 {name=p79074 lab=_46216_/A }
C {sky130_stdcells/nand3_4.sym} 79900 -32910 0 0 {name=X_46215_ }
C {devices/lab_pin.sym} 79840 -32780 0 0 {name=p79075 lab=_77036_/A }
C {devices/lab_pin.sym} 79840 -32740 0 0 {name=p79076 lab=_77036_/B }
C {devices/lab_pin.sym} 79960 -32760 0 1 {name=p79077 lab=_77035_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -32760 0 0 {name=X_77035_ }
C {sky130_stdcells/decap_3.sym} 79900 -32600 0 0 {name=XPHY_270 }
C {devices/lab_pin.sym} 79820 -32490 0 0 {name=p79078 lab=_43422_/X }
C {devices/lab_pin.sym} 79820 -32450 0 0 {name=p79079 lab=_43426_/X }
C {devices/lab_pin.sym} 79820 -32410 0 0 {name=p79080 lab=_41545_/X }
C {devices/lab_pin.sym} 79820 -32370 0 0 {name=p79081 lab=_87427_/Q }
C {devices/lab_pin.sym} 79820 -32330 0 0 {name=p79082 lab=_43407_/X }
C {devices/lab_pin.sym} 79980 -32410 0 1 {name=p79083 lab=_43428_/A }
C {sky130_stdcells/o32ai_4.sym} 79900 -32410 0 0 {name=X_43427_ }
C {devices/lab_pin.sym} 79840 -32270 0 0 {name=p79084 lab=_62249_/A }
C {devices/lab_pin.sym} 79840 -32230 0 0 {name=p79085 lab=_63396_/B }
C {devices/lab_pin.sym} 79840 -32190 0 0 {name=p79086 lab=_59987_/X }
C {devices/lab_pin.sym} 79960 -32230 0 1 {name=p79087 lab=_62261_/Y }
C {sky130_stdcells/nand3_4.sym} 79900 -32230 0 0 {name=X_62261_ }
C {devices/lab_pin.sym} 79820 -32120 0 0 {name=p79088 lab=_43107_/Y }
C {devices/lab_pin.sym} 79820 -32080 0 0 {name=p79089 lab=_72900_/X }
C {devices/lab_pin.sym} 79820 -32040 0 0 {name=p79090 lab=_73920_/X }
C {devices/lab_pin.sym} 79820 -32000 0 0 {name=p79091 lab=_74246_/Y }
C {devices/lab_pin.sym} 79980 -32060 0 1 {name=p79092 lab=_74247_/X }
C {sky130_stdcells/a211o_4.sym} 79900 -32060 0 0 {name=X_74247_ }
C {devices/lab_pin.sym} 79840 -31920 0 0 {name=p79093 lab=_40639_/A }
C {devices/lab_pin.sym} 79840 -31880 0 0 {name=p79094 lab=_40654_/B }
C {devices/lab_pin.sym} 79960 -31900 0 1 {name=p79095 lab=_40639_/X }
C {sky130_stdcells/or2_4.sym} 79900 -31900 0 0 {name=X_40639_ }
C {sky130_stdcells/decap_3.sym} 79900 -31740 0 0 {name=XPHY_281 }
C {devices/lab_pin.sym} 79860 -31590 0 0 {name=p79096 lab=_47195_/A }
C {devices/lab_pin.sym} 79940 -31590 0 1 {name=p79097 lab=_47195_/X }
C {sky130_stdcells/buf_2.sym} 79900 -31590 0 0 {name=X_47195_ }
C {devices/lab_pin.sym} 79820 -31490 0 0 {name=p79098 lab=_71444_/Y }
C {devices/lab_pin.sym} 79820 -31450 0 0 {name=p79099 lab=_83491_/Q }
C {devices/lab_pin.sym} 79820 -31410 0 0 {name=p79100 lab=_71458_/Y }
C {devices/lab_pin.sym} 79980 -31450 0 1 {name=p79101 lab=_71459_/X }
C {sky130_stdcells/a21o_4.sym} 79900 -31450 0 0 {name=X_71459_ }
C {sky130_stdcells/decap_3.sym} 79900 -31280 0 0 {name=XPHY_292 }
C {devices/lab_pin.sym} 79840 -31160 0 0 {name=p79102 lab=_61980_/A }
C {devices/lab_pin.sym} 79840 -31120 0 0 {name=p79103 lab=_64046_/B }
C {devices/lab_pin.sym} 79840 -31080 0 0 {name=p79104 lab=_64046_/C }
C {devices/lab_pin.sym} 79840 -31040 0 0 {name=p79105 lab=_64016_/D }
C {devices/lab_pin.sym} 79960 -31100 0 1 {name=p79106 lab=_64001_/D }
C {sky130_stdcells/nand4_4.sym} 79900 -31100 0 0 {name=X_64000_ }
C {devices/lab_pin.sym} 79840 -30970 0 0 {name=p79107 lab=_61254_/B }
C {devices/lab_pin.sym} 79840 -30930 0 0 {name=p79108 lab=_60296_/X }
C {devices/lab_pin.sym} 79840 -30890 0 0 {name=p79109 lab=_61238_/C }
C {devices/lab_pin.sym} 79960 -30930 0 1 {name=p79110 lab=_61212_/Y }
C {sky130_stdcells/nand3_4.sym} 79900 -30930 0 0 {name=X_61212_ }
C {devices/lab_pin.sym} 79860 -30790 0 0 {name=p79111 lab=_40591_/C }
C {devices/lab_pin.sym} 79940 -30790 0 1 {name=p79112 lab=_49793_/A }
C {sky130_stdcells/buf_2.sym} 79900 -30790 0 0 {name=X_46146_ }
C {devices/lab_pin.sym} 79820 -30700 0 0 {name=p79113 lab=_41352_/X }
C {devices/lab_pin.sym} 79820 -30660 0 0 {name=p79114 lab=_43356_/X }
C {devices/lab_pin.sym} 79820 -30620 0 0 {name=p79115 lab=_87463_/Q }
C {devices/lab_pin.sym} 79820 -30580 0 0 {name=p79116 lab=_43357_/X }
C {devices/lab_pin.sym} 79980 -30640 0 1 {name=p79117 lab=_87463_/D }
C {sky130_stdcells/a2bb2o_4.sym} 79900 -30640 0 0 {name=X_43358_ }
C {devices/lab_pin.sym} 79820 -30510 0 0 {name=p79118 lab=_62190_/Y }
C {devices/lab_pin.sym} 79820 -30470 0 0 {name=p79119 lab=_62166_/X }
C {devices/lab_pin.sym} 79820 -30430 0 0 {name=p79120 lab=_62191_/Y }
C {devices/lab_pin.sym} 79980 -30470 0 1 {name=p79121 lab=_62192_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -30470 0 0 {name=X_62192_ }
C {devices/lab_pin.sym} 79820 -30360 0 0 {name=p79122 lab=_74155_/X }
C {devices/lab_pin.sym} 79820 -30320 0 0 {name=p79123 lab=_84967_/Q }
C {devices/lab_pin.sym} 79820 -30280 0 0 {name=p79124 lab=_74087_/X }
C {devices/lab_pin.sym} 79820 -30240 0 0 {name=p79125 lab=_74177_/X }
C {devices/lab_pin.sym} 79980 -30300 0 1 {name=p79126 lab=_74179_/B }
C {sky130_stdcells/a211o_4.sym} 79900 -30300 0 0 {name=X_74178_ }
C {devices/lab_pin.sym} 79860 -30150 0 0 {name=p79127 lab=_56456_/A }
C {devices/lab_pin.sym} 79940 -30150 0 1 {name=p79128 lab=_56370_/C }
C {sky130_stdcells/buf_8.sym} 79900 -30150 0 0 {name=Xpsn_inst_psn_buff_19 }
C {devices/lab_pin.sym} 79860 -30030 0 0 {name=p79129 lab=_42308_/Y }
C {devices/lab_pin.sym} 79940 -30030 0 1 {name=p79130 lab=_87929_/D }
C {sky130_stdcells/inv_2.sym} 79900 -30030 0 0 {name=X_42309_ }
C {devices/lab_pin.sym} 79840 -29940 0 0 {name=p79131 lab=_61140_/X }
C {devices/lab_pin.sym} 79840 -29900 0 0 {name=p79132 lab=_61179_/A }
C {devices/lab_pin.sym} 79840 -29860 0 0 {name=p79133 lab=_61172_/A }
C {devices/lab_pin.sym} 79840 -29820 0 0 {name=p79134 lab=_64250_/C }
C {devices/lab_pin.sym} 79960 -29880 0 1 {name=p79135 lab=_64210_/A }
C {sky130_stdcells/nand4_4.sym} 79900 -29880 0 0 {name=X_61143_ }
C {devices/lab_pin.sym} 79860 -29730 0 0 {name=p79136 lab=_72973_/B }
C {devices/lab_pin.sym} 79940 -29730 0 1 {name=p79137 lab=_73129_/X }
C {sky130_stdcells/buf_2.sym} 79900 -29730 0 0 {name=X_73129_ }
C {devices/lab_pin.sym} 79820 -29650 0 0 {name=p79138 lab=_46067_/X }
C {devices/lab_pin.sym} 79820 -29610 0 0 {name=p79139 lab=_43046_/A }
C {devices/lab_pin.sym} 79820 -29570 0 0 {name=p79140 lab=_41605_/X }
C {devices/lab_pin.sym} 79820 -29530 0 0 {name=p79141 lab=_86778_/Q }
C {devices/lab_pin.sym} 79820 -29490 0 0 {name=p79142 lab=_46068_/X }
C {devices/lab_pin.sym} 79980 -29570 0 1 {name=p79143 lab=_46077_/Y }
C {sky130_stdcells/o32ai_4.sym} 79900 -29570 0 0 {name=X_46077_ }
C {devices/lab_pin.sym} 79820 -29440 0 0 {name=p79144 lab=_41165_/X }
C {devices/lab_pin.sym} 79820 -29400 0 0 {name=p79145 lab=_43287_/X }
C {devices/lab_pin.sym} 79820 -29360 0 0 {name=p79146 lab=_87497_/Q }
C {devices/lab_pin.sym} 79820 -29320 0 0 {name=p79147 lab=_43288_/X }
C {devices/lab_pin.sym} 79980 -29380 0 1 {name=p79148 lab=_43289_/X }
C {sky130_stdcells/a2bb2o_4.sym} 79900 -29380 0 0 {name=X_43289_ }
C {devices/lab_pin.sym} 79840 -29240 0 0 {name=p79149 lab=_78969_/A }
C {devices/lab_pin.sym} 79840 -29200 0 0 {name=p79150 lab=_78986_/B }
C {devices/lab_pin.sym} 79960 -29220 0 1 {name=p79151 lab=_78986_/X }
C {sky130_stdcells/and2_4.sym} 79900 -29220 0 0 {name=X_78986_ }
C {devices/lab_pin.sym} 79820 -29110 0 0 {name=p79152 lab=_49902_/Y }
C {devices/lab_pin.sym} 79820 -29070 0 0 {name=p79153 lab=_49897_/X }
C {devices/lab_pin.sym} 79820 -29030 0 0 {name=p79154 lab=_49904_/X }
C {devices/lab_pin.sym} 79980 -29070 0 1 {name=p79155 lab=_49905_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -29070 0 0 {name=X_49905_ }
C {devices/lab_pin.sym} 79820 -28950 0 0 {name=p79156 lab=_56488_/C }
C {devices/lab_pin.sym} 79820 -28910 0 0 {name=p79157 lab=_44982_/X }
C {devices/lab_pin.sym} 79820 -28870 0 0 {name=p79158 lab=_44959_/X }
C {devices/lab_pin.sym} 79980 -28910 0 1 {name=p79159 lab=_45028_/X }
C {sky130_stdcells/o21a_4.sym} 79900 -28910 0 0 {name=X_45028_ }
C {devices/lab_pin.sym} 79840 -28780 0 0 {name=p79160 lab=_65896_/A }
C {devices/lab_pin.sym} 79840 -28740 0 0 {name=p79161 lab=_86558_/Q }
C {devices/lab_pin.sym} 79960 -28760 0 1 {name=p79162 lab=_65951_/X }
C {sky130_stdcells/and2_4.sym} 79900 -28760 0 0 {name=X_65951_ }
C {devices/lab_pin.sym} 79860 -28630 0 0 {name=p79163 lab=_61074_/A }
C {devices/lab_pin.sym} 79940 -28630 0 1 {name=p79164 lab=_61083_/B }
C {sky130_stdcells/buf_2.sym} 79900 -28630 0 0 {name=X_61074_ }
C {devices/lab_pin.sym} 79840 -28520 0 0 {name=p79165 lab=_77935_/Y }
C {devices/lab_pin.sym} 79840 -28480 0 0 {name=p79166 lab=_77946_/A }
C {devices/lab_pin.sym} 79960 -28500 0 1 {name=p79167 lab=_77941_/A }
C {sky130_stdcells/xor2_4.sym} 79900 -28500 0 0 {name=X_77937_ }
C {devices/lab_pin.sym} 79860 -28370 0 0 {name=p79168 lab=_64902_/A }
C {devices/lab_pin.sym} 79940 -28370 0 1 {name=p79169 lab=_64902_/X }
C {sky130_stdcells/buf_2.sym} 79900 -28370 0 0 {name=X_64902_ }
C {devices/lab_pin.sym} 79860 -28250 0 0 {name=p79170 lab=_59943_/X }
C {devices/lab_pin.sym} 79940 -28250 0 1 {name=p79171 lab=_60025_/X }
C {sky130_stdcells/buf_2.sym} 79900 -28250 0 0 {name=X_60025_ }
C {devices/lab_pin.sym} 79820 -28150 0 0 {name=p79172 lab=_49833_/Y }
C {devices/lab_pin.sym} 79820 -28110 0 0 {name=p79173 lab=_49815_/X }
C {devices/lab_pin.sym} 79820 -28070 0 0 {name=p79174 lab=_49835_/X }
C {devices/lab_pin.sym} 79980 -28110 0 1 {name=p79175 lab=_49836_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -28110 0 0 {name=X_49836_ }
C {devices/lab_pin.sym} 79820 -28000 0 0 {name=p79176 lab=_73842_/A }
C {devices/lab_pin.sym} 79820 -27960 0 0 {name=p79177 lab=_68414_/X }
C {devices/lab_pin.sym} 79820 -27920 0 0 {name=p79178 lab=_68379_/X }
C {devices/lab_pin.sym} 79820 -27880 0 0 {name=p79179 lab=_68669_/Y }
C {devices/lab_pin.sym} 79980 -27940 0 1 {name=p79180 lab=_68670_/X }
C {sky130_stdcells/a211o_4.sym} 79900 -27940 0 0 {name=X_68670_ }
C {devices/lab_pin.sym} 79840 -27800 0 0 {name=p79181 lab=_65825_/A }
C {devices/lab_pin.sym} 79840 -27760 0 0 {name=p79182 lab=_86499_/Q }
C {devices/lab_pin.sym} 79960 -27780 0 1 {name=p79183 lab=_65882_/X }
C {sky130_stdcells/and2_4.sym} 79900 -27780 0 0 {name=X_65882_ }
C {devices/lab_pin.sym} 79820 -27670 0 0 {name=p79184 lab=_77851_/A }
C {devices/lab_pin.sym} 79820 -27630 0 0 {name=p79185 lab=_77866_/Y }
C {devices/lab_pin.sym} 79820 -27590 0 0 {name=p79186 lab=_77867_/Y }
C {devices/lab_pin.sym} 79980 -27630 0 1 {name=p79187 lab=_77868_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -27630 0 0 {name=X_77868_ }
C {devices/lab_pin.sym} 79840 -27500 0 0 {name=p79188 lab=_67696_/A }
C {devices/lab_pin.sym} 79840 -27460 0 0 {name=p79189 lab=_88231_/Q }
C {devices/lab_pin.sym} 79960 -27480 0 1 {name=p79190 lab=_67621_/X }
C {sky130_stdcells/and2_4.sym} 79900 -27480 0 0 {name=X_67621_ }
C {devices/lab_pin.sym} 79840 -27360 0 0 {name=p79191 lab=_79607_/A }
C {devices/lab_pin.sym} 79840 -27320 0 0 {name=p79192 lab=_79607_/B }
C {devices/lab_pin.sym} 79960 -27340 0 1 {name=p79193 lab=_79609_/B }
C {sky130_stdcells/nand2_4.sym} 79900 -27340 0 0 {name=X_79607_ }
C {devices/lab_pin.sym} 79840 -27220 0 0 {name=p79194 lab=_76819_/A }
C {devices/lab_pin.sym} 79840 -27180 0 0 {name=p79195 lab=_76819_/B }
C {devices/lab_pin.sym} 79960 -27200 0 1 {name=p79196 lab=_76819_/X }
C {sky130_stdcells/xor2_4.sym} 79900 -27200 0 0 {name=X_76819_ }
C {devices/lab_pin.sym} 79860 -27070 0 0 {name=p79197 lab=_64731_/A }
C {devices/lab_pin.sym} 79940 -27070 0 1 {name=p79198 lab=_64834_/A }
C {sky130_stdcells/buf_2.sym} 79900 -27070 0 0 {name=X_64833_ }
C {devices/lab_pin.sym} 79820 -26970 0 0 {name=p79199 lab=_49764_/Y }
C {devices/lab_pin.sym} 79820 -26930 0 0 {name=p79200 lab=_49759_/X }
C {devices/lab_pin.sym} 79820 -26890 0 0 {name=p79201 lab=_49766_/X }
C {devices/lab_pin.sym} 79980 -26930 0 1 {name=p79202 lab=_49767_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -26930 0 0 {name=X_49767_ }
C {devices/lab_pin.sym} 79860 -26790 0 0 {name=p79203 lab=_82395_/Q }
C {devices/lab_pin.sym} 79940 -26790 0 1 {name=p79204 lab=_46979_/Y }
C {sky130_stdcells/inv_2.sym} 79900 -26790 0 0 {name=X_46979_ }
C {devices/lab_pin.sym} 79840 -26680 0 0 {name=p79205 lab=_77787_/A }
C {devices/lab_pin.sym} 79840 -26640 0 0 {name=p79206 lab=_77786_/X }
C {devices/lab_pin.sym} 79960 -26660 0 1 {name=p79207 lab=_77799_/X }
C {sky130_stdcells/or2_4.sym} 79900 -26660 0 0 {name=X_77799_ }
C {devices/lab_pin.sym} 79820 -26550 0 0 {name=p79208 lab=_65441_/B }
C {devices/lab_pin.sym} 79820 -26510 0 0 {name=p79209 lab=_48150_/X }
C {devices/lab_pin.sym} 79820 -26470 0 0 {name=p79210 lab=_48717_/Y }
C {devices/lab_pin.sym} 79980 -26510 0 1 {name=p79211 lab=_48718_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -26510 0 0 {name=X_48718_ }
C {devices/lab_pin.sym} 79860 -26370 0 0 {name=p79212 lab=_67312_/X }
C {devices/lab_pin.sym} 79940 -26370 0 1 {name=p79213 lab=_67552_/X }
C {sky130_stdcells/buf_2.sym} 79900 -26370 0 0 {name=X_67552_ }
C {devices/lab_pin.sym} 79860 -26250 0 0 {name=p79214 lab=_79538_/A }
C {devices/lab_pin.sym} 79940 -26250 0 1 {name=p79215 lab=_79538_/Y }
C {sky130_stdcells/inv_2.sym} 79900 -26250 0 0 {name=X_79538_ }
C {devices/lab_pin.sym} 79840 -26150 0 0 {name=p79216 lab=_64870_/A }
C {devices/lab_pin.sym} 79840 -26110 0 0 {name=p79217 lab=_64741_/B }
C {devices/lab_pin.sym} 79840 -26070 0 0 {name=p79218 lab=_64764_/C }
C {devices/lab_pin.sym} 79960 -26110 0 1 {name=p79219 lab=_64764_/Y }
C {sky130_stdcells/nor3_4.sym} 79900 -26110 0 0 {name=X_64764_ }
C {devices/lab_pin.sym} 79820 -25990 0 0 {name=p79220 lab=_49695_/Y }
C {devices/lab_pin.sym} 79820 -25950 0 0 {name=p79221 lab=_49677_/X }
C {devices/lab_pin.sym} 79820 -25910 0 0 {name=p79222 lab=_49697_/X }
C {devices/lab_pin.sym} 79980 -25950 0 1 {name=p79223 lab=_49698_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -25950 0 0 {name=X_49698_ }
C {devices/lab_pin.sym} 79860 -25810 0 0 {name=p79224 lab=_61820_/A }
C {devices/lab_pin.sym} 79940 -25810 0 1 {name=p79225 lab=_62002_/B }
C {sky130_stdcells/buf_2.sym} 79900 -25810 0 0 {name=X_61976_ }
C {devices/lab_pin.sym} 79840 -25710 0 0 {name=p79226 lab=_65305_/X }
C {devices/lab_pin.sym} 79840 -25670 0 0 {name=p79227 lab=_66521_/B }
C {devices/lab_pin.sym} 79840 -25630 0 0 {name=p79228 lab=_65311_/X }
C {devices/lab_pin.sym} 79960 -25670 0 1 {name=p79229 lab=_66503_/Y }
C {sky130_stdcells/nand3_4.sym} 79900 -25670 0 0 {name=X_66503_ }
C {devices/lab_pin.sym} 79820 -25560 0 0 {name=p79230 lab=_60798_/X }
C {devices/lab_pin.sym} 79820 -25520 0 0 {name=p79231 lab=_63713_/Y }
C {devices/lab_pin.sym} 79820 -25480 0 0 {name=p79232 lab=_63358_/X }
C {devices/lab_pin.sym} 79820 -25440 0 0 {name=p79233 lab=_63714_/Y }
C {devices/lab_pin.sym} 79980 -25500 0 1 {name=p79234 lab=_63715_/X }
C {sky130_stdcells/a211o_4.sym} 79900 -25500 0 0 {name=X_63715_ }
C {devices/lab_pin.sym} 79840 -25380 0 0 {name=p79235 lab=_60844_/X }
C {devices/lab_pin.sym} 79840 -25340 0 0 {name=p79236 lab=_60857_/D }
C {devices/lab_pin.sym} 79840 -25300 0 0 {name=p79237 lab=_61293_/A }
C {devices/lab_pin.sym} 79840 -25260 0 0 {name=p79238 lab=_60861_/X }
C {devices/lab_pin.sym} 79960 -25320 0 1 {name=p79239 lab=_60928_/A }
C {sky130_stdcells/and4_4.sym} 79900 -25320 0 0 {name=X_60927_ }
C {devices/lab_pin.sym} 79840 -25180 0 0 {name=p79240 lab=_48661_/A }
C {devices/lab_pin.sym} 79840 -25140 0 0 {name=p79241 lab=_48847_/B }
C {devices/lab_pin.sym} 79960 -25160 0 1 {name=p79242 lab=_48649_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -25160 0 0 {name=X_48649_ }
C {devices/lab_pin.sym} 79840 -25040 0 0 {name=p79243 lab=_79484_/A }
C {devices/lab_pin.sym} 79840 -25000 0 0 {name=p79244 lab=_79484_/B }
C {devices/lab_pin.sym} 79960 -25020 0 1 {name=p79245 lab=_79480_/A }
C {sky130_stdcells/xor2_4.sym} 79900 -25020 0 0 {name=X_79469_ }
C {devices/lab_pin.sym} 79820 -24920 0 0 {name=p79246 lab=_87161_/Q }
C {devices/lab_pin.sym} 79820 -24880 0 0 {name=p79247 lab=_67432_/X }
C {devices/lab_pin.sym} 79820 -24840 0 0 {name=p79248 lab=_67433_/X }
C {devices/lab_pin.sym} 79820 -24800 0 0 {name=p79249 lab=_67482_/X }
C {devices/lab_pin.sym} 79980 -24860 0 1 {name=p79250 lab=_67483_/X }
C {sky130_stdcells/a211o_4.sym} 79900 -24860 0 0 {name=X_67483_ }
C {devices/lab_pin.sym} 79820 -24740 0 0 {name=p79251 lab=_64691_/X }
C {devices/lab_pin.sym} 79820 -24700 0 0 {name=p79252 lab=_86141_/Q }
C {devices/lab_pin.sym} 79820 -24660 0 0 {name=p79253 lab=_64692_/X }
C {devices/lab_pin.sym} 79820 -24620 0 0 {name=p79254 lab=_64694_/X }
C {devices/lab_pin.sym} 79980 -24680 0 1 {name=p79255 lab=_64695_/X }
C {sky130_stdcells/a211o_4.sym} 79900 -24680 0 0 {name=X_64695_ }
C {devices/lab_pin.sym} 79860 -24530 0 0 {name=p79256 lab=clkbuf_9_135_0_CLK/X }
C {devices/lab_pin.sym} 79940 -24530 0 1 {name=p79257 lab=_83491_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 79900 -24530 0 0 {name=Xclkbuf_10_271_0_CLK }
C {devices/lab_pin.sym} 79810 -24410 0 0 {name=p79258 lab=_84064_/CLK }
C {devices/lab_pin.sym} 79810 -24390 0 0 {name=p79259 lab=_81500_/D }
C {devices/lab_pin.sym} 79990 -24410 0 1 {name=p79260 lab=_81500_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -24400 0 0 {name=X_81500_ }
C {devices/lab_pin.sym} 79820 -24290 0 0 {name=p79261 lab=_69219_/X }
C {devices/lab_pin.sym} 79820 -24250 0 0 {name=p79262 lab=_69221_/X }
C {devices/lab_pin.sym} 79820 -24210 0 0 {name=p79263 lab=_69025_/X }
C {devices/lab_pin.sym} 79980 -24250 0 1 {name=p79264 lab=_69222_/X }
C {sky130_stdcells/a21o_4.sym} 79900 -24250 0 0 {name=X_69222_ }
C {devices/lab_pin.sym} 79820 -24130 0 0 {name=p79265 lab=_66432_/Y }
C {devices/lab_pin.sym} 79820 -24090 0 0 {name=p79266 lab=_66414_/X }
C {devices/lab_pin.sym} 79820 -24050 0 0 {name=p79267 lab=_66433_/X }
C {devices/lab_pin.sym} 79980 -24090 0 1 {name=p79268 lab=_84124_/D }
C {sky130_stdcells/a21o_4.sym} 79900 -24090 0 0 {name=X_66434_ }
C {devices/lab_pin.sym} 79840 -23960 0 0 {name=p79269 lab=_51671_/A }
C {devices/lab_pin.sym} 79840 -23920 0 0 {name=p79270 lab=_53183_/B }
C {devices/lab_pin.sym} 79960 -23940 0 1 {name=p79271 lab=_51660_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -23940 0 0 {name=X_51660_ }
C {devices/lab_pin.sym} 79840 -23830 0 0 {name=p79272 lab=_63670_/A }
C {devices/lab_pin.sym} 79840 -23790 0 0 {name=p79273 lab=_63670_/B }
C {devices/lab_pin.sym} 79840 -23750 0 0 {name=p79274 lab=_80379_/B }
C {devices/lab_pin.sym} 79960 -23790 0 1 {name=p79275 lab=_63646_/Y }
C {sky130_stdcells/nor3_4.sym} 79900 -23790 0 0 {name=X_63646_ }
C {devices/lab_pin.sym} 79810 -23650 0 0 {name=p79276 lab=_82563_/CLK }
C {devices/lab_pin.sym} 79810 -23630 0 0 {name=p79277 lab=_78520_/X }
C {devices/lab_pin.sym} 79990 -23650 0 1 {name=p79278 lab=_78125_/B }
C {sky130_stdcells/dfxtp_4.sym} 79900 -23640 0 0 {name=X_82480_ }
C {devices/lab_pin.sym} 79860 -23510 0 0 {name=p79279 lab=_60857_/X }
C {devices/lab_pin.sym} 79940 -23510 0 1 {name=p79280 lab=_60915_/A }
C {sky130_stdcells/buf_2.sym} 79900 -23510 0 0 {name=X_60858_ }
C {devices/lab_pin.sym} 79820 -23410 0 0 {name=p79281 lab=_50608_/Y }
C {devices/lab_pin.sym} 79820 -23370 0 0 {name=p79282 lab=_50609_/X }
C {devices/lab_pin.sym} 79820 -23330 0 0 {name=p79283 lab=_50610_/X }
C {devices/lab_pin.sym} 79980 -23370 0 1 {name=p79284 lab=_50611_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -23370 0 0 {name=X_50611_ }
C {devices/lab_pin.sym} 79810 -23230 0 0 {name=p79285 lab=_81431_/CLK }
C {devices/lab_pin.sym} 79810 -23210 0 0 {name=p79286 lab=_81463_/Q }
C {devices/lab_pin.sym} 79990 -23230 0 1 {name=p79287 lab=_76070_/B }
C {sky130_stdcells/dfxtp_4.sym} 79900 -23220 0 0 {name=X_81431_ }
C {devices/lab_pin.sym} 79860 -23090 0 0 {name=p79288 lab=clkbuf_9_26_0_CLK/X }
C {devices/lab_pin.sym} 79940 -23090 0 1 {name=p79289 lab=_85128_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 79900 -23090 0 0 {name=Xclkbuf_10_53_0_CLK }
C {devices/lab_pin.sym} 79860 -22970 0 0 {name=p79290 lab=_68394_/A }
C {devices/lab_pin.sym} 79940 -22970 0 1 {name=p79291 lab=_69153_/X }
C {sky130_stdcells/buf_2.sym} 79900 -22970 0 0 {name=X_69153_ }
C {devices/lab_pin.sym} 79820 -22870 0 0 {name=p79292 lab=_66362_/Y }
C {devices/lab_pin.sym} 79820 -22830 0 0 {name=p79293 lab=_66343_/X }
C {devices/lab_pin.sym} 79820 -22790 0 0 {name=p79294 lab=_66364_/X }
C {devices/lab_pin.sym} 79980 -22830 0 1 {name=p79295 lab=_84137_/D }
C {sky130_stdcells/a21o_4.sym} 79900 -22830 0 0 {name=X_66365_ }
C {devices/lab_pin.sym} 79820 -22710 0 0 {name=p79296 lab=_85982_/Q }
C {devices/lab_pin.sym} 79820 -22670 0 0 {name=p79297 lab=_51566_/X }
C {devices/lab_pin.sym} 79820 -22630 0 0 {name=p79298 lab=_51590_/Y }
C {devices/lab_pin.sym} 79980 -22670 0 1 {name=p79299 lab=_51591_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -22670 0 0 {name=X_51591_ }
C {devices/lab_pin.sym} 79860 -22530 0 0 {name=p79300 lab=_64328_/A }
C {devices/lab_pin.sym} 79940 -22530 0 1 {name=p79301 lab=_63578_/A }
C {sky130_stdcells/buf_2.sym} 79900 -22530 0 0 {name=X_63577_ }
C {devices/lab_pin.sym} 79840 -22430 0 0 {name=p79302 lab=_60792_/A }
C {devices/lab_pin.sym} 79840 -22390 0 0 {name=p79303 lab=_60761_/B }
C {devices/lab_pin.sym} 79840 -22350 0 0 {name=p79304 lab=_60789_/C }
C {devices/lab_pin.sym} 79960 -22390 0 1 {name=p79305 lab=_60789_/Y }
C {sky130_stdcells/nor3_4.sym} 79900 -22390 0 0 {name=X_60789_ }
C {devices/lab_pin.sym} 79860 -22250 0 0 {name=p79306 lab=clkbuf_9_393_0_CLK/A }
C {devices/lab_pin.sym} 79940 -22250 0 1 {name=p79307 lab=clkbuf_9_392_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 79900 -22250 0 0 {name=Xclkbuf_9_392_0_CLK }
C {devices/lab_pin.sym} 79820 -22150 0 0 {name=p79308 lab=_82078_/D }
C {devices/lab_pin.sym} 79820 -22110 0 0 {name=p79309 lab=_68101_/X }
C {devices/lab_pin.sym} 79820 -22070 0 0 {name=p79310 lab=_68103_/X }
C {devices/lab_pin.sym} 79980 -22110 0 1 {name=p79311 lab=_84038_/D }
C {sky130_stdcells/a21bo_4.sym} 79900 -22110 0 0 {name=X_68104_ }
C {devices/lab_pin.sym} 79840 -22000 0 0 {name=p79312 lab=_53330_/A }
C {devices/lab_pin.sym} 79840 -21960 0 0 {name=p79313 lab=_53330_/B }
C {devices/lab_pin.sym} 79840 -21920 0 0 {name=p79314 lab=_53330_/C }
C {devices/lab_pin.sym} 79840 -21880 0 0 {name=p79315 lab=_52811_/D }
C {devices/lab_pin.sym} 79960 -21940 0 1 {name=p79316 lab=_53330_/X }
C {sky130_stdcells/and4_4.sym} 79900 -21940 0 0 {name=X_53330_ }
C {devices/lab_pin.sym} 79820 -21820 0 0 {name=p79317 lab=_64696_/X }
C {devices/lab_pin.sym} 79820 -21780 0 0 {name=p79318 lab=_85542_/Q }
C {devices/lab_pin.sym} 79820 -21740 0 0 {name=p79319 lab=_64697_/X }
C {devices/lab_pin.sym} 79820 -21700 0 0 {name=p79320 lab=_65315_/X }
C {devices/lab_pin.sym} 79980 -21760 0 1 {name=p79321 lab=_65316_/X }
C {sky130_stdcells/a211o_4.sym} 79900 -21760 0 0 {name=X_65316_ }
C {devices/lab_pin.sym} 79810 -21610 0 0 {name=p79322 lab=_84150_/CLK }
C {devices/lab_pin.sym} 79810 -21590 0 0 {name=p79323 lab=_84150_/D }
C {devices/lab_pin.sym} 79990 -21610 0 1 {name=p79324 lab=_84150_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -21600 0 0 {name=X_84150_ }
C {devices/lab_pin.sym} 79820 -21490 0 0 {name=p79325 lab=_86181_/Q }
C {devices/lab_pin.sym} 79820 -21450 0 0 {name=p79326 lab=_50533_/X }
C {devices/lab_pin.sym} 79820 -21410 0 0 {name=p79327 lab=_50541_/Y }
C {devices/lab_pin.sym} 79980 -21450 0 1 {name=p79328 lab=_50542_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -21450 0 0 {name=X_50542_ }
C {devices/lab_pin.sym} 79820 -21330 0 0 {name=p79329 lab=_62526_/Y }
C {devices/lab_pin.sym} 79820 -21290 0 0 {name=p79330 lab=_62467_/X }
C {devices/lab_pin.sym} 79820 -21250 0 0 {name=p79331 lab=_62527_/Y }
C {devices/lab_pin.sym} 79980 -21290 0 1 {name=p79332 lab=_62528_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -21290 0 0 {name=X_62528_ }
C {devices/lab_pin.sym} 79810 -21150 0 0 {name=p79333 lab=_81362_/CLK }
C {devices/lab_pin.sym} 79810 -21130 0 0 {name=p79334 lab=_81362_/D }
C {devices/lab_pin.sym} 79990 -21150 0 1 {name=p79335 lab=_81362_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -21140 0 0 {name=X_81362_ }
C {devices/lab_pin.sym} 79820 -21040 0 0 {name=p79336 lab=_68907_/X }
C {devices/lab_pin.sym} 79820 -21000 0 0 {name=p79337 lab=_68882_/X }
C {devices/lab_pin.sym} 79820 -20960 0 0 {name=p79338 lab=_69075_/Y }
C {devices/lab_pin.sym} 79820 -20920 0 0 {name=p79339 lab=_69083_/Y }
C {devices/lab_pin.sym} 79980 -20980 0 1 {name=p79340 lab=_69084_/X }
C {sky130_stdcells/a211o_4.sym} 79900 -20980 0 0 {name=X_69084_ }
C {devices/lab_pin.sym} 79840 -20840 0 0 {name=p79341 lab=_66267_/X }
C {devices/lab_pin.sym} 79840 -20800 0 0 {name=p79342 lab=_66296_/B }
C {devices/lab_pin.sym} 79960 -20820 0 1 {name=p79343 lab=_66296_/X }
C {sky130_stdcells/and2_4.sym} 79900 -20820 0 0 {name=X_66296_ }
C {devices/lab_pin.sym} 79860 -20690 0 0 {name=p79344 lab=clkbuf_9_143_0_CLK/X }
C {devices/lab_pin.sym} 79940 -20690 0 1 {name=p79345 lab=_82386_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 79900 -20690 0 0 {name=Xclkbuf_10_286_0_CLK }
C {devices/lab_pin.sym} 79810 -20570 0 0 {name=p79346 lab=_83846_/CLK }
C {devices/lab_pin.sym} 79810 -20550 0 0 {name=p79347 lab=_74318_/X }
C {devices/lab_pin.sym} 79990 -20570 0 1 {name=p79348 lab=_70301_/C }
C {sky130_stdcells/dfxtp_4.sym} 79900 -20560 0 0 {name=X_83101_ }
C {devices/lab_pin.sym} 79860 -20430 0 0 {name=p79349 lab=_80313_/A }
C {devices/lab_pin.sym} 79940 -20430 0 1 {name=p79350 lab=_80313_/Y }
C {sky130_stdcells/inv_2.sym} 79900 -20430 0 0 {name=X_80313_ }
C {devices/lab_pin.sym} 79840 -20320 0 0 {name=p79351 lab=_68371_/A }
C {devices/lab_pin.sym} 79840 -20280 0 0 {name=p79352 lab=_88214_/Q }
C {devices/lab_pin.sym} 79960 -20300 0 1 {name=p79353 lab=_68035_/X }
C {sky130_stdcells/and2_4.sym} 79900 -20300 0 0 {name=X_68035_ }
C {devices/lab_pin.sym} 79840 -20200 0 0 {name=p79354 lab=_53243_/X }
C {devices/lab_pin.sym} 79840 -20160 0 0 {name=p79355 lab=_51747_/A }
C {devices/lab_pin.sym} 79840 -20120 0 0 {name=p79356 lab=_53266_/C }
C {devices/lab_pin.sym} 79840 -20080 0 0 {name=p79357 lab=_53261_/D }
C {devices/lab_pin.sym} 79960 -20140 0 1 {name=p79358 lab=_53261_/X }
C {sky130_stdcells/and4_4.sym} 79900 -20140 0 0 {name=X_53261_ }
C {devices/lab_pin.sym} 79840 -20000 0 0 {name=p79359 lab=_65225_/A }
C {devices/lab_pin.sym} 79840 -19960 0 0 {name=p79360 lab=_65247_/B }
C {devices/lab_pin.sym} 79960 -19980 0 1 {name=p79361 lab=_65247_/X }
C {sky130_stdcells/and2_4.sym} 79900 -19980 0 0 {name=X_65247_ }
C {devices/lab_pin.sym} 79810 -19850 0 0 {name=p79362 lab=_83933_/CLK }
C {devices/lab_pin.sym} 79810 -19830 0 0 {name=p79363 lab=_67165_/X }
C {devices/lab_pin.sym} 79990 -19850 0 1 {name=p79364 lab=_84081_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -19840 0 0 {name=X_84081_ }
C {devices/lab_pin.sym} 79860 -19710 0 0 {name=p79365 lab=_50473_/A }
C {devices/lab_pin.sym} 79940 -19710 0 1 {name=p79366 lab=_50577_/A }
C {sky130_stdcells/buf_2.sym} 79900 -19710 0 0 {name=X_50473_ }
C {devices/lab_pin.sym} 79840 -19610 0 0 {name=p79367 lab=_62448_/A }
C {devices/lab_pin.sym} 79840 -19570 0 0 {name=p79368 lab=_58474_/A }
C {devices/lab_pin.sym} 79840 -19530 0 0 {name=p79369 lab=_62491_/C }
C {devices/lab_pin.sym} 79960 -19570 0 1 {name=p79370 lab=_62461_/C }
C {sky130_stdcells/nand3_4.sym} 79900 -19570 0 0 {name=X_62459_ }
C {devices/lab_pin.sym} 79810 -19430 0 0 {name=p79371 lab=_81260_/CLK }
C {devices/lab_pin.sym} 79810 -19410 0 0 {name=p79372 lab=_76981_/X }
C {devices/lab_pin.sym} 79990 -19430 0 1 {name=p79373 lab=_81261_/D }
C {sky130_stdcells/dfxtp_4.sym} 79900 -19420 0 0 {name=X_81293_ }
C {devices/lab_pin.sym} 79840 -19320 0 0 {name=p79374 lab=_55013_/A }
C {devices/lab_pin.sym} 79840 -19280 0 0 {name=p79375 lab=_54978_/X }
C {devices/lab_pin.sym} 79840 -19240 0 0 {name=p79376 lab=_55013_/C }
C {devices/lab_pin.sym} 79840 -19200 0 0 {name=p79377 lab=_47594_/A }
C {devices/lab_pin.sym} 79960 -19260 0 1 {name=p79378 lab=_55000_/X }
C {sky130_stdcells/and4_4.sym} 79900 -19260 0 0 {name=X_55000_ }
C {devices/lab_pin.sym} 79860 -19110 0 0 {name=p79379 lab=clkbuf_9_34_0_CLK/X }
C {devices/lab_pin.sym} 79940 -19110 0 1 {name=p79380 lab=_86861_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 79900 -19110 0 0 {name=Xclkbuf_10_68_0_CLK }
C {devices/lab_pin.sym} 79840 -19010 0 0 {name=p79381 lab=_50511_/A }
C {devices/lab_pin.sym} 79840 -18970 0 0 {name=p79382 lab=_52198_/X }
C {devices/lab_pin.sym} 79840 -18930 0 0 {name=p79383 lab=_52218_/C }
C {devices/lab_pin.sym} 79960 -18970 0 1 {name=p79384 lab=_52212_/X }
C {sky130_stdcells/and3_4.sym} 79900 -18970 0 0 {name=X_52212_ }
C {devices/lab_pin.sym} 79810 -18830 0 0 {name=p79385 lab=_85180_/CLK }
C {devices/lab_pin.sym} 79810 -18810 0 0 {name=p79386 lab=_74567_/Y }
C {devices/lab_pin.sym} 79990 -18830 0 1 {name=p79387 lab=_45046_/A }
C {sky130_stdcells/dfxtp_4.sym} 79900 -18820 0 0 {name=X_83032_ }
C {devices/lab_pin.sym} 79840 -18700 0 0 {name=p79388 lab=_80244_/A }
C {devices/lab_pin.sym} 79840 -18660 0 0 {name=p79389 lab=_80244_/B }
C {devices/lab_pin.sym} 79960 -18680 0 1 {name=p79390 lab=_80244_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -18680 0 0 {name=X_80244_ }
C {devices/lab_pin.sym} 79820 -18570 0 0 {name=p79391 lab=_53188_/Y }
C {devices/lab_pin.sym} 79820 -18530 0 0 {name=p79392 lab=_53189_/X }
C {devices/lab_pin.sym} 79820 -18490 0 0 {name=p79393 lab=_53191_/X }
C {devices/lab_pin.sym} 79980 -18530 0 1 {name=p79394 lab=_53192_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -18530 0 0 {name=X_53192_ }
C {devices/lab_pin.sym} 79860 -18390 0 0 {name=p79395 lab=_64809_/A }
C {devices/lab_pin.sym} 79940 -18390 0 1 {name=p79396 lab=_65178_/X }
C {sky130_stdcells/buf_2.sym} 79900 -18390 0 0 {name=X_65178_ }
C {devices/lab_pin.sym} 79860 -18270 0 0 {name=p79397 lab=clkbuf_8_215_0_CLK/A }
C {devices/lab_pin.sym} 79940 -18270 0 1 {name=p79398 lab=clkbuf_9_429_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 79900 -18270 0 0 {name=Xclkbuf_8_214_0_CLK }
C {devices/lab_pin.sym} 79840 -18160 0 0 {name=p79399 lab=_52127_/X }
C {devices/lab_pin.sym} 79840 -18120 0 0 {name=p79400 lab=_50440_/B }
C {devices/lab_pin.sym} 79960 -18140 0 1 {name=p79401 lab=_52143_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -18140 0 0 {name=X_52143_ }
C {devices/lab_pin.sym} 79860 -18010 0 0 {name=p79402 lab=_63912_/X }
C {devices/lab_pin.sym} 79940 -18010 0 1 {name=p79403 lab=_64129_/X }
C {sky130_stdcells/buf_2.sym} 79900 -18010 0 0 {name=X_64129_ }
C {devices/lab_pin.sym} 79810 -17890 0 0 {name=p79404 lab=_88104_/CLK }
C {devices/lab_pin.sym} 79810 -17870 0 0 {name=p79405 lab=_42510_/Y }
C {devices/lab_pin.sym} 79990 -17890 0 1 {name=p79406 lab=_74005_/A }
C {sky130_stdcells/dfxtp_4.sym} 79900 -17880 0 0 {name=X_87840_ }
C {devices/lab_pin.sym} 79840 -17760 0 0 {name=p79407 lab=_60021_/C }
C {devices/lab_pin.sym} 79840 -17720 0 0 {name=p79408 lab=_63864_/C }
C {devices/lab_pin.sym} 79960 -17740 0 1 {name=p79409 lab=_80175_/X }
C {sky130_stdcells/xor2_4.sym} 79900 -17740 0 0 {name=X_80175_ }
C {devices/lab_pin.sym} 79820 -17640 0 0 {name=p79410 lab=_69599_/Y }
C {devices/lab_pin.sym} 79820 -17600 0 0 {name=p79411 lab=_69916_/X }
C {devices/lab_pin.sym} 79820 -17560 0 0 {name=p79412 lab=_69984_/X }
C {devices/lab_pin.sym} 79820 -17520 0 0 {name=p79413 lab=_69985_/Y }
C {devices/lab_pin.sym} 79980 -17580 0 1 {name=p79414 lab=_69986_/X }
C {sky130_stdcells/a211o_4.sym} 79900 -17580 0 0 {name=X_69986_ }
C {devices/lab_pin.sym} 79860 -17430 0 0 {name=p79415 lab=_52126_/A }
C {devices/lab_pin.sym} 79940 -17430 0 1 {name=p79416 lab=_52438_/A }
C {sky130_stdcells/buf_2.sym} 79900 -17430 0 0 {name=X_52074_ }
C {devices/lab_pin.sym} 79860 -17310 0 0 {name=p79417 lab=_56940_/Y }
C {devices/lab_pin.sym} 79940 -17310 0 1 {name=p79418 lab=_56952_/A }
C {sky130_stdcells/inv_2.sym} 79900 -17310 0 0 {name=X_56951_ }
C {devices/lab_pin.sym} 79820 -17210 0 0 {name=p79419 lab=_68932_/X }
C {devices/lab_pin.sym} 79820 -17170 0 0 {name=p79420 lab=_68936_/X }
C {devices/lab_pin.sym} 79820 -17130 0 0 {name=p79421 lab=_68773_/X }
C {devices/lab_pin.sym} 79980 -17170 0 1 {name=p79422 lab=_68937_/X }
C {sky130_stdcells/a21o_4.sym} 79900 -17170 0 0 {name=X_68937_ }
C {devices/lab_pin.sym} 79810 -17030 0 0 {name=p79423 lab=_87273_/CLK }
C {devices/lab_pin.sym} 79810 -17010 0 0 {name=p79424 lab=_42684_/X }
C {devices/lab_pin.sym} 79990 -17030 0 1 {name=p79425 lab=_69466_/B }
C {sky130_stdcells/dfxtp_4.sym} 79900 -17020 0 0 {name=X_87771_ }
C {devices/lab_pin.sym} 79810 -16890 0 0 {name=p79426 lab=_86587_/CLK }
C {devices/lab_pin.sym} 79810 -16870 0 0 {name=p79427 lab=_84983_/D }
C {devices/lab_pin.sym} 79990 -16890 0 1 {name=p79428 lab=_84983_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -16880 0 0 {name=X_84983_ }
C {devices/lab_pin.sym} 79860 -16750 0 0 {name=p79429 lab=clkbuf_9_331_0_CLK/A }
C {devices/lab_pin.sym} 79940 -16750 0 1 {name=p79430 lab=clkbuf_9_330_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 79900 -16750 0 0 {name=Xclkbuf_9_330_0_CLK }
C {devices/lab_pin.sym} 79820 -16650 0 0 {name=p79431 lab=_51023_/Y }
C {devices/lab_pin.sym} 79820 -16610 0 0 {name=p79432 lab=_51011_/X }
C {devices/lab_pin.sym} 79820 -16570 0 0 {name=p79433 lab=_51024_/X }
C {devices/lab_pin.sym} 79980 -16610 0 1 {name=p79434 lab=_51025_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -16610 0 0 {name=X_51025_ }
C {devices/lab_pin.sym} 79840 -16480 0 0 {name=p79435 lab=_55902_/A }
C {devices/lab_pin.sym} 79840 -16440 0 0 {name=p79436 lab=_55901_/X }
C {devices/lab_pin.sym} 79960 -16460 0 1 {name=p79437 lab=_55928_/B }
C {sky130_stdcells/and2_4.sym} 79900 -16460 0 0 {name=X_55902_ }
C {devices/lab_pin.sym} 79810 -16330 0 0 {name=p79438 lab=_86733_/CLK }
C {devices/lab_pin.sym} 79810 -16310 0 0 {name=p79439 lab=_86722_/D }
C {devices/lab_pin.sym} 79990 -16330 0 1 {name=p79440 lab=_86722_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -16320 0 0 {name=X_86722_ }
C {devices/lab_pin.sym} 79860 -16190 0 0 {name=p79441 lab=_64738_/A }
C {devices/lab_pin.sym} 79940 -16190 0 1 {name=p79442 lab=_66046_/A }
C {sky130_stdcells/buf_2.sym} 79900 -16190 0 0 {name=X_59670_ }
C {devices/lab_pin.sym} 79810 -16070 0 0 {name=p79443 lab=_81346_/CLK }
C {devices/lab_pin.sym} 79810 -16050 0 0 {name=p79444 lab=_83934_/D }
C {devices/lab_pin.sym} 79990 -16070 0 1 {name=p79445 lab=_81398_/D }
C {sky130_stdcells/dfxtp_4.sym} 79900 -16060 0 0 {name=X_83934_ }
C {devices/lab_pin.sym} 79820 -15950 0 0 {name=p79446 lab=_55654_/X }
C {devices/lab_pin.sym} 79820 -15910 0 0 {name=p79447 lab=_55672_/X }
C {devices/lab_pin.sym} 79820 -15870 0 0 {name=p79448 lab=_56881_/X }
C {devices/lab_pin.sym} 79980 -15910 0 1 {name=p79449 lab=_56885_/A }
C {sky130_stdcells/o21ai_4.sym} 79900 -15910 0 0 {name=X_56882_ }
C {devices/lab_pin.sym} 79840 -15780 0 0 {name=p79450 lab=_68779_/A }
C {devices/lab_pin.sym} 79840 -15740 0 0 {name=p79451 lab=_68868_/B }
C {devices/lab_pin.sym} 79960 -15760 0 1 {name=p79452 lab=_68868_/X }
C {sky130_stdcells/and2_4.sym} 79900 -15760 0 0 {name=X_68868_ }
C {devices/lab_pin.sym} 79860 -15630 0 0 {name=p79453 lab=clkbuf_8_229_0_CLK/A }
C {devices/lab_pin.sym} 79940 -15630 0 1 {name=p79454 lab=clkbuf_9_459_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 79900 -15630 0 0 {name=Xclkbuf_8_229_0_CLK }
C {devices/lab_pin.sym} 79860 -15510 0 0 {name=p79455 lab=clkbuf_9_112_0_CLK/X }
C {devices/lab_pin.sym} 79940 -15510 0 1 {name=p79456 lab=_80696_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 79900 -15510 0 0 {name=Xclkbuf_10_224_0_CLK }
C {devices/lab_pin.sym} 79820 -15410 0 0 {name=p79457 lab=_58617_/Y }
C {devices/lab_pin.sym} 79820 -15370 0 0 {name=p79458 lab=_58620_/Y }
C {devices/lab_pin.sym} 79820 -15330 0 0 {name=p79459 lab=_58610_/X }
C {devices/lab_pin.sym} 79980 -15370 0 1 {name=p79460 lab=_58621_/X }
C {sky130_stdcells/a21o_4.sym} 79900 -15370 0 0 {name=X_58621_ }
C {devices/lab_pin.sym} 79840 -15240 0 0 {name=p79461 lab=_55836_/A }
C {devices/lab_pin.sym} 79840 -15200 0 0 {name=p79462 lab=_55833_/B }
C {devices/lab_pin.sym} 79960 -15220 0 1 {name=p79463 lab=_55833_/X }
C {sky130_stdcells/and2_4.sym} 79900 -15220 0 0 {name=X_55833_ }
C {devices/lab_pin.sym} 79820 -15120 0 0 {name=p79464 lab=_87903_/Q }
C {devices/lab_pin.sym} 79820 -15080 0 0 {name=p79465 lab=_67770_/X }
C {devices/lab_pin.sym} 79820 -15040 0 0 {name=p79466 lab=_67748_/X }
C {devices/lab_pin.sym} 79820 -15000 0 0 {name=p79467 lab=_67818_/X }
C {devices/lab_pin.sym} 79980 -15060 0 1 {name=p79468 lab=_67819_/X }
C {sky130_stdcells/a211o_4.sym} 79900 -15060 0 0 {name=X_67819_ }
C {devices/lab_pin.sym} 79810 -14910 0 0 {name=p79469 lab=_86651_/CLK }
C {devices/lab_pin.sym} 79810 -14890 0 0 {name=p79470 lab=_47266_/Y }
C {devices/lab_pin.sym} 79990 -14910 0 1 {name=p79471 lab=_57792_/A }
C {sky130_stdcells/dfxtp_4.sym} 79900 -14900 0 0 {name=X_86653_ }
C {devices/lab_pin.sym} 79860 -14770 0 0 {name=p79472 lab=clkbuf_9_427_0_CLK/X }
C {devices/lab_pin.sym} 79940 -14770 0 1 {name=p79473 lab=_86422_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 79900 -14770 0 0 {name=Xclkbuf_10_854_0_CLK }
C {devices/lab_pin.sym} 79810 -14650 0 0 {name=p79474 lab=_82541_/CLK }
C {devices/lab_pin.sym} 79810 -14630 0 0 {name=p79475 lab=_70043_/X }
C {devices/lab_pin.sym} 79990 -14650 0 1 {name=p79476 lab=_82545_/D }
C {sky130_stdcells/dfxtp_4.sym} 79900 -14640 0 0 {name=X_83865_ }
C {devices/lab_pin.sym} 79860 -14510 0 0 {name=p79477 lab=_66673_/X }
C {devices/lab_pin.sym} 79940 -14510 0 1 {name=p79478 lab=_69478_/A }
C {sky130_stdcells/buf_2.sym} 79900 -14510 0 0 {name=X_68799_ }
C {devices/lab_pin.sym} 79810 -14390 0 0 {name=p79479 lab=_86203_/CLK }
C {devices/lab_pin.sym} 79810 -14370 0 0 {name=p79480 lab=_85604_/D }
C {devices/lab_pin.sym} 79990 -14390 0 1 {name=p79481 lab=_85604_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -14380 0 0 {name=X_85604_ }
C {devices/lab_pin.sym} 79840 -14260 0 0 {name=p79482 lab=_70698_/A }
C {devices/lab_pin.sym} 79840 -14220 0 0 {name=p79483 lab=_70830_/B }
C {devices/lab_pin.sym} 79960 -14240 0 1 {name=p79484 lab=_70830_/Y }
C {sky130_stdcells/nor2_4.sym} 79900 -14240 0 0 {name=X_70830_ }
C {devices/lab_pin.sym} 79820 -14130 0 0 {name=p79485 lab=_58538_/X }
C {devices/lab_pin.sym} 79820 -14090 0 0 {name=p79486 lab=_83357_/Q }
C {devices/lab_pin.sym} 79820 -14050 0 0 {name=p79487 lab=_58551_/Y }
C {devices/lab_pin.sym} 79980 -14090 0 1 {name=p79488 lab=_84821_/D }
C {sky130_stdcells/o21a_4.sym} 79900 -14090 0 0 {name=X_58552_ }
C {devices/lab_pin.sym} 79810 -13950 0 0 {name=p79489 lab=_82740_/CLK }
C {devices/lab_pin.sym} 79810 -13930 0 0 {name=p79490 lab=_82848_/Q }
C {devices/lab_pin.sym} 79990 -13950 0 1 {name=p79491 lab=_82816_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -13940 0 0 {name=X_82816_ }
C {devices/lab_pin.sym} 79840 -13820 0 0 {name=p79492 lab=_55224_/A }
C {devices/lab_pin.sym} 79840 -13780 0 0 {name=p79493 lab=_55764_/B }
C {devices/lab_pin.sym} 79960 -13800 0 1 {name=p79494 lab=_55764_/X }
C {sky130_stdcells/and2_4.sym} 79900 -13800 0 0 {name=X_55764_ }
C {devices/lab_pin.sym} 79810 -13670 0 0 {name=p79495 lab=_86587_/CLK }
C {devices/lab_pin.sym} 79810 -13650 0 0 {name=p79496 lab=_86584_/D }
C {devices/lab_pin.sym} 79990 -13670 0 1 {name=p79497 lab=_66037_/B }
C {sky130_stdcells/dfxtp_4.sym} 79900 -13660 0 0 {name=X_86584_ }
C {devices/lab_pin.sym} 79860 -13530 0 0 {name=p79498 lab=_52893_/X }
C {devices/lab_pin.sym} 79940 -13530 0 1 {name=p79499 lab=_52997_/A }
C {sky130_stdcells/buf_2.sym} 79900 -13530 0 0 {name=X_52976_ }
C {devices/lab_pin.sym} 79820 -13440 0 0 {name=p79500 lab=_40986_/X }
C {devices/lab_pin.sym} 79820 -13400 0 0 {name=p79501 lab=_40987_/X }
C {devices/lab_pin.sym} 79820 -13360 0 0 {name=p79502 lab=_69279_/B }
C {devices/lab_pin.sym} 79820 -13320 0 0 {name=p79503 lab=_40989_/X }
C {devices/lab_pin.sym} 79980 -13380 0 1 {name=p79504 lab=_88297_/D }
C {sky130_stdcells/a2bb2o_4.sym} 79900 -13380 0 0 {name=X_40990_ }
C {devices/lab_pin.sym} 79860 -13230 0 0 {name=p79505 lab=clkbuf_9_345_0_CLK/A }
C {devices/lab_pin.sym} 79940 -13230 0 1 {name=p79506 lab=clkbuf_9_345_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 79900 -13230 0 0 {name=Xclkbuf_9_345_0_CLK }
C {devices/lab_pin.sym} 79810 -13110 0 0 {name=p79507 lab=_83787_/CLK }
C {devices/lab_pin.sym} 79810 -13090 0 0 {name=p79508 lab=_83796_/D }
C {devices/lab_pin.sym} 79990 -13110 0 1 {name=p79509 lab=_83796_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -13100 0 0 {name=X_83796_ }
C {devices/lab_pin.sym} 79840 -12980 0 0 {name=p79510 lab=_47819_/A }
C {devices/lab_pin.sym} 79840 -12940 0 0 {name=p79511 lab=_47863_/Y }
C {devices/lab_pin.sym} 79960 -12960 0 1 {name=p79512 lab=_57503_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -12960 0 0 {name=X_57503_ }
C {devices/lab_pin.sym} 79810 -12830 0 0 {name=p79513 lab=_88060_/CLK }
C {devices/lab_pin.sym} 79810 -12810 0 0 {name=p79514 lab=_88323_/D }
C {devices/lab_pin.sym} 79990 -12830 0 1 {name=p79515 lab=_88323_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -12820 0 0 {name=X_88323_ }
C {devices/lab_pin.sym} 79820 -12710 0 0 {name=p79516 lab=_85391_/Q }
C {devices/lab_pin.sym} 79820 -12670 0 0 {name=p79517 lab=_54703_/X }
C {devices/lab_pin.sym} 79820 -12630 0 0 {name=p79518 lab=_54714_/Y }
C {devices/lab_pin.sym} 79980 -12670 0 1 {name=p79519 lab=_54715_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -12670 0 0 {name=X_54715_ }
C {devices/lab_pin.sym} 79810 -12530 0 0 {name=p79520 lab=_85535_/CLK }
C {devices/lab_pin.sym} 79810 -12510 0 0 {name=p79521 lab=_85535_/D }
C {devices/lab_pin.sym} 79990 -12530 0 1 {name=p79522 lab=_85535_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -12520 0 0 {name=X_85535_ }
C {devices/lab_pin.sym} 79860 -12390 0 0 {name=p79523 lab=_52398_/A }
C {devices/lab_pin.sym} 79940 -12390 0 1 {name=p79524 lab=_52126_/A }
C {sky130_stdcells/buf_2.sym} 79900 -12390 0 0 {name=X_51927_ }
C {devices/lab_pin.sym} 79860 -12270 0 0 {name=p79525 lab=_70761_/A }
C {devices/lab_pin.sym} 79940 -12270 0 1 {name=p79526 lab=_70761_/X }
C {sky130_stdcells/buf_2.sym} 79900 -12270 0 0 {name=X_70761_ }
C {devices/lab_pin.sym} 79810 -12150 0 0 {name=p79527 lab=_82748_/CLK }
C {devices/lab_pin.sym} 79810 -12130 0 0 {name=p79528 lab=_84131_/Q }
C {devices/lab_pin.sym} 79990 -12150 0 1 {name=p79529 lab=_82747_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -12140 0 0 {name=X_82747_ }
C {devices/lab_pin.sym} 79840 -12020 0 0 {name=p79530 lab=_58483_/A }
C {devices/lab_pin.sym} 79840 -11980 0 0 {name=p79531 lab=_58502_/B }
C {devices/lab_pin.sym} 79960 -12000 0 1 {name=p79532 lab=_58483_/Y }
C {sky130_stdcells/nor2_4.sym} 79900 -12000 0 0 {name=X_58483_ }
C {devices/lab_pin.sym} 79840 -11880 0 0 {name=p79533 lab=_55695_/A }
C {devices/lab_pin.sym} 79840 -11840 0 0 {name=p79534 lab=_85185_/Q }
C {devices/lab_pin.sym} 79960 -11860 0 1 {name=p79535 lab=_55695_/X }
C {sky130_stdcells/and2_4.sym} 79900 -11860 0 0 {name=X_55695_ }
C {devices/lab_pin.sym} 79860 -11730 0 0 {name=p79536 lab=clkbuf_9_119_0_CLK/X }
C {devices/lab_pin.sym} 79940 -11730 0 1 {name=p79537 lab=_82220_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 79900 -11730 0 0 {name=Xclkbuf_10_239_0_CLK }
C {devices/lab_pin.sym} 79840 -11620 0 0 {name=p79538 lab=_64473_/A }
C {devices/lab_pin.sym} 79840 -11580 0 0 {name=p79539 lab=_72498_/B }
C {devices/lab_pin.sym} 79960 -11600 0 1 {name=p79540 lab=_72500_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -11600 0 0 {name=X_72500_ }
C {devices/lab_pin.sym} 79860 -11470 0 0 {name=p79541 lab=_57434_/A }
C {devices/lab_pin.sym} 79940 -11470 0 1 {name=p79542 lab=_57434_/Y }
C {sky130_stdcells/inv_2.sym} 79900 -11470 0 0 {name=X_57434_ }
C {devices/lab_pin.sym} 79860 -11350 0 0 {name=p79543 lab=clkbuf_9_434_0_CLK/X }
C {devices/lab_pin.sym} 79940 -11350 0 1 {name=p79544 lab=_85507_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 79900 -11350 0 0 {name=Xclkbuf_10_869_0_CLK }
C {devices/lab_pin.sym} 79810 -11230 0 0 {name=p79545 lab=_88006_/CLK }
C {devices/lab_pin.sym} 79810 -11210 0 0 {name=p79546 lab=_41227_/Y }
C {devices/lab_pin.sym} 79990 -11230 0 1 {name=p79547 lab=_88254_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -11220 0 0 {name=X_88254_ }
C {devices/lab_pin.sym} 79860 -11090 0 0 {name=p79548 lab=_42659_/Y }
C {devices/lab_pin.sym} 79940 -11090 0 1 {name=p79549 lab=_42660_/Y }
C {sky130_stdcells/inv_2.sym} 79900 -11090 0 0 {name=X_42660_ }
C {devices/lab_pin.sym} 79820 -10990 0 0 {name=p79550 lab=_54642_/Y }
C {devices/lab_pin.sym} 79820 -10950 0 0 {name=p79551 lab=_54638_/X }
C {devices/lab_pin.sym} 79820 -10910 0 0 {name=p79552 lab=_54645_/X }
C {devices/lab_pin.sym} 79980 -10950 0 1 {name=p79553 lab=_54646_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -10950 0 0 {name=X_54646_ }
C {devices/lab_pin.sym} 79820 -10830 0 0 {name=p79554 lab=_73481_/B }
C {devices/lab_pin.sym} 79820 -10790 0 0 {name=p79555 lab=_73481_/C }
C {devices/lab_pin.sym} 79820 -10750 0 0 {name=p79556 lab=_73479_/X }
C {devices/lab_pin.sym} 79980 -10790 0 1 {name=p79557 lab=_73480_/X }
C {sky130_stdcells/a21o_4.sym} 79900 -10790 0 0 {name=X_73480_ }
C {devices/lab_pin.sym} 79810 -10650 0 0 {name=p79558 lab=_82961_/CLK }
C {devices/lab_pin.sym} 79810 -10630 0 0 {name=p79559 lab=_54308_/Y }
C {devices/lab_pin.sym} 79990 -10650 0 1 {name=p79560 lab=_85466_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -10640 0 0 {name=X_85466_ }
C {devices/lab_pin.sym} 79820 -10530 0 0 {name=p79561 lab=_85933_/Q }
C {devices/lab_pin.sym} 79820 -10490 0 0 {name=p79562 lab=_51846_/X }
C {devices/lab_pin.sym} 79820 -10450 0 0 {name=p79563 lab=_51857_/Y }
C {devices/lab_pin.sym} 79980 -10490 0 1 {name=p79564 lab=_51858_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -10490 0 0 {name=X_51858_ }
C {devices/lab_pin.sym} 79840 -10370 0 0 {name=p79565 lab=_70692_/A }
C {devices/lab_pin.sym} 79840 -10330 0 0 {name=p79566 lab=_70692_/B }
C {devices/lab_pin.sym} 79840 -10290 0 0 {name=p79567 lab=_70692_/C }
C {devices/lab_pin.sym} 79960 -10330 0 1 {name=p79568 lab=_70692_/Y }
C {sky130_stdcells/nor3_4.sym} 79900 -10330 0 0 {name=X_70692_ }
C {devices/lab_pin.sym} 79810 -10190 0 0 {name=p79569 lab=_81216_/CLK }
C {devices/lab_pin.sym} 79810 -10170 0 0 {name=p79570 lab=_82678_/D }
C {devices/lab_pin.sym} 79990 -10190 0 1 {name=p79571 lab=_78226_/A }
C {sky130_stdcells/dfxtp_4.sym} 79900 -10180 0 0 {name=X_82678_ }
C {devices/lab_pin.sym} 79860 -10050 0 0 {name=p79572 lab=_41336_/X }
C {devices/lab_pin.sym} 79940 -10050 0 1 {name=p79573 lab=_41611_/X }
C {sky130_stdcells/buf_2.sym} 79900 -10050 0 0 {name=X_41611_ }
C {devices/lab_pin.sym} 79810 -9930 0 0 {name=p79574 lab=_87394_/CLK }
C {devices/lab_pin.sym} 79810 -9910 0 0 {name=p79575 lab=_43909_/X }
C {devices/lab_pin.sym} 79990 -9930 0 1 {name=p79576 lab=_67667_/B }
C {sky130_stdcells/dfxtp_4.sym} 79900 -9920 0 0 {name=X_87205_ }
C {devices/lab_pin.sym} 79820 -9810 0 0 {name=p79577 lab=_72419_/X }
C {devices/lab_pin.sym} 79820 -9770 0 0 {name=p79578 lab=_85351_/Q }
C {devices/lab_pin.sym} 79820 -9730 0 0 {name=p79579 lab=_72430_/X }
C {devices/lab_pin.sym} 79980 -9770 0 1 {name=p79580 lab=_72431_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -9770 0 0 {name=X_72431_ }
C {devices/lab_pin.sym} 79810 -9630 0 0 {name=p79581 lab=_84414_/CLK }
C {devices/lab_pin.sym} 79810 -9610 0 0 {name=p79582 lab=_84417_/D }
C {devices/lab_pin.sym} 79990 -9630 0 1 {name=p79583 lab=_76993_/B }
C {sky130_stdcells/dfxtp_4.sym} 79900 -9620 0 0 {name=X_84417_ }
C {devices/lab_pin.sym} 79820 -9510 0 0 {name=p79584 lab=_50807_/Y }
C {devices/lab_pin.sym} 79820 -9470 0 0 {name=p79585 lab=_50792_/X }
C {devices/lab_pin.sym} 79820 -9430 0 0 {name=p79586 lab=_50808_/Y }
C {devices/lab_pin.sym} 79980 -9470 0 1 {name=p79587 lab=_50809_/Y }
C {sky130_stdcells/a21boi_4.sym} 79900 -9470 0 0 {name=X_50809_ }
C {devices/lab_pin.sym} 79820 -9350 0 0 {name=p79588 lab=_57261_/X }
C {devices/lab_pin.sym} 79820 -9310 0 0 {name=p79589 lab=_57362_/X }
C {devices/lab_pin.sym} 79820 -9270 0 0 {name=p79590 lab=_57364_/X }
C {devices/lab_pin.sym} 79980 -9310 0 1 {name=p79591 lab=_85028_/D }
C {sky130_stdcells/a21o_4.sym} 79900 -9310 0 0 {name=X_57365_ }
C {devices/lab_pin.sym} 79810 -9170 0 0 {name=p79592 lab=_81632_/CLK }
C {devices/lab_pin.sym} 79810 -9150 0 0 {name=p79593 lab=_76564_/X }
C {devices/lab_pin.sym} 79990 -9170 0 1 {name=p79594 lab=_81821_/D }
C {sky130_stdcells/dfxtp_4.sym} 79900 -9160 0 0 {name=X_81629_ }
C {devices/lab_pin.sym} 79810 -9030 0 0 {name=p79595 lab=_87417_/CLK }
C {devices/lab_pin.sym} 79810 -9010 0 0 {name=p79596 lab=_88185_/D }
C {devices/lab_pin.sym} 79990 -9030 0 1 {name=p79597 lab=_88185_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -9020 0 0 {name=X_88185_ }
C {devices/lab_pin.sym} 79860 -8890 0 0 {name=p79598 lab=_42429_/A }
C {devices/lab_pin.sym} 79940 -8890 0 1 {name=p79599 lab=_42592_/A }
C {sky130_stdcells/buf_2.sym} 79900 -8890 0 0 {name=X_42591_ }
C {devices/lab_pin.sym} 79820 -8790 0 0 {name=p79600 lab=_54574_/Y }
C {devices/lab_pin.sym} 79820 -8750 0 0 {name=p79601 lab=_54558_/X }
C {devices/lab_pin.sym} 79820 -8710 0 0 {name=p79602 lab=_54576_/X }
C {devices/lab_pin.sym} 79980 -8750 0 1 {name=p79603 lab=_54577_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -8750 0 0 {name=X_54577_ }
C {devices/lab_pin.sym} 79810 -8610 0 0 {name=p79604 lab=_85492_/CLK }
C {devices/lab_pin.sym} 79810 -8590 0 0 {name=p79605 lab=_54686_/Y }
C {devices/lab_pin.sym} 79990 -8610 0 1 {name=p79606 lab=_85397_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -8600 0 0 {name=X_85397_ }
C {devices/lab_pin.sym} 79860 -8470 0 0 {name=p79607 lab=_51789_/A }
C {devices/lab_pin.sym} 79940 -8470 0 1 {name=p79608 lab=_51789_/X }
C {sky130_stdcells/buf_2.sym} 79900 -8470 0 0 {name=X_51789_ }
C {devices/lab_pin.sym} 79820 -8370 0 0 {name=p79609 lab=_58858_/X }
C {devices/lab_pin.sym} 79820 -8330 0 0 {name=p79610 lab=_85432_/Q }
C {devices/lab_pin.sym} 79820 -8290 0 0 {name=p79611 lab=_59103_/X }
C {devices/lab_pin.sym} 79980 -8330 0 1 {name=p79612 lab=_59104_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -8330 0 0 {name=X_59104_ }
C {devices/lab_pin.sym} 79860 -8190 0 0 {name=p79613 lab=_44381_/A }
C {devices/lab_pin.sym} 79940 -8190 0 1 {name=p79614 lab=_44330_/X }
C {sky130_stdcells/buf_2.sym} 79900 -8190 0 0 {name=X_44330_ }
C {devices/lab_pin.sym} 79820 -8090 0 0 {name=p79615 lab=_56060_/X }
C {devices/lab_pin.sym} 79820 -8050 0 0 {name=p79616 lab=_56305_/X }
C {devices/lab_pin.sym} 79820 -8010 0 0 {name=p79617 lab=_56315_/Y }
C {devices/lab_pin.sym} 79980 -8050 0 1 {name=p79618 lab=_56316_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -8050 0 0 {name=X_56316_ }
C {devices/lab_pin.sym} 79840 -7920 0 0 {name=p79619 lab=_80775_/Q }
C {devices/lab_pin.sym} 79840 -7880 0 0 {name=p79620 lab=_81031_/D }
C {devices/lab_pin.sym} 79960 -7900 0 1 {name=p79621 lab=_80743_/D }
C {sky130_stdcells/xor2_4.sym} 79900 -7900 0 0 {name=X_75150_ }
C {devices/lab_pin.sym} 79810 -7770 0 0 {name=p79622 lab=_87137_/CLK }
C {devices/lab_pin.sym} 79810 -7750 0 0 {name=p79623 lab=_44387_/Y }
C {devices/lab_pin.sym} 79990 -7770 0 1 {name=p79624 lab=_87136_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -7760 0 0 {name=X_87136_ }
C {devices/lab_pin.sym} 79860 -7630 0 0 {name=p79625 lab=_40413_/X }
C {devices/lab_pin.sym} 79940 -7630 0 1 {name=p79626 lab=_41604_/A }
C {sky130_stdcells/buf_2.sym} 79900 -7630 0 0 {name=X_41542_ }
C {devices/lab_pin.sym} 79820 -7530 0 0 {name=p79627 lab=_85619_/Q }
C {devices/lab_pin.sym} 79820 -7490 0 0 {name=p79628 lab=_53506_/X }
C {devices/lab_pin.sym} 79820 -7450 0 0 {name=p79629 lab=_53527_/Y }
C {devices/lab_pin.sym} 79980 -7490 0 1 {name=p79630 lab=_53528_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -7490 0 0 {name=X_53528_ }
C {devices/lab_pin.sym} 79860 -7350 0 0 {name=p79631 lab=_64591_/X }
C {devices/lab_pin.sym} 79940 -7350 0 1 {name=p79632 lab=_72362_/X }
C {sky130_stdcells/buf_2.sym} 79900 -7350 0 0 {name=X_72362_ }
C {devices/lab_pin.sym} 79810 -7230 0 0 {name=p79633 lab=_83227_/CLK }
C {devices/lab_pin.sym} 79810 -7210 0 0 {name=p79634 lab=_63163_/X }
C {devices/lab_pin.sym} 79990 -7230 0 1 {name=p79635 lab=_79372_/A }
C {sky130_stdcells/dfxtp_4.sym} 79900 -7220 0 0 {name=X_84348_ }
C {devices/lab_pin.sym} 79820 -7130 0 0 {name=p79636 lab=_56766_/X }
C {devices/lab_pin.sym} 79820 -7090 0 0 {name=p79637 lab=_56782_/X }
C {devices/lab_pin.sym} 79820 -7050 0 0 {name=p79638 lab=_56735_/X }
C {devices/lab_pin.sym} 79820 -7010 0 0 {name=p79639 lab=_57319_/D }
C {devices/lab_pin.sym} 79820 -6980 0 0 {name=p79640 lab=_56733_/X }
C {devices/lab_pin.sym} 79980 -7050 0 1 {name=p79641 lab=_57296_/Y }
C {sky130_stdcells/a41oi_4.sym} 79900 -7050 0 0 {name=X_57296_ }
C {devices/lab_pin.sym} 79820 -6910 0 0 {name=p79642 lab=_44727_/Y }
C {devices/lab_pin.sym} 79820 -6870 0 0 {name=p79643 lab=_73491_/X }
C {devices/lab_pin.sym} 79820 -6830 0 0 {name=p79644 lab=_74100_/Y }
C {devices/lab_pin.sym} 79980 -6870 0 1 {name=p79645 lab=_74102_/B }
C {sky130_stdcells/a21o_4.sym} 79900 -6870 0 0 {name=X_74101_ }
C {devices/lab_pin.sym} 79820 -6750 0 0 {name=p79646 lab=_59033_/X }
C {devices/lab_pin.sym} 79820 -6710 0 0 {name=p79647 lab=_85438_/Q }
C {devices/lab_pin.sym} 79820 -6670 0 0 {name=p79648 lab=_59034_/X }
C {devices/lab_pin.sym} 79980 -6710 0 1 {name=p79649 lab=_59035_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -6710 0 0 {name=X_59035_ }
C {devices/lab_pin.sym} 79860 -6570 0 0 {name=p79650 lab=_70400_/A }
C {devices/lab_pin.sym} 79940 -6570 0 1 {name=p79651 lab=_71313_/X }
C {sky130_stdcells/buf_2.sym} 79900 -6570 0 0 {name=X_71313_ }
C {devices/lab_pin.sym} 79860 -6450 0 0 {name=p79652 lab=_64642_/A }
C {devices/lab_pin.sym} 79940 -6450 0 1 {name=p79653 lab=_44261_/X }
C {sky130_stdcells/buf_2.sym} 79900 -6450 0 0 {name=X_44261_ }
C {devices/lab_pin.sym} 79820 -6350 0 0 {name=p79654 lab=_56114_/X }
C {devices/lab_pin.sym} 79820 -6310 0 0 {name=p79655 lab=_56242_/X }
C {devices/lab_pin.sym} 79820 -6270 0 0 {name=p79656 lab=_56246_/Y }
C {devices/lab_pin.sym} 79980 -6310 0 1 {name=p79657 lab=_56247_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -6310 0 0 {name=X_56247_ }
C {devices/lab_pin.sym} 79840 -6180 0 0 {name=p79658 lab=_80770_/Q }
C {devices/lab_pin.sym} 79840 -6140 0 0 {name=p79659 lab=_81026_/D }
C {devices/lab_pin.sym} 79960 -6160 0 1 {name=p79660 lab=_75081_/X }
C {sky130_stdcells/xor2_4.sym} 79900 -6160 0 0 {name=X_75081_ }
C {devices/lab_pin.sym} 79860 -6030 0 0 {name=p79661 lab=_41472_/X }
C {devices/lab_pin.sym} 79940 -6030 0 1 {name=p79662 lab=_41473_/X }
C {sky130_stdcells/buf_2.sym} 79900 -6030 0 0 {name=X_41473_ }
C {devices/lab_pin.sym} 79810 -5910 0 0 {name=p79663 lab=_88327_/CLK }
C {devices/lab_pin.sym} 79810 -5890 0 0 {name=p79664 lab=_87067_/D }
C {devices/lab_pin.sym} 79990 -5910 0 1 {name=p79665 lab=_87067_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -5900 0 0 {name=X_87067_ }
C {devices/lab_pin.sym} 79820 -5790 0 0 {name=p79666 lab=_53454_/Y }
C {devices/lab_pin.sym} 79820 -5750 0 0 {name=p79667 lab=_53455_/X }
C {devices/lab_pin.sym} 79820 -5710 0 0 {name=p79668 lab=_53458_/Y }
C {devices/lab_pin.sym} 79980 -5750 0 1 {name=p79669 lab=_53459_/Y }
C {sky130_stdcells/a21boi_4.sym} 79900 -5750 0 0 {name=X_53459_ }
C {devices/lab_pin.sym} 79820 -5630 0 0 {name=p79670 lab=_72289_/Y }
C {devices/lab_pin.sym} 79820 -5590 0 0 {name=p79671 lab=_72291_/Y }
C {devices/lab_pin.sym} 79820 -5550 0 0 {name=p79672 lab=_72292_/X }
C {devices/lab_pin.sym} 79980 -5590 0 1 {name=p79673 lab=_72293_/X }
C {sky130_stdcells/a21o_4.sym} 79900 -5590 0 0 {name=X_72293_ }
C {devices/lab_pin.sym} 79810 -5450 0 0 {name=p79674 lab=_84273_/CLK }
C {devices/lab_pin.sym} 79810 -5430 0 0 {name=p79675 lab=_84279_/D }
C {devices/lab_pin.sym} 79990 -5450 0 1 {name=p79676 lab=_64037_/C }
C {sky130_stdcells/dfxtp_4.sym} 79900 -5440 0 0 {name=X_84279_ }
C {devices/lab_pin.sym} 79860 -5310 0 0 {name=p79677 lab=_45999_/Y }
C {devices/lab_pin.sym} 79940 -5310 0 1 {name=p79678 lab=_86821_/D }
C {sky130_stdcells/inv_2.sym} 79900 -5310 0 0 {name=X_46000_ }
C {devices/lab_pin.sym} 79860 -5190 0 0 {name=p79679 lab=_43212_/A }
C {devices/lab_pin.sym} 79940 -5190 0 1 {name=p79680 lab=_43212_/X }
C {sky130_stdcells/buf_2.sym} 79900 -5190 0 0 {name=X_43212_ }
C {devices/lab_pin.sym} 79820 -5100 0 0 {name=p79681 lab=_68859_/B }
C {devices/lab_pin.sym} 79820 -5060 0 0 {name=p79682 lab=_73891_/X }
C {devices/lab_pin.sym} 79820 -5020 0 0 {name=p79683 lab=_73962_/X }
C {devices/lab_pin.sym} 79820 -4980 0 0 {name=p79684 lab=_74031_/Y }
C {devices/lab_pin.sym} 79980 -5040 0 1 {name=p79685 lab=_74032_/X }
C {sky130_stdcells/a211o_4.sym} 79900 -5040 0 0 {name=X_74032_ }
C {devices/lab_pin.sym} 79810 -4890 0 0 {name=p79686 lab=_85953_/CLK }
C {devices/lab_pin.sym} 79810 -4870 0 0 {name=p79687 lab=_51397_/Y }
C {devices/lab_pin.sym} 79990 -4890 0 1 {name=p79688 lab=_65413_/B }
C {sky130_stdcells/dfxtp_4.sym} 79900 -4880 0 0 {name=X_86018_ }
C {devices/lab_pin.sym} 79840 -4760 0 0 {name=p79689 lab=_82327_/Q }
C {devices/lab_pin.sym} 79840 -4720 0 0 {name=p79690 lab=_40907_/B }
C {devices/lab_pin.sym} 79960 -4740 0 1 {name=p79691 lab=_40424_/X }
C {sky130_stdcells/or2_4.sym} 79900 -4740 0 0 {name=X_40424_ }
C {devices/lab_pin.sym} 79820 -4630 0 0 {name=p79692 lab=_57489_/B }
C {devices/lab_pin.sym} 79820 -4590 0 0 {name=p79693 lab=_71239_/X }
C {devices/lab_pin.sym} 79820 -4550 0 0 {name=p79694 lab=_71243_/Y }
C {devices/lab_pin.sym} 79980 -4590 0 1 {name=p79695 lab=_71244_/Y }
C {sky130_stdcells/o21ai_4.sym} 79900 -4590 0 0 {name=X_71244_ }
C {devices/lab_pin.sym} 79860 -4450 0 0 {name=p79696 lab=_72838_/A }
C {devices/lab_pin.sym} 79940 -4450 0 1 {name=p79697 lab=_72745_/A }
C {sky130_stdcells/inv_2.sym} 79900 -4450 0 0 {name=X_44192_ }
C {devices/lab_pin.sym} 79840 -4340 0 0 {name=p79698 lab=_56175_/Y }
C {devices/lab_pin.sym} 79840 -4300 0 0 {name=p79699 lab=_56178_/B }
C {devices/lab_pin.sym} 79960 -4320 0 1 {name=p79700 lab=_56178_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -4320 0 0 {name=X_56178_ }
C {devices/lab_pin.sym} 79820 -4230 0 0 {name=p79701 lab=_43129_/X }
C {devices/lab_pin.sym} 79820 -4190 0 0 {name=p79702 lab=_43130_/X }
C {devices/lab_pin.sym} 79820 -4150 0 0 {name=p79703 lab=_40820_/X }
C {devices/lab_pin.sym} 79820 -4110 0 0 {name=p79704 lab=_43141_/Y }
C {devices/lab_pin.sym} 79820 -4070 0 0 {name=p79705 lab=_43142_/X }
C {devices/lab_pin.sym} 79980 -4150 0 1 {name=p79706 lab=_87560_/D }
C {sky130_stdcells/o32ai_4.sym} 79900 -4150 0 0 {name=X_43143_ }
C {devices/lab_pin.sym} 79860 -3990 0 0 {name=p79707 lab=_55129_/A }
C {devices/lab_pin.sym} 79940 -3990 0 1 {name=p79708 lab=_55149_/A }
C {sky130_stdcells/buf_2.sym} 79900 -3990 0 0 {name=X_55129_ }
C {devices/lab_pin.sym} 79840 -3880 0 0 {name=p79709 lab=_78840_/A }
C {devices/lab_pin.sym} 79840 -3840 0 0 {name=p79710 lab=_78839_/X }
C {devices/lab_pin.sym} 79960 -3860 0 1 {name=p79711 lab=_78874_/A }
C {sky130_stdcells/xnor2_4.sym} 79900 -3860 0 0 {name=X_78840_ }
C {devices/lab_pin.sym} 79860 -3730 0 0 {name=p79712 lab=_40354_/X }
C {devices/lab_pin.sym} 79940 -3730 0 1 {name=p79713 lab=_40355_/X }
C {sky130_stdcells/buf_2.sym} 79900 -3730 0 0 {name=X_40355_ }
C {devices/lab_pin.sym} 79860 -3610 0 0 {name=p79714 lab=clkbuf_9_403_0_CLK/X }
C {devices/lab_pin.sym} 79940 -3610 0 1 {name=p79715 lab=_82563_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 79900 -3610 0 0 {name=Xclkbuf_10_807_0_CLK }
C {devices/lab_pin.sym} 79840 -3520 0 0 {name=p79716 lab=_71175_/A }
C {devices/lab_pin.sym} 79840 -3480 0 0 {name=p79717 lab=_71173_/B }
C {devices/lab_pin.sym} 79840 -3440 0 0 {name=p79718 lab=_71181_/C }
C {devices/lab_pin.sym} 79840 -3400 0 0 {name=p79719 lab=_71178_/D }
C {devices/lab_pin.sym} 79960 -3460 0 1 {name=p79720 lab=_71175_/Y }
C {sky130_stdcells/nand4_4.sym} 79900 -3460 0 0 {name=X_71175_ }
C {devices/lab_pin.sym} 79820 -3350 0 0 {name=p79721 lab=_83505_/Q }
C {devices/lab_pin.sym} 79820 -3310 0 0 {name=p79722 lab=_83153_/Q }
C {devices/lab_pin.sym} 79820 -3270 0 0 {name=p79723 lab=_83145_/Q }
C {devices/lab_pin.sym} 79820 -3230 0 0 {name=p79724 lab=_83144_/Q }
C {devices/lab_pin.sym} 79820 -3190 0 0 {name=p79725 lab=_70125_/Y }
C {devices/lab_pin.sym} 79980 -3270 0 1 {name=p79726 lab=_70127_/D }
C {sky130_stdcells/a2111oi_4.sym} 79900 -3270 0 0 {name=X_70126_ }
C {devices/lab_pin.sym} 79860 -3110 0 0 {name=p79727 lab=_53514_/B }
C {devices/lab_pin.sym} 79940 -3110 0 1 {name=p79728 lab=_48236_/B }
C {sky130_stdcells/buf_2.sym} 79900 -3110 0 0 {name=X_47951_ }
C {devices/lab_pin.sym} 79860 -2990 0 0 {name=p79729 lab=_43073_/Y }
C {devices/lab_pin.sym} 79940 -2990 0 1 {name=p79730 lab=_87586_/D }
C {sky130_stdcells/inv_2.sym} 79900 -2990 0 0 {name=X_43074_ }
C {devices/lab_pin.sym} 79860 -2870 0 0 {name=p79731 lab=_59936_/X }
C {devices/lab_pin.sym} 79940 -2870 0 1 {name=p79732 lab=_60042_/D }
C {sky130_stdcells/inv_2.sym} 79900 -2870 0 0 {name=X_59937_ }
C {devices/lab_pin.sym} 79860 -2750 0 0 {name=p79733 lab=_78771_/A }
C {devices/lab_pin.sym} 79940 -2750 0 1 {name=p79734 lab=_78772_/A }
C {sky130_stdcells/inv_2.sym} 79900 -2750 0 0 {name=X_78771_ }
C {devices/lab_pin.sym} 79840 -2640 0 0 {name=p79735 lab=_81707_/D }
C {devices/lab_pin.sym} 79840 -2600 0 0 {name=p79736 lab=_75991_/B }
C {devices/lab_pin.sym} 79960 -2620 0 1 {name=p79737 lab=_75986_/A }
C {sky130_stdcells/xor2_4.sym} 79900 -2620 0 0 {name=X_75983_ }
C {devices/lab_pin.sym} 79810 -2490 0 0 {name=p79738 lab=_87210_/CLK }
C {devices/lab_pin.sym} 79810 -2470 0 0 {name=p79739 lab=_87969_/D }
C {devices/lab_pin.sym} 79990 -2490 0 1 {name=p79740 lab=_87969_/Q }
C {sky130_stdcells/dfxtp_4.sym} 79900 -2480 0 0 {name=X_87969_ }
C {devices/lab_pin.sym} 79860 -2350 0 0 {name=p79741 lab=_46902_/A }
C {devices/lab_pin.sym} 79940 -2350 0 1 {name=p79742 lab=_46903_/A }
C {sky130_stdcells/buf_2.sym} 79900 -2350 0 0 {name=X_46902_ }
C {devices/lab_pin.sym} 79860 -2230 0 0 {name=p79743 lab=_42025_/A }
C {devices/lab_pin.sym} 79940 -2230 0 1 {name=p79744 lab=_42025_/X }
C {sky130_stdcells/buf_2.sym} 79900 -2230 0 0 {name=X_42025_ }
C {devices/lab_pin.sym} 79840 -2120 0 0 {name=p79745 lab=_82209_/D }
C {devices/lab_pin.sym} 79840 -2080 0 0 {name=p79746 lab=_77722_/B }
C {devices/lab_pin.sym} 79960 -2100 0 1 {name=p79747 lab=_77724_/A }
C {sky130_stdcells/nand2_4.sym} 79900 -2100 0 0 {name=X_77722_ }
C {devices/lab_pin.sym} 79840 -1980 0 0 {name=p79748 lab=_74942_/A }
C {devices/lab_pin.sym} 79840 -1940 0 0 {name=p79749 lab=_74933_/Y }
C {devices/lab_pin.sym} 79960 -1960 0 1 {name=p79750 lab=_74935_/B }
C {sky130_stdcells/xor2_4.sym} 79900 -1960 0 0 {name=X_74934_ }
C {devices/lab_pin.sym} 79820 -1850 0 0 {name=p79751 lab=_68863_/X }
C {devices/lab_pin.sym} 79820 -1810 0 0 {name=p79752 lab=_68866_/X }
C {devices/lab_pin.sym} 79820 -1770 0 0 {name=p79753 lab=_70044_/X }
C {devices/lab_pin.sym} 79980 -1810 0 1 {name=p79754 lab=_70057_/Y }
C {sky130_stdcells/a21oi_4.sym} 79900 -1810 0 0 {name=X_70057_ }
C {devices/lab_pin.sym} 79840 -1680 0 0 {name=p79755 lab=_47855_/A }
C {devices/lab_pin.sym} 79840 -1640 0 0 {name=p79756 lab=_51954_/B }
C {devices/lab_pin.sym} 79960 -1660 0 1 {name=p79757 lab=_47882_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -1660 0 0 {name=X_47882_ }
C {devices/lab_pin.sym} 79860 -1530 0 0 {name=p79758 lab=_63130_/A }
C {devices/lab_pin.sym} 79940 -1530 0 1 {name=p79759 lab=_59868_/X }
C {sky130_stdcells/buf_2.sym} 79900 -1530 0 0 {name=X_59868_ }
C {devices/lab_pin.sym} 79840 -1420 0 0 {name=p79760 lab=_49607_/X }
C {devices/lab_pin.sym} 79840 -1380 0 0 {name=p79761 lab=_52837_/B }
C {devices/lab_pin.sym} 79960 -1400 0 1 {name=p79762 lab=_49621_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -1400 0 0 {name=X_49621_ }
C {devices/lab_pin.sym} 79860 -1270 0 0 {name=p79763 lab=_52700_/B }
C {devices/lab_pin.sym} 79940 -1270 0 1 {name=p79764 lab=_51008_/B }
C {sky130_stdcells/buf_2.sym} 79900 -1270 0 0 {name=X_46833_ }
C {devices/lab_pin.sym} 79840 -1160 0 0 {name=p79765 lab=_86701_/Q }
C {devices/lab_pin.sym} 79840 -1120 0 0 {name=p79766 lab=_58873_/B }
C {devices/lab_pin.sym} 79960 -1140 0 1 {name=p79767 lab=_58819_/Y }
C {sky130_stdcells/nor2_4.sym} 79900 -1140 0 0 {name=X_58819_ }
C {devices/lab_pin.sym} 79840 -1020 0 0 {name=p79768 lab=_77652_/A }
C {devices/lab_pin.sym} 79840 -980 0 0 {name=p79769 lab=_82110_/D }
C {devices/lab_pin.sym} 79960 -1000 0 1 {name=p79770 lab=_77653_/Y }
C {sky130_stdcells/nand2_4.sym} 79900 -1000 0 0 {name=X_77653_ }
C {devices/lab_pin.sym} 79860 -870 0 0 {name=p79771 lab=_74865_/A }
C {devices/lab_pin.sym} 79940 -870 0 1 {name=p79772 lab=_74865_/Y }
C {sky130_stdcells/inv_2.sym} 79900 -870 0 0 {name=X_74865_ }
C {devices/lab_pin.sym} 79840 -770 0 0 {name=p79773 lab=_59737_/A }
C {devices/lab_pin.sym} 79840 -730 0 0 {name=p79774 lab=_59848_/B }
C {devices/lab_pin.sym} 79840 -690 0 0 {name=p79775 lab=_80464_/A }
C {devices/lab_pin.sym} 79960 -730 0 1 {name=p79776 lab=_59799_/Y }
C {sky130_stdcells/nor3_4.sym} 79900 -730 0 0 {name=X_59799_ }
C {devices/lab_pin.sym} 80780 -42150 0 0 {name=p79777 lab=_76603_/X }
C {devices/lab_pin.sym} 80860 -42150 0 1 {name=p79778 lab=_76604_/Y }
C {sky130_stdcells/inv_2.sym} 80820 -42150 0 0 {name=X_76604_ }
C {devices/lab_pin.sym} 80780 -42030 0 0 {name=p79779 lab=_49416_/A }
C {devices/lab_pin.sym} 80860 -42030 0 1 {name=p79780 lab=_49580_/A }
C {sky130_stdcells/buf_2.sym} 80820 -42030 0 0 {name=X_49552_ }
C {devices/lab_pin.sym} 80760 -41940 0 0 {name=p79781 lab=_61398_/B }
C {devices/lab_pin.sym} 80760 -41900 0 0 {name=p79782 lab=_61795_/B }
C {devices/lab_pin.sym} 80760 -41860 0 0 {name=p79783 lab=_61795_/C }
C {devices/lab_pin.sym} 80760 -41820 0 0 {name=p79784 lab=_61778_/X }
C {devices/lab_pin.sym} 80880 -41880 0 1 {name=p79785 lab=_61830_/Y }
C {sky130_stdcells/nand4_4.sym} 80820 -41880 0 0 {name=X_61830_ }
C {devices/lab_pin.sym} 80740 -41750 0 0 {name=p79786 lab=_73814_/X }
C {devices/lab_pin.sym} 80740 -41710 0 0 {name=p79787 lab=_73815_/Y }
C {devices/lab_pin.sym} 80740 -41670 0 0 {name=p79788 lab=_73720_/X }
C {devices/lab_pin.sym} 80900 -41710 0 1 {name=p79789 lab=_73816_/X }
C {sky130_stdcells/a21o_4.sym} 80820 -41710 0 0 {name=X_73816_ }
C {devices/lab_pin.sym} 80760 -41600 0 0 {name=p79790 lab=_46737_/A }
C {devices/lab_pin.sym} 80760 -41560 0 0 {name=p79791 lab=_46784_/B }
C {devices/lab_pin.sym} 80760 -41520 0 0 {name=p79792 lab=_46784_/C }
C {devices/lab_pin.sym} 80760 -41480 0 0 {name=p79793 lab=_52661_/D }
C {devices/lab_pin.sym} 80880 -41540 0 1 {name=p79794 lab=_46764_/X }
C {sky130_stdcells/and4_4.sym} 80820 -41540 0 0 {name=X_46764_ }
C {devices/lab_pin.sym} 80760 -41410 0 0 {name=p79795 lab=_77584_/A }
C {devices/lab_pin.sym} 80760 -41370 0 0 {name=p79796 lab=_77584_/B }
C {devices/lab_pin.sym} 80760 -41330 0 0 {name=p79797 lab=_77584_/C }
C {devices/lab_pin.sym} 80880 -41370 0 1 {name=p79798 lab=_77584_/X }
C {sky130_stdcells/or3_4.sym} 80820 -41370 0 0 {name=X_77584_ }
C {devices/lab_pin.sym} 80740 -41260 0 0 {name=p79799 lab=_44072_/A }
C {devices/lab_pin.sym} 80740 -41220 0 0 {name=p79800 lab=_43944_/A }
C {devices/lab_pin.sym} 80740 -41180 0 0 {name=p79801 lab=_43945_/A }
C {devices/lab_pin.sym} 80740 -41140 0 0 {name=p79802 lab=_43975_/Y }
C {devices/lab_pin.sym} 80900 -41200 0 1 {name=p79803 lab=_43976_/X }
C {sky130_stdcells/a211o_4.sym} 80820 -41200 0 0 {name=X_43976_ }
C {devices/lab_pin.sym} 80760 -41080 0 0 {name=p79804 lab=_74796_/A }
C {devices/lab_pin.sym} 80760 -41040 0 0 {name=p79805 lab=_74796_/B }
C {devices/lab_pin.sym} 80760 -41000 0 0 {name=p79806 lab=_74796_/C }
C {devices/lab_pin.sym} 80760 -40960 0 0 {name=p79807 lab=_74769_/D }
C {devices/lab_pin.sym} 80880 -41020 0 1 {name=p79808 lab=_74796_/Y }
C {sky130_stdcells/nand4_4.sym} 80820 -41020 0 0 {name=X_74796_ }
C {devices/lab_pin.sym} 80780 -40870 0 0 {name=p79809 lab=_48503_/A }
C {devices/lab_pin.sym} 80860 -40870 0 1 {name=p79810 lab=_74428_/B }
C {sky130_stdcells/inv_2.sym} 80820 -40870 0 0 {name=X_48503_ }
C {devices/lab_pin.sym} 80760 -40760 0 0 {name=p79811 lab=_79336_/B }
C {devices/lab_pin.sym} 80760 -40720 0 0 {name=p79812 lab=_79322_/Y }
C {devices/lab_pin.sym} 80880 -40740 0 1 {name=p79813 lab=_79334_/A }
C {sky130_stdcells/xor2_4.sym} 80820 -40740 0 0 {name=X_79323_ }
C {devices/lab_pin.sym} 80740 -40630 0 0 {name=p79814 lab=_45710_/X }
C {devices/lab_pin.sym} 80740 -40590 0 0 {name=p79815 lab=_45713_/Y }
C {devices/lab_pin.sym} 80740 -40550 0 0 {name=p79816 lab=_45714_/X }
C {devices/lab_pin.sym} 80900 -40590 0 1 {name=p79817 lab=_45715_/Y }
C {sky130_stdcells/a21oi_4.sym} 80820 -40590 0 0 {name=X_45715_ }
C {devices/lab_pin.sym} 80760 -40470 0 0 {name=p79818 lab=_76531_/Y }
C {devices/lab_pin.sym} 80760 -40430 0 0 {name=p79819 lab=_76535_/B }
C {devices/lab_pin.sym} 80760 -40390 0 0 {name=p79820 lab=_76534_/Y }
C {devices/lab_pin.sym} 80880 -40430 0 1 {name=p79821 lab=_76535_/X }
C {sky130_stdcells/or3_4.sym} 80820 -40430 0 0 {name=X_76535_ }
C {devices/lab_pin.sym} 80740 -40330 0 0 {name=p79822 lab=_42916_/X }
C {devices/lab_pin.sym} 80740 -40290 0 0 {name=p79823 lab=_42917_/X }
C {devices/lab_pin.sym} 80740 -40250 0 0 {name=p79824 lab=_41735_/X }
C {devices/lab_pin.sym} 80740 -40210 0 0 {name=p79825 lab=_87647_/Q }
C {devices/lab_pin.sym} 80740 -40170 0 0 {name=p79826 lab=_42905_/X }
C {devices/lab_pin.sym} 80900 -40250 0 1 {name=p79827 lab=_42927_/Y }
C {sky130_stdcells/o32ai_4.sym} 80820 -40250 0 0 {name=X_42927_ }
C {devices/lab_pin.sym} 80760 -40120 0 0 {name=p79828 lab=_49467_/A }
C {devices/lab_pin.sym} 80760 -40080 0 0 {name=p79829 lab=_49500_/B }
C {devices/lab_pin.sym} 80760 -40040 0 0 {name=p79830 lab=_49467_/C }
C {devices/lab_pin.sym} 80760 -40000 0 0 {name=p79831 lab=_52698_/D }
C {devices/lab_pin.sym} 80880 -40060 0 1 {name=p79832 lab=_49483_/X }
C {sky130_stdcells/and4_4.sym} 80820 -40060 0 0 {name=X_49483_ }
