C {sky130_stdcells/buf_2.sym} 89100 -12570 0 0 {name=X_57363_ }
C {devices/lab_pin.sym} 89020 -12480 0 0 {name=p88676 lab=_87024_/Q }
C {devices/lab_pin.sym} 89020 -12440 0 0 {name=p88677 lab=_69153_/X }
C {devices/lab_pin.sym} 89020 -12400 0 0 {name=p88678 lab=_69168_/X }
C {devices/lab_pin.sym} 89020 -12360 0 0 {name=p88679 lab=_69348_/X }
C {devices/lab_pin.sym} 89180 -12420 0 1 {name=p88680 lab=_69349_/X }
C {sky130_stdcells/a211o_4.sym} 89100 -12420 0 0 {name=X_69349_ }
C {devices/lab_pin.sym} 89010 -12270 0 0 {name=p88681 lab=_87417_/CLK }
C {devices/lab_pin.sym} 89010 -12250 0 0 {name=p88682 lab=_41610_/Y }
C {devices/lab_pin.sym} 89190 -12270 0 1 {name=p88683 lab=_88183_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -12260 0 0 {name=X_88183_ }
C {devices/lab_pin.sym} 89060 -12130 0 0 {name=p88684 lab=_54521_/A }
C {devices/lab_pin.sym} 89140 -12130 0 1 {name=p88685 lab=_54585_/B }
C {sky130_stdcells/buf_2.sym} 89100 -12130 0 0 {name=X_54575_ }
C {devices/lab_pin.sym} 89010 -12010 0 0 {name=p88686 lab=_85491_/CLK }
C {devices/lab_pin.sym} 89010 -11990 0 0 {name=p88687 lab=_54696_/Y }
C {devices/lab_pin.sym} 89190 -12010 0 1 {name=p88688 lab=_85395_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -12000 0 0 {name=X_85395_ }
C {devices/lab_pin.sym} 89040 -11900 0 0 {name=p88689 lab=_51794_/A }
C {devices/lab_pin.sym} 89040 -11860 0 0 {name=p88690 lab=_51794_/B }
C {devices/lab_pin.sym} 89040 -11820 0 0 {name=p88691 lab=_51794_/C }
C {devices/lab_pin.sym} 89040 -11780 0 0 {name=p88692 lab=_51787_/D }
C {devices/lab_pin.sym} 89160 -11840 0 1 {name=p88693 lab=_51787_/X }
C {sky130_stdcells/and4_4.sym} 89100 -11840 0 0 {name=X_51787_ }
C {devices/lab_pin.sym} 89060 -11690 0 0 {name=p88694 lab=_84768_/Q }
C {devices/lab_pin.sym} 89140 -11690 0 1 {name=p88695 lab=_59102_/Y }
C {sky130_stdcells/inv_2.sym} 89100 -11690 0 0 {name=X_59102_ }
C {devices/lab_pin.sym} 89020 -11590 0 0 {name=p88696 lab=_56055_/X }
C {devices/lab_pin.sym} 89020 -11550 0 0 {name=p88697 lab=_56305_/X }
C {devices/lab_pin.sym} 89020 -11510 0 0 {name=p88698 lab=_56313_/Y }
C {devices/lab_pin.sym} 89180 -11550 0 1 {name=p88699 lab=_85240_/D }
C {sky130_stdcells/o21ai_4.sym} 89100 -11550 0 0 {name=X_56314_ }
C {devices/lab_pin.sym} 89010 -11410 0 0 {name=p88700 lab=_87888_/CLK }
C {devices/lab_pin.sym} 89010 -11390 0 0 {name=p88701 lab=_87134_/D }
C {devices/lab_pin.sym} 89190 -11410 0 1 {name=p88702 lab=_87134_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -11400 0 0 {name=X_87134_ }
C {devices/lab_pin.sym} 89060 -11270 0 0 {name=p88703 lab=_41336_/X }
C {devices/lab_pin.sym} 89140 -11270 0 1 {name=p88704 lab=_41540_/X }
C {sky130_stdcells/buf_2.sym} 89100 -11270 0 0 {name=X_41540_ }
C {devices/lab_pin.sym} 89020 -11170 0 0 {name=p88705 lab=_53523_/Y }
C {devices/lab_pin.sym} 89020 -11130 0 0 {name=p88706 lab=_53524_/X }
C {devices/lab_pin.sym} 89020 -11090 0 0 {name=p88707 lab=_53525_/Y }
C {devices/lab_pin.sym} 89180 -11130 0 1 {name=p88708 lab=_53526_/Y }
C {sky130_stdcells/a21boi_4.sym} 89100 -11130 0 0 {name=X_53526_ }
C {devices/lab_pin.sym} 89020 -11010 0 0 {name=p88709 lab=_72264_/X }
C {devices/lab_pin.sym} 89020 -10970 0 0 {name=p88710 lab=_85357_/Q }
C {devices/lab_pin.sym} 89020 -10930 0 0 {name=p88711 lab=_72359_/X }
C {devices/lab_pin.sym} 89180 -10970 0 1 {name=p88712 lab=_72360_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -10970 0 0 {name=X_72360_ }
C {devices/lab_pin.sym} 89010 -10830 0 0 {name=p88713 lab=_82253_/CLK }
C {devices/lab_pin.sym} 89010 -10810 0 0 {name=p88714 lab=_84346_/D }
C {devices/lab_pin.sym} 89190 -10830 0 1 {name=p88715 lab=_84346_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -10820 0 0 {name=X_84346_ }
C {devices/lab_pin.sym} 89040 -10700 0 0 {name=p88716 lab=_50738_/A }
C {devices/lab_pin.sym} 89040 -10660 0 0 {name=p88717 lab=_50738_/B }
C {devices/lab_pin.sym} 89160 -10680 0 1 {name=p88718 lab=_50738_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -10680 0 0 {name=X_50738_ }
C {devices/lab_pin.sym} 89020 -10570 0 0 {name=p88719 lab=_57292_/Y }
C {devices/lab_pin.sym} 89020 -10530 0 0 {name=p88720 lab=_57293_/Y }
C {devices/lab_pin.sym} 89020 -10490 0 0 {name=p88721 lab=_57249_/X }
C {devices/lab_pin.sym} 89180 -10530 0 1 {name=p88722 lab=_57295_/B }
C {sky130_stdcells/a21o_4.sym} 89100 -10530 0 0 {name=X_57294_ }
C {devices/lab_pin.sym} 89010 -10390 0 0 {name=p88723 lab=_81330_/CLK }
C {devices/lab_pin.sym} 89010 -10370 0 0 {name=p88724 lab=_81558_/D }
C {devices/lab_pin.sym} 89190 -10390 0 1 {name=p88725 lab=_81514_/D }
C {sky130_stdcells/dfxtp_4.sym} 89100 -10380 0 0 {name=X_81558_ }
C {devices/lab_pin.sym} 89060 -10250 0 0 {name=p88726 lab=_59033_/A }
C {devices/lab_pin.sym} 89140 -10250 0 1 {name=p88727 lab=_59033_/X }
C {sky130_stdcells/buf_2.sym} 89100 -10250 0 0 {name=X_59033_ }
C {devices/lab_pin.sym} 89040 -10150 0 0 {name=p88728 lab=_71500_/A }
C {devices/lab_pin.sym} 89040 -10110 0 0 {name=p88729 lab=_71314_/B }
C {devices/lab_pin.sym} 89040 -10070 0 0 {name=p88730 lab=_71333_/C }
C {devices/lab_pin.sym} 89160 -10110 0 1 {name=p88731 lab=_71311_/Y }
C {sky130_stdcells/nand3_4.sym} 89100 -10110 0 0 {name=X_71311_ }
C {devices/lab_pin.sym} 89060 -9970 0 0 {name=p88732 lab=_56245_/A }
C {devices/lab_pin.sym} 89140 -9970 0 1 {name=p88733 lab=_56253_/B }
C {sky130_stdcells/buf_2.sym} 89100 -9970 0 0 {name=X_56245_ }
C {devices/lab_pin.sym} 89040 -9860 0 0 {name=p88734 lab=_80487_/A }
C {devices/lab_pin.sym} 89040 -9820 0 0 {name=p88735 lab=_80502_/A }
C {devices/lab_pin.sym} 89160 -9840 0 1 {name=p88736 lab=_80509_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -9840 0 0 {name=X_80509_ }
C {devices/lab_pin.sym} 89010 -9710 0 0 {name=p88737 lab=_87063_/CLK }
C {devices/lab_pin.sym} 89010 -9690 0 0 {name=p88738 lab=_87065_/D }
C {devices/lab_pin.sym} 89190 -9710 0 1 {name=p88739 lab=_44531_/A }
C {sky130_stdcells/dfxtp_4.sym} 89100 -9700 0 0 {name=X_87065_ }
C {devices/lab_pin.sym} 89060 -9570 0 0 {name=p88740 lab=_53821_/B }
C {devices/lab_pin.sym} 89140 -9570 0 1 {name=p88741 lab=_53458_/A }
C {sky130_stdcells/buf_2.sym} 89100 -9570 0 0 {name=X_53457_ }
C {devices/lab_pin.sym} 89040 -9460 0 0 {name=p88742 lab=_81182_/Q }
C {devices/lab_pin.sym} 89040 -9420 0 0 {name=p88743 lab=_41471_/B }
C {devices/lab_pin.sym} 89160 -9440 0 1 {name=p88744 lab=_41471_/X }
C {sky130_stdcells/or2_4.sym} 89100 -9440 0 0 {name=X_41471_ }
C {devices/lab_pin.sym} 89020 -9330 0 0 {name=p88745 lab=_72228_/X }
C {devices/lab_pin.sym} 89020 -9290 0 0 {name=p88746 lab=_85971_/Q }
C {devices/lab_pin.sym} 89020 -9250 0 0 {name=p88747 lab=_72290_/X }
C {devices/lab_pin.sym} 89180 -9290 0 1 {name=p88748 lab=_72291_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -9290 0 0 {name=X_72291_ }
C {devices/lab_pin.sym} 89010 -9150 0 0 {name=p88749 lab=_84273_/CLK }
C {devices/lab_pin.sym} 89010 -9130 0 0 {name=p88750 lab=_64075_/Y }
C {devices/lab_pin.sym} 89190 -9150 0 1 {name=p88751 lab=_80040_/B }
C {sky130_stdcells/dfxtp_4.sym} 89100 -9140 0 0 {name=X_84277_ }
C {devices/lab_pin.sym} 89020 -9030 0 0 {name=p88752 lab=_50667_/Y }
C {devices/lab_pin.sym} 89020 -8990 0 0 {name=p88753 lab=_50609_/X }
C {devices/lab_pin.sym} 89020 -8950 0 0 {name=p88754 lab=_50668_/X }
C {devices/lab_pin.sym} 89180 -8990 0 1 {name=p88755 lab=_50669_/Y }
C {sky130_stdcells/a21oi_4.sym} 89100 -8990 0 0 {name=X_50669_ }
C {devices/lab_pin.sym} 89010 -8850 0 0 {name=p88756 lab=_81492_/CLK }
C {devices/lab_pin.sym} 89010 -8830 0 0 {name=p88757 lab=_84057_/Q }
C {devices/lab_pin.sym} 89190 -8850 0 1 {name=p88758 lab=_81489_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -8840 0 0 {name=X_81489_ }
C {devices/lab_pin.sym} 89020 -8740 0 0 {name=p88759 lab=_40955_/X }
C {devices/lab_pin.sym} 89020 -8700 0 0 {name=p88760 lab=_43180_/X }
C {devices/lab_pin.sym} 89020 -8660 0 0 {name=p88761 lab=_87536_/Q }
C {devices/lab_pin.sym} 89020 -8620 0 0 {name=p88762 lab=_43185_/X }
C {devices/lab_pin.sym} 89180 -8680 0 1 {name=p88763 lab=_43210_/X }
C {sky130_stdcells/a2bb2o_4.sym} 89100 -8680 0 0 {name=X_43210_ }
C {devices/lab_pin.sym} 89020 -8550 0 0 {name=p88764 lab=_70109_/Y }
C {devices/lab_pin.sym} 89020 -8510 0 0 {name=p88765 lab=_73939_/X }
C {devices/lab_pin.sym} 89020 -8470 0 0 {name=p88766 lab=_74029_/X }
C {devices/lab_pin.sym} 89180 -8510 0 1 {name=p88767 lab=_83126_/D }
C {sky130_stdcells/o21ai_4.sym} 89100 -8510 0 0 {name=X_74030_ }
C {devices/lab_pin.sym} 89010 -8370 0 0 {name=p88768 lab=_85727_/CLK }
C {devices/lab_pin.sym} 89010 -8350 0 0 {name=p88769 lab=_86016_/D }
C {devices/lab_pin.sym} 89190 -8370 0 1 {name=p88770 lab=_86016_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -8360 0 0 {name=X_86016_ }
C {devices/lab_pin.sym} 89060 -8230 0 0 {name=p88771 lab=_40321_/A }
C {devices/lab_pin.sym} 89140 -8230 0 1 {name=p88772 lab=_40947_/A }
C {sky130_stdcells/buf_2.sym} 89100 -8230 0 0 {name=X_40422_ }
C {devices/lab_pin.sym} 89020 -8130 0 0 {name=p88773 lab=_52406_/Y }
C {devices/lab_pin.sym} 89020 -8090 0 0 {name=p88774 lab=_52390_/X }
C {devices/lab_pin.sym} 89020 -8050 0 0 {name=p88775 lab=_52407_/X }
C {devices/lab_pin.sym} 89180 -8090 0 1 {name=p88776 lab=_52408_/Y }
C {sky130_stdcells/a21oi_4.sym} 89100 -8090 0 0 {name=X_52408_ }
C {devices/lab_pin.sym} 89060 -7950 0 0 {name=p88777 lab=_71225_/A }
C {devices/lab_pin.sym} 89140 -7950 0 1 {name=p88778 lab=_71248_/C }
C {sky130_stdcells/buf_2.sym} 89100 -7950 0 0 {name=X_71242_ }
C {devices/lab_pin.sym} 89010 -7830 0 0 {name=p88779 lab=_83231_/CLK }
C {devices/lab_pin.sym} 89010 -7810 0 0 {name=p88780 lab=_72582_/Y }
C {devices/lab_pin.sym} 89190 -7830 0 1 {name=p88781 lab=_79372_/B }
C {sky130_stdcells/dfxtp_4.sym} 89100 -7820 0 0 {name=X_83228_ }
C {devices/lab_pin.sym} 89060 -7690 0 0 {name=p88782 lab=_44189_/X }
C {devices/lab_pin.sym} 89140 -7690 0 1 {name=p88783 lab=_72899_/A }
C {sky130_stdcells/buf_2.sym} 89100 -7690 0 0 {name=X_44190_ }
C {devices/lab_pin.sym} 89060 -7570 0 0 {name=p88784 lab=_44907_/A }
C {devices/lab_pin.sym} 89140 -7570 0 1 {name=p88785 lab=_56177_/B }
C {sky130_stdcells/buf_2.sym} 89100 -7570 0 0 {name=X_56176_ }
C {devices/lab_pin.sym} 89040 -7480 0 0 {name=p88786 lab=_53371_/A }
C {devices/lab_pin.sym} 89040 -7440 0 0 {name=p88787 lab=_53388_/B }
C {devices/lab_pin.sym} 89040 -7400 0 0 {name=p88788 lab=_53388_/C }
C {devices/lab_pin.sym} 89040 -7360 0 0 {name=p88789 lab=_52872_/D }
C {devices/lab_pin.sym} 89160 -7420 0 1 {name=p88790 lab=_53388_/X }
C {sky130_stdcells/and4_4.sym} 89100 -7420 0 0 {name=X_53388_ }
C {devices/lab_pin.sym} 89060 -7270 0 0 {name=p88791 lab=_43141_/A }
C {devices/lab_pin.sym} 89140 -7270 0 1 {name=p88792 lab=_43141_/Y }
C {sky130_stdcells/inv_2.sym} 89100 -7270 0 0 {name=X_43141_ }
C {devices/lab_pin.sym} 89060 -7150 0 0 {name=p88793 lab=_80665_/Q }
C {devices/lab_pin.sym} 89140 -7150 0 1 {name=p88794 lab=_55128_/A }
C {sky130_stdcells/buf_2.sym} 89100 -7150 0 0 {name=X_55127_ }
C {devices/lab_pin.sym} 89020 -7050 0 0 {name=p88795 lab=_46725_/A }
C {devices/lab_pin.sym} 89020 -7010 0 0 {name=p88796 lab=_74458_/A }
C {devices/lab_pin.sym} 89020 -6970 0 0 {name=p88797 lab=_46290_/A }
C {devices/lab_pin.sym} 89180 -7010 0 1 {name=p88798 lab=_40353_/Y }
C {sky130_stdcells/a21oi_4.sym} 89100 -7010 0 0 {name=X_40353_ }
C {devices/lab_pin.sym} 89020 -6890 0 0 {name=p88799 lab=_85842_/Q }
C {devices/lab_pin.sym} 89020 -6850 0 0 {name=p88800 lab=_52324_/X }
C {devices/lab_pin.sym} 89020 -6810 0 0 {name=p88801 lab=_52338_/Y }
C {devices/lab_pin.sym} 89180 -6850 0 1 {name=p88802 lab=_52339_/Y }
C {sky130_stdcells/o21ai_4.sym} 89100 -6850 0 0 {name=X_52339_ }
C {devices/lab_pin.sym} 89040 -6740 0 0 {name=p88803 lab=_71173_/A }
C {devices/lab_pin.sym} 89040 -6700 0 0 {name=p88804 lab=_71173_/B }
C {devices/lab_pin.sym} 89040 -6660 0 0 {name=p88805 lab=_71181_/C }
C {devices/lab_pin.sym} 89040 -6620 0 0 {name=p88806 lab=_71178_/D }
C {devices/lab_pin.sym} 89160 -6680 0 1 {name=p88807 lab=_71173_/Y }
C {sky130_stdcells/nand4_4.sym} 89100 -6680 0 0 {name=X_71173_ }
C {devices/lab_pin.sym} 89010 -6530 0 0 {name=p88808 lab=_85895_/CLK }
C {devices/lab_pin.sym} 89010 -6510 0 0 {name=p88809 lab=_83159_/D }
C {devices/lab_pin.sym} 89190 -6530 0 1 {name=p88810 lab=_83159_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -6520 0 0 {name=X_83159_ }
C {devices/lab_pin.sym} 89060 -6390 0 0 {name=p88811 lab=_83140_/Q }
C {devices/lab_pin.sym} 89140 -6390 0 1 {name=p88812 lab=_70125_/D }
C {sky130_stdcells/inv_2.sym} 89100 -6390 0 0 {name=X_70124_ }
C {devices/lab_pin.sym} 89020 -6290 0 0 {name=p88813 lab=_55055_/Y }
C {devices/lab_pin.sym} 89020 -6250 0 0 {name=p88814 lab=_55050_/X }
C {devices/lab_pin.sym} 89020 -6210 0 0 {name=p88815 lab=_55057_/X }
C {devices/lab_pin.sym} 89180 -6250 0 1 {name=p88816 lab=_85327_/D }
C {sky130_stdcells/a21oi_4.sym} 89100 -6250 0 0 {name=X_55058_ }
C {devices/lab_pin.sym} 89040 -6140 0 0 {name=p88817 lab=_59935_/A }
C {devices/lab_pin.sym} 89040 -6100 0 0 {name=p88818 lab=_62237_/A }
C {devices/lab_pin.sym} 89040 -6060 0 0 {name=p88819 lab=_59973_/A }
C {devices/lab_pin.sym} 89040 -6020 0 0 {name=p88820 lab=_59943_/A }
C {devices/lab_pin.sym} 89160 -6080 0 1 {name=p88821 lab=_59935_/X }
C {sky130_stdcells/and4_4.sym} 89100 -6080 0 0 {name=X_59935_ }
C {devices/lab_pin.sym} 89060 -5930 0 0 {name=p88822 lab=_43146_/A }
C {devices/lab_pin.sym} 89140 -5930 0 1 {name=p88823 lab=_43072_/X }
C {sky130_stdcells/buf_2.sym} 89100 -5930 0 0 {name=X_43072_ }
C {devices/lab_pin.sym} 89040 -5820 0 0 {name=p88824 lab=_75981_/A }
C {devices/lab_pin.sym} 89040 -5780 0 0 {name=p88825 lab=_75980_/Y }
C {devices/lab_pin.sym} 89160 -5800 0 1 {name=p88826 lab=_75982_/B }
C {sky130_stdcells/xor2_4.sym} 89100 -5800 0 0 {name=X_75981_ }
C {devices/lab_pin.sym} 89010 -5670 0 0 {name=p88827 lab=_87720_/CLK }
C {devices/lab_pin.sym} 89010 -5650 0 0 {name=p88828 lab=_42236_/X }
C {devices/lab_pin.sym} 89190 -5670 0 1 {name=p88829 lab=_87967_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -5660 0 0 {name=X_87967_ }
C {devices/lab_pin.sym} 89040 -5540 0 0 {name=p88830 lab=_46860_/X }
C {devices/lab_pin.sym} 89040 -5500 0 0 {name=p88831 lab=_46899_/X }
C {devices/lab_pin.sym} 89160 -5520 0 1 {name=p88832 lab=_46900_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -5520 0 0 {name=X_46900_ }
C {devices/lab_pin.sym} 89060 -5390 0 0 {name=p88833 lab=_42023_/A }
C {devices/lab_pin.sym} 89140 -5390 0 1 {name=p88834 lab=_42023_/Y }
C {sky130_stdcells/inv_2.sym} 89100 -5390 0 0 {name=X_42023_ }
C {devices/lab_pin.sym} 89040 -5280 0 0 {name=p88835 lab=_53991_/A }
C {devices/lab_pin.sym} 89040 -5240 0 0 {name=p88836 lab=_46411_/A }
C {devices/lab_pin.sym} 89160 -5260 0 1 {name=p88837 lab=_54009_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -5260 0 0 {name=X_54009_ }
C {devices/lab_pin.sym} 89040 -5140 0 0 {name=p88838 lab=_77723_/A }
C {devices/lab_pin.sym} 89040 -5100 0 0 {name=p88839 lab=_77723_/C }
C {devices/lab_pin.sym} 89160 -5120 0 1 {name=p88840 lab=_82209_/D }
C {sky130_stdcells/nand2_4.sym} 89100 -5120 0 0 {name=X_77720_ }
C {devices/lab_pin.sym} 89010 -4990 0 0 {name=p88841 lab=_87141_/CLK }
C {devices/lab_pin.sym} 89010 -4970 0 0 {name=p88842 lab=_86918_/D }
C {devices/lab_pin.sym} 89190 -4990 0 1 {name=p88843 lab=_67929_/B }
C {sky130_stdcells/dfxtp_4.sym} 89100 -4980 0 0 {name=X_86918_ }
C {devices/lab_pin.sym} 89040 -4860 0 0 {name=p88844 lab=_74931_/Y }
C {devices/lab_pin.sym} 89040 -4820 0 0 {name=p88845 lab=_74923_/B }
C {devices/lab_pin.sym} 89160 -4840 0 1 {name=p88846 lab=_74932_/X }
C {sky130_stdcells/and2_4.sym} 89100 -4840 0 0 {name=X_74932_ }
C {devices/lab_pin.sym} 89020 -4730 0 0 {name=p88847 lab=_83862_/Q }
C {devices/lab_pin.sym} 89020 -4690 0 0 {name=p88848 lab=_70048_/X }
C {devices/lab_pin.sym} 89020 -4650 0 0 {name=p88849 lab=_70054_/Y }
C {devices/lab_pin.sym} 89180 -4690 0 1 {name=p88850 lab=_83862_/D }
C {sky130_stdcells/a21bo_4.sym} 89100 -4690 0 0 {name=X_70055_ }
C {devices/lab_pin.sym} 89060 -4550 0 0 {name=p88851 lab=_47880_/A }
C {devices/lab_pin.sym} 89140 -4550 0 1 {name=p88852 lab=_47880_/Y }
C {sky130_stdcells/inv_2.sym} 89100 -4550 0 0 {name=X_47880_ }
C {devices/lab_pin.sym} 89060 -4430 0 0 {name=p88853 lab=_80294_/B }
C {devices/lab_pin.sym} 89140 -4430 0 1 {name=p88854 lab=_59866_/Y }
C {sky130_stdcells/inv_2.sym} 89100 -4430 0 0 {name=X_59866_ }
C {devices/lab_pin.sym} 89010 -4310 0 0 {name=p88855 lab=_87898_/CLK }
C {devices/lab_pin.sym} 89010 -4290 0 0 {name=p88856 lab=_42367_/Y }
C {devices/lab_pin.sym} 89190 -4310 0 1 {name=p88857 lab=_87898_/Q }
C {sky130_stdcells/dfxtp_4.sym} 89100 -4300 0 0 {name=X_87898_ }
C {devices/lab_pin.sym} 89020 -4190 0 0 {name=p88858 lab=_46827_/Y }
C {devices/lab_pin.sym} 89020 -4150 0 0 {name=p88859 lab=_46798_/X }
C {devices/lab_pin.sym} 89020 -4110 0 0 {name=p88860 lab=_46830_/X }
C {devices/lab_pin.sym} 89180 -4150 0 1 {name=p88861 lab=_86699_/D }
C {sky130_stdcells/a21oi_4.sym} 89100 -4150 0 0 {name=X_46831_ }
C {devices/lab_pin.sym} 89020 -4040 0 0 {name=p88862 lab=_84798_/Q }
C {devices/lab_pin.sym} 89020 -4000 0 0 {name=p88863 lab=_58725_/X }
C {devices/lab_pin.sym} 89020 -3960 0 0 {name=p88864 lab=_58808_/X }
C {devices/lab_pin.sym} 89020 -3920 0 0 {name=p88865 lab=_58816_/X }
C {devices/lab_pin.sym} 89180 -3980 0 1 {name=p88866 lab=_84798_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 89100 -3980 0 0 {name=X_58817_ }
C {devices/lab_pin.sym} 89060 -3830 0 0 {name=p88867 lab=_82238_/Q }
C {devices/lab_pin.sym} 89140 -3830 0 1 {name=p88868 lab=_77655_/A }
C {sky130_stdcells/inv_2.sym} 89100 -3830 0 0 {name=X_77651_ }
C {devices/lab_pin.sym} 89040 -3720 0 0 {name=p88869 lab=_80932_/Q }
C {devices/lab_pin.sym} 89040 -3680 0 0 {name=p88870 lab=_74863_/B }
C {devices/lab_pin.sym} 89160 -3700 0 1 {name=p88871 lab=_81213_/D }
C {sky130_stdcells/xnor2_4.sym} 89100 -3700 0 0 {name=X_74863_ }
C {devices/lab_pin.sym} 89010 -3570 0 0 {name=p88872 lab=_84420_/CLK }
C {devices/lab_pin.sym} 89010 -3550 0 0 {name=p88873 lab=_45866_/Y }
C {devices/lab_pin.sym} 89190 -3570 0 1 {name=p88874 lab=_63342_/B }
C {sky130_stdcells/dfxtp_4.sym} 89100 -3560 0 0 {name=X_86849_ }
C {devices/lab_pin.sym} 89040 -3440 0 0 {name=p88875 lab=_59797_/A }
C {devices/lab_pin.sym} 89040 -3400 0 0 {name=p88876 lab=_59797_/B }
C {devices/lab_pin.sym} 89160 -3420 0 1 {name=p88877 lab=_59797_/Y }
C {sky130_stdcells/nor2_4.sym} 89100 -3420 0 0 {name=X_59797_ }
C {devices/lab_pin.sym} 89040 -3310 0 0 {name=p88878 lab=_76597_/X }
C {devices/lab_pin.sym} 89040 -3270 0 0 {name=p88879 lab=_76602_/B }
C {devices/lab_pin.sym} 89040 -3230 0 0 {name=p88880 lab=_76598_/Y }
C {devices/lab_pin.sym} 89160 -3270 0 1 {name=p88881 lab=_76602_/Y }
C {sky130_stdcells/nand3_4.sym} 89100 -3270 0 0 {name=X_76602_ }
C {devices/lab_pin.sym} 89020 -3150 0 0 {name=p88882 lab=_49547_/Y }
C {devices/lab_pin.sym} 89020 -3110 0 0 {name=p88883 lab=_49541_/X }
C {devices/lab_pin.sym} 89020 -3070 0 0 {name=p88884 lab=_49549_/X }
C {devices/lab_pin.sym} 89180 -3110 0 1 {name=p88885 lab=_86367_/D }
C {sky130_stdcells/a21oi_4.sym} 89100 -3110 0 0 {name=X_49550_ }
C {devices/lab_pin.sym} 89020 -2990 0 0 {name=p88886 lab=_73815_/B }
C {devices/lab_pin.sym} 89020 -2950 0 0 {name=p88887 lab=_73815_/C }
C {devices/lab_pin.sym} 89020 -2910 0 0 {name=p88888 lab=_73813_/X }
C {devices/lab_pin.sym} 89180 -2950 0 1 {name=p88889 lab=_73814_/X }
C {sky130_stdcells/a21o_4.sym} 89100 -2950 0 0 {name=X_73814_ }
C {devices/lab_pin.sym} 89060 -2810 0 0 {name=p88890 lab=_46762_/A }
C {devices/lab_pin.sym} 89140 -2810 0 1 {name=p88891 lab=_54353_/D }
C {sky130_stdcells/inv_2.sym} 89100 -2810 0 0 {name=X_46762_ }
C {devices/lab_pin.sym} 89060 -2690 0 0 {name=p88892 lab=_58864_/A }
C {devices/lab_pin.sym} 89140 -2690 0 1 {name=p88893 lab=_58748_/X }
C {sky130_stdcells/buf_2.sym} 89100 -2690 0 0 {name=X_58748_ }
C {devices/lab_pin.sym} 89040 -2580 0 0 {name=p88894 lab=_77582_/A }
C {devices/lab_pin.sym} 89040 -2540 0 0 {name=p88895 lab=_82118_/Q }
C {devices/lab_pin.sym} 89160 -2560 0 1 {name=p88896 lab=_77583_/A }
C {sky130_stdcells/nand2_4.sym} 89100 -2560 0 0 {name=X_77582_ }
C {devices/lab_pin.sym} 89060 -2430 0 0 {name=p88897 lab=_87169_/Q }
C {devices/lab_pin.sym} 89140 -2430 0 1 {name=p88898 lab=_43975_/B }
C {sky130_stdcells/inv_2.sym} 89100 -2430 0 0 {name=X_43974_ }
C {devices/lab_pin.sym} 89040 -2330 0 0 {name=p88899 lab=_74723_/X }
C {devices/lab_pin.sym} 89040 -2290 0 0 {name=p88900 lab=_74794_/B }
C {devices/lab_pin.sym} 89040 -2250 0 0 {name=p88901 lab=_74780_/D }
C {devices/lab_pin.sym} 89160 -2290 0 1 {name=p88902 lab=_74794_/Y }
C {sky130_stdcells/nand3_4.sym} 89100 -2290 0 0 {name=X_74794_ }
C {devices/lab_pin.sym} 89040 -2170 0 0 {name=p88903 lab=_52161_/A }
C {devices/lab_pin.sym} 89040 -2130 0 0 {name=p88904 lab=_48500_/X }
C {devices/lab_pin.sym} 89040 -2090 0 0 {name=p88905 lab=_48533_/C }
C {devices/lab_pin.sym} 89160 -2130 0 1 {name=p88906 lab=_48501_/X }
C {sky130_stdcells/and3_4.sym} 89100 -2130 0 0 {name=X_48501_ }
C {devices/lab_pin.sym} 89040 -2000 0 0 {name=p88907 lab=_79321_/A }
C {devices/lab_pin.sym} 89040 -1960 0 0 {name=p88908 lab=_79321_/B }
C {devices/lab_pin.sym} 89160 -1980 0 1 {name=p88909 lab=_79322_/B }
C {sky130_stdcells/xor2_4.sym} 89100 -1980 0 0 {name=X_79321_ }
C {devices/lab_pin.sym} 89040 -1860 0 0 {name=p88910 lab=_45713_/A }
C {devices/lab_pin.sym} 89040 -1820 0 0 {name=p88911 lab=_45746_/B }
C {devices/lab_pin.sym} 89160 -1840 0 1 {name=p88912 lab=_45713_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -1840 0 0 {name=X_45713_ }
C {devices/lab_pin.sym} 89040 -1720 0 0 {name=p88913 lab=_81276_/Q }
C {devices/lab_pin.sym} 89040 -1680 0 0 {name=p88914 lab=_76533_/B }
C {devices/lab_pin.sym} 89160 -1700 0 1 {name=p88915 lab=_76533_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -1700 0 0 {name=X_76533_ }
C {devices/lab_pin.sym} 89020 -1600 0 0 {name=p88916 lab=_41727_/X }
C {devices/lab_pin.sym} 89020 -1560 0 0 {name=p88917 lab=_42920_/X }
C {devices/lab_pin.sym} 89020 -1520 0 0 {name=p88918 lab=_87649_/Q }
C {devices/lab_pin.sym} 89020 -1480 0 0 {name=p88919 lab=_42922_/X }
C {devices/lab_pin.sym} 89180 -1540 0 1 {name=p88920 lab=_87649_/D }
C {sky130_stdcells/a2bb2o_4.sym} 89100 -1540 0 0 {name=X_42925_ }
C {devices/lab_pin.sym} 89040 -1400 0 0 {name=p88921 lab=_49481_/A }
C {devices/lab_pin.sym} 89040 -1360 0 0 {name=p88922 lab=_51003_/B }
C {devices/lab_pin.sym} 89160 -1380 0 1 {name=p88923 lab=_49481_/Y }
C {sky130_stdcells/nand2_4.sym} 89100 -1380 0 0 {name=X_49481_ }
C {devices/lab_pin.sym} 89040 -1260 0 0 {name=p88924 lab=_57523_/B }
C {devices/lab_pin.sym} 89040 -1220 0 0 {name=p88925 lab=_73745_/B }
C {devices/lab_pin.sym} 89160 -1240 0 1 {name=p88926 lab=_73745_/X }
C {sky130_stdcells/xor2_4.sym} 89100 -1240 0 0 {name=X_73745_ }
C {devices/lab_pin.sym} 89060 -1110 0 0 {name=p88927 lab=_54309_/B }
C {devices/lab_pin.sym} 89140 -1110 0 1 {name=p88928 lab=_51791_/B }
C {sky130_stdcells/buf_2.sym} 89100 -1110 0 0 {name=X_46693_ }
C {devices/lab_pin.sym} 89060 -990 0 0 {name=p88929 lab=_58679_/A }
C {devices/lab_pin.sym} 89140 -990 0 1 {name=p88930 lab=_58679_/X }
C {sky130_stdcells/buf_2.sym} 89100 -990 0 0 {name=X_58679_ }
C {devices/lab_pin.sym} 89040 -890 0 0 {name=p88931 lab=_70969_/A }
C {devices/lab_pin.sym} 89040 -850 0 0 {name=p88932 lab=_71066_/B }
C {devices/lab_pin.sym} 89040 -810 0 0 {name=p88933 lab=_70954_/C }
C {devices/lab_pin.sym} 89160 -850 0 1 {name=p88934 lab=_70957_/Y }
C {sky130_stdcells/nand3_4.sym} 89100 -850 0 0 {name=X_70957_ }
C {devices/lab_pin.sym} 89020 -730 0 0 {name=p88935 lab=_48425_/Y }
C {devices/lab_pin.sym} 89020 -690 0 0 {name=p88936 lab=_48383_/X }
C {devices/lab_pin.sym} 89020 -650 0 0 {name=p88937 lab=_48431_/X }
C {devices/lab_pin.sym} 89180 -690 0 1 {name=p88938 lab=_48432_/Y }
C {sky130_stdcells/a21oi_4.sym} 89100 -690 0 0 {name=X_48432_ }
C {devices/lab_pin.sym} 89960 -42160 0 0 {name=p88939 lab=_60713_/A }
C {devices/lab_pin.sym} 89960 -42120 0 0 {name=p88940 lab=_60659_/A }
C {devices/lab_pin.sym} 90080 -42140 0 1 {name=p88941 lab=_60722_/A }
C {sky130_stdcells/nor2_4.sym} 90020 -42140 0 0 {name=X_60710_ }
C {devices/lab_pin.sym} 89940 -42030 0 0 {name=p88942 lab=_79224_/B }
C {devices/lab_pin.sym} 89940 -41990 0 0 {name=p88943 lab=_79240_/Y }
C {devices/lab_pin.sym} 89940 -41950 0 0 {name=p88944 lab=_79238_/Y }
C {devices/lab_pin.sym} 90100 -41990 0 1 {name=p88945 lab=_79252_/Y }
C {sky130_stdcells/a21boi_4.sym} 90020 -41990 0 0 {name=X_79252_ }
C {devices/lab_pin.sym} 89980 -41850 0 0 {name=p88946 lab=_45720_/A }
C {devices/lab_pin.sym} 90060 -41850 0 1 {name=p88947 lab=_45644_/X }
C {sky130_stdcells/buf_2.sym} 90020 -41850 0 0 {name=X_45644_ }
C {devices/lab_pin.sym} 89960 -41740 0 0 {name=p88948 lab=_76482_/B }
C {devices/lab_pin.sym} 89960 -41700 0 0 {name=p88949 lab=_76463_/X }
C {devices/lab_pin.sym} 90080 -41720 0 1 {name=p88950 lab=_76464_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -41720 0 0 {name=X_76464_ }
C {devices/lab_pin.sym} 89940 -41630 0 0 {name=p88951 lab=_42847_/X }
C {devices/lab_pin.sym} 89940 -41590 0 0 {name=p88952 lab=_42849_/X }
C {devices/lab_pin.sym} 89940 -41550 0 0 {name=p88953 lab=_41536_/X }
C {devices/lab_pin.sym} 89940 -41510 0 0 {name=p88954 lab=_66927_/B }
C {devices/lab_pin.sym} 89940 -41470 0 0 {name=p88955 lab=_42836_/X }
C {devices/lab_pin.sym} 90100 -41550 0 1 {name=p88956 lab=_42856_/Y }
C {sky130_stdcells/o32ai_4.sym} 90020 -41550 0 0 {name=X_42856_ }
C {devices/lab_pin.sym} 89960 -41410 0 0 {name=p88957 lab=_61690_/A }
C {devices/lab_pin.sym} 89960 -41370 0 0 {name=p88958 lab=_61690_/B }
C {devices/lab_pin.sym} 89960 -41330 0 0 {name=p88959 lab=_61690_/C }
C {devices/lab_pin.sym} 90080 -41370 0 1 {name=p88960 lab=_61690_/Y }
C {sky130_stdcells/nor3_4.sym} 90020 -41370 0 0 {name=X_61690_ }
C {devices/lab_pin.sym} 89940 -41260 0 0 {name=p88961 lab=_68491_/B }
C {devices/lab_pin.sym} 89940 -41220 0 0 {name=p88962 lab=_73674_/X }
C {devices/lab_pin.sym} 89940 -41180 0 0 {name=p88963 lab=_73344_/X }
C {devices/lab_pin.sym} 89940 -41140 0 0 {name=p88964 lab=_73675_/Y }
C {devices/lab_pin.sym} 90100 -41200 0 1 {name=p88965 lab=_73676_/X }
C {sky130_stdcells/a211o_4.sym} 90020 -41200 0 0 {name=X_73676_ }
C {devices/lab_pin.sym} 89960 -41080 0 0 {name=p88966 lab=_70860_/A }
C {devices/lab_pin.sym} 89960 -41040 0 0 {name=p88967 lab=_70890_/B }
C {devices/lab_pin.sym} 89960 -41000 0 0 {name=p88968 lab=_70890_/C }
C {devices/lab_pin.sym} 89960 -40960 0 0 {name=p88969 lab=_70890_/D }
C {devices/lab_pin.sym} 90080 -41020 0 1 {name=p88970 lab=_70888_/Y }
C {sky130_stdcells/nand4_4.sym} 90020 -41020 0 0 {name=X_70888_ }
C {devices/lab_pin.sym} 89960 -40880 0 0 {name=p88971 lab=_78203_/A }
C {devices/lab_pin.sym} 89960 -40840 0 0 {name=p88972 lab=_82492_/Q }
C {devices/lab_pin.sym} 90080 -40860 0 1 {name=p88973 lab=_78220_/A }
C {sky130_stdcells/xor2_4.sym} 90020 -40860 0 0 {name=X_78203_ }
C {devices/lab_pin.sym} 89940 -40750 0 0 {name=p88974 lab=_75396_/A }
C {devices/lab_pin.sym} 89940 -40710 0 0 {name=p88975 lab=_75393_/Y }
C {devices/lab_pin.sym} 89940 -40670 0 0 {name=p88976 lab=_75394_/Y }
C {devices/lab_pin.sym} 90100 -40710 0 1 {name=p88977 lab=_75416_/A }
C {sky130_stdcells/o21a_4.sym} 90020 -40710 0 0 {name=X_75415_ }
C {devices/lab_pin.sym} 89940 -40600 0 0 {name=p88978 lab=_40391_/X }
C {devices/lab_pin.sym} 89940 -40560 0 0 {name=p88979 lab=_41799_/X }
C {devices/lab_pin.sym} 89940 -40520 0 0 {name=p88980 lab=_66683_/B }
C {devices/lab_pin.sym} 89940 -40480 0 0 {name=p88981 lab=_41800_/X }
C {devices/lab_pin.sym} 90100 -40540 0 1 {name=p88982 lab=_88143_/D }
C {sky130_stdcells/a2bb2o_4.sym} 90020 -40540 0 0 {name=X_41807_ }
C {devices/lab_pin.sym} 89980 -40390 0 0 {name=p88983 lab=_74366_/A }
C {devices/lab_pin.sym} 90060 -40390 0 1 {name=p88984 lab=_53620_/A }
C {sky130_stdcells/buf_2.sym} 90020 -40390 0 0 {name=X_48363_ }
C {devices/lab_pin.sym} 89980 -40270 0 0 {name=p88985 lab=_60641_/A }
C {devices/lab_pin.sym} 90060 -40270 0 1 {name=p88986 lab=_60642_/C }
C {sky130_stdcells/inv_2.sym} 90020 -40270 0 0 {name=X_60641_ }
C {devices/lab_pin.sym} 89940 -40190 0 0 {name=p88987 lab=_60069_/Y }
C {devices/lab_pin.sym} 89940 -40150 0 0 {name=p88988 lab=_72583_/Y }
C {devices/lab_pin.sym} 89940 -40110 0 0 {name=p88989 lab=_72625_/X }
C {devices/lab_pin.sym} 89940 -40070 0 0 {name=p88990 lab=_61079_/Y }
C {devices/lab_pin.sym} 89940 -40040 0 0 {name=p88991 lab=_72626_/Y }
C {devices/lab_pin.sym} 90100 -40110 0 1 {name=p88992 lab=_72627_/Y }
C {sky130_stdcells/a41oi_4.sym} 90020 -40110 0 0 {name=X_72627_ }
C {devices/lab_pin.sym} 89960 -39960 0 0 {name=p88993 lab=_79183_/A }
C {devices/lab_pin.sym} 89960 -39920 0 0 {name=p88994 lab=_79183_/B }
C {devices/lab_pin.sym} 90080 -39940 0 1 {name=p88995 lab=_79185_/B }
C {sky130_stdcells/nand2_4.sym} 90020 -39940 0 0 {name=X_79183_ }
C {devices/lab_pin.sym} 89960 -39820 0 0 {name=p88996 lab=_45575_/A }
C {devices/lab_pin.sym} 89960 -39780 0 0 {name=p88997 lab=_45604_/B }
C {devices/lab_pin.sym} 90080 -39800 0 1 {name=p88998 lab=_45575_/Y }
C {sky130_stdcells/nor2_4.sym} 90020 -39800 0 0 {name=X_45575_ }
C {devices/lab_pin.sym} 89980 -39670 0 0 {name=p88999 lab=_81651_/Q }
C {devices/lab_pin.sym} 90060 -39670 0 1 {name=p89000 lab=_76395_/Y }
C {sky130_stdcells/inv_2.sym} 90020 -39670 0 0 {name=X_76395_ }
C {devices/lab_pin.sym} 89980 -39550 0 0 {name=p89001 lab=_42745_/A }
C {devices/lab_pin.sym} 90060 -39550 0 1 {name=p89002 lab=_42787_/X }
C {sky130_stdcells/buf_2.sym} 90020 -39550 0 0 {name=X_42787_ }
C {devices/lab_pin.sym} 89980 -39430 0 0 {name=p89003 lab=_47313_/Y }
C {devices/lab_pin.sym} 90060 -39430 0 1 {name=p89004 lab=_52979_/B }
C {sky130_stdcells/buf_2.sym} 90020 -39430 0 0 {name=X_47314_ }
C {devices/lab_pin.sym} 89960 -39320 0 0 {name=p89005 lab=_78125_/Y }
C {devices/lab_pin.sym} 89960 -39280 0 0 {name=p89006 lab=_78134_/B }
C {devices/lab_pin.sym} 90080 -39300 0 1 {name=p89007 lab=_78134_/Y }
C {sky130_stdcells/nor2_4.sym} 90020 -39300 0 0 {name=X_78134_ }
C {devices/lab_pin.sym} 89980 -39170 0 0 {name=p89008 lab=_87066_/Q }
C {devices/lab_pin.sym} 90060 -39170 0 1 {name=p89009 lab=_44526_/Y }
C {sky130_stdcells/inv_2.sym} 90020 -39170 0 0 {name=X_44526_ }
C {devices/lab_pin.sym} 89940 -39080 0 0 {name=p89010 lab=_60798_/X }
C {devices/lab_pin.sym} 89940 -39040 0 0 {name=p89011 lab=_63355_/Y }
C {devices/lab_pin.sym} 89940 -39000 0 0 {name=p89012 lab=_63358_/X }
C {devices/lab_pin.sym} 89940 -38960 0 0 {name=p89013 lab=_63359_/Y }
C {devices/lab_pin.sym} 90100 -39020 0 1 {name=p89014 lab=_63360_/X }
C {sky130_stdcells/a211o_4.sym} 90020 -39020 0 0 {name=X_63360_ }
C {devices/lab_pin.sym} 89960 -38880 0 0 {name=p89015 lab=_75346_/A }
C {devices/lab_pin.sym} 89960 -38840 0 0 {name=p89016 lab=_75345_/X }
C {devices/lab_pin.sym} 90080 -38860 0 1 {name=p89017 lab=_80756_/D }
C {sky130_stdcells/xor2_4.sym} 90020 -38860 0 0 {name=X_75346_ }
C {devices/lab_pin.sym} 89980 -38730 0 0 {name=p89018 lab=_41737_/Y }
C {devices/lab_pin.sym} 90060 -38730 0 1 {name=p89019 lab=_88159_/D }
C {sky130_stdcells/inv_2.sym} 90020 -38730 0 0 {name=X_41738_ }
C {devices/lab_pin.sym} 89980 -38610 0 0 {name=p89020 lab=_49223_/A }
C {devices/lab_pin.sym} 90060 -38610 0 1 {name=p89021 lab=_48319_/A }
C {sky130_stdcells/buf_2.sym} 90020 -38610 0 0 {name=X_48294_ }
C {devices/lab_pin.sym} 89960 -38510 0 0 {name=p89022 lab=_60572_/A }
C {devices/lab_pin.sym} 89960 -38470 0 0 {name=p89023 lab=_60572_/B }
C {devices/lab_pin.sym} 89960 -38430 0 0 {name=p89024 lab=_60572_/C }
C {devices/lab_pin.sym} 90080 -38470 0 1 {name=p89025 lab=_60572_/X }
C {sky130_stdcells/and3_4.sym} 90020 -38470 0 0 {name=X_60572_ }
C {devices/lab_pin.sym} 89960 -38350 0 0 {name=p89026 lab=_64561_/A }
C {devices/lab_pin.sym} 89960 -38310 0 0 {name=p89027 lab=_57872_/A }
C {devices/lab_pin.sym} 89960 -38270 0 0 {name=p89028 lab=_79436_/B }
C {devices/lab_pin.sym} 90080 -38310 0 1 {name=p89029 lab=_72558_/X }
C {sky130_stdcells/or3_4.sym} 90020 -38310 0 0 {name=X_72558_ }
C {devices/lab_pin.sym} 89940 -38210 0 0 {name=p89030 lab=_62304_/X }
C {devices/lab_pin.sym} 89940 -38170 0 0 {name=p89031 lab=_62306_/X }
C {devices/lab_pin.sym} 89940 -38130 0 0 {name=p89032 lab=_62310_/Y }
C {devices/lab_pin.sym} 89940 -38090 0 0 {name=p89033 lab=_84915_/Q }
C {devices/lab_pin.sym} 89940 -38050 0 0 {name=p89034 lab=_62300_/X }
C {devices/lab_pin.sym} 90100 -38130 0 1 {name=p89035 lab=_62311_/Y }
C {sky130_stdcells/o32ai_4.sym} 90020 -38130 0 0 {name=X_62311_ }
C {devices/lab_pin.sym} 89940 -37990 0 0 {name=p89036 lab=_57734_/A }
C {devices/lab_pin.sym} 89940 -37950 0 0 {name=p89037 lab=_47240_/X }
C {devices/lab_pin.sym} 89940 -37910 0 0 {name=p89038 lab=_47244_/Y }
C {devices/lab_pin.sym} 90100 -37950 0 1 {name=p89039 lab=_47245_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -37950 0 0 {name=X_47245_ }
C {devices/lab_pin.sym} 89980 -37810 0 0 {name=p89040 lab=_71525_/A }
C {devices/lab_pin.sym} 90060 -37810 0 1 {name=p89041 lab=_71512_/A }
C {sky130_stdcells/buf_2.sym} 90020 -37810 0 0 {name=X_71509_ }
C {devices/lab_pin.sym} 89960 -37700 0 0 {name=p89042 lab=_84570_/Q }
C {devices/lab_pin.sym} 89960 -37660 0 0 {name=p89043 lab=_78065_/B }
C {devices/lab_pin.sym} 90080 -37680 0 1 {name=p89044 lab=_78065_/X }
C {sky130_stdcells/xor2_4.sym} 90020 -37680 0 0 {name=X_78065_ }
C {devices/lab_pin.sym} 89980 -37550 0 0 {name=p89045 lab=_44457_/A }
C {devices/lab_pin.sym} 90060 -37550 0 1 {name=p89046 lab=_44457_/Y }
C {sky130_stdcells/inv_2.sym} 90020 -37550 0 0 {name=X_44457_ }
C {devices/lab_pin.sym} 89960 -37440 0 0 {name=p89047 lab=_75277_/A }
C {devices/lab_pin.sym} 89960 -37400 0 0 {name=p89048 lab=_75276_/Y }
C {devices/lab_pin.sym} 90080 -37420 0 1 {name=p89049 lab=_75303_/B }
C {sky130_stdcells/and2_4.sym} 90020 -37420 0 0 {name=X_75277_ }
C {devices/lab_pin.sym} 89960 -37320 0 0 {name=p89050 lab=_63289_/X }
C {devices/lab_pin.sym} 89960 -37280 0 0 {name=p89051 lab=_84888_/Q }
C {devices/lab_pin.sym} 89960 -37240 0 0 {name=p89052 lab=_63341_/C }
C {devices/lab_pin.sym} 89960 -37200 0 0 {name=p89053 lab=_63332_/D }
C {devices/lab_pin.sym} 90080 -37260 0 1 {name=p89054 lab=_63291_/X }
C {sky130_stdcells/and4_4.sym} 90020 -37260 0 0 {name=X_63291_ }
C {devices/lab_pin.sym} 89940 -37150 0 0 {name=p89055 lab=_41611_/X }
C {devices/lab_pin.sym} 89940 -37110 0 0 {name=p89056 lab=_41613_/X }
C {devices/lab_pin.sym} 89940 -37070 0 0 {name=p89057 lab=_41667_/X }
C {devices/lab_pin.sym} 89940 -37030 0 0 {name=p89058 lab=_88172_/Q }
C {devices/lab_pin.sym} 89940 -36990 0 0 {name=p89059 lab=_41668_/X }
C {devices/lab_pin.sym} 90100 -37070 0 1 {name=p89060 lab=_41670_/A }
C {sky130_stdcells/o32ai_4.sym} 90020 -37070 0 0 {name=X_41669_ }
C {devices/lab_pin.sym} 89940 -36930 0 0 {name=p89061 lab=_72484_/X }
C {devices/lab_pin.sym} 89940 -36890 0 0 {name=p89062 lab=_83384_/Q }
C {devices/lab_pin.sym} 89940 -36850 0 0 {name=p89063 lab=_72488_/Y }
C {devices/lab_pin.sym} 90100 -36890 0 1 {name=p89064 lab=_83248_/D }
C {sky130_stdcells/o21a_4.sym} 90020 -36890 0 0 {name=X_72489_ }
C {devices/lab_pin.sym} 89940 -36780 0 0 {name=p89065 lab=_64797_/X }
C {devices/lab_pin.sym} 89940 -36740 0 0 {name=p89066 lab=_86737_/Q }
C {devices/lab_pin.sym} 89940 -36700 0 0 {name=p89067 lab=_65028_/X }
C {devices/lab_pin.sym} 89940 -36660 0 0 {name=p89068 lab=_65029_/X }
C {devices/lab_pin.sym} 90100 -36720 0 1 {name=p89069 lab=_65031_/B }
C {sky130_stdcells/a211o_4.sym} 90020 -36720 0 0 {name=X_65030_ }
C {devices/lab_pin.sym} 89980 -36570 0 0 {name=p89070 lab=_77017_/B }
C {devices/lab_pin.sym} 90060 -36570 0 1 {name=p89071 lab=_77016_/Y }
C {sky130_stdcells/inv_2.sym} 90020 -36570 0 0 {name=X_77016_ }
C {devices/lab_pin.sym} 89940 -36490 0 0 {name=p89072 lab=_43399_/X }
C {devices/lab_pin.sym} 89940 -36450 0 0 {name=p89073 lab=_43404_/X }
C {devices/lab_pin.sym} 89940 -36410 0 0 {name=p89074 lab=_41498_/X }
C {devices/lab_pin.sym} 89940 -36370 0 0 {name=p89075 lab=_87436_/Q }
C {devices/lab_pin.sym} 89940 -36330 0 0 {name=p89076 lab=_43407_/X }
C {devices/lab_pin.sym} 90100 -36410 0 1 {name=p89077 lab=_43408_/Y }
C {sky130_stdcells/o32ai_4.sym} 90020 -36410 0 0 {name=X_43408_ }
C {devices/lab_pin.sym} 89940 -36270 0 0 {name=p89078 lab=_62240_/Y }
C {devices/lab_pin.sym} 89940 -36230 0 0 {name=p89079 lab=_62166_/X }
C {devices/lab_pin.sym} 89940 -36190 0 0 {name=p89080 lab=_62241_/Y }
C {devices/lab_pin.sym} 90100 -36230 0 1 {name=p89081 lab=_84424_/D }
C {sky130_stdcells/a21oi_4.sym} 90020 -36230 0 0 {name=X_62242_ }
C {devices/lab_pin.sym} 89940 -36110 0 0 {name=p89082 lab=_74225_/X }
C {devices/lab_pin.sym} 89940 -36070 0 0 {name=p89083 lab=_74227_/X }
C {devices/lab_pin.sym} 89940 -36030 0 0 {name=p89084 lab=_73602_/X }
C {devices/lab_pin.sym} 90100 -36070 0 1 {name=p89085 lab=_74228_/X }
C {sky130_stdcells/a21o_4.sym} 90020 -36070 0 0 {name=X_74228_ }
C {devices/lab_pin.sym} 89940 -35950 0 0 {name=p89086 lab=_86662_/Q }
C {devices/lab_pin.sym} 89940 -35910 0 0 {name=p89087 lab=_47145_/X }
C {devices/lab_pin.sym} 89940 -35870 0 0 {name=p89088 lab=_47175_/Y }
C {devices/lab_pin.sym} 90100 -35910 0 1 {name=p89089 lab=_47176_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -35910 0 0 {name=X_47176_ }
C {devices/lab_pin.sym} 89940 -35800 0 0 {name=p89090 lab=_41461_/X }
C {devices/lab_pin.sym} 89940 -35760 0 0 {name=p89091 lab=_44377_/X }
C {devices/lab_pin.sym} 89940 -35720 0 0 {name=p89092 lab=_87135_/Q }
C {devices/lab_pin.sym} 89940 -35680 0 0 {name=p89093 lab=_44379_/X }
C {devices/lab_pin.sym} 90100 -35740 0 1 {name=p89094 lab=_44388_/X }
C {sky130_stdcells/a2bb2o_4.sym} 90020 -35740 0 0 {name=X_44388_ }
C {devices/lab_pin.sym} 89980 -35590 0 0 {name=p89095 lab=_46094_/X }
C {devices/lab_pin.sym} 90060 -35590 0 1 {name=p89096 lab=_46128_/D }
C {sky130_stdcells/inv_2.sym} 90020 -35590 0 0 {name=X_46127_ }
C {devices/lab_pin.sym} 89940 -35500 0 0 {name=p89097 lab=_41302_/X }
C {devices/lab_pin.sym} 89940 -35460 0 0 {name=p89098 lab=_43336_/X }
C {devices/lab_pin.sym} 89940 -35420 0 0 {name=p89099 lab=_87472_/Q }
C {devices/lab_pin.sym} 89940 -35380 0 0 {name=p89100 lab=_43337_/X }
C {devices/lab_pin.sym} 90100 -35440 0 1 {name=p89101 lab=_87472_/D }
C {sky130_stdcells/a2bb2o_4.sym} 90020 -35440 0 0 {name=X_43339_ }
C {devices/lab_pin.sym} 89960 -35320 0 0 {name=p89102 lab=_61682_/B }
C {devices/lab_pin.sym} 89960 -35280 0 0 {name=p89103 lab=_62161_/B }
C {devices/lab_pin.sym} 89960 -35240 0 0 {name=p89104 lab=_62187_/C }
C {devices/lab_pin.sym} 89960 -35200 0 0 {name=p89105 lab=_61706_/X }
C {devices/lab_pin.sym} 90080 -35260 0 1 {name=p89106 lab=_62173_/Y }
C {sky130_stdcells/nand4_4.sym} 90020 -35260 0 0 {name=X_62173_ }
C {devices/lab_pin.sym} 89960 -35120 0 0 {name=p89107 lab=_74154_/X }
C {devices/lab_pin.sym} 89960 -35080 0 0 {name=p89108 lab=_74158_/X }
C {devices/lab_pin.sym} 90080 -35100 0 1 {name=p89109 lab=_74160_/B }
C {sky130_stdcells/nand2_4.sym} 90020 -35100 0 0 {name=X_74159_ }
C {devices/lab_pin.sym} 89980 -34970 0 0 {name=p89110 lab=_64306_/A }
C {devices/lab_pin.sym} 90060 -34970 0 1 {name=p89111 lab=_64525_/B }
C {sky130_stdcells/buf_2.sym} 90020 -34970 0 0 {name=X_61124_ }
C {devices/lab_pin.sym} 89980 -34850 0 0 {name=p89112 lab=_46058_/A }
C {devices/lab_pin.sym} 90060 -34850 0 1 {name=p89113 lab=_86790_/D }
C {sky130_stdcells/inv_2.sym} 90020 -34850 0 0 {name=X_46058_ }
C {devices/lab_pin.sym} 89980 -34730 0 0 {name=p89114 lab=_66625_/A }
C {devices/lab_pin.sym} 90060 -34730 0 1 {name=p89115 lab=_67057_/A }
C {sky130_stdcells/buf_2.sym} 90020 -34730 0 0 {name=X_66981_ }
C {devices/lab_pin.sym} 89960 -34620 0 0 {name=p89116 lab=_82820_/Q }
C {devices/lab_pin.sym} 89960 -34580 0 0 {name=p89117 lab=_82532_/Q }
C {devices/lab_pin.sym} 90080 -34600 0 1 {name=p89118 lab=_78967_/Y }
C {sky130_stdcells/xnor2_4.sym} 90020 -34600 0 0 {name=X_78967_ }
C {devices/lab_pin.sym} 89980 -34470 0 0 {name=p89119 lab=_64284_/B }
C {devices/lab_pin.sym} 90060 -34470 0 1 {name=p89120 lab=_61398_/B }
C {sky130_stdcells/buf_2.sym} 90020 -34470 0 0 {name=X_45009_ }
C {devices/lab_pin.sym} 89940 -34370 0 0 {name=p89121 lab=_68717_/X }
C {devices/lab_pin.sym} 89940 -34330 0 0 {name=p89122 lab=_68719_/X }
C {devices/lab_pin.sym} 89940 -34290 0 0 {name=p89123 lab=_58002_/A }
C {devices/lab_pin.sym} 90100 -34330 0 1 {name=p89124 lab=_68720_/X }
C {sky130_stdcells/a21o_4.sym} 90020 -34330 0 0 {name=X_68720_ }
C {devices/lab_pin.sym} 89960 -34200 0 0 {name=p89125 lab=_65932_/A }
C {devices/lab_pin.sym} 89960 -34160 0 0 {name=p89126 lab=_65932_/B }
C {devices/lab_pin.sym} 90080 -34180 0 1 {name=p89127 lab=_65932_/X }
C {sky130_stdcells/and2_4.sym} 90020 -34180 0 0 {name=X_65932_ }
C {devices/lab_pin.sym} 89960 -34070 0 0 {name=p89128 lab=_61055_/A }
C {devices/lab_pin.sym} 89960 -34030 0 0 {name=p89129 lab=_61000_/X }
C {devices/lab_pin.sym} 89960 -33990 0 0 {name=p89130 lab=_61055_/C }
C {devices/lab_pin.sym} 90080 -34030 0 1 {name=p89131 lab=_61055_/X }
C {sky130_stdcells/or3_4.sym} 90020 -34030 0 0 {name=X_61055_ }
C {devices/lab_pin.sym} 89980 -33890 0 0 {name=p89132 lab=_82071_/Q }
C {devices/lab_pin.sym} 90060 -33890 0 1 {name=p89133 lab=_77920_/A }
C {sky130_stdcells/inv_2.sym} 90020 -33890 0 0 {name=X_77918_ }
C {devices/lab_pin.sym} 89940 -33790 0 0 {name=p89134 lab=_82635_/Q }
C {devices/lab_pin.sym} 89940 -33750 0 0 {name=p89135 lab=_82507_/D }
C {devices/lab_pin.sym} 89940 -33710 0 0 {name=p89136 lab=_78897_/X }
C {devices/lab_pin.sym} 90100 -33750 0 1 {name=p89137 lab=_78898_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -33750 0 0 {name=X_78898_ }
C {devices/lab_pin.sym} 89940 -33640 0 0 {name=p89138 lab=_80186_/A }
C {devices/lab_pin.sym} 89940 -33600 0 0 {name=p89139 lab=_59787_/X }
C {devices/lab_pin.sym} 89940 -33560 0 0 {name=p89140 lab=_60003_/Y }
C {devices/lab_pin.sym} 89940 -33520 0 0 {name=p89141 lab=_60005_/Y }
C {devices/lab_pin.sym} 90100 -33580 0 1 {name=p89142 lab=_60007_/A }
C {sky130_stdcells/a2bb2o_4.sym} 90020 -33580 0 0 {name=X_60006_ }
C {devices/lab_pin.sym} 89980 -33430 0 0 {name=p89143 lab=_49925_/A }
C {devices/lab_pin.sym} 90060 -33430 0 1 {name=p89144 lab=_49830_/A }
C {sky130_stdcells/buf_2.sym} 90020 -33430 0 0 {name=X_49817_ }
C {devices/lab_pin.sym} 89980 -33310 0 0 {name=p89145 lab=_68651_/A }
C {devices/lab_pin.sym} 90060 -33310 0 1 {name=p89146 lab=_68651_/X }
C {sky130_stdcells/buf_2.sym} 90020 -33310 0 0 {name=X_68651_ }
C {devices/lab_pin.sym} 89940 -33210 0 0 {name=p89147 lab=_65858_/X }
C {devices/lab_pin.sym} 89940 -33170 0 0 {name=p89148 lab=_65862_/X }
C {devices/lab_pin.sym} 89940 -33130 0 0 {name=p89149 lab=_65809_/X }
C {devices/lab_pin.sym} 90100 -33170 0 1 {name=p89150 lab=_65863_/X }
C {sky130_stdcells/a21o_4.sym} 90020 -33170 0 0 {name=X_65863_ }
C {devices/lab_pin.sym} 89960 -33040 0 0 {name=p89151 lab=_77849_/A }
C {devices/lab_pin.sym} 89960 -33000 0 0 {name=p89152 lab=_77849_/B }
C {devices/lab_pin.sym} 90080 -33020 0 1 {name=p89153 lab=_77850_/B }
C {sky130_stdcells/xnor2_4.sym} 90020 -33020 0 0 {name=X_77849_ }
C {devices/lab_pin.sym} 89960 -32900 0 0 {name=p89154 lab=_67602_/A }
C {devices/lab_pin.sym} 89960 -32860 0 0 {name=p89155 lab=_67602_/B }
C {devices/lab_pin.sym} 90080 -32880 0 1 {name=p89156 lab=_67602_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -32880 0 0 {name=X_67602_ }
C {devices/lab_pin.sym} 89980 -32750 0 0 {name=p89157 lab=_64939_/A }
C {devices/lab_pin.sym} 90060 -32750 0 1 {name=p89158 lab=_64814_/X }
C {sky130_stdcells/buf_2.sym} 90020 -32750 0 0 {name=X_64814_ }
C {devices/lab_pin.sym} 89960 -32640 0 0 {name=p89159 lab=_49757_/A }
C {devices/lab_pin.sym} 89960 -32600 0 0 {name=p89160 lab=_52965_/B }
C {devices/lab_pin.sym} 90080 -32620 0 1 {name=p89161 lab=_49748_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -32620 0 0 {name=X_49748_ }
C {devices/lab_pin.sym} 89980 -32490 0 0 {name=p89162 lab=clkbuf_9_226_0_CLK/X }
C {devices/lab_pin.sym} 90060 -32490 0 1 {name=p89163 lab=_85697_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 90020 -32490 0 0 {name=Xclkbuf_10_453_0_CLK }
C {devices/lab_pin.sym} 89940 -32400 0 0 {name=p89164 lab=_87095_/Q }
C {devices/lab_pin.sym} 89940 -32360 0 0 {name=p89165 lab=_68580_/X }
C {devices/lab_pin.sym} 89940 -32320 0 0 {name=p89166 lab=_68509_/X }
C {devices/lab_pin.sym} 89940 -32280 0 0 {name=p89167 lab=_68581_/X }
C {devices/lab_pin.sym} 90100 -32340 0 1 {name=p89168 lab=_68582_/X }
C {sky130_stdcells/a211o_4.sym} 90020 -32340 0 0 {name=X_68582_ }
C {devices/lab_pin.sym} 89930 -32190 0 0 {name=p89169 lab=_80740_/CLK }
C {devices/lab_pin.sym} 89930 -32170 0 0 {name=p89170 lab=_80892_/Q }
C {devices/lab_pin.sym} 90110 -32190 0 1 {name=p89171 lab=_75042_/B }
C {sky130_stdcells/dfxtp_4.sym} 90020 -32180 0 0 {name=X_80860_ }
C {devices/lab_pin.sym} 89960 -32060 0 0 {name=p89172 lab=_65779_/A }
C {devices/lab_pin.sym} 89960 -32020 0 0 {name=p89173 lab=_86473_/Q }
C {devices/lab_pin.sym} 90080 -32040 0 1 {name=p89174 lab=_65794_/X }
C {sky130_stdcells/and2_4.sym} 90020 -32040 0 0 {name=X_65794_ }
C {devices/lab_pin.sym} 89980 -31910 0 0 {name=p89175 lab=_67055_/X }
C {devices/lab_pin.sym} 90060 -31910 0 1 {name=p89176 lab=_67533_/X }
C {sky130_stdcells/buf_2.sym} 90020 -31910 0 0 {name=X_67533_ }
C {devices/lab_pin.sym} 89980 -31790 0 0 {name=p89177 lab=_79519_/A }
C {devices/lab_pin.sym} 90060 -31790 0 1 {name=p89178 lab=_79520_/B }
C {sky130_stdcells/inv_2.sym} 90020 -31790 0 0 {name=X_79519_ }
C {devices/lab_pin.sym} 89960 -31680 0 0 {name=p89179 lab=_64680_/A }
C {devices/lab_pin.sym} 89960 -31640 0 0 {name=p89180 lab=_64745_/B }
C {devices/lab_pin.sym} 90080 -31660 0 1 {name=p89181 lab=_64745_/X }
C {sky130_stdcells/and2_4.sym} 90020 -31660 0 0 {name=X_64745_ }
C {devices/lab_pin.sym} 89980 -31530 0 0 {name=p89182 lab=_49678_/X }
C {devices/lab_pin.sym} 90060 -31530 0 1 {name=p89183 lab=_49685_/A }
C {sky130_stdcells/buf_2.sym} 90020 -31530 0 0 {name=X_49679_ }
C {devices/lab_pin.sym} 89960 -31440 0 0 {name=p89184 lab=_61957_/A }
C {devices/lab_pin.sym} 89960 -31400 0 0 {name=p89185 lab=_61952_/Y }
C {devices/lab_pin.sym} 89960 -31360 0 0 {name=p89186 lab=_61953_/Y }
C {devices/lab_pin.sym} 89960 -31320 0 0 {name=p89187 lab=_61956_/Y }
C {devices/lab_pin.sym} 90080 -31380 0 1 {name=p89188 lab=_61957_/Y }
C {sky130_stdcells/nand4_4.sym} 90020 -31380 0 0 {name=X_61957_ }
C {devices/lab_pin.sym} 89930 -31230 0 0 {name=p89189 lab=_83973_/CLK }
C {devices/lab_pin.sym} 89930 -31210 0 0 {name=p89190 lab=_80791_/D }
C {devices/lab_pin.sym} 90110 -31230 0 1 {name=p89191 lab=_80791_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -31220 0 0 {name=X_80791_ }
C {devices/lab_pin.sym} 89960 -31120 0 0 {name=p89192 lab=_51709_/X }
C {devices/lab_pin.sym} 89960 -31080 0 0 {name=p89193 lab=_51715_/B }
C {devices/lab_pin.sym} 89960 -31040 0 0 {name=p89194 lab=_51695_/C }
C {devices/lab_pin.sym} 89960 -31000 0 0 {name=p89195 lab=_53234_/D }
C {devices/lab_pin.sym} 90080 -31060 0 1 {name=p89196 lab=_51710_/X }
C {sky130_stdcells/and4_4.sym} 90020 -31060 0 0 {name=X_51710_ }
C {devices/lab_pin.sym} 89930 -30910 0 0 {name=p89197 lab=_82786_/CLK }
C {devices/lab_pin.sym} 89930 -30890 0 0 {name=p89198 lab=_82530_/D }
C {devices/lab_pin.sym} 90110 -30910 0 1 {name=p89199 lab=_78949_/B }
C {sky130_stdcells/dfxtp_4.sym} 90020 -30900 0 0 {name=X_82530_ }
C {devices/lab_pin.sym} 89980 -30770 0 0 {name=p89200 lab=_60908_/A }
C {devices/lab_pin.sym} 90060 -30770 0 1 {name=p89201 lab=_60908_/X }
C {sky130_stdcells/buf_2.sym} 90020 -30770 0 0 {name=X_60908_ }
C {devices/lab_pin.sym} 89940 -30680 0 0 {name=p89202 lab=_87406_/Q }
C {devices/lab_pin.sym} 89940 -30640 0 0 {name=p89203 lab=_67394_/X }
C {devices/lab_pin.sym} 89940 -30600 0 0 {name=p89204 lab=_67462_/X }
C {devices/lab_pin.sym} 89940 -30560 0 0 {name=p89205 lab=_67463_/X }
C {devices/lab_pin.sym} 90100 -30620 0 1 {name=p89206 lab=_67464_/X }
C {sky130_stdcells/a211o_4.sym} 90020 -30620 0 0 {name=X_67464_ }
C {devices/lab_pin.sym} 89960 -30500 0 0 {name=p89207 lab=_52674_/X }
C {devices/lab_pin.sym} 89960 -30460 0 0 {name=p89208 lab=_52694_/B }
C {devices/lab_pin.sym} 89960 -30420 0 0 {name=p89209 lab=_52694_/C }
C {devices/lab_pin.sym} 89960 -30380 0 0 {name=p89210 lab=_46810_/X }
C {devices/lab_pin.sym} 90080 -30440 0 1 {name=p89211 lab=_52690_/X }
C {sky130_stdcells/and4_4.sym} 90020 -30440 0 0 {name=X_52690_ }
C {devices/lab_pin.sym} 89960 -30300 0 0 {name=p89212 lab=_64676_/A }
C {devices/lab_pin.sym} 89960 -30260 0 0 {name=p89213 lab=_85854_/Q }
C {devices/lab_pin.sym} 90080 -30280 0 1 {name=p89214 lab=_64676_/X }
C {sky130_stdcells/and2_4.sym} 90020 -30280 0 0 {name=X_64676_ }
C {devices/lab_pin.sym} 89980 -30150 0 0 {name=p89215 lab=_59668_/B }
C {devices/lab_pin.sym} 90060 -30150 0 1 {name=p89216 lab=_61907_/C }
C {sky130_stdcells/buf_2.sym} 90020 -30150 0 0 {name=X_61888_ }
C {devices/lab_pin.sym} 89960 -30040 0 0 {name=p89217 lab=_69067_/A }
C {devices/lab_pin.sym} 89960 -30000 0 0 {name=p89218 lab=_69203_/B }
C {devices/lab_pin.sym} 90080 -30020 0 1 {name=p89219 lab=_69203_/X }
C {sky130_stdcells/and2_4.sym} 90020 -30020 0 0 {name=X_69203_ }
C {devices/lab_pin.sym} 89960 -29910 0 0 {name=p89220 lab=_66433_/A }
C {devices/lab_pin.sym} 89960 -29870 0 0 {name=p89221 lab=_66415_/B }
C {devices/lab_pin.sym} 89960 -29830 0 0 {name=p89222 lab=_66415_/C }
C {devices/lab_pin.sym} 90080 -29870 0 1 {name=p89223 lab=_66415_/X }
C {sky130_stdcells/and3_4.sym} 90020 -29870 0 0 {name=X_66415_ }
C {devices/lab_pin.sym} 89980 -29730 0 0 {name=p89224 lab=clkbuf_9_234_0_CLK/X }
C {devices/lab_pin.sym} 90060 -29730 0 1 {name=p89225 lab=_85444_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 90020 -29730 0 0 {name=Xclkbuf_10_468_0_CLK }
C {devices/lab_pin.sym} 89960 -29640 0 0 {name=p89226 lab=_51629_/X }
C {devices/lab_pin.sym} 89960 -29600 0 0 {name=p89227 lab=_51651_/B }
C {devices/lab_pin.sym} 89960 -29560 0 0 {name=p89228 lab=_51651_/C }
C {devices/lab_pin.sym} 89960 -29520 0 0 {name=p89229 lab=_53165_/D }
C {devices/lab_pin.sym} 90080 -29580 0 1 {name=p89230 lab=_51641_/X }
C {sky130_stdcells/and4_4.sym} 90020 -29580 0 0 {name=X_51641_ }
C {devices/lab_pin.sym} 89980 -29430 0 0 {name=p89231 lab=_63372_/A }
C {devices/lab_pin.sym} 90060 -29430 0 1 {name=p89232 lab=_63627_/X }
C {sky130_stdcells/buf_2.sym} 90020 -29430 0 0 {name=X_63627_ }
C {devices/lab_pin.sym} 89930 -29310 0 0 {name=p89233 lab=_83514_/CLK }
C {devices/lab_pin.sym} 89930 -29290 0 0 {name=p89234 lab=_79153_/X }
C {devices/lab_pin.sym} 90110 -29310 0 1 {name=p89235 lab=_82429_/D }
C {sky130_stdcells/dfxtp_4.sym} 90020 -29300 0 0 {name=X_82461_ }
C {devices/lab_pin.sym} 89960 -29190 0 0 {name=p89236 lab=_60826_/A }
C {devices/lab_pin.sym} 89960 -29150 0 0 {name=p89237 lab=_60838_/X }
C {devices/lab_pin.sym} 89960 -29110 0 0 {name=p89238 lab=_78049_/A }
C {devices/lab_pin.sym} 90080 -29150 0 1 {name=p89239 lab=_60839_/Y }
C {sky130_stdcells/nor3_4.sym} 90020 -29150 0 0 {name=X_60839_ }
C {devices/lab_pin.sym} 89960 -29020 0 0 {name=p89240 lab=_67320_/A }
C {devices/lab_pin.sym} 89960 -28980 0 0 {name=p89241 lab=_67395_/B }
C {devices/lab_pin.sym} 90080 -29000 0 1 {name=p89242 lab=_67395_/X }
C {sky130_stdcells/and2_4.sym} 90020 -29000 0 0 {name=X_67395_ }
C {devices/lab_pin.sym} 89930 -28870 0 0 {name=p89243 lab=_85315_/CLK }
C {devices/lab_pin.sym} 89930 -28850 0 0 {name=p89244 lab=_84200_/D }
C {devices/lab_pin.sym} 90110 -28870 0 1 {name=p89245 lab=_65449_/C }
C {sky130_stdcells/dfxtp_4.sym} 90020 -28860 0 0 {name=X_84200_ }
C {devices/lab_pin.sym} 89930 -28730 0 0 {name=p89246 lab=_81412_/CLK }
C {devices/lab_pin.sym} 89930 -28710 0 0 {name=p89247 lab=_81412_/D }
C {devices/lab_pin.sym} 90110 -28730 0 1 {name=p89248 lab=_75930_/B }
C {sky130_stdcells/dfxtp_4.sym} 90020 -28720 0 0 {name=X_81412_ }
C {devices/lab_pin.sym} 89960 -28600 0 0 {name=p89249 lab=_69134_/A }
C {devices/lab_pin.sym} 89960 -28560 0 0 {name=p89250 lab=_87795_/Q }
C {devices/lab_pin.sym} 90080 -28580 0 1 {name=p89251 lab=_69134_/X }
C {sky130_stdcells/and2_4.sym} 90020 -28580 0 0 {name=X_69134_ }
C {devices/lab_pin.sym} 89960 -28460 0 0 {name=p89252 lab=_54355_/A }
C {devices/lab_pin.sym} 89960 -28420 0 0 {name=p89253 lab=_52667_/B }
C {devices/lab_pin.sym} 90080 -28440 0 1 {name=p89254 lab=_54360_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -28440 0 0 {name=X_54360_ }
C {devices/lab_pin.sym} 89940 -28330 0 0 {name=p89255 lab=_66342_/Y }
C {devices/lab_pin.sym} 89940 -28290 0 0 {name=p89256 lab=_66343_/X }
C {devices/lab_pin.sym} 89940 -28250 0 0 {name=p89257 lab=_66345_/Y }
C {devices/lab_pin.sym} 90100 -28290 0 1 {name=p89258 lab=_84139_/D }
C {sky130_stdcells/a21o_4.sym} 90020 -28290 0 0 {name=X_66346_ }
C {devices/lab_pin.sym} 89930 -28150 0 0 {name=p89259 lab=_85180_/CLK }
C {devices/lab_pin.sym} 89930 -28130 0 0 {name=p89260 lab=_85180_/D }
C {devices/lab_pin.sym} 90110 -28150 0 1 {name=p89261 lab=_85180_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -28140 0 0 {name=X_85180_ }
C {devices/lab_pin.sym} 89960 -28020 0 0 {name=p89262 lab=_51590_/A }
C {devices/lab_pin.sym} 89960 -27980 0 0 {name=p89263 lab=_53101_/B }
C {devices/lab_pin.sym} 90080 -28000 0 1 {name=p89264 lab=_51572_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -28000 0 0 {name=X_51572_ }
C {devices/lab_pin.sym} 89980 -27870 0 0 {name=p89265 lab=_63436_/A }
C {devices/lab_pin.sym} 90060 -27870 0 1 {name=p89266 lab=_63558_/X }
C {sky130_stdcells/buf_2.sym} 90020 -27870 0 0 {name=X_63558_ }
C {devices/lab_pin.sym} 89930 -27750 0 0 {name=p89267 lab=_83681_/CLK }
C {devices/lab_pin.sym} 89930 -27730 0 0 {name=p89268 lab=_82392_/D }
C {devices/lab_pin.sym} 90110 -27750 0 1 {name=p89269 lab=_82392_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -27740 0 0 {name=X_82392_ }
C {devices/lab_pin.sym} 89980 -27610 0 0 {name=p89270 lab=_53311_/A }
C {devices/lab_pin.sym} 90060 -27610 0 1 {name=p89271 lab=_53330_/A }
C {sky130_stdcells/buf_2.sym} 90020 -27610 0 0 {name=X_53311_ }
C {devices/lab_pin.sym} 89930 -27490 0 0 {name=p89272 lab=_82975_/CLK }
C {devices/lab_pin.sym} 89930 -27470 0 0 {name=p89273 lab=_84131_/D }
C {devices/lab_pin.sym} 90110 -27490 0 1 {name=p89274 lab=_84131_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -27480 0 0 {name=X_84131_ }
C {devices/lab_pin.sym} 89980 -27350 0 0 {name=p89275 lab=_50523_/A }
C {devices/lab_pin.sym} 90060 -27350 0 1 {name=p89276 lab=_51010_/A }
C {sky130_stdcells/buf_2.sym} 90020 -27350 0 0 {name=X_50523_ }
C {devices/lab_pin.sym} 89960 -27260 0 0 {name=p89277 lab=_62570_/A }
C {devices/lab_pin.sym} 89960 -27220 0 0 {name=p89278 lab=_63610_/B }
C {devices/lab_pin.sym} 89960 -27180 0 0 {name=p89279 lab=_62601_/C }
C {devices/lab_pin.sym} 89960 -27140 0 0 {name=p89280 lab=_62463_/X }
C {devices/lab_pin.sym} 90080 -27200 0 1 {name=p89281 lab=_62509_/X }
C {sky130_stdcells/and4_4.sym} 90020 -27200 0 0 {name=X_62509_ }
C {devices/lab_pin.sym} 89930 -27050 0 0 {name=p89282 lab=_83926_/CLK }
C {devices/lab_pin.sym} 89930 -27030 0 0 {name=p89283 lab=_81343_/D }
C {devices/lab_pin.sym} 90110 -27050 0 1 {name=p89284 lab=_81719_/D }
C {sky130_stdcells/dfxtp_4.sym} 90020 -27040 0 0 {name=X_81343_ }
C {devices/lab_pin.sym} 89980 -26910 0 0 {name=p89285 lab=_70009_/A }
C {devices/lab_pin.sym} 90060 -26910 0 1 {name=p89286 lab=_69065_/X }
C {sky130_stdcells/buf_2.sym} 90020 -26910 0 0 {name=X_69065_ }
C {devices/lab_pin.sym} 89980 -26790 0 0 {name=p89287 lab=_54317_/A }
C {devices/lab_pin.sym} 90060 -26790 0 1 {name=p89288 lab=_54312_/C }
C {sky130_stdcells/buf_2.sym} 90020 -26790 0 0 {name=X_54291_ }
C {devices/lab_pin.sym} 89940 -26690 0 0 {name=p89289 lab=_66179_/X }
C {devices/lab_pin.sym} 89940 -26650 0 0 {name=p89290 lab=_66275_/Y }
C {devices/lab_pin.sym} 89940 -26610 0 0 {name=p89291 lab=_66276_/Y }
C {devices/lab_pin.sym} 90100 -26650 0 1 {name=p89292 lab=_66277_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -26650 0 0 {name=X_66277_ }
C {devices/lab_pin.sym} 89960 -26530 0 0 {name=p89293 lab=_63463_/A }
C {devices/lab_pin.sym} 89960 -26490 0 0 {name=p89294 lab=_84959_/Q }
C {devices/lab_pin.sym} 89960 -26450 0 0 {name=p89295 lab=_63476_/C }
C {devices/lab_pin.sym} 90080 -26490 0 1 {name=p89296 lab=_63489_/X }
C {sky130_stdcells/and3_4.sym} 90020 -26490 0 0 {name=X_63489_ }
C {devices/lab_pin.sym} 89960 -26360 0 0 {name=p89297 lab=_74297_/C }
C {devices/lab_pin.sym} 89960 -26320 0 0 {name=p89298 lab=_56030_/B }
C {devices/lab_pin.sym} 90080 -26340 0 1 {name=p89299 lab=_56030_/X }
C {sky130_stdcells/xor2_4.sym} 90020 -26340 0 0 {name=X_56030_ }
C {devices/lab_pin.sym} 89940 -26240 0 0 {name=p89300 lab=_67948_/X }
C {devices/lab_pin.sym} 89940 -26200 0 0 {name=p89301 lab=_68005_/Y }
C {devices/lab_pin.sym} 89940 -26160 0 0 {name=p89302 lab=_67983_/X }
C {devices/lab_pin.sym} 89940 -26120 0 0 {name=p89303 lab=_68015_/Y }
C {devices/lab_pin.sym} 90100 -26180 0 1 {name=p89304 lab=_68016_/X }
C {sky130_stdcells/a211o_4.sym} 90020 -26180 0 0 {name=X_68016_ }
C {devices/lab_pin.sym} 89980 -26030 0 0 {name=p89305 lab=_53189_/A }
C {devices/lab_pin.sym} 90060 -26030 0 1 {name=p89306 lab=_53242_/X }
C {sky130_stdcells/buf_2.sym} 90020 -26030 0 0 {name=X_53242_ }
C {devices/lab_pin.sym} 89940 -25940 0 0 {name=p89307 lab=_65118_/X }
C {devices/lab_pin.sym} 89940 -25900 0 0 {name=p89308 lab=_85545_/Q }
C {devices/lab_pin.sym} 89940 -25860 0 0 {name=p89309 lab=_65146_/X }
C {devices/lab_pin.sym} 89940 -25820 0 0 {name=p89310 lab=_65227_/X }
C {devices/lab_pin.sym} 90100 -25880 0 1 {name=p89311 lab=_65228_/X }
C {sky130_stdcells/a211o_4.sym} 90020 -25880 0 0 {name=X_65228_ }
C {devices/lab_pin.sym} 89930 -25730 0 0 {name=p89312 lab=_82648_/CLK }
C {devices/lab_pin.sym} 89930 -25710 0 0 {name=p89313 lab=_84062_/D }
C {devices/lab_pin.sym} 90110 -25730 0 1 {name=p89314 lab=_81494_/D }
C {sky130_stdcells/dfxtp_4.sym} 90020 -25720 0 0 {name=X_84062_ }
C {devices/lab_pin.sym} 89940 -25610 0 0 {name=p89315 lab=_86197_/Q }
C {devices/lab_pin.sym} 89940 -25570 0 0 {name=p89316 lab=_50437_/X }
C {devices/lab_pin.sym} 89940 -25530 0 0 {name=p89317 lab=_50453_/Y }
C {devices/lab_pin.sym} 90100 -25570 0 1 {name=p89318 lab=_50454_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -25570 0 0 {name=X_50454_ }
C {devices/lab_pin.sym} 89930 -25430 0 0 {name=p89319 lab=_81279_/CLK }
C {devices/lab_pin.sym} 89930 -25410 0 0 {name=p89320 lab=_81306_/Q }
C {devices/lab_pin.sym} 90110 -25430 0 1 {name=p89321 lab=_76503_/A }
C {sky130_stdcells/dfxtp_4.sym} 90020 -25420 0 0 {name=X_81274_ }
C {devices/lab_pin.sym} 89930 -25290 0 0 {name=p89322 lab=_83013_/CLK }
C {devices/lab_pin.sym} 89930 -25270 0 0 {name=p89323 lab=_83013_/D }
C {devices/lab_pin.sym} 90110 -25290 0 1 {name=p89324 lab=_45331_/A }
C {sky130_stdcells/dfxtp_4.sym} 90020 -25280 0 0 {name=X_83013_ }
C {devices/lab_pin.sym} 89960 -25170 0 0 {name=p89325 lab=_80222_/X }
C {devices/lab_pin.sym} 89960 -25130 0 0 {name=p89326 lab=_80225_/B }
C {devices/lab_pin.sym} 89960 -25090 0 0 {name=p89327 lab=_80224_/X }
C {devices/lab_pin.sym} 90080 -25130 0 1 {name=p89328 lab=_80226_/A }
C {sky130_stdcells/and3_4.sym} 90020 -25130 0 0 {name=X_80225_ }
C {devices/lab_pin.sym} 89980 -24990 0 0 {name=p89329 lab=_53199_/A }
C {devices/lab_pin.sym} 90060 -24990 0 1 {name=p89330 lab=_53187_/A }
C {sky130_stdcells/buf_2.sym} 90020 -24990 0 0 {name=X_53173_ }
C {devices/lab_pin.sym} 89960 -24880 0 0 {name=p89331 lab=_65159_/A }
C {devices/lab_pin.sym} 89960 -24840 0 0 {name=p89332 lab=_86252_/Q }
C {devices/lab_pin.sym} 90080 -24860 0 1 {name=p89333 lab=_65159_/X }
C {sky130_stdcells/and2_4.sym} 90020 -24860 0 0 {name=X_65159_ }
C {devices/lab_pin.sym} 89960 -24740 0 0 {name=p89334 lab=_50381_/A }
C {devices/lab_pin.sym} 89960 -24700 0 0 {name=p89335 lab=_50385_/B }
C {devices/lab_pin.sym} 90080 -24720 0 1 {name=p89336 lab=_50385_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -24720 0 0 {name=X_50385_ }
C {devices/lab_pin.sym} 89940 -24610 0 0 {name=p89337 lab=_52122_/Y }
C {devices/lab_pin.sym} 89940 -24570 0 0 {name=p89338 lab=_52117_/X }
C {devices/lab_pin.sym} 89940 -24530 0 0 {name=p89339 lab=_52123_/Y }
C {devices/lab_pin.sym} 90100 -24570 0 1 {name=p89340 lab=_85884_/D }
C {sky130_stdcells/a21boi_4.sym} 90020 -24570 0 0 {name=X_52124_ }
C {devices/lab_pin.sym} 89930 -24430 0 0 {name=p89341 lab=_87821_/CLK }
C {devices/lab_pin.sym} 89930 -24410 0 0 {name=p89342 lab=_42559_/Y }
C {devices/lab_pin.sym} 90110 -24430 0 1 {name=p89343 lab=_87821_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -24420 0 0 {name=X_87821_ }
C {devices/lab_pin.sym} 89980 -24290 0 0 {name=p89344 lab=clkbuf_9_203_0_CLK/X }
C {devices/lab_pin.sym} 90060 -24290 0 1 {name=p89345 lab=_83278_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 90020 -24290 0 0 {name=Xclkbuf_10_406_0_CLK }
C {devices/lab_pin.sym} 89980 -24170 0 0 {name=p89346 lab=_80178_/A }
C {devices/lab_pin.sym} 90060 -24170 0 1 {name=p89347 lab=_80156_/Y }
C {sky130_stdcells/inv_2.sym} 90020 -24170 0 0 {name=X_80156_ }
C {devices/lab_pin.sym} 89980 -24050 0 0 {name=p89348 lab=_58857_/A }
C {devices/lab_pin.sym} 90060 -24050 0 1 {name=p89349 lab=_57981_/X }
C {sky130_stdcells/buf_2.sym} 90020 -24050 0 0 {name=X_57981_ }
C {devices/lab_pin.sym} 89960 -23940 0 0 {name=p89350 lab=_69633_/A }
C {devices/lab_pin.sym} 89960 -23900 0 0 {name=p89351 lab=_69967_/B }
C {devices/lab_pin.sym} 90080 -23920 0 1 {name=p89352 lab=_69967_/X }
C {sky130_stdcells/and2_4.sym} 90020 -23920 0 0 {name=X_69967_ }
C {devices/lab_pin.sym} 89980 -23790 0 0 {name=p89353 lab=_59642_/X }
C {devices/lab_pin.sym} 90060 -23790 0 1 {name=p89354 lab=_59721_/A }
C {sky130_stdcells/buf_2.sym} 90020 -23790 0 0 {name=X_59720_ }
C {devices/lab_pin.sym} 89980 -23670 0 0 {name=p89355 lab=_72838_/A }
C {devices/lab_pin.sym} 90060 -23670 0 1 {name=p89356 lab=_72909_/A }
C {sky130_stdcells/buf_2.sym} 90020 -23670 0 0 {name=X_56932_ }
C {devices/lab_pin.sym} 89940 -23570 0 0 {name=p89357 lab=_52053_/Y }
C {devices/lab_pin.sym} 89940 -23530 0 0 {name=p89358 lab=_52022_/X }
C {devices/lab_pin.sym} 89940 -23490 0 0 {name=p89359 lab=_52054_/Y }
C {devices/lab_pin.sym} 90100 -23530 0 1 {name=p89360 lab=_85898_/D }
C {sky130_stdcells/a21boi_4.sym} 90020 -23530 0 0 {name=X_52055_ }
C {devices/lab_pin.sym} 89960 -23400 0 0 {name=p89361 lab=_68987_/A }
C {devices/lab_pin.sym} 89960 -23360 0 0 {name=p89362 lab=_68918_/B }
C {devices/lab_pin.sym} 90080 -23380 0 1 {name=p89363 lab=_68918_/X }
C {sky130_stdcells/and2_4.sym} 90020 -23380 0 0 {name=X_68918_ }
C {devices/lab_pin.sym} 89930 -23250 0 0 {name=p89364 lab=_88006_/CLK }
C {devices/lab_pin.sym} 89930 -23230 0 0 {name=p89365 lab=_87752_/D }
C {devices/lab_pin.sym} 90110 -23250 0 1 {name=p89366 lab=_87752_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -23240 0 0 {name=X_87752_ }
C {devices/lab_pin.sym} 89930 -23110 0 0 {name=p89367 lab=_86203_/CLK }
C {devices/lab_pin.sym} 89930 -23090 0 0 {name=p89368 lab=_84964_/D }
C {devices/lab_pin.sym} 90110 -23110 0 1 {name=p89369 lab=_84964_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -23100 0 0 {name=X_84964_ }
C {devices/lab_pin.sym} 89960 -22980 0 0 {name=p89370 lab=_80084_/X }
C {devices/lab_pin.sym} 89960 -22940 0 0 {name=p89371 lab=_80087_/B }
C {devices/lab_pin.sym} 90080 -22960 0 1 {name=p89372 lab=_81681_/D }
C {sky130_stdcells/xor2_4.sym} 90020 -22960 0 0 {name=X_80087_ }
C {devices/lab_pin.sym} 89940 -22860 0 0 {name=p89373 lab=_88058_/Q }
C {devices/lab_pin.sym} 89940 -22820 0 0 {name=p89374 lab=_69837_/X }
C {devices/lab_pin.sym} 89940 -22780 0 0 {name=p89375 lab=_69088_/X }
C {devices/lab_pin.sym} 89940 -22740 0 0 {name=p89376 lab=_69897_/Y }
C {devices/lab_pin.sym} 90100 -22800 0 1 {name=p89377 lab=_69898_/X }
C {sky130_stdcells/a211o_4.sym} 90020 -22800 0 0 {name=X_69898_ }
C {devices/lab_pin.sym} 89960 -22680 0 0 {name=p89378 lab=_51018_/A }
C {devices/lab_pin.sym} 89960 -22640 0 0 {name=p89379 lab=_50985_/B }
C {devices/lab_pin.sym} 89960 -22600 0 0 {name=p89380 lab=_51029_/C }
C {devices/lab_pin.sym} 89960 -22560 0 0 {name=p89381 lab=_52698_/D }
C {devices/lab_pin.sym} 90080 -22620 0 1 {name=p89382 lab=_51006_/X }
C {sky130_stdcells/and4_4.sym} 90020 -22620 0 0 {name=X_51006_ }
C {devices/lab_pin.sym} 89930 -22470 0 0 {name=p89383 lab=_86384_/CLK }
C {devices/lab_pin.sym} 89930 -22450 0 0 {name=p89384 lab=_86703_/D }
C {devices/lab_pin.sym} 90110 -22470 0 1 {name=p89385 lab=_86703_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -22460 0 0 {name=X_86703_ }
C {devices/lab_pin.sym} 89960 -22350 0 0 {name=p89386 lab=_59651_/A }
C {devices/lab_pin.sym} 89960 -22310 0 0 {name=p89387 lab=_59651_/B }
C {devices/lab_pin.sym} 89960 -22270 0 0 {name=p89388 lab=_59651_/C }
C {devices/lab_pin.sym} 90080 -22310 0 1 {name=p89389 lab=_59713_/A }
C {sky130_stdcells/nand3_4.sym} 90020 -22310 0 0 {name=X_59651_ }
C {devices/lab_pin.sym} 89930 -22170 0 0 {name=p89390 lab=_80784_/CLK }
C {devices/lab_pin.sym} 89930 -22150 0 0 {name=p89391 lab=_69552_/X }
C {devices/lab_pin.sym} 90110 -22170 0 1 {name=p89392 lab=_83915_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -22160 0 0 {name=X_83915_ }
C {devices/lab_pin.sym} 89980 -22030 0 0 {name=p89393 lab=_56995_/A }
C {devices/lab_pin.sym} 90060 -22030 0 1 {name=p89394 lab=_56863_/X }
C {sky130_stdcells/buf_2.sym} 90020 -22030 0 0 {name=X_56863_ }
C {devices/lab_pin.sym} 89940 -21940 0 0 {name=p89395 lab=_88000_/Q }
C {devices/lab_pin.sym} 89940 -21900 0 0 {name=p89396 lab=_68778_/X }
C {devices/lab_pin.sym} 89940 -21860 0 0 {name=p89397 lab=_68800_/X }
C {devices/lab_pin.sym} 89940 -21820 0 0 {name=p89398 lab=_68848_/X }
C {devices/lab_pin.sym} 90100 -21880 0 1 {name=p89399 lab=_68849_/X }
C {sky130_stdcells/a211o_4.sym} 90020 -21880 0 0 {name=X_68849_ }
C {devices/lab_pin.sym} 89930 -21730 0 0 {name=p89400 lab=_87686_/CLK }
C {devices/lab_pin.sym} 89930 -21710 0 0 {name=p89401 lab=_42860_/Y }
C {devices/lab_pin.sym} 90110 -21730 0 1 {name=p89402 lab=_66959_/B }
C {sky130_stdcells/dfxtp_4.sym} 90020 -21720 0 0 {name=X_87683_ }
C {devices/lab_pin.sym} 89930 -21590 0 0 {name=p89403 lab=_84895_/CLK }
C {devices/lab_pin.sym} 89930 -21570 0 0 {name=p89404 lab=_84895_/D }
C {devices/lab_pin.sym} 90110 -21590 0 1 {name=p89405 lab=_58258_/A }
C {sky130_stdcells/dfxtp_4.sym} 90020 -21580 0 0 {name=X_84895_ }
C {devices/lab_pin.sym} 89980 -21450 0 0 {name=p89406 lab=_58602_/A }
C {devices/lab_pin.sym} 90060 -21450 0 1 {name=p89407 lab=_58603_/A }
C {sky130_stdcells/buf_2.sym} 90020 -21450 0 0 {name=X_58602_ }
C {devices/lab_pin.sym} 89960 -21340 0 0 {name=p89408 lab=_44077_/X }
C {devices/lab_pin.sym} 89960 -21300 0 0 {name=p89409 lab=_55814_/B }
C {devices/lab_pin.sym} 90080 -21320 0 1 {name=p89410 lab=_55814_/X }
C {sky130_stdcells/and2_4.sym} 90020 -21320 0 0 {name=X_55814_ }
C {devices/lab_pin.sym} 89930 -21190 0 0 {name=p89411 lab=_85993_/CLK }
C {devices/lab_pin.sym} 89930 -21170 0 0 {name=p89412 lab=_86634_/D }
C {devices/lab_pin.sym} 90110 -21190 0 1 {name=p89413 lab=_86634_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -21180 0 0 {name=X_86634_ }
C {devices/lab_pin.sym} 89940 -21070 0 0 {name=p89414 lab=_71848_/X }
C {devices/lab_pin.sym} 89940 -21030 0 0 {name=p89415 lab=_83350_/Q }
C {devices/lab_pin.sym} 89940 -20990 0 0 {name=p89416 lab=_71859_/Y }
C {devices/lab_pin.sym} 90100 -21030 0 1 {name=p89417 lab=_83350_/D }
C {sky130_stdcells/a21o_4.sym} 90020 -21030 0 0 {name=X_71860_ }
C {devices/lab_pin.sym} 89960 -20900 0 0 {name=p89418 lab=_59582_/A }
C {devices/lab_pin.sym} 89960 -20860 0 0 {name=p89419 lab=_59582_/B }
C {devices/lab_pin.sym} 90080 -20880 0 1 {name=p89420 lab=_61071_/C }
C {sky130_stdcells/and2_4.sym} 90020 -20880 0 0 {name=X_59582_ }
C {devices/lab_pin.sym} 89930 -20750 0 0 {name=p89421 lab=_83846_/CLK }
C {devices/lab_pin.sym} 89930 -20730 0 0 {name=p89422 lab=_70182_/Y }
C {devices/lab_pin.sym} 90110 -20750 0 1 {name=p89423 lab=_83846_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -20740 0 0 {name=X_83846_ }
C {devices/lab_pin.sym} 89980 -20610 0 0 {name=p89424 lab=clkbuf_8_81_0_CLK/A }
C {devices/lab_pin.sym} 90060 -20610 0 1 {name=p89425 lab=clkbuf_8_80_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 90020 -20610 0 0 {name=Xclkbuf_8_80_0_CLK }
C {devices/lab_pin.sym} 89960 -20510 0 0 {name=p89426 lab=_56653_/Y }
C {devices/lab_pin.sym} 89960 -20470 0 0 {name=p89427 lab=_56651_/Y }
C {devices/lab_pin.sym} 89960 -20430 0 0 {name=p89428 lab=_56721_/D }
C {devices/lab_pin.sym} 90080 -20470 0 1 {name=p89429 lab=_56794_/Y }
C {sky130_stdcells/nor3_4.sym} 90020 -20470 0 0 {name=X_56794_ }
C {devices/lab_pin.sym} 89940 -20350 0 0 {name=p89430 lab=_52885_/B }
C {devices/lab_pin.sym} 89940 -20310 0 0 {name=p89431 lab=_70802_/X }
C {devices/lab_pin.sym} 89940 -20270 0 0 {name=p89432 lab=_70810_/Y }
C {devices/lab_pin.sym} 90100 -20310 0 1 {name=p89433 lab=_70811_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -20310 0 0 {name=X_70811_ }
C {devices/lab_pin.sym} 89960 -20180 0 0 {name=p89434 lab=_58533_/A }
C {devices/lab_pin.sym} 89960 -20140 0 0 {name=p89435 lab=_58532_/X }
C {devices/lab_pin.sym} 90080 -20160 0 1 {name=p89436 lab=_58533_/Y }
C {sky130_stdcells/nor2_4.sym} 90020 -20160 0 0 {name=X_58533_ }
C {devices/lab_pin.sym} 89960 -20060 0 0 {name=p89437 lab=_56167_/B }
C {devices/lab_pin.sym} 89960 -20020 0 0 {name=p89438 lab=_56163_/A }
C {devices/lab_pin.sym} 89960 -19980 0 0 {name=p89439 lab=_56158_/A }
C {devices/lab_pin.sym} 89960 -19940 0 0 {name=p89440 lab=_55745_/D }
C {devices/lab_pin.sym} 90080 -20000 0 1 {name=p89441 lab=_56127_/C }
C {sky130_stdcells/nand4_4.sym} 90020 -20000 0 0 {name=X_55745_ }
C {devices/lab_pin.sym} 89930 -19850 0 0 {name=p89442 lab=_86213_/CLK }
C {devices/lab_pin.sym} 89930 -19830 0 0 {name=p89443 lab=_86565_/D }
C {devices/lab_pin.sym} 90110 -19850 0 1 {name=p89444 lab=_66310_/B }
C {sky130_stdcells/dfxtp_4.sym} 90020 -19840 0 0 {name=X_86565_ }
C {devices/lab_pin.sym} 89980 -19710 0 0 {name=p89445 lab=_53065_/A }
C {devices/lab_pin.sym} 90060 -19710 0 1 {name=p89446 lab=_52957_/X }
C {sky130_stdcells/buf_2.sym} 90020 -19710 0 0 {name=X_52957_ }
C {devices/lab_pin.sym} 89940 -19610 0 0 {name=p89447 lab=_40512_/X }
C {devices/lab_pin.sym} 89940 -19570 0 0 {name=p89448 lab=_41149_/A }
C {devices/lab_pin.sym} 89940 -19530 0 0 {name=p89449 lab=_40970_/X }
C {devices/lab_pin.sym} 90100 -19570 0 1 {name=p89450 lab=_40972_/A }
C {sky130_stdcells/o21a_4.sym} 90020 -19570 0 0 {name=X_40971_ }
C {devices/lab_pin.sym} 89940 -19450 0 0 {name=p89451 lab=_58192_/Y }
C {devices/lab_pin.sym} 89940 -19410 0 0 {name=p89452 lab=_71784_/X }
C {devices/lab_pin.sym} 89940 -19370 0 0 {name=p89453 lab=_71790_/Y }
C {devices/lab_pin.sym} 90100 -19410 0 1 {name=p89454 lab=_71791_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -19410 0 0 {name=X_71791_ }
C {devices/lab_pin.sym} 89930 -19270 0 0 {name=p89455 lab=_86553_/CLK }
C {devices/lab_pin.sym} 89930 -19250 0 0 {name=p89456 lab=_70432_/Y }
C {devices/lab_pin.sym} 90110 -19270 0 1 {name=p89457 lab=_83777_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -19260 0 0 {name=X_83777_ }
C {devices/lab_pin.sym} 89930 -19130 0 0 {name=p89458 lab=_80968_/CLK }
C {devices/lab_pin.sym} 89930 -19110 0 0 {name=p89459 lab=_80989_/D }
C {devices/lab_pin.sym} 90110 -19130 0 1 {name=p89460 lab=_80945_/D }
C {sky130_stdcells/dfxtp_4.sym} 90020 -19120 0 0 {name=X_80989_ }
C {devices/lab_pin.sym} 89930 -18990 0 0 {name=p89461 lab=_86989_/CLK }
C {devices/lab_pin.sym} 89930 -18970 0 0 {name=p89462 lab=_88304_/D }
C {devices/lab_pin.sym} 90110 -18990 0 1 {name=p89463 lab=_88304_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -18980 0 0 {name=X_88304_ }
C {devices/lab_pin.sym} 89980 -18850 0 0 {name=p89464 lab=_42651_/X }
C {devices/lab_pin.sym} 90060 -18850 0 1 {name=p89465 lab=_42710_/X }
C {sky130_stdcells/buf_2.sym} 90020 -18850 0 0 {name=X_42710_ }
C {devices/lab_pin.sym} 89960 -18740 0 0 {name=p89466 lab=_69967_/B }
C {devices/lab_pin.sym} 89960 -18700 0 0 {name=p89467 lab=_73530_/B }
C {devices/lab_pin.sym} 90080 -18720 0 1 {name=p89468 lab=_73530_/Y }
C {sky130_stdcells/nor2_4.sym} 90020 -18720 0 0 {name=X_73530_ }
C {devices/lab_pin.sym} 89930 -18590 0 0 {name=p89469 lab=_85516_/CLK }
C {devices/lab_pin.sym} 89930 -18570 0 0 {name=p89470 lab=_85516_/D }
C {devices/lab_pin.sym} 90110 -18590 0 1 {name=p89471 lab=_85516_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -18580 0 0 {name=X_85516_ }
C {devices/lab_pin.sym} 89940 -18470 0 0 {name=p89472 lab=_85924_/Q }
C {devices/lab_pin.sym} 89940 -18430 0 0 {name=p89473 lab=_51900_/X }
C {devices/lab_pin.sym} 89940 -18390 0 0 {name=p89474 lab=_51907_/Y }
C {devices/lab_pin.sym} 90100 -18430 0 1 {name=p89475 lab=_51908_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -18430 0 0 {name=X_51908_ }
C {devices/lab_pin.sym} 89960 -18300 0 0 {name=p89476 lab=_70740_/A }
C {devices/lab_pin.sym} 89960 -18260 0 0 {name=p89477 lab=_70710_/A }
C {devices/lab_pin.sym} 90080 -18280 0 1 {name=p89478 lab=_70742_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -18280 0 0 {name=X_70742_ }
C {devices/lab_pin.sym} 89930 -18150 0 0 {name=p89479 lab=_84111_/CLK }
C {devices/lab_pin.sym} 89930 -18130 0 0 {name=p89480 lab=_66495_/C }
C {devices/lab_pin.sym} 90110 -18150 0 1 {name=p89481 lab=_78862_/A }
C {sky130_stdcells/dfxtp_4.sym} 90020 -18140 0 0 {name=X_82728_ }
C {devices/lab_pin.sym} 89980 -18010 0 0 {name=p89482 lab=_84842_/Q }
C {devices/lab_pin.sym} 90060 -18010 0 1 {name=p89483 lab=_58465_/A }
C {sky130_stdcells/buf_2.sym} 90020 -18010 0 0 {name=X_58464_ }
C {devices/lab_pin.sym} 89940 -17920 0 0 {name=p89484 lab=_40806_/X }
C {devices/lab_pin.sym} 89940 -17880 0 0 {name=p89485 lab=_43685_/X }
C {devices/lab_pin.sym} 89940 -17840 0 0 {name=p89486 lab=_87307_/Q }
C {devices/lab_pin.sym} 89940 -17800 0 0 {name=p89487 lab=_43686_/X }
C {devices/lab_pin.sym} 90100 -17860 0 1 {name=p89488 lab=_87307_/D }
C {sky130_stdcells/a2bb2o_4.sym} 90020 -17860 0 0 {name=X_43690_ }
C {devices/lab_pin.sym} 89960 -17740 0 0 {name=p89489 lab=_55676_/A }
C {devices/lab_pin.sym} 89960 -17700 0 0 {name=p89490 lab=_55676_/B }
C {devices/lab_pin.sym} 89960 -17660 0 0 {name=p89491 lab=_55676_/C }
C {devices/lab_pin.sym} 89960 -17620 0 0 {name=p89492 lab=_55675_/X }
C {devices/lab_pin.sym} 90080 -17680 0 1 {name=p89493 lab=_55683_/B }
C {sky130_stdcells/and4_4.sym} 90020 -17680 0 0 {name=X_55676_ }
C {devices/lab_pin.sym} 89930 -17530 0 0 {name=p89494 lab=_86490_/CLK }
C {devices/lab_pin.sym} 89930 -17510 0 0 {name=p89495 lab=_86496_/D }
C {devices/lab_pin.sym} 90110 -17530 0 1 {name=p89496 lab=_65441_/B }
C {sky130_stdcells/dfxtp_4.sym} 90020 -17520 0 0 {name=X_86496_ }
C {devices/lab_pin.sym} 89940 -17410 0 0 {name=p89497 lab=_52886_/Y }
C {devices/lab_pin.sym} 89940 -17370 0 0 {name=p89498 lab=_52865_/X }
C {devices/lab_pin.sym} 89940 -17330 0 0 {name=p89499 lab=_52887_/X }
C {devices/lab_pin.sym} 90100 -17370 0 1 {name=p89500 lab=_52888_/Y }
C {sky130_stdcells/a21oi_4.sym} 90020 -17370 0 0 {name=X_52888_ }
C {devices/lab_pin.sym} 89940 -17250 0 0 {name=p89501 lab=_57275_/X }
C {devices/lab_pin.sym} 89940 -17210 0 0 {name=p89502 lab=_57270_/X }
C {devices/lab_pin.sym} 89940 -17170 0 0 {name=p89503 lab=_57414_/X }
C {devices/lab_pin.sym} 90100 -17210 0 1 {name=p89504 lab=_57415_/X }
C {sky130_stdcells/o21a_4.sym} 90020 -17210 0 0 {name=X_57415_ }
C {devices/lab_pin.sym} 89930 -17070 0 0 {name=p89505 lab=_86934_/CLK }
C {devices/lab_pin.sym} 89930 -17050 0 0 {name=p89506 lab=_88235_/D }
C {devices/lab_pin.sym} 90110 -17070 0 1 {name=p89507 lab=_88235_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -17060 0 0 {name=X_88235_ }
C {devices/lab_pin.sym} 89940 -16970 0 0 {name=p89508 lab=_42614_/X }
C {devices/lab_pin.sym} 89940 -16930 0 0 {name=p89509 lab=_42615_/X }
C {devices/lab_pin.sym} 89940 -16890 0 0 {name=p89510 lab=_40959_/X }
C {devices/lab_pin.sym} 89940 -16850 0 0 {name=p89511 lab=_87791_/Q }
C {devices/lab_pin.sym} 89940 -16810 0 0 {name=p89512 lab=_42637_/X }
C {devices/lab_pin.sym} 90100 -16890 0 1 {name=p89513 lab=_42641_/Y }
C {sky130_stdcells/o32ai_4.sym} 90020 -16890 0 0 {name=X_42641_ }
C {devices/lab_pin.sym} 89960 -16740 0 0 {name=p89514 lab=_54636_/A }
C {devices/lab_pin.sym} 89960 -16700 0 0 {name=p89515 lab=_54102_/B }
C {devices/lab_pin.sym} 90080 -16720 0 1 {name=p89516 lab=_54627_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -16720 0 0 {name=X_54627_ }
C {devices/lab_pin.sym} 89980 -16590 0 0 {name=p89517 lab=clkbuf_8_95_0_CLK/A }
C {devices/lab_pin.sym} 90060 -16590 0 1 {name=p89518 lab=clkbuf_8_95_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 90020 -16590 0 0 {name=Xclkbuf_8_95_0_CLK }
C {devices/lab_pin.sym} 89940 -16490 0 0 {name=p89519 lab=_83150_/Q }
C {devices/lab_pin.sym} 89940 -16450 0 0 {name=p89520 lab=_73437_/X }
C {devices/lab_pin.sym} 89940 -16410 0 0 {name=p89521 lab=_73460_/Y }
C {devices/lab_pin.sym} 90100 -16450 0 1 {name=p89522 lab=_83150_/D }
C {sky130_stdcells/a21o_4.sym} 90020 -16450 0 0 {name=X_73461_ }
C {devices/lab_pin.sym} 89930 -16310 0 0 {name=p89523 lab=_85447_/CLK }
C {devices/lab_pin.sym} 89930 -16290 0 0 {name=p89524 lab=_85447_/D }
C {devices/lab_pin.sym} 90110 -16310 0 1 {name=p89525 lab=_85447_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -16300 0 0 {name=X_85447_ }
C {devices/lab_pin.sym} 89940 -16190 0 0 {name=p89526 lab=_51836_/Y }
C {devices/lab_pin.sym} 89940 -16150 0 0 {name=p89527 lab=_51823_/X }
C {devices/lab_pin.sym} 89940 -16110 0 0 {name=p89528 lab=_51838_/X }
C {devices/lab_pin.sym} 90100 -16150 0 1 {name=p89529 lab=_51839_/Y }
C {sky130_stdcells/a21oi_4.sym} 90020 -16150 0 0 {name=X_51839_ }
C {devices/lab_pin.sym} 89960 -16030 0 0 {name=p89530 lab=_70673_/A }
C {devices/lab_pin.sym} 89960 -15990 0 0 {name=p89531 lab=_70676_/B }
C {devices/lab_pin.sym} 89960 -15950 0 0 {name=p89532 lab=_70676_/C }
C {devices/lab_pin.sym} 90080 -15990 0 1 {name=p89533 lab=_70673_/Y }
C {sky130_stdcells/nor3_4.sym} 90020 -15990 0 0 {name=X_70673_ }
C {devices/lab_pin.sym} 89940 -15870 0 0 {name=p89534 lab=_58388_/X }
C {devices/lab_pin.sym} 89940 -15830 0 0 {name=p89535 lab=_83348_/Q }
C {devices/lab_pin.sym} 89940 -15790 0 0 {name=p89536 lab=_58394_/Y }
C {devices/lab_pin.sym} 90100 -15830 0 1 {name=p89537 lab=_58395_/X }
C {sky130_stdcells/o21a_4.sym} 90020 -15830 0 0 {name=X_58395_ }
C {devices/lab_pin.sym} 89930 -15690 0 0 {name=p89538 lab=_82665_/CLK }
C {devices/lab_pin.sym} 89930 -15670 0 0 {name=p89539 lab=_82659_/D }
C {devices/lab_pin.sym} 90110 -15690 0 1 {name=p89540 lab=_82659_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -15680 0 0 {name=X_82659_ }
C {devices/lab_pin.sym} 89960 -15560 0 0 {name=p89541 lab=_75201_/B }
C {devices/lab_pin.sym} 89960 -15520 0 0 {name=p89542 lab=_75201_/A }
C {devices/lab_pin.sym} 90080 -15540 0 1 {name=p89543 lab=_75207_/B }
C {sky130_stdcells/or2_4.sym} 90020 -15540 0 0 {name=X_75200_ }
C {devices/lab_pin.sym} 89940 -15440 0 0 {name=p89544 lab=_83257_/Q }
C {devices/lab_pin.sym} 89940 -15400 0 0 {name=p89545 lab=_72381_/X }
C {devices/lab_pin.sym} 89940 -15360 0 0 {name=p89546 lab=_72406_/X }
C {devices/lab_pin.sym} 89940 -15320 0 0 {name=p89547 lab=_72411_/X }
C {devices/lab_pin.sym} 90100 -15380 0 1 {name=p89548 lab=_83257_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 90020 -15380 0 0 {name=X_72412_ }
C {devices/lab_pin.sym} 89980 -15230 0 0 {name=p89549 lab=_44887_/X }
C {devices/lab_pin.sym} 90060 -15230 0 1 {name=p89550 lab=_45678_/A }
C {sky130_stdcells/buf_2.sym} 90020 -15230 0 0 {name=X_45360_ }
C {devices/lab_pin.sym} 89960 -15130 0 0 {name=p89551 lab=_57318_/D }
C {devices/lab_pin.sym} 89960 -15090 0 0 {name=p89552 lab=_56894_/Y }
C {devices/lab_pin.sym} 89960 -15050 0 0 {name=p89553 lab=_57346_/C }
C {devices/lab_pin.sym} 90080 -15090 0 1 {name=p89554 lab=_57346_/Y }
C {sky130_stdcells/nand3_4.sym} 90020 -15090 0 0 {name=X_57346_ }
C {devices/lab_pin.sym} 89960 -14970 0 0 {name=p89555 lab=_76178_/Y }
C {devices/lab_pin.sym} 89960 -14930 0 0 {name=p89556 lab=_76177_/Y }
C {devices/lab_pin.sym} 89960 -14890 0 0 {name=p89557 lab=_76174_/Y }
C {devices/lab_pin.sym} 90080 -14930 0 1 {name=p89558 lab=_76181_/A }
C {sky130_stdcells/nand3_4.sym} 90020 -14930 0 0 {name=X_76180_ }
C {devices/lab_pin.sym} 89930 -14790 0 0 {name=p89559 lab=_86930_/CLK }
C {devices/lab_pin.sym} 89930 -14770 0 0 {name=p89560 lab=_88166_/D }
C {devices/lab_pin.sym} 90110 -14790 0 1 {name=p89561 lab=_67659_/B }
C {sky130_stdcells/dfxtp_4.sym} 90020 -14780 0 0 {name=X_88166_ }
C {devices/lab_pin.sym} 89980 -14650 0 0 {name=p89562 lab=_54558_/A }
C {devices/lab_pin.sym} 90060 -14650 0 1 {name=p89563 lab=_54558_/X }
C {sky130_stdcells/buf_2.sym} 90020 -14650 0 0 {name=X_54558_ }
C {devices/lab_pin.sym} 89940 -14570 0 0 {name=p89564 lab=_42568_/X }
C {devices/lab_pin.sym} 89940 -14530 0 0 {name=p89565 lab=_42569_/X }
C {devices/lab_pin.sym} 89940 -14490 0 0 {name=p89566 lab=_40820_/X }
C {devices/lab_pin.sym} 89940 -14450 0 0 {name=p89567 lab=_69710_/B }
C {devices/lab_pin.sym} 89940 -14410 0 0 {name=p89568 lab=_42571_/X }
C {devices/lab_pin.sym} 90100 -14490 0 1 {name=p89569 lab=_42572_/Y }
C {sky130_stdcells/o32ai_4.sym} 90020 -14490 0 0 {name=X_42572_ }
C {devices/lab_pin.sym} 89940 -14350 0 0 {name=p89570 lab=_83153_/Q }
C {devices/lab_pin.sym} 89940 -14310 0 0 {name=p89571 lab=_73318_/X }
C {devices/lab_pin.sym} 89940 -14270 0 0 {name=p89572 lab=_73391_/Y }
C {devices/lab_pin.sym} 90100 -14310 0 1 {name=p89573 lab=_83153_/D }
C {sky130_stdcells/a21o_4.sym} 90020 -14310 0 0 {name=X_73392_ }
C {devices/lab_pin.sym} 89930 -14170 0 0 {name=p89574 lab=_85378_/CLK }
C {devices/lab_pin.sym} 89930 -14150 0 0 {name=p89575 lab=_54789_/Y }
C {devices/lab_pin.sym} 90110 -14170 0 1 {name=p89576 lab=_85378_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -14160 0 0 {name=X_85378_ }
C {devices/lab_pin.sym} 89940 -14050 0 0 {name=p89577 lab=_44301_/Y }
C {devices/lab_pin.sym} 89940 -14010 0 0 {name=p89578 lab=_44304_/Y }
C {devices/lab_pin.sym} 89940 -13970 0 0 {name=p89579 lab=_44318_/A }
C {devices/lab_pin.sym} 90100 -14010 0 1 {name=p89580 lab=_44311_/Y }
C {sky130_stdcells/a21oi_4.sym} 90020 -14010 0 0 {name=X_44311_ }
C {devices/lab_pin.sym} 89960 -13890 0 0 {name=p89581 lab=_75129_/Y }
C {devices/lab_pin.sym} 89960 -13850 0 0 {name=p89582 lab=_75126_/X }
C {devices/lab_pin.sym} 89960 -13810 0 0 {name=p89583 lab=_75143_/A }
C {devices/lab_pin.sym} 90080 -13850 0 1 {name=p89584 lab=_75131_/Y }
C {sky130_stdcells/nand3_4.sym} 90020 -13850 0 0 {name=X_75131_ }
C {devices/lab_pin.sym} 89930 -13710 0 0 {name=p89585 lab=_82888_/CLK }
C {devices/lab_pin.sym} 89930 -13690 0 0 {name=p89586 lab=_44420_/X }
C {devices/lab_pin.sym} 90110 -13710 0 1 {name=p89587 lab=_87117_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -13700 0 0 {name=X_87117_ }
C {devices/lab_pin.sym} 89960 -13580 0 0 {name=p89588 lab=_41523_/A }
C {devices/lab_pin.sym} 89960 -13540 0 0 {name=p89589 lab=_41523_/B }
C {devices/lab_pin.sym} 90080 -13560 0 1 {name=p89590 lab=_41523_/X }
C {sky130_stdcells/or2_4.sym} 90020 -13560 0 0 {name=X_41523_ }
C {devices/lab_pin.sym} 89940 -13450 0 0 {name=p89591 lab=_72209_/X }
C {devices/lab_pin.sym} 89940 -13410 0 0 {name=p89592 lab=_85967_/Q }
C {devices/lab_pin.sym} 89940 -13370 0 0 {name=p89593 lab=_72342_/X }
C {devices/lab_pin.sym} 90100 -13410 0 1 {name=p89594 lab=_72343_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -13410 0 0 {name=X_72343_ }
C {devices/lab_pin.sym} 89960 -13280 0 0 {name=p89595 lab=_53509_/A }
C {devices/lab_pin.sym} 89960 -13240 0 0 {name=p89596 lab=_57537_/B }
C {devices/lab_pin.sym} 90080 -13260 0 1 {name=p89597 lab=_53509_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -13260 0 0 {name=X_53509_ }
C {devices/lab_pin.sym} 89930 -13130 0 0 {name=p89598 lab=_84329_/CLK }
C {devices/lab_pin.sym} 89930 -13110 0 0 {name=p89599 lab=_63366_/Y }
C {devices/lab_pin.sym} 90110 -13130 0 1 {name=p89600 lab=_63365_/C }
C {sky130_stdcells/dfxtp_4.sym} 90020 -13120 0 0 {name=X_84329_ }
C {devices/lab_pin.sym} 89960 -13000 0 0 {name=p89601 lab=_45290_/Y }
C {devices/lab_pin.sym} 89960 -12960 0 0 {name=p89602 lab=_45272_/X }
C {devices/lab_pin.sym} 90080 -12980 0 1 {name=p89603 lab=_45291_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -12980 0 0 {name=X_45291_ }
C {devices/lab_pin.sym} 89960 -12860 0 0 {name=p89604 lab=_45647_/Y }
C {devices/lab_pin.sym} 89960 -12820 0 0 {name=p89605 lab=_56671_/X }
C {devices/lab_pin.sym} 90080 -12840 0 1 {name=p89606 lab=_57277_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -12840 0 0 {name=X_57277_ }
C {devices/lab_pin.sym} 89930 -12710 0 0 {name=p89607 lab=_88097_/CLK }
C {devices/lab_pin.sym} 89930 -12690 0 0 {name=p89608 lab=_41946_/Y }
C {devices/lab_pin.sym} 90110 -12710 0 1 {name=p89609 lab=_73987_/A }
C {sky130_stdcells/dfxtp_4.sym} 90020 -12700 0 0 {name=X_88097_ }
C {devices/lab_pin.sym} 89960 -12600 0 0 {name=p89610 lab=_54483_/A }
C {devices/lab_pin.sym} 89960 -12560 0 0 {name=p89611 lab=_54471_/B }
C {devices/lab_pin.sym} 89960 -12520 0 0 {name=p89612 lab=_54483_/C }
C {devices/lab_pin.sym} 89960 -12480 0 0 {name=p89613 lab=_46999_/A }
C {devices/lab_pin.sym} 90080 -12540 0 1 {name=p89614 lab=_54489_/X }
C {sky130_stdcells/and4_4.sym} 90020 -12540 0 0 {name=X_54489_ }
C {devices/lab_pin.sym} 89940 -12410 0 0 {name=p89615 lab=_47026_/Y }
C {devices/lab_pin.sym} 89940 -12370 0 0 {name=p89616 lab=_46987_/X }
C {devices/lab_pin.sym} 89940 -12330 0 0 {name=p89617 lab=_47029_/X }
C {devices/lab_pin.sym} 90100 -12370 0 1 {name=p89618 lab=_86678_/D }
C {sky130_stdcells/a21oi_4.sym} 90020 -12370 0 0 {name=X_47030_ }
C {devices/lab_pin.sym} 89940 -12250 0 0 {name=p89619 lab=_59012_/Y }
C {devices/lab_pin.sym} 89940 -12210 0 0 {name=p89620 lab=_59015_/Y }
C {devices/lab_pin.sym} 89940 -12170 0 0 {name=p89621 lab=_58966_/X }
C {devices/lab_pin.sym} 90100 -12210 0 1 {name=p89622 lab=_59016_/X }
C {sky130_stdcells/a21o_4.sym} 90020 -12210 0 0 {name=X_59016_ }
C {devices/lab_pin.sym} 89960 -12090 0 0 {name=p89623 lab=_44227_/Y }
C {devices/lab_pin.sym} 89960 -12050 0 0 {name=p89624 lab=_87178_/Q }
C {devices/lab_pin.sym} 89960 -12010 0 0 {name=p89625 lab=_44242_/C }
C {devices/lab_pin.sym} 90080 -12050 0 1 {name=p89626 lab=_44242_/Y }
C {sky130_stdcells/nand3_4.sym} 90020 -12050 0 0 {name=X_44242_ }
C {devices/lab_pin.sym} 89940 -11930 0 0 {name=p89627 lab=_56074_/X }
C {devices/lab_pin.sym} 89940 -11890 0 0 {name=p89628 lab=_56225_/X }
C {devices/lab_pin.sym} 89940 -11850 0 0 {name=p89629 lab=_56227_/Y }
C {devices/lab_pin.sym} 90100 -11890 0 1 {name=p89630 lab=_85268_/D }
C {sky130_stdcells/o21ai_4.sym} 90020 -11890 0 0 {name=X_56228_ }
C {devices/lab_pin.sym} 89960 -11760 0 0 {name=p89631 lab=_75062_/A }
C {devices/lab_pin.sym} 89960 -11720 0 0 {name=p89632 lab=_75062_/B }
C {devices/lab_pin.sym} 90080 -11740 0 1 {name=p89633 lab=_75062_/Y }
C {sky130_stdcells/nor2_4.sym} 90020 -11740 0 0 {name=X_75062_ }
C {devices/lab_pin.sym} 89980 -11610 0 0 {name=p89634 lab=_41453_/Y }
C {devices/lab_pin.sym} 90060 -11610 0 1 {name=p89635 lab=_41454_/X }
C {sky130_stdcells/buf_2.sym} 90020 -11610 0 0 {name=X_41454_ }
C {devices/lab_pin.sym} 89930 -11490 0 0 {name=p89636 lab=_87045_/CLK }
C {devices/lab_pin.sym} 89930 -11470 0 0 {name=p89637 lab=_87048_/D }
C {devices/lab_pin.sym} 90110 -11490 0 1 {name=p89638 lab=_87048_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90020 -11480 0 0 {name=X_87048_ }
C {devices/lab_pin.sym} 89980 -11350 0 0 {name=p89639 lab=_72176_/A }
C {devices/lab_pin.sym} 90060 -11350 0 1 {name=p89640 lab=_72274_/X }
C {sky130_stdcells/buf_2.sym} 90020 -11350 0 0 {name=X_72274_ }
C {devices/lab_pin.sym} 89980 -11230 0 0 {name=p89641 lab=_73709_/X }
C {devices/lab_pin.sym} 90060 -11230 0 1 {name=p89642 lab=_74038_/A }
C {sky130_stdcells/buf_2.sym} 90020 -11230 0 0 {name=X_74013_ }
C {devices/lab_pin.sym} 89940 -11140 0 0 {name=p89643 lab=_40404_/X }
C {devices/lab_pin.sym} 89940 -11100 0 0 {name=p89644 lab=_40342_/X }
C {devices/lab_pin.sym} 89940 -11060 0 0 {name=p89645 lab=_88396_/Q }
C {devices/lab_pin.sym} 89940 -11020 0 0 {name=p89646 lab=_40355_/X }
C {devices/lab_pin.sym} 90100 -11080 0 1 {name=p89647 lab=_40405_/X }
C {sky130_stdcells/a2bb2o_4.sym} 90020 -11080 0 0 {name=X_40405_ }
C {devices/lab_pin.sym} 89980 -10930 0 0 {name=p89648 lab=_71225_/A }
C {devices/lab_pin.sym} 90060 -10930 0 1 {name=p89649 lab=_71232_/C }
C {sky130_stdcells/buf_2.sym} 90020 -10930 0 0 {name=X_71225_ }
C {devices/lab_pin.sym} 89980 -10810 0 0 {name=p89650 lab=_44315_/A }
C {devices/lab_pin.sym} 90060 -10810 0 1 {name=p89651 lab=_44173_/X }
C {sky130_stdcells/buf_2.sym} 90020 -10810 0 0 {name=X_44173_ }
C {devices/lab_pin.sym} 89940 -10710 0 0 {name=p89652 lab=_79862_/X }
C {devices/lab_pin.sym} 89940 -10670 0 0 {name=p89653 lab=_79864_/B }
C {devices/lab_pin.sym} 89940 -10630 0 0 {name=p89654 lab=_79869_/Y }
C {devices/lab_pin.sym} 90100 -10670 0 1 {name=p89655 lab=_79870_/Y }
C {sky130_stdcells/a21boi_4.sym} 90020 -10670 0 0 {name=X_79870_ }
C {devices/lab_pin.sym} 89980 -10530 0 0 {name=p89656 lab=_56159_/A }
C {devices/lab_pin.sym} 90060 -10530 0 1 {name=p89657 lab=_56159_/X }
C {sky130_stdcells/buf_2.sym} 90020 -10530 0 0 {name=X_56159_ }
C {devices/lab_pin.sym} 89960 -10420 0 0 {name=p89658 lab=_81742_/Q }
C {devices/lab_pin.sym} 89960 -10380 0 0 {name=p89659 lab=_41379_/X }
C {devices/lab_pin.sym} 90080 -10400 0 1 {name=p89660 lab=_41385_/X }
C {sky130_stdcells/or2_4.sym} 90020 -10400 0 0 {name=X_41385_ }
C {devices/lab_pin.sym} 89980 -10270 0 0 {name=p89661 lab=_42059_/A }
C {devices/lab_pin.sym} 90060 -10270 0 1 {name=p89662 lab=_44530_/A }
C {sky130_stdcells/buf_2.sym} 90020 -10270 0 0 {name=X_43124_ }
C {devices/lab_pin.sym} 89960 -10160 0 0 {name=p89663 lab=_82723_/Q }
C {devices/lab_pin.sym} 89960 -10120 0 0 {name=p89664 lab=_78821_/B }
C {devices/lab_pin.sym} 90080 -10140 0 1 {name=p89665 lab=_78821_/X }
C {sky130_stdcells/xor2_4.sym} 90020 -10140 0 0 {name=X_78821_ }
C {devices/lab_pin.sym} 89980 -10010 0 0 {name=p89666 lab=_43175_/A }
C {devices/lab_pin.sym} 90060 -10010 0 1 {name=p89667 lab=_40591_/B }
C {sky130_stdcells/buf_2.sym} 90020 -10010 0 0 {name=X_40336_ }
C {devices/lab_pin.sym} 89940 -9910 0 0 {name=p89668 lab=_52121_/B }
C {devices/lab_pin.sym} 89940 -9870 0 0 {name=p89669 lab=_71138_/A }
C {devices/lab_pin.sym} 89940 -9830 0 0 {name=p89670 lab=_71155_/Y }
C {devices/lab_pin.sym} 90100 -9870 0 1 {name=p89671 lab=_71156_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -9870 0 0 {name=X_71156_ }
C {devices/lab_pin.sym} 89980 -9730 0 0 {name=p89672 lab=clkbuf_7_16_0_CLK/X }
C {devices/lab_pin.sym} 90060 -9730 0 1 {name=p89673 lab=clkbuf_9_67_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 90020 -9730 0 0 {name=Xclkbuf_8_33_0_CLK }
C {devices/lab_pin.sym} 89980 -9610 0 0 {name=p89674 lab=_83615_/Q }
C {devices/lab_pin.sym} 90060 -9610 0 1 {name=p89675 lab=_72007_/B }
C {sky130_stdcells/inv_2.sym} 90020 -9610 0 0 {name=X_48981_ }
C {devices/lab_pin.sym} 89960 -9520 0 0 {name=p89676 lab=_70107_/A }
C {devices/lab_pin.sym} 89960 -9480 0 0 {name=p89677 lab=_70107_/B }
C {devices/lab_pin.sym} 89960 -9440 0 0 {name=p89678 lab=_70107_/C }
C {devices/lab_pin.sym} 89960 -9400 0 0 {name=p89679 lab=_70106_/Y }
C {devices/lab_pin.sym} 90080 -9460 0 1 {name=p89680 lab=_70107_/Y }
C {sky130_stdcells/nand4_4.sym} 90020 -9460 0 0 {name=X_70107_ }
C {devices/lab_pin.sym} 89960 -9320 0 0 {name=p89681 lab=_47912_/A }
C {devices/lab_pin.sym} 89960 -9280 0 0 {name=p89682 lab=_47932_/B }
C {devices/lab_pin.sym} 90080 -9300 0 1 {name=p89683 lab=_47932_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -9300 0 0 {name=X_47932_ }
C {devices/lab_pin.sym} 89980 -9170 0 0 {name=p89684 lab=_87593_/Q }
C {devices/lab_pin.sym} 90060 -9170 0 1 {name=p89685 lab=_43055_/Y }
C {sky130_stdcells/inv_2.sym} 90020 -9170 0 0 {name=X_43055_ }
C {devices/lab_pin.sym} 89980 -9050 0 0 {name=p89686 lab=_59917_/X }
C {devices/lab_pin.sym} 90060 -9050 0 1 {name=p89687 lab=_59918_/Y }
C {sky130_stdcells/inv_2.sym} 90020 -9050 0 0 {name=X_59918_ }
C {devices/lab_pin.sym} 89980 -8930 0 0 {name=p89688 lab=_78752_/A }
C {devices/lab_pin.sym} 90060 -8930 0 1 {name=p89689 lab=_78753_/C }
C {sky130_stdcells/inv_2.sym} 90020 -8930 0 0 {name=X_78752_ }
C {devices/lab_pin.sym} 89940 -8830 0 0 {name=p89690 lab=_49015_/X }
C {devices/lab_pin.sym} 89940 -8790 0 0 {name=p89691 lab=_71070_/A }
C {devices/lab_pin.sym} 89940 -8750 0 0 {name=p89692 lab=_71086_/Y }
C {devices/lab_pin.sym} 90100 -8790 0 1 {name=p89693 lab=_71087_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -8790 0 0 {name=X_71087_ }
C {devices/lab_pin.sym} 89960 -8660 0 0 {name=p89694 lab=_75964_/A }
C {devices/lab_pin.sym} 89960 -8620 0 0 {name=p89695 lab=_75963_/Y }
C {devices/lab_pin.sym} 90080 -8640 0 1 {name=p89696 lab=_75964_/X }
C {sky130_stdcells/and2_4.sym} 90020 -8640 0 0 {name=X_75964_ }
C {devices/lab_pin.sym} 89980 -8510 0 0 {name=p89697 lab=_42024_/A }
C {devices/lab_pin.sym} 90060 -8510 0 1 {name=p89698 lab=_42006_/X }
C {sky130_stdcells/buf_2.sym} 90020 -8510 0 0 {name=X_42006_ }
C {devices/lab_pin.sym} 89960 -8410 0 0 {name=p89699 lab=_77703_/A }
C {devices/lab_pin.sym} 89960 -8370 0 0 {name=p89700 lab=_77703_/B }
C {devices/lab_pin.sym} 89960 -8330 0 0 {name=p89701 lab=_77703_/C }
C {devices/lab_pin.sym} 90080 -8370 0 1 {name=p89702 lab=_77703_/Y }
C {sky130_stdcells/nand3_4.sym} 90020 -8370 0 0 {name=X_77703_ }
C {devices/lab_pin.sym} 89960 -8240 0 0 {name=p89703 lab=_81131_/D }
C {devices/lab_pin.sym} 89960 -8200 0 0 {name=p89704 lab=_74916_/B }
C {devices/lab_pin.sym} 90080 -8220 0 1 {name=p89705 lab=_74915_/Y }
C {sky130_stdcells/nor2_4.sym} 90020 -8220 0 0 {name=X_74915_ }
C {devices/lab_pin.sym} 89940 -8120 0 0 {name=p89706 lab=_69520_/X }
C {devices/lab_pin.sym} 89940 -8080 0 0 {name=p89707 lab=_69772_/Y }
C {devices/lab_pin.sym} 89940 -8040 0 0 {name=p89708 lab=_70033_/X }
C {devices/lab_pin.sym} 89940 -8000 0 0 {name=p89709 lab=_70037_/Y }
C {devices/lab_pin.sym} 90100 -8060 0 1 {name=p89710 lab=_70038_/X }
C {sky130_stdcells/a211o_4.sym} 90020 -8060 0 0 {name=X_70038_ }
C {devices/lab_pin.sym} 89980 -7910 0 0 {name=p89711 lab=_83558_/Q }
C {devices/lab_pin.sym} 90060 -7910 0 1 {name=p89712 lab=_47863_/Y }
C {sky130_stdcells/inv_2.sym} 90020 -7910 0 0 {name=X_47863_ }
C {devices/lab_pin.sym} 89940 -7830 0 0 {name=p89713 lab=_59634_/B }
C {devices/lab_pin.sym} 89940 -7790 0 0 {name=p89714 lab=_59790_/X }
C {devices/lab_pin.sym} 89940 -7750 0 0 {name=p89715 lab=_59745_/X }
C {devices/lab_pin.sym} 89940 -7710 0 0 {name=p89716 lab=_59847_/Y }
C {devices/lab_pin.sym} 89940 -7680 0 0 {name=p89717 lab=_59848_/Y }
C {devices/lab_pin.sym} 90100 -7750 0 1 {name=p89718 lab=_84689_/D }
C {sky130_stdcells/a41oi_4.sym} 90020 -7750 0 0 {name=X_59849_ }
C {devices/lab_pin.sym} 89940 -7610 0 0 {name=p89719 lab=_78682_/B }
C {devices/lab_pin.sym} 89940 -7570 0 0 {name=p89720 lab=_78682_/C }
C {devices/lab_pin.sym} 89940 -7530 0 0 {name=p89721 lab=_78682_/A }
C {devices/lab_pin.sym} 90100 -7570 0 1 {name=p89722 lab=_78684_/B }
C {sky130_stdcells/o21ai_4.sym} 90020 -7570 0 0 {name=X_78683_ }
C {devices/lab_pin.sym} 89960 -7440 0 0 {name=p89723 lab=_84493_/Q }
C {devices/lab_pin.sym} 89960 -7400 0 0 {name=p89724 lab=_84365_/Q }
C {devices/lab_pin.sym} 90080 -7420 0 1 {name=p89725 lab=_75895_/X }
C {sky130_stdcells/xor2_4.sym} 90020 -7420 0 0 {name=X_75895_ }
C {devices/lab_pin.sym} 89980 -7290 0 0 {name=p89726 lab=_49548_/A }
C {devices/lab_pin.sym} 90060 -7290 0 1 {name=p89727 lab=_49615_/C }
C {sky130_stdcells/buf_2.sym} 90020 -7290 0 0 {name=X_49602_ }
C {devices/lab_pin.sym} 89980 -7170 0 0 {name=p89728 lab=_46720_/A }
C {devices/lab_pin.sym} 90060 -7170 0 1 {name=p89729 lab=_46817_/A }
C {sky130_stdcells/buf_2.sym} 90020 -7170 0 0 {name=X_46814_ }
C {devices/lab_pin.sym} 89980 -7050 0 0 {name=p89730 lab=clkbuf_8_49_0_CLK/A }
C {devices/lab_pin.sym} 90060 -7050 0 1 {name=p89731 lab=clkbuf_9_97_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 90020 -7050 0 0 {name=Xclkbuf_8_48_0_CLK }
C {devices/lab_pin.sym} 89940 -6950 0 0 {name=p89732 lab=_77633_/B }
C {devices/lab_pin.sym} 89940 -6910 0 0 {name=p89733 lab=_77632_/Y }
C {devices/lab_pin.sym} 89940 -6870 0 0 {name=p89734 lab=_77629_/Y }
C {devices/lab_pin.sym} 90100 -6910 0 1 {name=p89735 lab=_77634_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -6910 0 0 {name=X_77634_ }
C {devices/lab_pin.sym} 89960 -6800 0 0 {name=p89736 lab=_61541_/B }
C {devices/lab_pin.sym} 89960 -6760 0 0 {name=p89737 lab=_62858_/X }
C {devices/lab_pin.sym} 89960 -6720 0 0 {name=p89738 lab=_62859_/X }
C {devices/lab_pin.sym} 89960 -6680 0 0 {name=p89739 lab=_62889_/D }
C {devices/lab_pin.sym} 90080 -6740 0 1 {name=p89740 lab=_62860_/Y }
C {sky130_stdcells/nand4_4.sym} 90020 -6740 0 0 {name=X_62860_ }
C {devices/lab_pin.sym} 89960 -6600 0 0 {name=p89741 lab=_58153_/X }
C {devices/lab_pin.sym} 89960 -6560 0 0 {name=p89742 lab=_74846_/B }
C {devices/lab_pin.sym} 90080 -6580 0 1 {name=p89743 lab=_74846_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -6580 0 0 {name=X_74846_ }
C {devices/lab_pin.sym} 89980 -6450 0 0 {name=p89744 lab=_47794_/A }
C {devices/lab_pin.sym} 90060 -6450 0 1 {name=p89745 lab=_53249_/D }
C {sky130_stdcells/buf_2.sym} 90020 -6450 0 0 {name=X_47794_ }
C {devices/lab_pin.sym} 89960 -6360 0 0 {name=p89746 lab=_49537_/A }
C {devices/lab_pin.sym} 89960 -6320 0 0 {name=p89747 lab=_49537_/B }
C {devices/lab_pin.sym} 89960 -6280 0 0 {name=p89748 lab=_49522_/C }
C {devices/lab_pin.sym} 89960 -6240 0 0 {name=p89749 lab=_52746_/D }
C {devices/lab_pin.sym} 90080 -6300 0 1 {name=p89750 lab=_49533_/X }
C {sky130_stdcells/and4_4.sym} 90020 -6300 0 0 {name=X_49533_ }
C {devices/lab_pin.sym} 89980 -6150 0 0 {name=p89751 lab=_84724_/Q }
C {devices/lab_pin.sym} 90060 -6150 0 1 {name=p89752 lab=_61811_/X }
C {sky130_stdcells/buf_2.sym} 90020 -6150 0 0 {name=X_61811_ }
C {devices/lab_pin.sym} 89960 -6060 0 0 {name=p89753 lab=_46737_/A }
C {devices/lab_pin.sym} 89960 -6020 0 0 {name=p89754 lab=_46717_/B }
C {devices/lab_pin.sym} 89960 -5980 0 0 {name=p89755 lab=_46717_/C }
C {devices/lab_pin.sym} 89960 -5940 0 0 {name=p89756 lab=_46744_/X }
C {devices/lab_pin.sym} 90080 -6000 0 1 {name=p89757 lab=_46745_/X }
C {sky130_stdcells/and4_4.sym} 90020 -6000 0 0 {name=X_46745_ }
C {devices/lab_pin.sym} 89960 -5860 0 0 {name=p89758 lab=_81944_/Q }
C {devices/lab_pin.sym} 89960 -5820 0 0 {name=p89759 lab=_82200_/D }
C {devices/lab_pin.sym} 90080 -5840 0 1 {name=p89760 lab=_81912_/D }
C {sky130_stdcells/xor2_4.sym} 90020 -5840 0 0 {name=X_77565_ }
C {devices/lab_pin.sym} 89960 -5720 0 0 {name=p89761 lab=_43957_/A }
C {devices/lab_pin.sym} 89960 -5680 0 0 {name=p89762 lab=_43957_/B }
C {devices/lab_pin.sym} 90080 -5700 0 1 {name=p89763 lab=_43957_/X }
C {sky130_stdcells/and2_4.sym} 90020 -5700 0 0 {name=X_43957_ }
C {devices/lab_pin.sym} 89960 -5590 0 0 {name=p89764 lab=_74741_/X }
C {devices/lab_pin.sym} 89960 -5550 0 0 {name=p89765 lab=_74777_/B }
C {devices/lab_pin.sym} 89960 -5510 0 0 {name=p89766 lab=_74776_/Y }
C {devices/lab_pin.sym} 90080 -5550 0 1 {name=p89767 lab=_74777_/Y }
C {sky130_stdcells/nand3_4.sym} 90020 -5550 0 0 {name=X_74777_ }
C {devices/lab_pin.sym} 89980 -5410 0 0 {name=p89768 lab=_44173_/X }
C {devices/lab_pin.sym} 90060 -5410 0 1 {name=p89769 lab=_62791_/X }
C {sky130_stdcells/buf_2.sym} 90020 -5410 0 0 {name=X_62791_ }
C {devices/lab_pin.sym} 89960 -5300 0 0 {name=p89770 lab=_71970_/A }
C {devices/lab_pin.sym} 89960 -5260 0 0 {name=p89771 lab=_71989_/B }
C {devices/lab_pin.sym} 90080 -5280 0 1 {name=p89772 lab=_71989_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -5280 0 0 {name=X_71989_ }
C {devices/lab_pin.sym} 89960 -5160 0 0 {name=p89773 lab=_79286_/X }
C {devices/lab_pin.sym} 89960 -5120 0 0 {name=p89774 lab=_79304_/B }
C {devices/lab_pin.sym} 90080 -5140 0 1 {name=p89775 lab=_79304_/X }
C {sky130_stdcells/or2_4.sym} 90020 -5140 0 0 {name=X_79304_ }
C {devices/lab_pin.sym} 89940 -5030 0 0 {name=p89776 lab=_76514_/Y }
C {devices/lab_pin.sym} 89940 -4990 0 0 {name=p89777 lab=_76484_/Y }
C {devices/lab_pin.sym} 89940 -4950 0 0 {name=p89778 lab=_76515_/X }
C {devices/lab_pin.sym} 90100 -4990 0 1 {name=p89779 lab=_76516_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -4990 0 0 {name=X_76516_ }
C {devices/lab_pin.sym} 89940 -4870 0 0 {name=p89780 lab=_79566_/A }
C {devices/lab_pin.sym} 89940 -4830 0 0 {name=p89781 lab=_63310_/X }
C {devices/lab_pin.sym} 89940 -4790 0 0 {name=p89782 lab=_64529_/Y }
C {devices/lab_pin.sym} 90100 -4830 0 1 {name=p89783 lab=_84237_/D }
C {sky130_stdcells/o21ai_4.sym} 90020 -4830 0 0 {name=X_64530_ }
C {devices/lab_pin.sym} 89940 -4720 0 0 {name=p89784 lab=_41681_/X }
C {devices/lab_pin.sym} 89940 -4680 0 0 {name=p89785 lab=_42900_/X }
C {devices/lab_pin.sym} 89940 -4640 0 0 {name=p89786 lab=_67556_/B }
C {devices/lab_pin.sym} 89940 -4600 0 0 {name=p89787 lab=_42901_/X }
C {devices/lab_pin.sym} 90100 -4660 0 1 {name=p89788 lab=_42908_/X }
C {sky130_stdcells/a2bb2o_4.sym} 90020 -4660 0 0 {name=X_42908_ }
C {devices/lab_pin.sym} 89960 -4520 0 0 {name=p89789 lab=_49454_/A }
C {devices/lab_pin.sym} 89960 -4480 0 0 {name=p89790 lab=_50987_/B }
C {devices/lab_pin.sym} 90080 -4500 0 1 {name=p89791 lab=_49464_/Y }
C {sky130_stdcells/nand2_4.sym} 90020 -4500 0 0 {name=X_49464_ }
C {devices/lab_pin.sym} 89980 -4370 0 0 {name=p89792 lab=_59766_/X }
C {devices/lab_pin.sym} 90060 -4370 0 1 {name=p89793 lab=_62130_/D }
C {sky130_stdcells/buf_2.sym} 90020 -4370 0 0 {name=X_61742_ }
C {devices/lab_pin.sym} 89980 -4250 0 0 {name=p89794 lab=_72723_/X }
C {devices/lab_pin.sym} 90060 -4250 0 1 {name=p89795 lab=_73728_/X }
C {sky130_stdcells/buf_2.sym} 90020 -4250 0 0 {name=X_73728_ }
C {devices/lab_pin.sym} 89980 -4130 0 0 {name=p89796 lab=_46676_/A }
C {devices/lab_pin.sym} 90060 -4130 0 1 {name=p89797 lab=_51779_/B }
C {sky130_stdcells/buf_2.sym} 90020 -4130 0 0 {name=X_46676_ }
C {devices/lab_pin.sym} 89960 -4020 0 0 {name=p89798 lab=_77496_/A }
C {devices/lab_pin.sym} 89960 -3980 0 0 {name=p89799 lab=_77495_/Y }
C {devices/lab_pin.sym} 90080 -4000 0 1 {name=p89800 lab=_77497_/A }
C {sky130_stdcells/and2_4.sym} 90020 -4000 0 0 {name=X_77496_ }
C {devices/lab_pin.sym} 89940 -3900 0 0 {name=p89801 lab=_41306_/X }
C {devices/lab_pin.sym} 89940 -3860 0 0 {name=p89802 lab=_43886_/X }
C {devices/lab_pin.sym} 89940 -3820 0 0 {name=p89803 lab=_67440_/B }
C {devices/lab_pin.sym} 89940 -3780 0 0 {name=p89804 lab=_43887_/X }
C {devices/lab_pin.sym} 90100 -3840 0 1 {name=p89805 lab=_43888_/X }
C {sky130_stdcells/a2bb2o_4.sym} 90020 -3840 0 0 {name=X_43888_ }
C {devices/lab_pin.sym} 89940 -3710 0 0 {name=p89806 lab=_48134_/X }
C {devices/lab_pin.sym} 89940 -3670 0 0 {name=p89807 lab=_47893_/A }
C {devices/lab_pin.sym} 89940 -3630 0 0 {name=p89808 lab=_48414_/X }
C {devices/lab_pin.sym} 90100 -3670 0 1 {name=p89809 lab=_48416_/A }
C {sky130_stdcells/o21ai_4.sym} 90020 -3670 0 0 {name=X_48415_ }
C {devices/lab_pin.sym} 89960 -3540 0 0 {name=p89810 lab=_79248_/C }
C {devices/lab_pin.sym} 89960 -3500 0 0 {name=p89811 lab=_79235_/B }
C {devices/lab_pin.sym} 90080 -3520 0 1 {name=p89812 lab=_79238_/A }
C {sky130_stdcells/nand2_4.sym} 90020 -3520 0 0 {name=X_79235_ }
C {devices/lab_pin.sym} 89980 -3390 0 0 {name=p89813 lab=_45734_/A }
C {devices/lab_pin.sym} 90060 -3390 0 1 {name=p89814 lab=_45627_/X }
C {sky130_stdcells/buf_2.sym} 90020 -3390 0 0 {name=X_45627_ }
C {devices/lab_pin.sym} 89940 -3310 0 0 {name=p89815 lab=_64454_/Y }
C {devices/lab_pin.sym} 89940 -3270 0 0 {name=p89816 lab=_64457_/Y }
C {devices/lab_pin.sym} 89940 -3230 0 0 {name=p89817 lab=_64460_/X }
C {devices/lab_pin.sym} 89940 -3190 0 0 {name=p89818 lab=_84844_/Q }
C {devices/lab_pin.sym} 89940 -3150 0 0 {name=p89819 lab=_64213_/X }
C {devices/lab_pin.sym} 90100 -3230 0 1 {name=p89820 lab=_64461_/Y }
C {sky130_stdcells/o32ai_4.sym} 90020 -3230 0 0 {name=X_64461_ }
C {devices/lab_pin.sym} 89940 -3090 0 0 {name=p89821 lab=_76443_/Y }
C {devices/lab_pin.sym} 89940 -3050 0 0 {name=p89822 lab=_76422_/Y }
C {devices/lab_pin.sym} 89940 -3010 0 0 {name=p89823 lab=_76446_/X }
C {devices/lab_pin.sym} 90100 -3050 0 1 {name=p89824 lab=_76448_/B }
C {sky130_stdcells/o21ai_4.sym} 90020 -3050 0 0 {name=X_76447_ }
C {devices/lab_pin.sym} 89940 -2950 0 0 {name=p89825 lab=_42816_/X }
C {devices/lab_pin.sym} 89940 -2910 0 0 {name=p89826 lab=_42817_/X }
C {devices/lab_pin.sym} 89940 -2870 0 0 {name=p89827 lab=_41498_/X }
C {devices/lab_pin.sym} 89940 -2830 0 0 {name=p89828 lab=_66745_/B }
C {devices/lab_pin.sym} 89940 -2790 0 0 {name=p89829 lab=_42836_/X }
C {devices/lab_pin.sym} 90100 -2870 0 1 {name=p89830 lab=_42839_/Y }
C {sky130_stdcells/o32ai_4.sym} 90020 -2870 0 0 {name=X_42839_ }
C {devices/lab_pin.sym} 89940 -2730 0 0 {name=p89831 lab=_86395_/Q }
C {devices/lab_pin.sym} 89940 -2690 0 0 {name=p89832 lab=_49388_/X }
C {devices/lab_pin.sym} 89940 -2650 0 0 {name=p89833 lab=_49394_/Y }
C {devices/lab_pin.sym} 90100 -2690 0 1 {name=p89834 lab=_49395_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -2690 0 0 {name=X_49395_ }
C {devices/lab_pin.sym} 89960 -2570 0 0 {name=p89835 lab=_61636_/A }
C {devices/lab_pin.sym} 89960 -2530 0 0 {name=p89836 lab=_61673_/B }
C {devices/lab_pin.sym} 89960 -2490 0 0 {name=p89837 lab=_61682_/C }
C {devices/lab_pin.sym} 90080 -2530 0 1 {name=p89838 lab=_61673_/Y }
C {sky130_stdcells/nand3_4.sym} 90020 -2530 0 0 {name=X_61673_ }
C {devices/lab_pin.sym} 89960 -2400 0 0 {name=p89839 lab=_73607_/A }
C {devices/lab_pin.sym} 89960 -2360 0 0 {name=p89840 lab=_85917_/Q }
C {devices/lab_pin.sym} 90080 -2380 0 1 {name=p89841 lab=_73659_/X }
C {sky130_stdcells/and2_4.sym} 90020 -2380 0 0 {name=X_73659_ }
C {devices/lab_pin.sym} 89940 -2270 0 0 {name=p89842 lab=_66197_/X }
C {devices/lab_pin.sym} 89940 -2230 0 0 {name=p89843 lab=_66199_/X }
C {devices/lab_pin.sym} 89940 -2190 0 0 {name=p89844 lab=_65304_/X }
C {devices/lab_pin.sym} 90100 -2230 0 1 {name=p89845 lab=_66200_/X }
C {sky130_stdcells/a21o_4.sym} 90020 -2230 0 0 {name=X_66200_ }
C {devices/lab_pin.sym} 89960 -2100 0 0 {name=p89846 lab=_63427_/A }
C {devices/lab_pin.sym} 89960 -2060 0 0 {name=p89847 lab=_61796_/X }
C {devices/lab_pin.sym} 90080 -2080 0 1 {name=p89848 lab=_63412_/X }
C {sky130_stdcells/and2_4.sym} 90020 -2080 0 0 {name=X_63412_ }
C {devices/lab_pin.sym} 89980 -1950 0 0 {name=p89849 lab=_60624_/A }
C {devices/lab_pin.sym} 90060 -1950 0 1 {name=p89850 lab=_60624_/X }
C {sky130_stdcells/buf_2.sym} 90020 -1950 0 0 {name=X_60624_ }
C {devices/lab_pin.sym} 89940 -1850 0 0 {name=p89851 lab=_86531_/Q }
C {devices/lab_pin.sym} 89940 -1810 0 0 {name=p89852 lab=_48333_/X }
C {devices/lab_pin.sym} 89940 -1770 0 0 {name=p89853 lab=_48345_/Y }
C {devices/lab_pin.sym} 90100 -1810 0 1 {name=p89854 lab=_48346_/Y }
C {sky130_stdcells/o21ai_4.sym} 90020 -1810 0 0 {name=X_48346_ }
C {devices/lab_pin.sym} 89940 -1700 0 0 {name=p89855 lab=_87354_/Q }
C {devices/lab_pin.sym} 89940 -1660 0 0 {name=p89856 lab=_67156_/X }
C {devices/lab_pin.sym} 89940 -1620 0 0 {name=p89857 lab=_67106_/X }
C {devices/lab_pin.sym} 89940 -1580 0 0 {name=p89858 lab=_67179_/X }
C {devices/lab_pin.sym} 90100 -1640 0 1 {name=p89859 lab=_67180_/X }
C {sky130_stdcells/a211o_4.sym} 90020 -1640 0 0 {name=X_67180_ }
C {devices/lab_pin.sym} 89960 -1500 0 0 {name=p89860 lab=_84787_/Q }
C {devices/lab_pin.sym} 89960 -1460 0 0 {name=p89861 lab=_82723_/D }
C {devices/lab_pin.sym} 90080 -1480 0 1 {name=p89862 lab=_79173_/A }
C {sky130_stdcells/nand2_4.sym} 90020 -1480 0 0 {name=X_79166_ }
C {devices/lab_pin.sym} 89980 -1350 0 0 {name=p89863 lab=_45558_/A }
C {devices/lab_pin.sym} 90060 -1350 0 1 {name=p89864 lab=_45560_/A }
C {sky130_stdcells/inv_2.sym} 90020 -1350 0 0 {name=X_45558_ }
C {devices/lab_pin.sym} 89960 -1240 0 0 {name=p89865 lab=_81266_/Q }
C {devices/lab_pin.sym} 89960 -1200 0 0 {name=p89866 lab=_81522_/D }
C {devices/lab_pin.sym} 90080 -1220 0 1 {name=p89867 lab=_76379_/B }
C {sky130_stdcells/xor2_4.sym} 90020 -1220 0 0 {name=X_76378_ }
C {devices/lab_pin.sym} 89960 -1110 0 0 {name=p89868 lab=_64377_/X }
C {devices/lab_pin.sym} 89960 -1070 0 0 {name=p89869 lab=_64392_/B }
C {devices/lab_pin.sym} 89960 -1030 0 0 {name=p89870 lab=_64391_/X }
C {devices/lab_pin.sym} 90080 -1070 0 1 {name=p89871 lab=_64392_/X }
C {sky130_stdcells/and3_4.sym} 90020 -1070 0 0 {name=X_64392_ }
C {devices/lab_pin.sym} 89940 -950 0 0 {name=p89872 lab=_66128_/X }
C {devices/lab_pin.sym} 89940 -910 0 0 {name=p89873 lab=_66130_/X }
C {devices/lab_pin.sym} 89940 -870 0 0 {name=p89874 lab=_66057_/X }
C {devices/lab_pin.sym} 90100 -910 0 1 {name=p89875 lab=_66134_/A }
C {sky130_stdcells/a21o_4.sym} 90020 -910 0 0 {name=X_66131_ }
C {devices/lab_pin.sym} 89960 -780 0 0 {name=p89876 lab=_82568_/Q }
C {devices/lab_pin.sym} 89960 -740 0 0 {name=p89877 lab=_78125_/B }
C {devices/lab_pin.sym} 90080 -760 0 1 {name=p89878 lab=_78130_/C }
C {sky130_stdcells/xor2_4.sym} 90020 -760 0 0 {name=X_78117_ }
C {devices/lab_pin.sym} 90900 -42150 0 0 {name=p89879 lab=_44509_/A }
C {devices/lab_pin.sym} 90980 -42150 0 1 {name=p89880 lab=_44509_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -42150 0 0 {name=X_44509_ }
C {devices/lab_pin.sym} 90860 -42070 0 0 {name=p89881 lab=_63339_/Y }
C {devices/lab_pin.sym} 90860 -42030 0 0 {name=p89882 lab=_63340_/X }
C {devices/lab_pin.sym} 90860 -41990 0 0 {name=p89883 lab=_63341_/X }
C {devices/lab_pin.sym} 90860 -41950 0 0 {name=p89884 lab=_63342_/X }
C {devices/lab_pin.sym} 90860 -41910 0 0 {name=p89885 lab=_63020_/A }
C {devices/lab_pin.sym} 91020 -41990 0 1 {name=p89886 lab=_63343_/Y }
C {sky130_stdcells/o41ai_4.sym} 90940 -41990 0 0 {name=X_63343_ }
C {devices/lab_pin.sym} 90880 -41840 0 0 {name=p89887 lab=_75329_/A }
C {devices/lab_pin.sym} 90880 -41800 0 0 {name=p89888 lab=_75328_/X }
C {devices/lab_pin.sym} 91000 -41820 0 1 {name=p89889 lab=_80755_/D }
C {sky130_stdcells/xor2_4.sym} 90940 -41820 0 0 {name=X_75329_ }
C {devices/lab_pin.sym} 90880 -41700 0 0 {name=p89890 lab=_48275_/X }
C {devices/lab_pin.sym} 90880 -41660 0 0 {name=p89891 lab=_50322_/B }
C {devices/lab_pin.sym} 91000 -41680 0 1 {name=p89892 lab=_48277_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -41680 0 0 {name=X_48277_ }
C {devices/lab_pin.sym} 90900 -41550 0 0 {name=p89893 lab=_60555_/A }
C {devices/lab_pin.sym} 90980 -41550 0 1 {name=p89894 lab=_60555_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -41550 0 0 {name=X_60555_ }
C {devices/lab_pin.sym} 90860 -41450 0 0 {name=p89895 lab=_79095_/X }
C {devices/lab_pin.sym} 90860 -41410 0 0 {name=p89896 lab=_79109_/A }
C {devices/lab_pin.sym} 90860 -41370 0 0 {name=p89897 lab=_82752_/Q }
C {devices/lab_pin.sym} 91020 -41410 0 1 {name=p89898 lab=_79097_/Y }
C {sky130_stdcells/a21oi_4.sym} 90940 -41410 0 0 {name=X_79097_ }
C {devices/lab_pin.sym} 90900 -41270 0 0 {name=p89899 lab=_44891_/X }
C {devices/lab_pin.sym} 90980 -41270 0 1 {name=p89900 lab=_45489_/X }
C {sky130_stdcells/buf_2.sym} 90940 -41270 0 0 {name=X_45489_ }
C {devices/lab_pin.sym} 90880 -41180 0 0 {name=p89901 lab=_47210_/A }
C {devices/lab_pin.sym} 90880 -41140 0 0 {name=p89902 lab=_47228_/B }
C {devices/lab_pin.sym} 90880 -41100 0 0 {name=p89903 lab=_47210_/C }
C {devices/lab_pin.sym} 90880 -41060 0 0 {name=p89904 lab=_52927_/D }
C {devices/lab_pin.sym} 91000 -41120 0 1 {name=p89905 lab=_47228_/X }
C {sky130_stdcells/and4_4.sym} 90940 -41120 0 0 {name=X_47228_ }
C {devices/lab_pin.sym} 90880 -40990 0 0 {name=p89906 lab=_65582_/X }
C {devices/lab_pin.sym} 90880 -40950 0 0 {name=p89907 lab=_66062_/B }
C {devices/lab_pin.sym} 90880 -40910 0 0 {name=p89908 lab=_65585_/X }
C {devices/lab_pin.sym} 91000 -40950 0 1 {name=p89909 lab=_66062_/Y }
C {sky130_stdcells/nand3_4.sym} 90940 -40950 0 0 {name=X_66062_ }
C {devices/lab_pin.sym} 90900 -40810 0 0 {name=p89910 lab=_77756_/Y }
C {devices/lab_pin.sym} 90980 -40810 0 1 {name=p89911 lab=_78048_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -40810 0 0 {name=X_78048_ }
C {devices/lab_pin.sym} 90900 -40690 0 0 {name=p89912 lab=_63273_/X }
C {devices/lab_pin.sym} 90980 -40690 0 1 {name=p89913 lab=_63274_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -40690 0 0 {name=X_63274_ }
C {devices/lab_pin.sym} 90860 -40610 0 0 {name=p89914 lab=_60488_/A }
C {devices/lab_pin.sym} 90860 -40570 0 0 {name=p89915 lab=_60488_/C }
C {devices/lab_pin.sym} 90860 -40530 0 0 {name=p89916 lab=_59691_/X }
C {devices/lab_pin.sym} 90860 -40490 0 0 {name=p89917 lab=_60414_/Y }
C {devices/lab_pin.sym} 90860 -40450 0 0 {name=p89918 lab=_60427_/A }
C {devices/lab_pin.sym} 91020 -40530 0 1 {name=p89919 lab=_60486_/Y }
C {sky130_stdcells/a2111oi_4.sym} 90940 -40530 0 0 {name=X_60486_ }
C {devices/lab_pin.sym} 90860 -40400 0 0 {name=p89920 lab=_64828_/X }
C {devices/lab_pin.sym} 90860 -40360 0 0 {name=p89921 lab=_85554_/Q }
C {devices/lab_pin.sym} 90860 -40320 0 0 {name=p89922 lab=_64829_/X }
C {devices/lab_pin.sym} 90860 -40280 0 0 {name=p89923 lab=_65012_/X }
C {devices/lab_pin.sym} 91020 -40340 0 1 {name=p89924 lab=_65013_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -40340 0 0 {name=X_65013_ }
C {devices/lab_pin.sym} 90900 -40190 0 0 {name=p89925 lab=_60084_/A }
C {devices/lab_pin.sym} 90980 -40190 0 1 {name=p89926 lab=_62225_/X }
C {sky130_stdcells/buf_2.sym} 90940 -40190 0 0 {name=X_62225_ }
C {devices/lab_pin.sym} 90880 -40080 0 0 {name=p89927 lab=_47150_/A }
C {devices/lab_pin.sym} 90880 -40040 0 0 {name=p89928 lab=_52885_/B }
C {devices/lab_pin.sym} 91000 -40060 0 1 {name=p89929 lab=_47159_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -40060 0 0 {name=X_47159_ }
C {devices/lab_pin.sym} 90880 -39940 0 0 {name=p89930 lab=_79999_/X }
C {devices/lab_pin.sym} 90880 -39900 0 0 {name=p89931 lab=_80000_/A }
C {devices/lab_pin.sym} 91000 -39920 0 1 {name=p89932 lab=_80011_/D }
C {sky130_stdcells/nand2_4.sym} 90940 -39920 0 0 {name=X_80010_ }
C {devices/lab_pin.sym} 90880 -39800 0 0 {name=p89933 lab=_64696_/A }
C {devices/lab_pin.sym} 90880 -39760 0 0 {name=p89934 lab=_69820_/Y }
C {devices/lab_pin.sym} 91000 -39780 0 1 {name=p89935 lab=_69821_/Y }
C {sky130_stdcells/nor2_4.sym} 90940 -39780 0 0 {name=X_69821_ }
C {devices/lab_pin.sym} 90860 -39670 0 0 {name=p89936 lab=_86250_/Q }
C {devices/lab_pin.sym} 90860 -39630 0 0 {name=p89937 lab=_50162_/X }
C {devices/lab_pin.sym} 90860 -39590 0 0 {name=p89938 lab=_50169_/Y }
C {devices/lab_pin.sym} 91020 -39630 0 1 {name=p89939 lab=_50170_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -39630 0 0 {name=X_50170_ }
C {devices/lab_pin.sym} 90860 -39510 0 0 {name=p89940 lab=_62154_/Y }
C {devices/lab_pin.sym} 90860 -39470 0 0 {name=p89941 lab=_62101_/X }
C {devices/lab_pin.sym} 90860 -39430 0 0 {name=p89942 lab=_62155_/Y }
C {devices/lab_pin.sym} 91020 -39470 0 1 {name=p89943 lab=_62156_/Y }
C {sky130_stdcells/a21oi_4.sym} 90940 -39470 0 0 {name=X_62156_ }
C {devices/lab_pin.sym} 90880 -39340 0 0 {name=p89944 lab=_79997_/X }
C {devices/lab_pin.sym} 90880 -39300 0 0 {name=p89945 lab=_80003_/B }
C {devices/lab_pin.sym} 91000 -39320 0 1 {name=p89946 lab=_79999_/X }
C {sky130_stdcells/xor2_4.sym} 90940 -39320 0 0 {name=X_79999_ }
C {devices/lab_pin.sym} 90900 -39190 0 0 {name=p89947 lab=_61107_/A }
C {devices/lab_pin.sym} 90980 -39190 0 1 {name=p89948 lab=_61107_/X }
C {sky130_stdcells/buf_2.sym} 90940 -39190 0 0 {name=X_61107_ }
C {devices/lab_pin.sym} 90880 -39080 0 0 {name=p89949 lab=_69766_/A }
C {devices/lab_pin.sym} 90880 -39040 0 0 {name=p89950 lab=_69752_/B }
C {devices/lab_pin.sym} 91000 -39060 0 1 {name=p89951 lab=_69752_/Y }
C {sky130_stdcells/nor2_4.sym} 90940 -39060 0 0 {name=X_69752_ }
C {devices/lab_pin.sym} 90900 -38930 0 0 {name=p89952 lab=_66606_/A }
C {devices/lab_pin.sym} 90980 -38930 0 1 {name=p89953 lab=_66964_/X }
C {sky130_stdcells/buf_2.sym} 90940 -38930 0 0 {name=X_66964_ }
C {devices/lab_pin.sym} 90880 -38840 0 0 {name=p89954 lab=_84834_/Q }
C {devices/lab_pin.sym} 90880 -38800 0 0 {name=p89955 lab=_62065_/B }
C {devices/lab_pin.sym} 90880 -38760 0 0 {name=p89956 lab=_62063_/X }
C {devices/lab_pin.sym} 90880 -38720 0 0 {name=p89957 lab=_62130_/D }
C {devices/lab_pin.sym} 91000 -38780 0 1 {name=p89958 lab=_62087_/Y }
C {sky130_stdcells/nand4_4.sym} 90940 -38780 0 0 {name=X_62087_ }
C {devices/lab_pin.sym} 90860 -38660 0 0 {name=p89959 lab=_88006_/Q }
C {devices/lab_pin.sym} 90860 -38620 0 0 {name=p89960 lab=_68650_/X }
C {devices/lab_pin.sym} 90860 -38580 0 0 {name=p89961 lab=_68651_/X }
C {devices/lab_pin.sym} 90860 -38540 0 0 {name=p89962 lab=_68702_/X }
C {devices/lab_pin.sym} 91020 -38600 0 1 {name=p89963 lab=_68703_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -38600 0 0 {name=X_68703_ }
C {devices/lab_pin.sym} 90900 -38450 0 0 {name=p89964 lab=_65757_/A }
C {devices/lab_pin.sym} 90980 -38450 0 1 {name=p89965 lab=_65915_/X }
C {sky130_stdcells/buf_2.sym} 90940 -38450 0 0 {name=X_65915_ }
C {devices/lab_pin.sym} 90860 -38370 0 0 {name=p89966 lab=_61035_/X }
C {devices/lab_pin.sym} 90860 -38330 0 0 {name=p89967 lab=_61025_/X }
C {devices/lab_pin.sym} 90860 -38290 0 0 {name=p89968 lab=_61037_/Y }
C {devices/lab_pin.sym} 90860 -38250 0 0 {name=p89969 lab=_76981_/A }
C {devices/lab_pin.sym} 90860 -38210 0 0 {name=p89970 lab=_61020_/X }
C {devices/lab_pin.sym} 91020 -38290 0 1 {name=p89971 lab=_84533_/D }
C {sky130_stdcells/o32a_4.sym} 90940 -38290 0 0 {name=X_61038_ }
C {devices/lab_pin.sym} 90850 -38130 0 0 {name=p89972 lab=_87345_/CLK }
C {devices/lab_pin.sym} 90850 -38110 0 0 {name=p89973 lab=_83889_/Q }
C {devices/lab_pin.sym} 91030 -38130 0 1 {name=p89974 lab=_81961_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -38120 0 0 {name=X_81961_ }
C {devices/lab_pin.sym} 90860 -38020 0 0 {name=p89975 lab=_69255_/Y }
C {devices/lab_pin.sym} 90860 -37980 0 0 {name=p89976 lab=_69644_/X }
C {devices/lab_pin.sym} 90860 -37940 0 0 {name=p89977 lab=_69672_/X }
C {devices/lab_pin.sym} 90860 -37900 0 0 {name=p89978 lab=_69682_/Y }
C {devices/lab_pin.sym} 91020 -37960 0 1 {name=p89979 lab=_69683_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -37960 0 0 {name=X_69683_ }
C {devices/lab_pin.sym} 90860 -37840 0 0 {name=p89980 lab=_66757_/X }
C {devices/lab_pin.sym} 90860 -37800 0 0 {name=p89981 lab=_66886_/Y }
C {devices/lab_pin.sym} 90860 -37760 0 0 {name=p89982 lab=_66793_/X }
C {devices/lab_pin.sym} 90860 -37720 0 0 {name=p89983 lab=_66894_/Y }
C {devices/lab_pin.sym} 91020 -37780 0 1 {name=p89984 lab=_66895_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -37780 0 0 {name=X_66895_ }
C {devices/lab_pin.sym} 90900 -37630 0 0 {name=p89985 lab=clkbuf_9_196_0_CLK/X }
C {devices/lab_pin.sym} 90980 -37630 0 1 {name=p89986 lab=_84606_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 90940 -37630 0 0 {name=Xclkbuf_10_392_0_CLK }
C {devices/lab_pin.sym} 90850 -37510 0 0 {name=p89987 lab=_85645_/CLK }
C {devices/lab_pin.sym} 90850 -37490 0 0 {name=p89988 lab=_70788_/Y }
C {devices/lab_pin.sym} 91030 -37510 0 1 {name=p89989 lab=_47115_/A }
C {sky130_stdcells/dfxtp_4.sym} 90940 -37500 0 0 {name=X_83700_ }
C {devices/lab_pin.sym} 90850 -37370 0 0 {name=p89990 lab=_80912_/CLK }
C {devices/lab_pin.sym} 90850 -37350 0 0 {name=p89991 lab=_84088_/Q }
C {devices/lab_pin.sym} 91030 -37370 0 1 {name=p89992 lab=_75694_/A }
C {sky130_stdcells/dfxtp_4.sym} 90940 -37360 0 0 {name=X_80912_ }
C {devices/lab_pin.sym} 90860 -37260 0 0 {name=p89993 lab=_68376_/X }
C {devices/lab_pin.sym} 90860 -37220 0 0 {name=p89994 lab=_68612_/X }
C {devices/lab_pin.sym} 90860 -37180 0 0 {name=p89995 lab=_68623_/Y }
C {devices/lab_pin.sym} 90860 -37140 0 0 {name=p89996 lab=_68633_/Y }
C {devices/lab_pin.sym} 91020 -37200 0 1 {name=p89997 lab=_68634_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -37200 0 0 {name=X_68634_ }
C {devices/lab_pin.sym} 90880 -37060 0 0 {name=p89998 lab=_53848_/A }
C {devices/lab_pin.sym} 90880 -37020 0 0 {name=p89999 lab=_53860_/B }
C {devices/lab_pin.sym} 91000 -37040 0 1 {name=p90000 lab=_53860_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -37040 0 0 {name=X_53860_ }
C {devices/lab_pin.sym} 90880 -36920 0 0 {name=p90001 lab=_65804_/A }
C {devices/lab_pin.sym} 90880 -36880 0 0 {name=p90002 lab=_85861_/Q }
C {devices/lab_pin.sym} 91000 -36900 0 1 {name=p90003 lab=_65846_/X }
C {sky130_stdcells/and2_4.sym} 90940 -36900 0 0 {name=X_65846_ }
C {devices/lab_pin.sym} 90850 -36770 0 0 {name=p90004 lab=_84430_/CLK }
C {devices/lab_pin.sym} 90850 -36750 0 0 {name=p90005 lab=_59964_/Y }
C {devices/lab_pin.sym} 91030 -36770 0 1 {name=p90006 lab=_80241_/A }
C {sky130_stdcells/dfxtp_4.sym} 90940 -36760 0 0 {name=X_84680_ }
C {devices/lab_pin.sym} 90850 -36630 0 0 {name=p90007 lab=_82009_/CLK }
C {devices/lab_pin.sym} 90850 -36610 0 0 {name=p90008 lab=_77262_/X }
C {devices/lab_pin.sym} 91030 -36630 0 1 {name=p90009 lab=_82300_/D }
C {sky130_stdcells/dfxtp_4.sym} 90940 -36620 0 0 {name=X_81892_ }
C {devices/lab_pin.sym} 90880 -36520 0 0 {name=p90010 lab=_52818_/A }
C {devices/lab_pin.sym} 90880 -36480 0 0 {name=p90011 lab=_52818_/B }
C {devices/lab_pin.sym} 90880 -36440 0 0 {name=p90012 lab=_52789_/X }
C {devices/lab_pin.sym} 90880 -36400 0 0 {name=p90013 lab=_52811_/D }
C {devices/lab_pin.sym} 91000 -36460 0 1 {name=p90014 lab=_52811_/X }
C {sky130_stdcells/and4_4.sym} 90940 -36460 0 0 {name=X_52811_ }
C {devices/lab_pin.sym} 90850 -36310 0 0 {name=p90015 lab=_83630_/CLK }
C {devices/lab_pin.sym} 90850 -36290 0 0 {name=p90016 lab=_83631_/D }
C {devices/lab_pin.sym} 91030 -36310 0 1 {name=p90017 lab=_47622_/A }
C {sky130_stdcells/dfxtp_4.sym} 90940 -36300 0 0 {name=X_83631_ }
C {devices/lab_pin.sym} 90850 -36170 0 0 {name=p90018 lab=_80754_/CLK }
C {devices/lab_pin.sym} 90850 -36150 0 0 {name=p90019 lab=_80875_/Q }
C {devices/lab_pin.sym} 91030 -36170 0 1 {name=p90020 lab=_74916_/B }
C {sky130_stdcells/dfxtp_4.sym} 90940 -36160 0 0 {name=X_80843_ }
C {devices/lab_pin.sym} 90880 -36040 0 0 {name=p90021 lab=_68437_/A }
C {devices/lab_pin.sym} 90880 -36000 0 0 {name=p90022 lab=_73752_/A }
C {devices/lab_pin.sym} 91000 -36020 0 1 {name=p90023 lab=_68565_/X }
C {sky130_stdcells/and2_4.sym} 90940 -36020 0 0 {name=X_68565_ }
C {devices/lab_pin.sym} 90880 -35900 0 0 {name=p90024 lab=_53791_/A }
C {devices/lab_pin.sym} 90880 -35860 0 0 {name=p90025 lab=_48899_/Y }
C {devices/lab_pin.sym} 91000 -35880 0 1 {name=p90026 lab=_53791_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -35880 0 0 {name=X_53791_ }
C {devices/lab_pin.sym} 90880 -35760 0 0 {name=p90027 lab=_65777_/A }
C {devices/lab_pin.sym} 90880 -35720 0 0 {name=p90028 lab=_85866_/Q }
C {devices/lab_pin.sym} 91000 -35740 0 1 {name=p90029 lab=_65777_/X }
C {sky130_stdcells/and2_4.sym} 90940 -35740 0 0 {name=X_65777_ }
C {devices/lab_pin.sym} 90860 -35630 0 0 {name=p90030 lab=_62984_/X }
C {devices/lab_pin.sym} 90860 -35590 0 0 {name=p90031 lab=_62987_/X }
C {devices/lab_pin.sym} 90860 -35550 0 0 {name=p90032 lab=_62988_/Y }
C {devices/lab_pin.sym} 91020 -35590 0 1 {name=p90033 lab=_62989_/Y }
C {sky130_stdcells/a21oi_4.sym} 90940 -35590 0 0 {name=X_62989_ }
C {devices/lab_pin.sym} 90860 -35480 0 0 {name=p90034 lab=_45575_/A }
C {devices/lab_pin.sym} 90860 -35440 0 0 {name=p90035 lab=_55527_/X }
C {devices/lab_pin.sym} 90860 -35400 0 0 {name=p90036 lab=_44098_/X }
C {devices/lab_pin.sym} 90860 -35360 0 0 {name=p90037 lab=_55529_/X }
C {devices/lab_pin.sym} 91020 -35420 0 1 {name=p90038 lab=_55536_/C }
C {sky130_stdcells/a211o_4.sym} 90940 -35420 0 0 {name=X_55530_ }
C {devices/lab_pin.sym} 90900 -35270 0 0 {name=p90039 lab=_67039_/X }
C {devices/lab_pin.sym} 90980 -35270 0 1 {name=p90040 lab=_67516_/X }
C {sky130_stdcells/buf_2.sym} 90940 -35270 0 0 {name=X_67516_ }
C {devices/lab_pin.sym} 90850 -35150 0 0 {name=p90041 lab=_83703_/CLK }
C {devices/lab_pin.sym} 90850 -35130 0 0 {name=p90042 lab=_49643_/Y }
C {devices/lab_pin.sym} 91030 -35150 0 1 {name=p90043 lab=_86350_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -35140 0 0 {name=X_86350_ }
C {devices/lab_pin.sym} 90880 -35040 0 0 {name=p90044 lab=_52729_/X }
C {devices/lab_pin.sym} 90880 -35000 0 0 {name=p90045 lab=_52746_/B }
C {devices/lab_pin.sym} 90880 -34960 0 0 {name=p90046 lab=_52746_/C }
C {devices/lab_pin.sym} 90880 -34920 0 0 {name=p90047 lab=_52742_/D }
C {devices/lab_pin.sym} 91000 -34980 0 1 {name=p90048 lab=_52742_/X }
C {sky130_stdcells/and4_4.sym} 90940 -34980 0 0 {name=X_52742_ }
C {devices/lab_pin.sym} 90900 -34830 0 0 {name=p90049 lab=_64806_/A }
C {devices/lab_pin.sym} 90980 -34830 0 1 {name=p90050 lab=_64729_/A }
C {sky130_stdcells/buf_2.sym} 90940 -34830 0 0 {name=X_64728_ }
C {devices/lab_pin.sym} 90850 -34710 0 0 {name=p90051 lab=_83562_/CLK }
C {devices/lab_pin.sym} 90850 -34690 0 0 {name=p90052 lab=_71236_/Y }
C {devices/lab_pin.sym} 91030 -34710 0 1 {name=p90053 lab=_48704_/A }
C {sky130_stdcells/dfxtp_4.sym} 90940 -34700 0 0 {name=X_83562_ }
C {devices/lab_pin.sym} 90850 -34570 0 0 {name=p90054 lab=_80962_/CLK }
C {devices/lab_pin.sym} 90850 -34550 0 0 {name=p90055 lab=_80774_/D }
C {devices/lab_pin.sym} 91030 -34570 0 1 {name=p90056 lab=_80774_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -34560 0 0 {name=X_80774_ }
C {devices/lab_pin.sym} 90860 -34460 0 0 {name=p90057 lab=_73677_/A }
C {devices/lab_pin.sym} 90860 -34420 0 0 {name=p90058 lab=_68493_/X }
C {devices/lab_pin.sym} 90860 -34380 0 0 {name=p90059 lab=_68494_/X }
C {devices/lab_pin.sym} 90860 -34340 0 0 {name=p90060 lab=_68495_/Y }
C {devices/lab_pin.sym} 91020 -34400 0 1 {name=p90061 lab=_68496_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -34400 0 0 {name=X_68496_ }
C {devices/lab_pin.sym} 90850 -34250 0 0 {name=p90062 lab=_85270_/CLK }
C {devices/lab_pin.sym} 90850 -34230 0 0 {name=p90063 lab=_56072_/Y }
C {devices/lab_pin.sym} 91030 -34250 0 1 {name=p90064 lab=_55879_/B }
C {sky130_stdcells/dfxtp_4.sym} 90940 -34240 0 0 {name=X_85301_ }
C {devices/lab_pin.sym} 90850 -34110 0 0 {name=p90065 lab=_82580_/CLK }
C {devices/lab_pin.sym} 90850 -34090 0 0 {name=p90066 lab=_82513_/D }
C {devices/lab_pin.sym} 91030 -34110 0 1 {name=p90067 lab=_82513_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -34100 0 0 {name=X_82513_ }
C {devices/lab_pin.sym} 90860 -33990 0 0 {name=p90068 lab=_55456_/X }
C {devices/lab_pin.sym} 90860 -33950 0 0 {name=p90069 lab=_55460_/X }
C {devices/lab_pin.sym} 90860 -33910 0 0 {name=p90070 lab=_44111_/X }
C {devices/lab_pin.sym} 91020 -33950 0 1 {name=p90071 lab=_55461_/X }
C {sky130_stdcells/a21o_4.sym} 90940 -33950 0 0 {name=X_55461_ }
C {devices/lab_pin.sym} 90860 -33840 0 0 {name=p90072 lab=_67305_/X }
C {devices/lab_pin.sym} 90860 -33800 0 0 {name=p90073 lab=_67436_/Y }
C {devices/lab_pin.sym} 90860 -33760 0 0 {name=p90074 lab=_67390_/X }
C {devices/lab_pin.sym} 90860 -33720 0 0 {name=p90075 lab=_67446_/Y }
C {devices/lab_pin.sym} 91020 -33780 0 1 {name=p90076 lab=_67447_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -33780 0 0 {name=X_67447_ }
C {devices/lab_pin.sym} 90850 -33630 0 0 {name=p90077 lab=_86600_/CLK }
C {devices/lab_pin.sym} 90850 -33610 0 0 {name=p90078 lab=_86281_/D }
C {devices/lab_pin.sym} 91030 -33630 0 1 {name=p90079 lab=_86281_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -33620 0 0 {name=X_86281_ }
C {devices/lab_pin.sym} 90900 -33490 0 0 {name=p90080 lab=_52619_/A }
C {devices/lab_pin.sym} 90980 -33490 0 1 {name=p90081 lab=_52673_/X }
C {sky130_stdcells/buf_2.sym} 90940 -33490 0 0 {name=X_52673_ }
C {devices/lab_pin.sym} 90860 -33400 0 0 {name=p90082 lab=_64657_/X }
C {devices/lab_pin.sym} 90860 -33360 0 0 {name=p90083 lab=_83311_/Q }
C {devices/lab_pin.sym} 90860 -33320 0 0 {name=p90084 lab=_64600_/X }
C {devices/lab_pin.sym} 90860 -33280 0 0 {name=p90085 lab=_64658_/X }
C {devices/lab_pin.sym} 91020 -33340 0 1 {name=p90086 lab=_64659_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -33340 0 0 {name=X_64659_ }
C {devices/lab_pin.sym} 90850 -33190 0 0 {name=p90087 lab=_83495_/CLK }
C {devices/lab_pin.sym} 90850 -33170 0 0 {name=p90088 lab=_71455_/X }
C {devices/lab_pin.sym} 91030 -33190 0 1 {name=p90089 lab=_83493_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -33180 0 0 {name=X_83493_ }
C {devices/lab_pin.sym} 90860 -33070 0 0 {name=p90090 lab=_57198_/X }
C {devices/lab_pin.sym} 90860 -33030 0 0 {name=p90091 lab=_56703_/X }
C {devices/lab_pin.sym} 90860 -32990 0 0 {name=p90092 lab=_57199_/Y }
C {devices/lab_pin.sym} 91020 -33030 0 1 {name=p90093 lab=_57200_/Y }
C {sky130_stdcells/a21oi_4.sym} 90940 -33030 0 0 {name=X_57200_ }
C {devices/lab_pin.sym} 90850 -32890 0 0 {name=p90094 lab=_87253_/CLK }
C {devices/lab_pin.sym} 90850 -32870 0 0 {name=p90095 lab=_88020_/D }
C {devices/lab_pin.sym} 91030 -32890 0 1 {name=p90096 lab=_88020_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -32880 0 0 {name=X_88020_ }
C {devices/lab_pin.sym} 90900 -32750 0 0 {name=p90097 lab=_54385_/A }
C {devices/lab_pin.sym} 90980 -32750 0 1 {name=p90098 lab=_54417_/B }
C {sky130_stdcells/buf_2.sym} 90940 -32750 0 0 {name=X_54412_ }
C {devices/lab_pin.sym} 90850 -32630 0 0 {name=p90099 lab=_85167_/CLK }
C {devices/lab_pin.sym} 90850 -32610 0 0 {name=p90100 lab=_56333_/Y }
C {devices/lab_pin.sym} 91030 -32630 0 1 {name=p90101 lab=_55836_/B }
C {sky130_stdcells/dfxtp_4.sym} 90940 -32620 0 0 {name=X_85232_ }
C {devices/lab_pin.sym} 90860 -32510 0 0 {name=p90102 lab=_85976_/Q }
C {devices/lab_pin.sym} 90860 -32470 0 0 {name=p90103 lab=_51621_/X }
C {devices/lab_pin.sym} 90860 -32430 0 0 {name=p90104 lab=_51623_/Y }
C {devices/lab_pin.sym} 91020 -32470 0 1 {name=p90105 lab=_51624_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -32470 0 0 {name=X_51624_ }
C {devices/lab_pin.sym} 90860 -32350 0 0 {name=p90106 lab=_58171_/X }
C {devices/lab_pin.sym} 90860 -32310 0 0 {name=p90107 lab=_83490_/Q }
C {devices/lab_pin.sym} 90860 -32270 0 0 {name=p90108 lab=_58179_/Y }
C {devices/lab_pin.sym} 91020 -32310 0 1 {name=p90109 lab=_84914_/D }
C {sky130_stdcells/o21a_4.sym} 90940 -32310 0 0 {name=X_58180_ }
C {devices/lab_pin.sym} 90850 -32170 0 0 {name=p90110 lab=_82820_/CLK }
C {devices/lab_pin.sym} 90850 -32150 0 0 {name=p90111 lab=_79136_/X }
C {devices/lab_pin.sym} 91030 -32170 0 1 {name=p90112 lab=_82444_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -32160 0 0 {name=X_82444_ }
C {devices/lab_pin.sym} 90880 -32040 0 0 {name=p90113 lab=_55392_/A }
C {devices/lab_pin.sym} 90880 -32000 0 0 {name=p90114 lab=_55392_/B }
C {devices/lab_pin.sym} 91000 -32020 0 1 {name=p90115 lab=_55443_/D }
C {sky130_stdcells/xor2_4.sym} 90940 -32020 0 0 {name=X_55392_ }
C {devices/lab_pin.sym} 90880 -31900 0 0 {name=p90116 lab=_67333_/A }
C {devices/lab_pin.sym} 90880 -31860 0 0 {name=p90117 lab=_67378_/B }
C {devices/lab_pin.sym} 91000 -31880 0 1 {name=p90118 lab=_67378_/X }
C {sky130_stdcells/and2_4.sym} 90940 -31880 0 0 {name=X_67378_ }
C {devices/lab_pin.sym} 90900 -31750 0 0 {name=p90119 lab=clkbuf_9_165_0_CLK/X }
C {devices/lab_pin.sym} 90980 -31750 0 1 {name=p90120 lab=_86322_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 90940 -31750 0 0 {name=Xclkbuf_10_330_0_CLK }
C {devices/lab_pin.sym} 90900 -31630 0 0 {name=p90121 lab=_57131_/A }
C {devices/lab_pin.sym} 90980 -31630 0 1 {name=p90122 lab=_57155_/D }
C {sky130_stdcells/inv_2.sym} 90940 -31630 0 0 {name=X_57131_ }
C {devices/lab_pin.sym} 90860 -31530 0 0 {name=p90123 lab=_69112_/X }
C {devices/lab_pin.sym} 90860 -31490 0 0 {name=p90124 lab=_69115_/X }
C {devices/lab_pin.sym} 90860 -31450 0 0 {name=p90125 lab=_69116_/X }
C {devices/lab_pin.sym} 91020 -31490 0 1 {name=p90126 lab=_69117_/X }
C {sky130_stdcells/a21o_4.sym} 90940 -31490 0 0 {name=X_69117_ }
C {devices/lab_pin.sym} 90900 -31350 0 0 {name=p90127 lab=_53097_/A }
C {devices/lab_pin.sym} 90980 -31350 0 1 {name=p90128 lab=_54344_/A }
C {sky130_stdcells/buf_2.sym} 90940 -31350 0 0 {name=X_54343_ }
C {devices/lab_pin.sym} 90880 -31250 0 0 {name=p90129 lab=_65863_/X }
C {devices/lab_pin.sym} 90880 -31210 0 0 {name=p90130 lab=_66276_/B }
C {devices/lab_pin.sym} 90880 -31170 0 0 {name=p90131 lab=_65867_/X }
C {devices/lab_pin.sym} 91000 -31210 0 1 {name=p90132 lab=_66329_/Y }
C {sky130_stdcells/nand3_4.sym} 90940 -31210 0 0 {name=X_66329_ }
C {devices/lab_pin.sym} 90850 -31070 0 0 {name=p90133 lab=_80671_/CLK }
C {devices/lab_pin.sym} 90850 -31050 0 0 {name=p90134 lab=_56524_/Y }
C {devices/lab_pin.sym} 91030 -31070 0 1 {name=p90135 lab=_56523_/C }
C {sky130_stdcells/dfxtp_4.sym} 90940 -31060 0 0 {name=X_85163_ }
C {devices/lab_pin.sym} 90880 -30940 0 0 {name=p90136 lab=_51545_/A }
C {devices/lab_pin.sym} 90880 -30900 0 0 {name=p90137 lab=_53080_/B }
C {devices/lab_pin.sym} 91000 -30920 0 1 {name=p90138 lab=_51555_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -30920 0 0 {name=X_51555_ }
C {devices/lab_pin.sym} 90900 -30790 0 0 {name=p90139 lab=clkbuf_9_480_0_CLK/X }
C {devices/lab_pin.sym} 90980 -30790 0 1 {name=p90140 lab=_86554_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 90940 -30790 0 0 {name=Xclkbuf_10_960_0_CLK }
C {devices/lab_pin.sym} 90850 -30670 0 0 {name=p90141 lab=_85407_/CLK }
C {devices/lab_pin.sym} 90850 -30650 0 0 {name=p90142 lab=_82183_/Q }
C {devices/lab_pin.sym} 91030 -30670 0 1 {name=p90143 lab=_82375_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -30660 0 0 {name=X_82375_ }
C {devices/lab_pin.sym} 90850 -30530 0 0 {name=p90144 lab=_84115_/CLK }
C {devices/lab_pin.sym} 90850 -30510 0 0 {name=p90145 lab=_84114_/D }
C {devices/lab_pin.sym} 91030 -30530 0 1 {name=p90146 lab=_84114_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -30520 0 0 {name=X_84114_ }
C {devices/lab_pin.sym} 90900 -30390 0 0 {name=p90147 lab=_50506_/A }
C {devices/lab_pin.sym} 90980 -30390 0 1 {name=p90148 lab=_50506_/X }
C {sky130_stdcells/buf_2.sym} 90940 -30390 0 0 {name=X_50506_ }
C {devices/lab_pin.sym} 90880 -30290 0 0 {name=p90149 lab=_57056_/Y }
C {devices/lab_pin.sym} 90880 -30250 0 0 {name=p90150 lab=_57673_/A }
C {devices/lab_pin.sym} 90880 -30210 0 0 {name=p90151 lab=_57061_/Y }
C {devices/lab_pin.sym} 91000 -30250 0 1 {name=p90152 lab=_57062_/Y }
C {sky130_stdcells/nand3_4.sym} 90940 -30250 0 0 {name=X_57062_ }
C {devices/lab_pin.sym} 90850 -30110 0 0 {name=p90153 lab=_81492_/CLK }
C {devices/lab_pin.sym} 90850 -30090 0 0 {name=p90154 lab=_76326_/X }
C {devices/lab_pin.sym} 91030 -30110 0 1 {name=p90155 lab=_81702_/D }
C {sky130_stdcells/dfxtp_4.sym} 90940 -30100 0 0 {name=X_81326_ }
C {devices/lab_pin.sym} 90880 -29980 0 0 {name=p90156 lab=_69027_/A }
C {devices/lab_pin.sym} 90880 -29940 0 0 {name=p90157 lab=_69048_/B }
C {devices/lab_pin.sym} 91000 -29960 0 1 {name=p90158 lab=_69048_/X }
C {sky130_stdcells/and2_4.sym} 90940 -29960 0 0 {name=X_69048_ }
C {devices/lab_pin.sym} 90900 -29830 0 0 {name=p90159 lab=_54329_/A }
C {devices/lab_pin.sym} 90980 -29830 0 1 {name=p90160 lab=_54298_/B }
C {sky130_stdcells/buf_2.sym} 90940 -29830 0 0 {name=X_54274_ }
C {devices/lab_pin.sym} 90850 -29710 0 0 {name=p90161 lab=_85096_/CLK }
C {devices/lab_pin.sym} 90850 -29690 0 0 {name=p90162 lab=_57065_/X }
C {devices/lab_pin.sym} 91030 -29710 0 1 {name=p90163 lab=_45808_/A }
C {sky130_stdcells/dfxtp_4.sym} 90940 -29700 0 0 {name=X_85094_ }
C {devices/lab_pin.sym} 90900 -29570 0 0 {name=p90164 lab=_51211_/A }
C {devices/lab_pin.sym} 90980 -29570 0 1 {name=p90165 lab=_51491_/A }
C {sky130_stdcells/buf_2.sym} 90940 -29570 0 0 {name=X_51486_ }
C {devices/lab_pin.sym} 90900 -29450 0 0 {name=p90166 lab=clkbuf_9_451_0_CLK/A }
C {devices/lab_pin.sym} 90980 -29450 0 1 {name=p90167 lab=clkbuf_9_451_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 90940 -29450 0 0 {name=Xclkbuf_9_451_0_CLK }
C {devices/lab_pin.sym} 90900 -29330 0 0 {name=p90168 lab=_56030_/B }
C {devices/lab_pin.sym} 90980 -29330 0 1 {name=p90169 lab=_56013_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -29330 0 0 {name=X_56013_ }
C {devices/lab_pin.sym} 90900 -29210 0 0 {name=p90170 lab=_51928_/X }
C {devices/lab_pin.sym} 90980 -29210 0 1 {name=p90171 lab=_53225_/X }
C {sky130_stdcells/buf_2.sym} 90940 -29210 0 0 {name=X_53225_ }
C {devices/lab_pin.sym} 90850 -29090 0 0 {name=p90172 lab=_88116_/CLK }
C {devices/lab_pin.sym} 90850 -29070 0 0 {name=p90173 lab=_84045_/D }
C {devices/lab_pin.sym} 91030 -29090 0 1 {name=p90174 lab=_81477_/D }
C {sky130_stdcells/dfxtp_4.sym} 90940 -29080 0 0 {name=X_84045_ }
C {devices/lab_pin.sym} 90900 -28950 0 0 {name=p90175 lab=_50464_/A }
C {devices/lab_pin.sym} 90980 -28950 0 1 {name=p90176 lab=_50437_/X }
C {sky130_stdcells/buf_2.sym} 90940 -28950 0 0 {name=X_50437_ }
C {devices/lab_pin.sym} 90850 -28830 0 0 {name=p90177 lab=_81257_/CLK }
C {devices/lab_pin.sym} 90850 -28810 0 0 {name=p90178 lab=_81257_/D }
C {devices/lab_pin.sym} 91030 -28830 0 1 {name=p90179 lab=_81257_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -28820 0 0 {name=X_81257_ }
C {devices/lab_pin.sym} 90900 -28690 0 0 {name=p90180 lab=clkbuf_9_172_0_CLK/X }
C {devices/lab_pin.sym} 90980 -28690 0 1 {name=p90181 lab=_83703_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 90940 -28690 0 0 {name=Xclkbuf_10_345_0_CLK }
C {devices/lab_pin.sym} 90900 -28570 0 0 {name=p90182 lab=_71266_/A }
C {devices/lab_pin.sym} 90980 -28570 0 1 {name=p90183 lab=_71010_/X }
C {sky130_stdcells/buf_2.sym} 90940 -28570 0 0 {name=X_71010_ }
C {devices/lab_pin.sym} 90900 -28450 0 0 {name=p90184 lab=clkbuf_9_487_0_CLK/X }
C {devices/lab_pin.sym} 90980 -28450 0 1 {name=p90185 lab=_83313_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 90940 -28450 0 0 {name=Xclkbuf_10_975_0_CLK }
C {devices/lab_pin.sym} 90880 -28340 0 0 {name=p90186 lab=_80204_/Y }
C {devices/lab_pin.sym} 90880 -28300 0 0 {name=p90187 lab=_80207_/Y }
C {devices/lab_pin.sym} 91000 -28320 0 1 {name=p90188 lab=_80208_/X }
C {sky130_stdcells/xor2_4.sym} 90940 -28320 0 0 {name=X_80208_ }
C {devices/lab_pin.sym} 90860 -28220 0 0 {name=p90189 lab=_41169_/X }
C {devices/lab_pin.sym} 90860 -28180 0 0 {name=p90190 lab=_41152_/X }
C {devices/lab_pin.sym} 90860 -28140 0 0 {name=p90191 lab=_68658_/B }
C {devices/lab_pin.sym} 90860 -28100 0 0 {name=p90192 lab=_41153_/X }
C {devices/lab_pin.sym} 91020 -28160 0 1 {name=p90193 lab=_41170_/X }
C {sky130_stdcells/a2bb2o_4.sym} 90940 -28160 0 0 {name=X_41170_ }
C {devices/lab_pin.sym} 90860 -28030 0 0 {name=p90194 lab=_53154_/Y }
C {devices/lab_pin.sym} 90860 -27990 0 0 {name=p90195 lab=_53137_/X }
C {devices/lab_pin.sym} 90860 -27950 0 0 {name=p90196 lab=_53155_/X }
C {devices/lab_pin.sym} 91020 -27990 0 1 {name=p90197 lab=_85687_/D }
C {sky130_stdcells/a21oi_4.sym} 90940 -27990 0 0 {name=X_53156_ }
C {devices/lab_pin.sym} 90880 -27860 0 0 {name=p90198 lab=_50381_/A }
C {devices/lab_pin.sym} 90880 -27820 0 0 {name=p90199 lab=_50368_/B }
C {devices/lab_pin.sym} 91000 -27840 0 1 {name=p90200 lab=_50368_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -27840 0 0 {name=X_50368_ }
C {devices/lab_pin.sym} 90850 -27710 0 0 {name=p90201 lab=_82692_/CLK }
C {devices/lab_pin.sym} 90850 -27690 0 0 {name=p90202 lab=_81188_/D }
C {devices/lab_pin.sym} 91030 -27710 0 1 {name=p90203 lab=_49179_/A }
C {sky130_stdcells/dfxtp_4.sym} 90940 -27700 0 0 {name=X_81188_ }
C {devices/lab_pin.sym} 90900 -27570 0 0 {name=p90204 lab=_52618_/A }
C {devices/lab_pin.sym} 90980 -27570 0 1 {name=p90205 lab=_52203_/A }
C {sky130_stdcells/buf_2.sym} 90940 -27570 0 0 {name=X_52107_ }
C {devices/lab_pin.sym} 90850 -27450 0 0 {name=p90206 lab=_88062_/CLK }
C {devices/lab_pin.sym} 90850 -27430 0 0 {name=p90207 lab=_87804_/D }
C {devices/lab_pin.sym} 91030 -27450 0 1 {name=p90208 lab=_73345_/A }
C {sky130_stdcells/dfxtp_4.sym} 90940 -27440 0 0 {name=X_87804_ }
C {devices/lab_pin.sym} 90860 -27330 0 0 {name=p90209 lab=_80136_/Y }
C {devices/lab_pin.sym} 90860 -27290 0 0 {name=p90210 lab=_80119_/Y }
C {devices/lab_pin.sym} 90860 -27250 0 0 {name=p90211 lab=_80138_/X }
C {devices/lab_pin.sym} 91020 -27290 0 1 {name=p90212 lab=_80139_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -27290 0 0 {name=X_80139_ }
C {devices/lab_pin.sym} 90900 -27150 0 0 {name=p90213 lab=clkbuf_9_467_0_CLK/A }
C {devices/lab_pin.sym} 90980 -27150 0 1 {name=p90214 lab=clkbuf_9_466_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 90940 -27150 0 0 {name=Xclkbuf_9_466_0_CLK }
C {devices/lab_pin.sym} 90860 -27050 0 0 {name=p90215 lab=_85699_/Q }
C {devices/lab_pin.sym} 90860 -27010 0 0 {name=p90216 lab=_53065_/X }
C {devices/lab_pin.sym} 90860 -26970 0 0 {name=p90217 lab=_53086_/Y }
C {devices/lab_pin.sym} 91020 -27010 0 1 {name=p90218 lab=_53087_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -27010 0 0 {name=X_53087_ }
C {devices/lab_pin.sym} 90860 -26890 0 0 {name=p90219 lab=_57875_/X }
C {devices/lab_pin.sym} 90860 -26850 0 0 {name=p90220 lab=_85392_/Q }
C {devices/lab_pin.sym} 90860 -26810 0 0 {name=p90221 lab=_57963_/X }
C {devices/lab_pin.sym} 91020 -26850 0 1 {name=p90222 lab=_57964_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -26850 0 0 {name=X_57964_ }
C {devices/lab_pin.sym} 90900 -26710 0 0 {name=p90223 lab=_50227_/A }
C {devices/lab_pin.sym} 90980 -26710 0 1 {name=p90224 lab=_50299_/X }
C {sky130_stdcells/buf_2.sym} 90940 -26710 0 0 {name=X_50299_ }
C {devices/lab_pin.sym} 90850 -26590 0 0 {name=p90225 lab=_85709_/CLK }
C {devices/lab_pin.sym} 90850 -26570 0 0 {name=p90226 lab=_85996_/D }
C {devices/lab_pin.sym} 91030 -26590 0 1 {name=p90227 lab=_85996_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -26580 0 0 {name=X_85996_ }
C {devices/lab_pin.sym} 90860 -26490 0 0 {name=p90228 lab=_59655_/X }
C {devices/lab_pin.sym} 90860 -26450 0 0 {name=p90229 lab=_59700_/Y }
C {devices/lab_pin.sym} 90860 -26410 0 0 {name=p90230 lab=_59680_/Y }
C {devices/lab_pin.sym} 90860 -26370 0 0 {name=p90231 lab=_59689_/Y }
C {devices/lab_pin.sym} 90860 -26340 0 0 {name=p90232 lab=_59702_/Y }
C {devices/lab_pin.sym} 91020 -26410 0 1 {name=p90233 lab=_59703_/Y }
C {sky130_stdcells/a41oi_4.sym} 90940 -26410 0 0 {name=X_59703_ }
C {devices/lab_pin.sym} 90900 -26250 0 0 {name=p90234 lab=_51265_/A }
C {devices/lab_pin.sym} 90980 -26250 0 1 {name=p90235 lab=_52098_/B }
C {sky130_stdcells/buf_2.sym} 90940 -26250 0 0 {name=X_52038_ }
C {devices/lab_pin.sym} 90880 -26140 0 0 {name=p90236 lab=_56609_/X }
C {devices/lab_pin.sym} 90880 -26100 0 0 {name=p90237 lab=_56914_/Y }
C {devices/lab_pin.sym} 91000 -26120 0 1 {name=p90238 lab=_56915_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -26120 0 0 {name=X_56915_ }
C {devices/lab_pin.sym} 90850 -25990 0 0 {name=p90239 lab=_88002_/CLK }
C {devices/lab_pin.sym} 90850 -25970 0 0 {name=p90240 lab=_42756_/X }
C {devices/lab_pin.sym} 91030 -25990 0 1 {name=p90241 lab=_69042_/B }
C {sky130_stdcells/dfxtp_4.sym} 90940 -25980 0 0 {name=X_87735_ }
C {devices/lab_pin.sym} 90860 -25880 0 0 {name=p90242 lab=_72959_/X }
C {devices/lab_pin.sym} 90860 -25840 0 0 {name=p90243 lab=_85594_/Q }
C {devices/lab_pin.sym} 90860 -25800 0 0 {name=p90244 lab=_72839_/X }
C {devices/lab_pin.sym} 90860 -25760 0 0 {name=p90245 lab=_72960_/X }
C {devices/lab_pin.sym} 91020 -25820 0 1 {name=p90246 lab=_72961_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -25820 0 0 {name=X_72961_ }
C {devices/lab_pin.sym} 90850 -25670 0 0 {name=p90247 lab=_83745_/CLK }
C {devices/lab_pin.sym} 90850 -25650 0 0 {name=p90248 lab=_57831_/Y }
C {devices/lab_pin.sym} 91030 -25670 0 1 {name=p90249 lab=_84947_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -25660 0 0 {name=X_84947_ }
C {devices/lab_pin.sym} 90860 -25560 0 0 {name=p90250 lab=_57883_/Y }
C {devices/lab_pin.sym} 90860 -25520 0 0 {name=p90251 lab=_57758_/X }
C {devices/lab_pin.sym} 90860 -25480 0 0 {name=p90252 lab=_57890_/X }
C {devices/lab_pin.sym} 90860 -25440 0 0 {name=p90253 lab=_57894_/X }
C {devices/lab_pin.sym} 91020 -25500 0 1 {name=p90254 lab=_57895_/Y }
C {sky130_stdcells/a22oi_4.sym} 90940 -25500 0 0 {name=X_57895_ }
C {devices/lab_pin.sym} 90880 -25360 0 0 {name=p90255 lab=_74673_/A }
C {devices/lab_pin.sym} 90880 -25320 0 0 {name=p90256 lab=_74700_/B }
C {devices/lab_pin.sym} 91000 -25340 0 1 {name=p90257 lab=_74700_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -25340 0 0 {name=X_74700_ }
C {devices/lab_pin.sym} 90900 -25210 0 0 {name=p90258 lab=_71891_/Y }
C {devices/lab_pin.sym} 90980 -25210 0 1 {name=p90259 lab=_71912_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -25210 0 0 {name=X_71912_ }
C {devices/lab_pin.sym} 90880 -25110 0 0 {name=p90260 lab=_59634_/A }
C {devices/lab_pin.sym} 90880 -25070 0 0 {name=p90261 lab=_59634_/B }
C {devices/lab_pin.sym} 90880 -25030 0 0 {name=p90262 lab=_59662_/B }
C {devices/lab_pin.sym} 91000 -25070 0 1 {name=p90263 lab=_59648_/A }
C {sky130_stdcells/nand3_4.sym} 90940 -25070 0 0 {name=X_59634_ }
C {devices/lab_pin.sym} 90900 -24930 0 0 {name=p90264 lab=_44860_/A }
C {devices/lab_pin.sym} 90980 -24930 0 1 {name=p90265 lab=_86916_/D }
C {sky130_stdcells/inv_2.sym} 90940 -24930 0 0 {name=X_44860_ }
C {devices/lab_pin.sym} 90860 -24850 0 0 {name=p90266 lab=_56691_/A }
C {devices/lab_pin.sym} 90860 -24810 0 0 {name=p90267 lab=_56836_/Y }
C {devices/lab_pin.sym} 90860 -24770 0 0 {name=p90268 lab=_56843_/Y }
C {devices/lab_pin.sym} 90860 -24730 0 0 {name=p90269 lab=_56844_/X }
C {devices/lab_pin.sym} 90860 -24690 0 0 {name=p90270 lab=_56845_/Y }
C {devices/lab_pin.sym} 91020 -24770 0 1 {name=p90271 lab=_56846_/Y }
C {sky130_stdcells/a32oi_4.sym} 90940 -24770 0 0 {name=X_56846_ }
C {devices/lab_pin.sym} 90880 -24620 0 0 {name=p90272 lab=_75680_/A }
C {devices/lab_pin.sym} 90880 -24580 0 0 {name=p90273 lab=_75679_/X }
C {devices/lab_pin.sym} 91000 -24600 0 1 {name=p90274 lab=_75684_/A }
C {sky130_stdcells/nand2_4.sym} 90940 -24600 0 0 {name=X_75680_ }
C {devices/lab_pin.sym} 90850 -24470 0 0 {name=p90275 lab=_81783_/CLK }
C {devices/lab_pin.sym} 90850 -24450 0 0 {name=p90276 lab=_87666_/D }
C {devices/lab_pin.sym} 91030 -24470 0 1 {name=p90277 lab=_67356_/B }
C {sky130_stdcells/dfxtp_4.sym} 90940 -24460 0 0 {name=X_87666_ }
C {devices/lab_pin.sym} 90880 -24340 0 0 {name=p90278 lab=_42555_/A }
C {devices/lab_pin.sym} 90880 -24300 0 0 {name=p90279 lab=_72892_/B }
C {devices/lab_pin.sym} 91000 -24320 0 1 {name=p90280 lab=_72892_/Y }
C {sky130_stdcells/nor2_4.sym} 90940 -24320 0 0 {name=X_72892_ }
C {devices/lab_pin.sym} 90850 -24190 0 0 {name=p90281 lab=_84849_/CLK }
C {devices/lab_pin.sym} 90850 -24170 0 0 {name=p90282 lab=_84878_/D }
C {devices/lab_pin.sym} 91030 -24190 0 1 {name=p90283 lab=_58322_/A }
C {sky130_stdcells/dfxtp_4.sym} 90940 -24180 0 0 {name=X_84878_ }
C {devices/lab_pin.sym} 90900 -24050 0 0 {name=p90284 lab=_43776_/A }
C {devices/lab_pin.sym} 90980 -24050 0 1 {name=p90285 lab=_43811_/X }
C {sky130_stdcells/buf_2.sym} 90940 -24050 0 0 {name=X_43811_ }
C {devices/lab_pin.sym} 90860 -23970 0 0 {name=p90286 lab=_56560_/X }
C {devices/lab_pin.sym} 90860 -23930 0 0 {name=p90287 lab=_45935_/X }
C {devices/lab_pin.sym} 90860 -23890 0 0 {name=p90288 lab=_56931_/X }
C {devices/lab_pin.sym} 90860 -23850 0 0 {name=p90289 lab=_83009_/Q }
C {devices/lab_pin.sym} 90860 -23810 0 0 {name=p90290 lab=_74630_/X }
C {devices/lab_pin.sym} 91020 -23890 0 1 {name=p90291 lab=_83009_/D }
C {sky130_stdcells/a32o_4.sym} 90940 -23890 0 0 {name=X_74631_ }
C {devices/lab_pin.sym} 90850 -23730 0 0 {name=p90292 lab=_85974_/CLK }
C {devices/lab_pin.sym} 90850 -23710 0 0 {name=p90293 lab=_86617_/D }
C {devices/lab_pin.sym} 91030 -23730 0 1 {name=p90294 lab=_86617_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -23720 0 0 {name=X_86617_ }
C {devices/lab_pin.sym} 90880 -23620 0 0 {name=p90295 lab=_71072_/A }
C {devices/lab_pin.sym} 90880 -23580 0 0 {name=p90296 lab=_71714_/Y }
C {devices/lab_pin.sym} 90880 -23540 0 0 {name=p90297 lab=_71439_/C }
C {devices/lab_pin.sym} 90880 -23500 0 0 {name=p90298 lab=_70721_/A }
C {devices/lab_pin.sym} 91000 -23560 0 1 {name=p90299 lab=_71843_/X }
C {sky130_stdcells/and4_4.sym} 90940 -23560 0 0 {name=X_71843_ }
C {devices/lab_pin.sym} 90850 -23410 0 0 {name=p90300 lab=_83188_/CLK }
C {devices/lab_pin.sym} 90850 -23390 0 0 {name=p90301 lab=_83829_/D }
C {devices/lab_pin.sym} 91030 -23410 0 1 {name=p90302 lab=_83829_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -23400 0 0 {name=X_83829_ }
C {devices/lab_pin.sym} 90880 -23290 0 0 {name=p90303 lab=_59564_/A }
C {devices/lab_pin.sym} 90880 -23250 0 0 {name=p90304 lab=_59890_/B }
C {devices/lab_pin.sym} 90880 -23210 0 0 {name=p90305 lab=_59544_/D }
C {devices/lab_pin.sym} 91000 -23250 0 1 {name=p90306 lab=_60122_/C }
C {sky130_stdcells/nand3_4.sym} 90940 -23250 0 0 {name=X_59565_ }
C {devices/lab_pin.sym} 90860 -23150 0 0 {name=p90307 lab=_44512_/A }
C {devices/lab_pin.sym} 90860 -23110 0 0 {name=p90308 lab=_41887_/A }
C {devices/lab_pin.sym} 90860 -23070 0 0 {name=p90309 lab=_41402_/X }
C {devices/lab_pin.sym} 90860 -23030 0 0 {name=p90310 lab=_86953_/Q }
C {devices/lab_pin.sym} 90860 -22990 0 0 {name=p90311 lab=_44516_/A }
C {devices/lab_pin.sym} 91020 -23070 0 1 {name=p90312 lab=_44791_/Y }
C {sky130_stdcells/o32ai_4.sym} 90940 -23070 0 0 {name=X_44791_ }
C {devices/lab_pin.sym} 90880 -22920 0 0 {name=p90313 lab=_56777_/A }
C {devices/lab_pin.sym} 90880 -22880 0 0 {name=p90314 lab=_56777_/B }
C {devices/lab_pin.sym} 91000 -22900 0 1 {name=p90315 lab=_56777_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -22900 0 0 {name=X_56777_ }
C {devices/lab_pin.sym} 90850 -22770 0 0 {name=p90316 lab=_87070_/CLK }
C {devices/lab_pin.sym} 90850 -22750 0 0 {name=p90317 lab=_87597_/D }
C {devices/lab_pin.sym} 91030 -22770 0 1 {name=p90318 lab=_87597_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -22760 0 0 {name=X_87597_ }
C {devices/lab_pin.sym} 90900 -22630 0 0 {name=p90319 lab=_53921_/A }
C {devices/lab_pin.sym} 90980 -22630 0 1 {name=p90320 lab=_53989_/X }
C {sky130_stdcells/buf_2.sym} 90940 -22630 0 0 {name=X_53989_ }
C {devices/lab_pin.sym} 90900 -22510 0 0 {name=p90321 lab=_51360_/B }
C {devices/lab_pin.sym} 90980 -22510 0 1 {name=p90322 lab=_50850_/B }
C {sky130_stdcells/buf_2.sym} 90940 -22510 0 0 {name=X_46530_ }
C {devices/lab_pin.sym} 90860 -22410 0 0 {name=p90323 lab=_58492_/X }
C {devices/lab_pin.sym} 90860 -22370 0 0 {name=p90324 lab=_58513_/Y }
C {devices/lab_pin.sym} 90860 -22330 0 0 {name=p90325 lab=_58515_/Y }
C {devices/lab_pin.sym} 91020 -22370 0 1 {name=p90326 lab=_58516_/Y }
C {sky130_stdcells/a21oi_4.sym} 90940 -22370 0 0 {name=X_58516_ }
C {devices/lab_pin.sym} 90860 -22250 0 0 {name=p90327 lab=_77346_/Y }
C {devices/lab_pin.sym} 90860 -22210 0 0 {name=p90328 lab=_77290_/B }
C {devices/lab_pin.sym} 90860 -22170 0 0 {name=p90329 lab=_77349_/X }
C {devices/lab_pin.sym} 91020 -22210 0 1 {name=p90330 lab=_77351_/B }
C {sky130_stdcells/o21ai_4.sym} 90940 -22210 0 0 {name=X_77350_ }
C {devices/lab_pin.sym} 90860 -22100 0 0 {name=p90331 lab=_40908_/X }
C {devices/lab_pin.sym} 90860 -22060 0 0 {name=p90332 lab=_47846_/A }
C {devices/lab_pin.sym} 90860 -22020 0 0 {name=p90333 lab=_43741_/Y }
C {devices/lab_pin.sym} 90860 -21980 0 0 {name=p90334 lab=_43607_/A }
C {devices/lab_pin.sym} 91020 -22040 0 1 {name=p90335 lab=_43743_/A }
C {sky130_stdcells/a2bb2o_4.sym} 90940 -22040 0 0 {name=X_43742_ }
C {devices/lab_pin.sym} 90900 -21890 0 0 {name=p90336 lab=clkbuf_9_456_0_CLK/X }
C {devices/lab_pin.sym} 90980 -21890 0 1 {name=p90337 lab=_83133_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 90940 -21890 0 0 {name=Xclkbuf_10_913_0_CLK }
C {devices/lab_pin.sym} 90880 -21780 0 0 {name=p90338 lab=_45331_/A }
C {devices/lab_pin.sym} 90880 -21740 0 0 {name=p90339 lab=_55145_/A }
C {devices/lab_pin.sym} 91000 -21760 0 1 {name=p90340 lab=_55728_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -21760 0 0 {name=X_55728_ }
C {devices/lab_pin.sym} 90860 -21660 0 0 {name=p90341 lab=_74559_/X }
C {devices/lab_pin.sym} 90860 -21620 0 0 {name=p90342 lab=_74553_/X }
C {devices/lab_pin.sym} 90860 -21580 0 0 {name=p90343 lab=_56039_/Y }
C {devices/lab_pin.sym} 90860 -21540 0 0 {name=p90344 lab=_74554_/X }
C {devices/lab_pin.sym} 91020 -21600 0 1 {name=p90345 lab=_74562_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -21600 0 0 {name=X_74562_ }
C {devices/lab_pin.sym} 90850 -21450 0 0 {name=p90346 lab=_86549_/CLK }
C {devices/lab_pin.sym} 90850 -21430 0 0 {name=p90347 lab=_86548_/D }
C {devices/lab_pin.sym} 91030 -21450 0 1 {name=p90348 lab=_66101_/B }
C {sky130_stdcells/dfxtp_4.sym} 90940 -21440 0 0 {name=X_86548_ }
C {devices/lab_pin.sym} 90860 -21330 0 0 {name=p90349 lab=_40931_/X }
C {devices/lab_pin.sym} 90860 -21290 0 0 {name=p90350 lab=_81726_/Q }
C {devices/lab_pin.sym} 90860 -21250 0 0 {name=p90351 lab=_40953_/X }
C {devices/lab_pin.sym} 91020 -21290 0 1 {name=p90352 lab=_40954_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -21290 0 0 {name=X_40954_ }
C {devices/lab_pin.sym} 90900 -21150 0 0 {name=p90353 lab=_70502_/Y }
C {devices/lab_pin.sym} 90980 -21150 0 1 {name=p90354 lab=_71779_/A }
C {sky130_stdcells/buf_2.sym} 90940 -21150 0 0 {name=X_71774_ }
C {devices/lab_pin.sym} 90900 -21030 0 0 {name=p90355 lab=_64276_/C }
C {devices/lab_pin.sym} 90980 -21030 0 1 {name=p90356 lab=_63424_/B }
C {sky130_stdcells/buf_2.sym} 90940 -21030 0 0 {name=X_59496_ }
C {devices/lab_pin.sym} 90880 -20920 0 0 {name=p90357 lab=_76301_/A }
C {devices/lab_pin.sym} 90880 -20880 0 0 {name=p90358 lab=_81561_/Q }
C {devices/lab_pin.sym} 91000 -20900 0 1 {name=p90359 lab=_76301_/Y }
C {sky130_stdcells/nor2_4.sym} 90940 -20900 0 0 {name=X_76301_ }
C {devices/lab_pin.sym} 90900 -20770 0 0 {name=p90360 lab=clkbuf_9_1_0_CLK/X }
C {devices/lab_pin.sym} 90980 -20770 0 1 {name=p90361 lab=_85269_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 90940 -20770 0 0 {name=Xclkbuf_10_2_0_CLK }
C {devices/lab_pin.sym} 90860 -20670 0 0 {name=p90362 lab=_44598_/Y }
C {devices/lab_pin.sym} 90860 -20630 0 0 {name=p90363 lab=_73420_/X }
C {devices/lab_pin.sym} 90860 -20590 0 0 {name=p90364 lab=_73512_/Y }
C {devices/lab_pin.sym} 91020 -20630 0 1 {name=p90365 lab=_73524_/C }
C {sky130_stdcells/a21o_4.sym} 90940 -20630 0 0 {name=X_73513_ }
C {devices/lab_pin.sym} 90860 -20510 0 0 {name=p90366 lab=_52781_/B }
C {devices/lab_pin.sym} 90860 -20470 0 0 {name=p90367 lab=_70699_/A }
C {devices/lab_pin.sym} 90860 -20430 0 0 {name=p90368 lab=_70724_/Y }
C {devices/lab_pin.sym} 91020 -20470 0 1 {name=p90369 lab=_70725_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -20470 0 0 {name=X_70725_ }
C {devices/lab_pin.sym} 90900 -20330 0 0 {name=p90370 lab=_51326_/B }
C {devices/lab_pin.sym} 90980 -20330 0 1 {name=p90371 lab=_50816_/B }
C {sky130_stdcells/buf_2.sym} 90940 -20330 0 0 {name=X_46461_ }
C {devices/lab_pin.sym} 90860 -20230 0 0 {name=p90372 lab=_58423_/X }
C {devices/lab_pin.sym} 90860 -20190 0 0 {name=p90373 lab=_83478_/Q }
C {devices/lab_pin.sym} 90860 -20150 0 0 {name=p90374 lab=_58446_/Y }
C {devices/lab_pin.sym} 91020 -20190 0 1 {name=p90375 lab=_58447_/X }
C {sky130_stdcells/o21a_4.sym} 90940 -20190 0 0 {name=X_58447_ }
C {devices/lab_pin.sym} 90880 -20070 0 0 {name=p90376 lab=_77278_/X }
C {devices/lab_pin.sym} 90880 -20030 0 0 {name=p90377 lab=_82214_/Q }
C {devices/lab_pin.sym} 90880 -19990 0 0 {name=p90378 lab=_77279_/Y }
C {devices/lab_pin.sym} 91000 -20030 0 1 {name=p90379 lab=_77285_/C }
C {sky130_stdcells/nand3_4.sym} 90940 -20030 0 0 {name=X_77281_ }
C {devices/lab_pin.sym} 90900 -19890 0 0 {name=p90380 lab=clkbuf_5_30_0_CLK/A }
C {devices/lab_pin.sym} 90980 -19890 0 1 {name=p90381 lab=clkbuf_6_61_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 90940 -19890 0 0 {name=Xclkbuf_5_30_0_CLK }
C {devices/lab_pin.sym} 90900 -19770 0 0 {name=p90382 lab=_43673_/A }
C {devices/lab_pin.sym} 90980 -19770 0 1 {name=p90383 lab=_43673_/X }
C {sky130_stdcells/buf_2.sym} 90940 -19770 0 0 {name=X_43673_ }
C {devices/lab_pin.sym} 90860 -19670 0 0 {name=p90384 lab=_55656_/X }
C {devices/lab_pin.sym} 90860 -19630 0 0 {name=p90385 lab=_55657_/Y }
C {devices/lab_pin.sym} 90860 -19590 0 0 {name=p90386 lab=_55658_/Y }
C {devices/lab_pin.sym} 91020 -19630 0 1 {name=p90387 lab=_55659_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -19630 0 0 {name=X_55659_ }
C {devices/lab_pin.sym} 90900 -19490 0 0 {name=p90388 lab=clkbuf_8_202_0_CLK/X }
C {devices/lab_pin.sym} 90980 -19490 0 1 {name=p90389 lab=clkbuf_9_404_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 90940 -19490 0 0 {name=Xclkbuf_9_404_0_CLK }
C {devices/lab_pin.sym} 90880 -19390 0 0 {name=p90390 lab=_48656_/A }
C {devices/lab_pin.sym} 90880 -19350 0 0 {name=p90391 lab=_74501_/B }
C {devices/lab_pin.sym} 90880 -19310 0 0 {name=p90392 lab=_74501_/C }
C {devices/lab_pin.sym} 91000 -19350 0 1 {name=p90393 lab=_74493_/X }
C {sky130_stdcells/and3_4.sym} 90940 -19350 0 0 {name=X_74493_ }
C {devices/lab_pin.sym} 90850 -19210 0 0 {name=p90394 lab=_86191_/CLK }
C {devices/lab_pin.sym} 90850 -19190 0 0 {name=p90395 lab=_86479_/D }
C {devices/lab_pin.sym} 91030 -19210 0 1 {name=p90396 lab=_86479_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -19200 0 0 {name=X_86479_ }
C {devices/lab_pin.sym} 90900 -19070 0 0 {name=p90397 lab=_40885_/A }
C {devices/lab_pin.sym} 90980 -19070 0 1 {name=p90398 lab=_40885_/X }
C {sky130_stdcells/buf_2.sym} 90940 -19070 0 0 {name=X_40885_ }
C {devices/lab_pin.sym} 90900 -18950 0 0 {name=p90399 lab=_46485_/X }
C {devices/lab_pin.sym} 90980 -18950 0 1 {name=p90400 lab=_48201_/B }
C {sky130_stdcells/buf_2.sym} 90940 -18950 0 0 {name=X_48200_ }
C {devices/lab_pin.sym} 90880 -18840 0 0 {name=p90401 lab=_82826_/Q }
C {devices/lab_pin.sym} 90880 -18800 0 0 {name=p90402 lab=_79020_/B }
C {devices/lab_pin.sym} 91000 -18820 0 1 {name=p90403 lab=_79021_/B }
C {sky130_stdcells/xor2_4.sym} 90940 -18820 0 0 {name=X_79020_ }
C {devices/lab_pin.sym} 90900 -18690 0 0 {name=p90404 lab=_44891_/X }
C {devices/lab_pin.sym} 90980 -18690 0 1 {name=p90405 lab=_45412_/X }
C {sky130_stdcells/buf_2.sym} 90940 -18690 0 0 {name=X_45412_ }
C {devices/lab_pin.sym} 90900 -18570 0 0 {name=p90406 lab=_76232_/A }
C {devices/lab_pin.sym} 90980 -18570 0 1 {name=p90407 lab=_76232_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -18570 0 0 {name=X_76232_ }
C {devices/lab_pin.sym} 90850 -18450 0 0 {name=p90408 lab=_88208_/CLK }
C {devices/lab_pin.sym} 90850 -18430 0 0 {name=p90409 lab=_88218_/D }
C {devices/lab_pin.sym} 91030 -18450 0 1 {name=p90410 lab=_88218_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -18440 0 0 {name=X_88218_ }
C {devices/lab_pin.sym} 90900 -18310 0 0 {name=p90411 lab=_73527_/A }
C {devices/lab_pin.sym} 90980 -18310 0 1 {name=p90412 lab=_69969_/B }
C {sky130_stdcells/inv_2.sym} 90940 -18310 0 0 {name=X_42624_ }
C {devices/lab_pin.sym} 90860 -18210 0 0 {name=p90413 lab=_49128_/X }
C {devices/lab_pin.sym} 90860 -18170 0 0 {name=p90414 lab=_48687_/A }
C {devices/lab_pin.sym} 90860 -18130 0 0 {name=p90415 lab=_49179_/Y }
C {devices/lab_pin.sym} 91020 -18170 0 1 {name=p90416 lab=_49181_/A }
C {sky130_stdcells/a21o_4.sym} 90940 -18170 0 0 {name=X_49180_ }
C {devices/lab_pin.sym} 90860 -18050 0 0 {name=p90417 lab=_87044_/Q }
C {devices/lab_pin.sym} 90860 -18010 0 0 {name=p90418 lab=_57092_/X }
C {devices/lab_pin.sym} 90860 -17970 0 0 {name=p90419 lab=_73443_/X }
C {devices/lab_pin.sym} 91020 -18010 0 1 {name=p90420 lab=_73444_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -18010 0 0 {name=X_73444_ }
C {devices/lab_pin.sym} 90880 -17880 0 0 {name=p90421 lab=_46362_/A }
C {devices/lab_pin.sym} 90880 -17840 0 0 {name=p90422 lab=_52482_/B }
C {devices/lab_pin.sym} 91000 -17860 0 1 {name=p90423 lab=_46392_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -17860 0 0 {name=X_46392_ }
C {devices/lab_pin.sym} 90880 -17760 0 0 {name=p90424 lab=_70724_/A }
C {devices/lab_pin.sym} 90880 -17720 0 0 {name=p90425 lab=_70656_/B }
C {devices/lab_pin.sym} 90880 -17680 0 0 {name=p90426 lab=_70890_/C }
C {devices/lab_pin.sym} 90880 -17640 0 0 {name=p90427 lab=_70656_/D }
C {devices/lab_pin.sym} 91000 -17700 0 1 {name=p90428 lab=_70656_/Y }
C {sky130_stdcells/nand4_4.sym} 90940 -17700 0 0 {name=X_70656_ }
C {devices/lab_pin.sym} 90860 -17570 0 0 {name=p90429 lab=_58366_/X }
C {devices/lab_pin.sym} 90860 -17530 0 0 {name=p90430 lab=_83353_/Q }
C {devices/lab_pin.sym} 90860 -17490 0 0 {name=p90431 lab=_58377_/Y }
C {devices/lab_pin.sym} 91020 -17530 0 1 {name=p90432 lab=_84865_/D }
C {sky130_stdcells/o21a_4.sym} 90940 -17530 0 0 {name=X_58378_ }
C {devices/lab_pin.sym} 90900 -17390 0 0 {name=p90433 lab=_57637_/B }
C {devices/lab_pin.sym} 90980 -17390 0 1 {name=p90434 lab=_50378_/B }
C {sky130_stdcells/buf_2.sym} 90940 -17390 0 0 {name=X_48131_ }
C {sky130_stdcells/decap_3.sym} 90940 -17240 0 0 {name=XPHY_70 }
C {devices/lab_pin.sym} 90900 -17090 0 0 {name=p90435 lab=clkbuf_9_464_0_CLK/X }
C {devices/lab_pin.sym} 90980 -17090 0 1 {name=p90436 lab=_88327_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 90940 -17090 0 0 {name=Xclkbuf_10_928_0_CLK }
C {devices/lab_pin.sym} 90900 -16970 0 0 {name=p90437 lab=_45709_/A }
C {devices/lab_pin.sym} 90980 -16970 0 1 {name=p90438 lab=_45343_/X }
C {sky130_stdcells/buf_2.sym} 90940 -16970 0 0 {name=X_45343_ }
C {devices/lab_pin.sym} 90860 -16880 0 0 {name=p90439 lab=_57280_/X }
C {devices/lab_pin.sym} 90860 -16840 0 0 {name=p90440 lab=_57325_/Y }
C {devices/lab_pin.sym} 90860 -16800 0 0 {name=p90441 lab=_57326_/Y }
C {devices/lab_pin.sym} 90860 -16760 0 0 {name=p90442 lab=_57328_/Y }
C {devices/lab_pin.sym} 91020 -16820 0 1 {name=p90443 lab=_57330_/A }
C {sky130_stdcells/a211o_4.sym} 90940 -16820 0 0 {name=X_57329_ }
C {sky130_stdcells/decap_3.sym} 90940 -16640 0 0 {name=XPHY_81 }
C {devices/lab_pin.sym} 90900 -16490 0 0 {name=p90444 lab=_76162_/Y }
C {devices/lab_pin.sym} 90980 -16490 0 1 {name=p90445 lab=_76163_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -16490 0 0 {name=X_76163_ }
C {devices/lab_pin.sym} 90850 -16370 0 0 {name=p90446 lab=_88208_/CLK }
C {devices/lab_pin.sym} 90850 -16350 0 0 {name=p90447 lab=_41788_/Y }
C {devices/lab_pin.sym} 91030 -16370 0 1 {name=p90448 lab=_88149_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -16360 0 0 {name=X_88149_ }
C {devices/lab_pin.sym} 90900 -16230 0 0 {name=p90449 lab=_42555_/A }
C {devices/lab_pin.sym} 90980 -16230 0 1 {name=p90450 lab=_42555_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -16230 0 0 {name=X_42555_ }
C {devices/lab_pin.sym} 90860 -16140 0 0 {name=p90451 lab=_69885_/B }
C {devices/lab_pin.sym} 90860 -16100 0 0 {name=p90452 lab=_44235_/X }
C {devices/lab_pin.sym} 90860 -16060 0 0 {name=p90453 lab=_72798_/X }
C {devices/lab_pin.sym} 90860 -16020 0 0 {name=p90454 lab=_73374_/Y }
C {devices/lab_pin.sym} 91020 -16080 0 1 {name=p90455 lab=_73375_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -16080 0 0 {name=X_73375_ }
C {sky130_stdcells/decap_3.sym} 90940 -15900 0 0 {name=XPHY_92 }
C {devices/lab_pin.sym} 90900 -15750 0 0 {name=p90456 lab=_70586_/X }
C {devices/lab_pin.sym} 90980 -15750 0 1 {name=p90457 lab=_70588_/A }
C {sky130_stdcells/buf_2.sym} 90940 -15750 0 0 {name=X_70587_ }
C {devices/lab_pin.sym} 90860 -15650 0 0 {name=p90458 lab=_75100_/Y }
C {devices/lab_pin.sym} 90860 -15610 0 0 {name=p90459 lab=_75096_/A }
C {devices/lab_pin.sym} 90860 -15570 0 0 {name=p90460 lab=_75099_/A }
C {devices/lab_pin.sym} 91020 -15610 0 1 {name=p90461 lab=_75115_/A }
C {sky130_stdcells/o21a_4.sym} 90940 -15610 0 0 {name=X_75114_ }
C {devices/lab_pin.sym} 90860 -15490 0 0 {name=p90462 lab=_41481_/X }
C {devices/lab_pin.sym} 90860 -15450 0 0 {name=p90463 lab=_82328_/Q }
C {devices/lab_pin.sym} 90860 -15410 0 0 {name=p90464 lab=_41505_/X }
C {devices/lab_pin.sym} 91020 -15450 0 1 {name=p90465 lab=_41506_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -15450 0 0 {name=X_41506_ }
C {devices/lab_pin.sym} 90860 -15350 0 0 {name=p90466 lab=_60249_/X }
C {devices/lab_pin.sym} 90860 -15310 0 0 {name=p90467 lab=_60325_/C }
C {devices/lab_pin.sym} 90860 -15270 0 0 {name=p90468 lab=_60367_/C }
C {devices/lab_pin.sym} 90860 -15230 0 0 {name=p90469 lab=_60229_/Y }
C {devices/lab_pin.sym} 90860 -15200 0 0 {name=p90470 lab=_60339_/Y }
C {devices/lab_pin.sym} 91020 -15270 0 1 {name=p90471 lab=_84628_/D }
C {sky130_stdcells/a41oi_4.sym} 90940 -15270 0 0 {name=X_60340_ }
C {devices/lab_pin.sym} 90900 -15110 0 0 {name=p90472 lab=clkbuf_9_419_0_CLK/A }
C {devices/lab_pin.sym} 90980 -15110 0 1 {name=p90473 lab=clkbuf_9_419_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 90940 -15110 0 0 {name=Xclkbuf_9_419_0_CLK }
C {devices/lab_pin.sym} 90860 -15010 0 0 {name=p90474 lab=_72264_/X }
C {devices/lab_pin.sym} 90860 -14970 0 0 {name=p90475 lab=_85360_/Q }
C {devices/lab_pin.sym} 90860 -14930 0 0 {name=p90476 lab=_72325_/X }
C {devices/lab_pin.sym} 91020 -14970 0 1 {name=p90477 lab=_72326_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -14970 0 0 {name=X_72326_ }
C {devices/lab_pin.sym} 90880 -14840 0 0 {name=p90478 lab=_48092_/A }
C {devices/lab_pin.sym} 90880 -14800 0 0 {name=p90479 lab=_52047_/B }
C {devices/lab_pin.sym} 91000 -14820 0 1 {name=p90480 lab=_48062_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -14820 0 0 {name=X_48062_ }
C {devices/lab_pin.sym} 90900 -14690 0 0 {name=p90481 lab=_44972_/A }
C {devices/lab_pin.sym} 90980 -14690 0 1 {name=p90482 lab=_45714_/A }
C {sky130_stdcells/buf_2.sym} 90940 -14690 0 0 {name=X_45274_ }
C {devices/lab_pin.sym} 90880 -14580 0 0 {name=p90483 lab=_76094_/A }
C {devices/lab_pin.sym} 90880 -14540 0 0 {name=p90484 lab=_76093_/Y }
C {devices/lab_pin.sym} 91000 -14560 0 1 {name=p90485 lab=_76099_/A }
C {sky130_stdcells/nor2_4.sym} 90940 -14560 0 0 {name=X_76094_ }
C {devices/lab_pin.sym} 90900 -14430 0 0 {name=p90486 lab=_42554_/A }
C {devices/lab_pin.sym} 90980 -14430 0 1 {name=p90487 lab=_42486_/X }
C {sky130_stdcells/buf_2.sym} 90940 -14430 0 0 {name=X_42486_ }
C {devices/lab_pin.sym} 90880 -14340 0 0 {name=p90488 lab=_47029_/A }
C {devices/lab_pin.sym} 90880 -14300 0 0 {name=p90489 lab=_47029_/B }
C {devices/lab_pin.sym} 90880 -14260 0 0 {name=p90490 lab=_47029_/C }
C {devices/lab_pin.sym} 90880 -14220 0 0 {name=p90491 lab=_52801_/D }
C {devices/lab_pin.sym} 91000 -14280 0 1 {name=p90492 lab=_47013_/X }
C {sky130_stdcells/and4_4.sym} 90940 -14280 0 0 {name=X_47013_ }
C {devices/lab_pin.sym} 90880 -14160 0 0 {name=p90493 lab=_65614_/A }
C {devices/lab_pin.sym} 90880 -14120 0 0 {name=p90494 lab=_44225_/B }
C {devices/lab_pin.sym} 90880 -14080 0 0 {name=p90495 lab=_57736_/A }
C {devices/lab_pin.sym} 90880 -14040 0 0 {name=p90496 lab=_44265_/D }
C {devices/lab_pin.sym} 91000 -14100 0 1 {name=p90497 lab=_44225_/Y }
C {sky130_stdcells/nor4_4.sym} 90940 -14100 0 0 {name=X_44225_ }
C {devices/lab_pin.sym} 90880 -13960 0 0 {name=p90498 lab=_75045_/A }
C {devices/lab_pin.sym} 90880 -13920 0 0 {name=p90499 lab=_75045_/B }
C {devices/lab_pin.sym} 91000 -13940 0 1 {name=p90500 lab=_75045_/X }
C {sky130_stdcells/xor2_4.sym} 90940 -13940 0 0 {name=X_75045_ }
C {devices/lab_pin.sym} 90880 -13820 0 0 {name=p90501 lab=_79922_/A }
C {devices/lab_pin.sym} 90880 -13780 0 0 {name=p90502 lab=_60145_/A }
C {devices/lab_pin.sym} 91000 -13800 0 1 {name=p90503 lab=_79924_/B }
C {sky130_stdcells/nand2_4.sym} 90940 -13800 0 0 {name=X_79922_ }
C {devices/lab_pin.sym} 90900 -13670 0 0 {name=p90504 lab=_41436_/Y }
C {devices/lab_pin.sym} 90980 -13670 0 1 {name=p90505 lab=_41437_/X }
C {sky130_stdcells/buf_2.sym} 90940 -13670 0 0 {name=X_41437_ }
C {devices/lab_pin.sym} 90900 -13550 0 0 {name=p90506 lab=_60271_/A }
C {devices/lab_pin.sym} 90980 -13550 0 1 {name=p90507 lab=_60271_/X }
C {sky130_stdcells/buf_2.sym} 90940 -13550 0 0 {name=X_60271_ }
C {devices/lab_pin.sym} 90860 -13450 0 0 {name=p90508 lab=_72143_/X }
C {devices/lab_pin.sym} 90860 -13410 0 0 {name=p90509 lab=_85366_/Q }
C {devices/lab_pin.sym} 90860 -13370 0 0 {name=p90510 lab=_72256_/X }
C {devices/lab_pin.sym} 91020 -13410 0 1 {name=p90511 lab=_72257_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -13410 0 0 {name=X_72257_ }
C {devices/lab_pin.sym} 90900 -13270 0 0 {name=p90512 lab=_61708_/X }
C {devices/lab_pin.sym} 90980 -13270 0 1 {name=p90513 lab=_62010_/X }
C {sky130_stdcells/buf_2.sym} 90940 -13270 0 0 {name=X_62010_ }
C {devices/lab_pin.sym} 90900 -13150 0 0 {name=p90514 lab=clkbuf_6_5_0_CLK/A }
C {devices/lab_pin.sym} 90980 -13150 0 1 {name=p90515 lab=clkbuf_6_4_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 90940 -13150 0 0 {name=Xclkbuf_6_4_0_CLK }
C {devices/lab_pin.sym} 90860 -13050 0 0 {name=p90516 lab=_48820_/B }
C {devices/lab_pin.sym} 90860 -13010 0 0 {name=p90517 lab=_71190_/A }
C {devices/lab_pin.sym} 90860 -12970 0 0 {name=p90518 lab=_71207_/Y }
C {devices/lab_pin.sym} 91020 -13010 0 1 {name=p90519 lab=_71208_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -13010 0 0 {name=X_71208_ }
C {devices/lab_pin.sym} 90900 -12870 0 0 {name=p90520 lab=_44012_/A }
C {devices/lab_pin.sym} 90980 -12870 0 1 {name=p90521 lab=_57776_/A }
C {sky130_stdcells/buf_2.sym} 90940 -12870 0 0 {name=X_44156_ }
C {devices/lab_pin.sym} 90860 -12790 0 0 {name=p90522 lab=_79819_/A }
C {devices/lab_pin.sym} 90860 -12750 0 0 {name=p90523 lab=_79818_/Y }
C {devices/lab_pin.sym} 90860 -12710 0 0 {name=p90524 lab=_79830_/X }
C {devices/lab_pin.sym} 90860 -12670 0 0 {name=p90525 lab=_79828_/Y }
C {devices/lab_pin.sym} 90860 -12630 0 0 {name=p90526 lab=_79850_/Y }
C {devices/lab_pin.sym} 91020 -12710 0 1 {name=p90527 lab=_79853_/X }
C {sky130_stdcells/a2111o_4.sym} 90940 -12710 0 0 {name=X_79853_ }
C {devices/lab_pin.sym} 90860 -12580 0 0 {name=p90528 lab=_41367_/X }
C {devices/lab_pin.sym} 90860 -12540 0 0 {name=p90529 lab=_41362_/X }
C {devices/lab_pin.sym} 90860 -12500 0 0 {name=p90530 lab=_67707_/B }
C {devices/lab_pin.sym} 90860 -12460 0 0 {name=p90531 lab=_41363_/X }
C {devices/lab_pin.sym} 91020 -12520 0 1 {name=p90532 lab=_88228_/D }
C {sky130_stdcells/a2bb2o_4.sym} 90940 -12520 0 0 {name=X_41368_ }
C {devices/lab_pin.sym} 90880 -12380 0 0 {name=p90533 lab=_72188_/A }
C {devices/lab_pin.sym} 90880 -12340 0 0 {name=p90534 lab=_72162_/B }
C {devices/lab_pin.sym} 91000 -12360 0 1 {name=p90535 lab=_72188_/Y }
C {sky130_stdcells/nor2_4.sym} 90940 -12360 0 0 {name=X_72188_ }
C {devices/lab_pin.sym} 90900 -12230 0 0 {name=p90536 lab=_87573_/Q }
C {devices/lab_pin.sym} 90980 -12230 0 1 {name=p90537 lab=_43107_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -12230 0 0 {name=X_43107_ }
C {devices/lab_pin.sym} 90880 -12120 0 0 {name=p90538 lab=_78802_/Y }
C {devices/lab_pin.sym} 90880 -12080 0 0 {name=p90539 lab=_78804_/B }
C {devices/lab_pin.sym} 91000 -12100 0 1 {name=p90540 lab=_78805_/B }
C {sky130_stdcells/xor2_4.sym} 90940 -12100 0 0 {name=X_78804_ }
C {devices/lab_pin.sym} 90900 -11970 0 0 {name=p90541 lab=_71145_/A }
C {devices/lab_pin.sym} 90980 -11970 0 1 {name=p90542 lab=_71141_/B }
C {sky130_stdcells/buf_2.sym} 90940 -11970 0 0 {name=X_71139_ }
C {devices/lab_pin.sym} 90880 -11860 0 0 {name=p90543 lab=_48964_/A }
C {devices/lab_pin.sym} 90880 -11820 0 0 {name=p90544 lab=_48963_/X }
C {devices/lab_pin.sym} 91000 -11840 0 1 {name=p90545 lab=_48964_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -11840 0 0 {name=X_48964_ }
C {devices/lab_pin.sym} 90880 -11730 0 0 {name=p90546 lab=_43950_/A }
C {devices/lab_pin.sym} 90880 -11690 0 0 {name=p90547 lab=_44087_/B }
C {devices/lab_pin.sym} 90880 -11650 0 0 {name=p90548 lab=_43975_/B }
C {devices/lab_pin.sym} 91000 -11690 0 1 {name=p90549 lab=_44088_/A }
C {sky130_stdcells/nor3_4.sym} 90940 -11690 0 0 {name=X_44087_ }
C {devices/lab_pin.sym} 90880 -11560 0 0 {name=p90550 lab=_79784_/A }
C {devices/lab_pin.sym} 90880 -11520 0 0 {name=p90551 lab=_79784_/B }
C {devices/lab_pin.sym} 91000 -11540 0 1 {name=p90552 lab=_79794_/B }
C {sky130_stdcells/xor2_4.sym} 90940 -11540 0 0 {name=X_79784_ }
C {devices/lab_pin.sym} 90860 -11440 0 0 {name=p90553 lab=_41298_/X }
C {devices/lab_pin.sym} 90860 -11400 0 0 {name=p90554 lab=_41283_/X }
C {devices/lab_pin.sym} 90860 -11360 0 0 {name=p90555 lab=_67399_/B }
C {devices/lab_pin.sym} 90860 -11320 0 0 {name=p90556 lab=_41284_/X }
C {devices/lab_pin.sym} 91020 -11380 0 1 {name=p90557 lab=_88241_/D }
C {sky130_stdcells/a2bb2o_4.sym} 90940 -11380 0 0 {name=X_41299_ }
C {devices/lab_pin.sym} 90880 -11240 0 0 {name=p90558 lab=_60959_/C }
C {devices/lab_pin.sym} 90880 -11200 0 0 {name=p90559 lab=_62302_/C }
C {devices/lab_pin.sym} 91000 -11220 0 1 {name=p90560 lab=_76996_/X }
C {sky130_stdcells/xor2_4.sym} 90940 -11220 0 0 {name=X_76996_ }
C {devices/lab_pin.sym} 90880 -11100 0 0 {name=p90561 lab=_48438_/B }
C {devices/lab_pin.sym} 90880 -11060 0 0 {name=p90562 lab=_47915_/B }
C {devices/lab_pin.sym} 91000 -11080 0 1 {name=p90563 lab=_47915_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -11080 0 0 {name=X_47915_ }
C {devices/lab_pin.sym} 90900 -10950 0 0 {name=p90564 lab=_43146_/A }
C {devices/lab_pin.sym} 90980 -10950 0 1 {name=p90565 lab=_43038_/X }
C {sky130_stdcells/buf_2.sym} 90940 -10950 0 0 {name=X_43038_ }
C {devices/lab_pin.sym} 90900 -10830 0 0 {name=p90566 lab=_78735_/A }
C {devices/lab_pin.sym} 90980 -10830 0 1 {name=p90567 lab=_78735_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -10830 0 0 {name=X_78735_ }
C {devices/lab_pin.sym} 90860 -10730 0 0 {name=p90568 lab=_63959_/X }
C {devices/lab_pin.sym} 90860 -10690 0 0 {name=p90569 lab=_63913_/X }
C {devices/lab_pin.sym} 90860 -10650 0 0 {name=p90570 lab=_63960_/Y }
C {devices/lab_pin.sym} 91020 -10690 0 1 {name=p90571 lab=_84284_/D }
C {sky130_stdcells/a21oi_4.sym} 90940 -10690 0 0 {name=X_63961_ }
C {devices/lab_pin.sym} 90880 -10560 0 0 {name=p90572 lab=_81701_/D }
C {devices/lab_pin.sym} 90880 -10520 0 0 {name=p90573 lab=_75940_/B }
C {devices/lab_pin.sym} 91000 -10540 0 1 {name=p90574 lab=_75947_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -10540 0 0 {name=X_75947_ }
C {devices/lab_pin.sym} 90860 -10430 0 0 {name=p90575 lab=_48890_/Y }
C {devices/lab_pin.sym} 90860 -10390 0 0 {name=p90576 lab=_48880_/X }
C {devices/lab_pin.sym} 90860 -10350 0 0 {name=p90577 lab=_48894_/X }
C {devices/lab_pin.sym} 91020 -10390 0 1 {name=p90578 lab=_48895_/Y }
C {sky130_stdcells/a21oi_4.sym} 90940 -10390 0 0 {name=X_48895_ }
C {devices/lab_pin.sym} 90900 -10250 0 0 {name=p90579 lab=_65198_/A }
C {devices/lab_pin.sym} 90980 -10250 0 1 {name=p90580 lab=_65700_/X }
C {sky130_stdcells/buf_2.sym} 90940 -10250 0 0 {name=X_65700_ }
C {devices/lab_pin.sym} 90860 -10170 0 0 {name=p90581 lab=_62906_/X }
C {devices/lab_pin.sym} 90860 -10130 0 0 {name=p90582 lab=_62886_/X }
C {devices/lab_pin.sym} 90860 -10090 0 0 {name=p90583 lab=_62907_/Y }
C {devices/lab_pin.sym} 90860 -10050 0 0 {name=p90584 lab=_62909_/Y }
C {devices/lab_pin.sym} 90860 -10020 0 0 {name=p90585 lab=_62911_/X }
C {devices/lab_pin.sym} 91020 -10090 0 1 {name=p90586 lab=_62912_/X }
C {sky130_stdcells/a41o_4.sym} 90940 -10090 0 0 {name=X_62912_ }
C {devices/lab_pin.sym} 90900 -9930 0 0 {name=p90587 lab=_47846_/A }
C {devices/lab_pin.sym} 90980 -9930 0 1 {name=p90588 lab=_47846_/X }
C {sky130_stdcells/buf_2.sym} 90940 -9930 0 0 {name=X_47846_ }
C {devices/lab_pin.sym} 90860 -9840 0 0 {name=p90589 lab=_87375_/Q }
C {devices/lab_pin.sym} 90860 -9800 0 0 {name=p90590 lab=_66678_/X }
C {devices/lab_pin.sym} 90860 -9760 0 0 {name=p90591 lab=_66629_/X }
C {devices/lab_pin.sym} 90860 -9720 0 0 {name=p90592 lab=_66679_/X }
C {devices/lab_pin.sym} 91020 -9780 0 1 {name=p90593 lab=_66680_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -9780 0 0 {name=X_66680_ }
C {devices/lab_pin.sym} 90900 -9630 0 0 {name=p90594 lab=_78665_/X }
C {devices/lab_pin.sym} 90980 -9630 0 1 {name=p90595 lab=_78666_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -9630 0 0 {name=X_78666_ }
C {devices/lab_pin.sym} 90880 -9540 0 0 {name=p90596 lab=_61876_/X }
C {devices/lab_pin.sym} 90880 -9500 0 0 {name=p90597 lab=_63876_/B }
C {devices/lab_pin.sym} 90880 -9460 0 0 {name=p90598 lab=_63860_/C }
C {devices/lab_pin.sym} 90880 -9420 0 0 {name=p90599 lab=_63892_/D }
C {devices/lab_pin.sym} 91000 -9480 0 1 {name=p90600 lab=_63892_/Y }
C {sky130_stdcells/nand4_4.sym} 90940 -9480 0 0 {name=X_63892_ }
C {devices/lab_pin.sym} 90880 -9340 0 0 {name=p90601 lab=_80897_/D }
C {devices/lab_pin.sym} 90880 -9300 0 0 {name=p90602 lab=_75878_/B }
C {devices/lab_pin.sym} 91000 -9320 0 1 {name=p90603 lab=_75880_/A }
C {sky130_stdcells/nand2_4.sym} 90940 -9320 0 0 {name=X_75878_ }
C {devices/lab_pin.sym} 90880 -9210 0 0 {name=p90604 lab=_65628_/X }
C {devices/lab_pin.sym} 90880 -9170 0 0 {name=p90605 lab=_65631_/B }
C {devices/lab_pin.sym} 90880 -9130 0 0 {name=p90606 lab=_65630_/X }
C {devices/lab_pin.sym} 91000 -9170 0 1 {name=p90607 lab=_65631_/Y }
C {sky130_stdcells/nand3_4.sym} 90940 -9170 0 0 {name=X_65631_ }
C {devices/lab_pin.sym} 90900 -9030 0 0 {name=p90608 lab=_77616_/X }
C {devices/lab_pin.sym} 90980 -9030 0 1 {name=p90609 lab=_77619_/B }
C {sky130_stdcells/inv_2.sym} 90940 -9030 0 0 {name=X_77617_ }
C {devices/lab_pin.sym} 90860 -8930 0 0 {name=p90610 lab=_63562_/A }
C {devices/lab_pin.sym} 90860 -8890 0 0 {name=p90611 lab=_60337_/D }
C {devices/lab_pin.sym} 90860 -8850 0 0 {name=p90612 lab=_62842_/Y }
C {devices/lab_pin.sym} 91020 -8890 0 1 {name=p90613 lab=_62843_/X }
C {sky130_stdcells/o21a_4.sym} 90940 -8890 0 0 {name=X_62843_ }
C {devices/lab_pin.sym} 90880 -8760 0 0 {name=p90614 lab=_74829_/A }
C {devices/lab_pin.sym} 90880 -8720 0 0 {name=p90615 lab=_46141_/A }
C {devices/lab_pin.sym} 91000 -8740 0 1 {name=p90616 lab=_74829_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -8740 0 0 {name=X_74829_ }
C {devices/lab_pin.sym} 90880 -8640 0 0 {name=p90617 lab=_47804_/A }
C {devices/lab_pin.sym} 90880 -8600 0 0 {name=p90618 lab=_47777_/B }
C {devices/lab_pin.sym} 90880 -8560 0 0 {name=p90619 lab=_47777_/C }
C {devices/lab_pin.sym} 90880 -8520 0 0 {name=p90620 lab=_53238_/D }
C {devices/lab_pin.sym} 91000 -8580 0 1 {name=p90621 lab=_47777_/X }
C {sky130_stdcells/and4_4.sym} 90940 -8580 0 0 {name=X_47777_ }
C {devices/lab_pin.sym} 90880 -8440 0 0 {name=p90622 lab=_78608_/A }
C {devices/lab_pin.sym} 90880 -8400 0 0 {name=p90623 lab=_82678_/D }
C {devices/lab_pin.sym} 91000 -8420 0 1 {name=p90624 lab=_78597_/X }
C {sky130_stdcells/xor2_4.sym} 90940 -8420 0 0 {name=X_78597_ }
C {devices/lab_pin.sym} 90900 -8290 0 0 {name=p90625 lab=_44989_/A }
C {devices/lab_pin.sym} 90980 -8290 0 1 {name=p90626 lab=_44990_/A }
C {sky130_stdcells/inv_2.sym} 90940 -8290 0 0 {name=X_44989_ }
C {devices/lab_pin.sym} 90880 -8200 0 0 {name=p90627 lab=_49537_/A }
C {devices/lab_pin.sym} 90880 -8160 0 0 {name=p90628 lab=_49516_/B }
C {devices/lab_pin.sym} 90880 -8120 0 0 {name=p90629 lab=_49493_/X }
C {devices/lab_pin.sym} 90880 -8080 0 0 {name=p90630 lab=_52730_/D }
C {devices/lab_pin.sym} 91000 -8140 0 1 {name=p90631 lab=_49516_/X }
C {sky130_stdcells/and4_4.sym} 90940 -8140 0 0 {name=X_49516_ }
C {devices/lab_pin.sym} 90880 -8000 0 0 {name=p90632 lab=_69906_/A }
C {devices/lab_pin.sym} 90880 -7960 0 0 {name=p90633 lab=_87251_/Q }
C {devices/lab_pin.sym} 91000 -7980 0 1 {name=p90634 lab=_68350_/X }
C {sky130_stdcells/and2_4.sym} 90940 -7980 0 0 {name=X_68350_ }
C {devices/lab_pin.sym} 90900 -7850 0 0 {name=p90635 lab=_46727_/Y }
C {devices/lab_pin.sym} 90980 -7850 0 1 {name=p90636 lab=_46728_/X }
C {sky130_stdcells/buf_2.sym} 90940 -7850 0 0 {name=X_46728_ }
C {devices/lab_pin.sym} 90860 -7760 0 0 {name=p90637 lab=_65334_/X }
C {devices/lab_pin.sym} 90860 -7720 0 0 {name=p90638 lab=_86200_/Q }
C {devices/lab_pin.sym} 90860 -7680 0 0 {name=p90639 lab=_65517_/X }
C {devices/lab_pin.sym} 90860 -7640 0 0 {name=p90640 lab=_65561_/X }
C {devices/lab_pin.sym} 91020 -7700 0 1 {name=p90641 lab=_65562_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -7700 0 0 {name=X_65562_ }
C {devices/lab_pin.sym} 90880 -7560 0 0 {name=p90642 lab=_81943_/Q }
C {devices/lab_pin.sym} 90880 -7520 0 0 {name=p90643 lab=_82199_/D }
C {devices/lab_pin.sym} 91000 -7540 0 1 {name=p90644 lab=_81911_/D }
C {sky130_stdcells/xor2_4.sym} 90940 -7540 0 0 {name=X_77548_ }
C {devices/lab_pin.sym} 90880 -7430 0 0 {name=p90645 lab=_62773_/X }
C {devices/lab_pin.sym} 90880 -7390 0 0 {name=p90646 lab=_62762_/B }
C {devices/lab_pin.sym} 90880 -7350 0 0 {name=p90647 lab=_61891_/X }
C {devices/lab_pin.sym} 91000 -7390 0 1 {name=p90648 lab=_62774_/Y }
C {sky130_stdcells/nand3_4.sym} 90940 -7390 0 0 {name=X_62774_ }
C {devices/lab_pin.sym} 90860 -7280 0 0 {name=p90649 lab=_87105_/Q }
C {devices/lab_pin.sym} 90860 -7240 0 0 {name=p90650 lab=_67230_/X }
C {devices/lab_pin.sym} 90860 -7200 0 0 {name=p90651 lab=_67278_/X }
C {devices/lab_pin.sym} 90860 -7160 0 0 {name=p90652 lab=_67300_/X }
C {devices/lab_pin.sym} 91020 -7220 0 1 {name=p90653 lab=_67301_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -7220 0 0 {name=X_67301_ }
C {devices/lab_pin.sym} 90880 -7090 0 0 {name=p90654 lab=_64494_/A }
C {devices/lab_pin.sym} 90880 -7050 0 0 {name=p90655 lab=_63312_/B }
C {devices/lab_pin.sym} 90880 -7010 0 0 {name=p90656 lab=_64207_/A }
C {devices/lab_pin.sym} 91000 -7050 0 1 {name=p90657 lab=_64513_/X }
C {sky130_stdcells/and3_4.sym} 90940 -7050 0 0 {name=X_64513_ }
C {devices/lab_pin.sym} 90860 -6930 0 0 {name=p90658 lab=_61720_/Y }
C {devices/lab_pin.sym} 90860 -6890 0 0 {name=p90659 lab=_61699_/X }
C {devices/lab_pin.sym} 90860 -6850 0 0 {name=p90660 lab=_61724_/Y }
C {devices/lab_pin.sym} 91020 -6890 0 1 {name=p90661 lab=_84457_/D }
C {sky130_stdcells/a21oi_4.sym} 90940 -6890 0 0 {name=X_61725_ }
C {devices/lab_pin.sym} 90880 -6780 0 0 {name=p90662 lab=_49447_/A }
C {devices/lab_pin.sym} 90880 -6740 0 0 {name=p90663 lab=_49447_/B }
C {devices/lab_pin.sym} 90880 -6700 0 0 {name=p90664 lab=_49447_/C }
C {devices/lab_pin.sym} 90880 -6660 0 0 {name=p90665 lab=_52661_/D }
C {devices/lab_pin.sym} 91000 -6720 0 1 {name=p90666 lab=_49447_/X }
C {sky130_stdcells/and4_4.sym} 90940 -6720 0 0 {name=X_49447_ }
C {devices/lab_pin.sym} 90860 -6600 0 0 {name=p90667 lab=_68254_/X }
C {devices/lab_pin.sym} 90860 -6560 0 0 {name=p90668 lab=_67726_/Y }
C {devices/lab_pin.sym} 90860 -6520 0 0 {name=p90669 lab=_68268_/X }
C {devices/lab_pin.sym} 90860 -6480 0 0 {name=p90670 lab=_68280_/Y }
C {devices/lab_pin.sym} 91020 -6540 0 1 {name=p90671 lab=_68281_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -6540 0 0 {name=X_68281_ }
C {devices/lab_pin.sym} 90880 -6420 0 0 {name=p90672 lab=_46670_/A }
C {devices/lab_pin.sym} 90880 -6380 0 0 {name=p90673 lab=_46682_/B }
C {devices/lab_pin.sym} 90880 -6340 0 0 {name=p90674 lab=_46659_/C }
C {devices/lab_pin.sym} 90880 -6300 0 0 {name=p90675 lab=_51772_/D }
C {devices/lab_pin.sym} 91000 -6360 0 1 {name=p90676 lab=_46659_/X }
C {sky130_stdcells/and4_4.sym} 90940 -6360 0 0 {name=X_46659_ }
C {devices/lab_pin.sym} 90860 -6240 0 0 {name=p90677 lab=_65428_/X }
C {devices/lab_pin.sym} 90860 -6200 0 0 {name=p90678 lab=_83077_/Q }
C {devices/lab_pin.sym} 90860 -6160 0 0 {name=p90679 lab=_65407_/X }
C {devices/lab_pin.sym} 90860 -6120 0 0 {name=p90680 lab=_65492_/X }
C {devices/lab_pin.sym} 91020 -6180 0 1 {name=p90681 lab=_65494_/B }
C {sky130_stdcells/a211o_4.sym} 90940 -6180 0 0 {name=X_65493_ }
C {devices/lab_pin.sym} 90860 -6050 0 0 {name=p90682 lab=_77478_/B }
C {devices/lab_pin.sym} 90860 -6010 0 0 {name=p90683 lab=_77477_/Y }
C {devices/lab_pin.sym} 90860 -5970 0 0 {name=p90684 lab=_77478_/A }
C {devices/lab_pin.sym} 91020 -6010 0 1 {name=p90685 lab=_77479_/X }
C {sky130_stdcells/o21a_4.sym} 90940 -6010 0 0 {name=X_77479_ }
C {devices/lab_pin.sym} 90860 -5890 0 0 {name=p90686 lab=_79215_/X }
C {devices/lab_pin.sym} 90860 -5850 0 0 {name=p90687 lab=_79236_/A }
C {devices/lab_pin.sym} 90860 -5810 0 0 {name=p90688 lab=_79213_/Y }
C {devices/lab_pin.sym} 91020 -5850 0 1 {name=p90689 lab=_79218_/X }
C {sky130_stdcells/a21o_4.sym} 90940 -5850 0 0 {name=X_79218_ }
C {devices/lab_pin.sym} 90860 -5740 0 0 {name=p90690 lab=_87108_/Q }
C {devices/lab_pin.sym} 90860 -5700 0 0 {name=p90691 lab=_67230_/X }
C {devices/lab_pin.sym} 90860 -5660 0 0 {name=p90692 lab=_67160_/X }
C {devices/lab_pin.sym} 90860 -5620 0 0 {name=p90693 lab=_67231_/X }
C {devices/lab_pin.sym} 91020 -5680 0 1 {name=p90694 lab=_67232_/X }
C {sky130_stdcells/a211o_4.sym} 90940 -5680 0 0 {name=X_67232_ }
C {devices/lab_pin.sym} 90860 -5550 0 0 {name=p90695 lab=_84246_/Q }
C {devices/lab_pin.sym} 90860 -5510 0 0 {name=p90696 lab=_64429_/X }
C {devices/lab_pin.sym} 90860 -5470 0 0 {name=p90697 lab=_64443_/X }
C {devices/lab_pin.sym} 91020 -5510 0 1 {name=p90698 lab=_64444_/X }
C {sky130_stdcells/a21o_4.sym} 90940 -5510 0 0 {name=X_64444_ }
C {devices/lab_pin.sym} 90900 -5370 0 0 {name=p90699 lab=_49405_/A }
C {devices/lab_pin.sym} 90980 -5370 0 1 {name=p90700 lab=_49378_/X }
C {sky130_stdcells/buf_2.sym} 90940 -5370 0 0 {name=X_49378_ }
C {devices/lab_pin.sym} 90880 -5280 0 0 {name=p90701 lab=_61656_/A }
C {devices/lab_pin.sym} 90880 -5240 0 0 {name=p90702 lab=_61598_/X }
C {devices/lab_pin.sym} 90880 -5200 0 0 {name=p90703 lab=_61677_/C }
C {devices/lab_pin.sym} 90880 -5160 0 0 {name=p90704 lab=_61563_/D }
C {devices/lab_pin.sym} 91000 -5220 0 1 {name=p90705 lab=_61657_/A }
C {sky130_stdcells/nand4_4.sym} 90940 -5220 0 0 {name=X_61656_ }
C {devices/lab_pin.sym} 90880 -5080 0 0 {name=p90706 lab=_80489_/B }
C {devices/lab_pin.sym} 90880 -5040 0 0 {name=p90707 lab=_80489_/A }
C {devices/lab_pin.sym} 91000 -5060 0 1 {name=p90708 lab=_80490_/X }
C {sky130_stdcells/and2_4.sym} 90940 -5060 0 0 {name=X_80490_ }
C {devices/lab_pin.sym} 90900 -4930 0 0 {name=p90709 lab=_48329_/A }
C {devices/lab_pin.sym} 90980 -4930 0 1 {name=p90710 lab=_50372_/B }
C {sky130_stdcells/buf_2.sym} 90940 -4930 0 0 {name=X_48329_ }
C {devices/lab_pin.sym} 90880 -4840 0 0 {name=p90711 lab=_60607_/A }
C {devices/lab_pin.sym} 90880 -4800 0 0 {name=p90712 lab=_60606_/X }
C {devices/lab_pin.sym} 90880 -4760 0 0 {name=p90713 lab=_60420_/A }
C {devices/lab_pin.sym} 90880 -4720 0 0 {name=p90714 lab=_60430_/Y }
C {devices/lab_pin.sym} 91000 -4780 0 1 {name=p90715 lab=_60608_/A }
C {sky130_stdcells/and4_4.sym} 90940 -4780 0 0 {name=X_60607_ }
C {devices/lab_pin.sym} 90860 -4650 0 0 {name=p90716 lab=_67159_/X }
C {devices/lab_pin.sym} 90860 -4610 0 0 {name=p90717 lab=_67162_/X }
C {devices/lab_pin.sym} 90860 -4570 0 0 {name=p90718 lab=_67015_/X }
C {devices/lab_pin.sym} 91020 -4610 0 1 {name=p90719 lab=_67163_/Y }
C {sky130_stdcells/a21oi_4.sym} 90940 -4610 0 0 {name=X_67163_ }
C {devices/lab_pin.sym} 90880 -4480 0 0 {name=p90720 lab=_79149_/A }
C {devices/lab_pin.sym} 90880 -4440 0 0 {name=p90721 lab=_61434_/C }
C {devices/lab_pin.sym} 91000 -4460 0 1 {name=p90722 lab=_79149_/X }
C {sky130_stdcells/xor2_4.sym} 90940 -4460 0 0 {name=X_79149_ }
C {devices/lab_pin.sym} 90880 -4340 0 0 {name=p90723 lab=_59415_/A }
C {devices/lab_pin.sym} 90880 -4300 0 0 {name=p90724 lab=_64418_/B }
C {devices/lab_pin.sym} 91000 -4320 0 1 {name=p90725 lab=_64375_/Y }
C {sky130_stdcells/nor2_4.sym} 90940 -4320 0 0 {name=X_64375_ }
C {devices/lab_pin.sym} 90880 -4210 0 0 {name=p90726 lab=_59834_/A }
C {devices/lab_pin.sym} 90880 -4170 0 0 {name=p90727 lab=_61587_/B }
C {devices/lab_pin.sym} 90880 -4130 0 0 {name=p90728 lab=_79136_/B }
C {devices/lab_pin.sym} 91000 -4170 0 1 {name=p90729 lab=_61587_/X }
C {sky130_stdcells/or3_4.sym} 90940 -4170 0 0 {name=X_61587_ }
C {devices/lab_pin.sym} 90880 -4040 0 0 {name=p90730 lab=_57788_/X }
C {devices/lab_pin.sym} 90880 -4000 0 0 {name=p90731 lab=_73904_/B }
C {devices/lab_pin.sym} 91000 -4020 0 1 {name=p90732 lab=_66114_/X }
C {sky130_stdcells/and2_4.sym} 90940 -4020 0 0 {name=X_66114_ }
C {devices/lab_pin.sym} 90900 -3890 0 0 {name=p90733 lab=_51340_/A }
C {devices/lab_pin.sym} 90980 -3890 0 1 {name=p90734 lab=_51842_/A }
C {sky130_stdcells/buf_2.sym} 90940 -3890 0 0 {name=X_51340_ }
C {devices/lab_pin.sym} 90880 -3800 0 0 {name=p90735 lab=_63326_/A }
C {devices/lab_pin.sym} 90880 -3760 0 0 {name=p90736 lab=_63344_/B }
C {devices/lab_pin.sym} 90880 -3720 0 0 {name=p90737 lab=_60588_/X }
C {devices/lab_pin.sym} 90880 -3680 0 0 {name=p90738 lab=_63344_/D }
C {devices/lab_pin.sym} 91000 -3740 0 1 {name=p90739 lab=_63326_/X }
C {sky130_stdcells/or4_4.sym} 90940 -3740 0 0 {name=X_63326_ }
C {devices/lab_pin.sym} 90850 -3590 0 0 {name=p90740 lab=_81224_/CLK }
C {devices/lab_pin.sym} 90850 -3570 0 0 {name=p90741 lab=_84152_/Q }
C {devices/lab_pin.sym} 91030 -3590 0 1 {name=p90742 lab=_82160_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -3580 0 0 {name=X_82160_ }
C {devices/lab_pin.sym} 90900 -3450 0 0 {name=p90743 lab=_60588_/A }
C {devices/lab_pin.sym} 90980 -3450 0 1 {name=p90744 lab=_63301_/C }
C {sky130_stdcells/buf_2.sym} 90940 -3450 0 0 {name=X_60538_ }
C {devices/lab_pin.sym} 90900 -3330 0 0 {name=p90745 lab=_67093_/X }
C {devices/lab_pin.sym} 90980 -3330 0 1 {name=p90746 lab=_67095_/A }
C {sky130_stdcells/buf_2.sym} 90940 -3330 0 0 {name=X_67094_ }
C {devices/lab_pin.sym} 90850 -3210 0 0 {name=p90747 lab=_81111_/CLK }
C {devices/lab_pin.sym} 90850 -3190 0 0 {name=p90748 lab=_79780_/Y }
C {devices/lab_pin.sym} 91030 -3210 0 1 {name=p90749 lab=_81111_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -3200 0 0 {name=X_81111_ }
C {devices/lab_pin.sym} 90860 -3090 0 0 {name=p90750 lab=_66020_/X }
C {devices/lab_pin.sym} 90860 -3050 0 0 {name=p90751 lab=_66043_/Y }
C {devices/lab_pin.sym} 90860 -3010 0 0 {name=p90752 lab=_66044_/Y }
C {devices/lab_pin.sym} 91020 -3050 0 1 {name=p90753 lab=_66045_/Y }
C {sky130_stdcells/o21ai_4.sym} 90940 -3050 0 0 {name=X_66045_ }
C {devices/lab_pin.sym} 90860 -2930 0 0 {name=p90754 lab=_51269_/Y }
C {devices/lab_pin.sym} 90860 -2890 0 0 {name=p90755 lab=_51263_/X }
C {devices/lab_pin.sym} 90860 -2850 0 0 {name=p90756 lab=_51270_/X }
C {devices/lab_pin.sym} 91020 -2890 0 1 {name=p90757 lab=_51271_/Y }
C {sky130_stdcells/a21oi_4.sym} 90940 -2890 0 0 {name=X_51271_ }
C {devices/lab_pin.sym} 90860 -2770 0 0 {name=p90758 lab=_63255_/X }
C {devices/lab_pin.sym} 90860 -2730 0 0 {name=p90759 lab=_62987_/X }
C {devices/lab_pin.sym} 90860 -2690 0 0 {name=p90760 lab=_63256_/Y }
C {devices/lab_pin.sym} 91020 -2730 0 1 {name=p90761 lab=_84340_/D }
C {sky130_stdcells/a21oi_4.sym} 90940 -2730 0 0 {name=X_63257_ }
C {devices/lab_pin.sym} 90850 -2590 0 0 {name=p90762 lab=_82008_/CLK }
C {devices/lab_pin.sym} 90850 -2570 0 0 {name=p90763 lab=_82091_/D }
C {devices/lab_pin.sym} 91030 -2590 0 1 {name=p90764 lab=_77065_/A }
C {sky130_stdcells/dfxtp_4.sym} 90940 -2580 0 0 {name=X_82091_ }
C {devices/lab_pin.sym} 90900 -2450 0 0 {name=p90765 lab=_60472_/A }
C {devices/lab_pin.sym} 90980 -2450 0 1 {name=p90766 lab=_60469_/X }
C {sky130_stdcells/buf_2.sym} 90940 -2450 0 0 {name=X_60469_ }
C {devices/lab_pin.sym} 90900 -2330 0 0 {name=p90767 lab=_53065_/A }
C {devices/lab_pin.sym} 90980 -2330 0 1 {name=p90768 lab=_53010_/X }
C {sky130_stdcells/buf_2.sym} 90940 -2330 0 0 {name=X_53010_ }
C {devices/lab_pin.sym} 90900 -2210 0 0 {name=p90769 lab=_51074_/A }
C {devices/lab_pin.sym} 90980 -2210 0 1 {name=p90770 lab=_50222_/X }
C {sky130_stdcells/buf_2.sym} 90940 -2210 0 0 {name=X_50222_ }
C {devices/lab_pin.sym} 90900 -2090 0 0 {name=p90771 lab=_62237_/A }
C {devices/lab_pin.sym} 90980 -2090 0 1 {name=p90772 lab=_62522_/B }
C {sky130_stdcells/buf_2.sym} 90940 -2090 0 0 {name=X_62208_ }
C {devices/lab_pin.sym} 90850 -1970 0 0 {name=p90773 lab=_81070_/CLK }
C {devices/lab_pin.sym} 90850 -1950 0 0 {name=p90774 lab=_81042_/D }
C {devices/lab_pin.sym} 91030 -1970 0 1 {name=p90775 lab=_81042_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -1960 0 0 {name=X_81042_ }
C {devices/lab_pin.sym} 90900 -1830 0 0 {name=p90776 lab=_57757_/A }
C {devices/lab_pin.sym} 90980 -1830 0 1 {name=p90777 lab=_64314_/A }
C {sky130_stdcells/buf_2.sym} 90940 -1830 0 0 {name=X_63188_ }
C {devices/lab_pin.sym} 90900 -1710 0 0 {name=p90778 lab=_69804_/A }
C {devices/lab_pin.sym} 90980 -1710 0 1 {name=p90779 lab=_69804_/Y }
C {sky130_stdcells/inv_2.sym} 90940 -1710 0 0 {name=X_69804_ }
C {devices/lab_pin.sym} 90880 -1600 0 0 {name=p90780 lab=_50153_/A }
C {devices/lab_pin.sym} 90880 -1560 0 0 {name=p90781 lab=_50153_/B }
C {devices/lab_pin.sym} 91000 -1580 0 1 {name=p90782 lab=_50153_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -1580 0 0 {name=X_50153_ }
C {devices/lab_pin.sym} 90880 -1480 0 0 {name=p90783 lab=_61649_/B }
C {devices/lab_pin.sym} 90880 -1440 0 0 {name=p90784 lab=_62161_/B }
C {devices/lab_pin.sym} 90880 -1400 0 0 {name=p90785 lab=_62128_/C }
C {devices/lab_pin.sym} 90880 -1360 0 0 {name=p90786 lab=_61706_/X }
C {devices/lab_pin.sym} 91000 -1420 0 1 {name=p90787 lab=_62139_/Y }
C {sky130_stdcells/nand4_4.sym} 90940 -1420 0 0 {name=X_62139_ }
C {devices/lab_pin.sym} 90850 -1270 0 0 {name=p90788 lab=_85558_/CLK }
C {devices/lab_pin.sym} 90850 -1250 0 0 {name=p90789 lab=_52302_/Y }
C {devices/lab_pin.sym} 91030 -1270 0 1 {name=p90790 lab=_85850_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -1260 0 0 {name=X_85850_ }
C {devices/lab_pin.sym} 90860 -1150 0 0 {name=p90791 lab=_81478_/D }
C {devices/lab_pin.sym} 90860 -1110 0 0 {name=p90792 lab=_67925_/X }
C {devices/lab_pin.sym} 90860 -1070 0 0 {name=p90793 lab=_67995_/X }
C {devices/lab_pin.sym} 91020 -1110 0 1 {name=p90794 lab=_67996_/X }
C {sky130_stdcells/a21bo_4.sym} 90940 -1110 0 0 {name=X_67996_ }
C {devices/lab_pin.sym} 90850 -970 0 0 {name=p90795 lab=_86713_/CLK }
C {devices/lab_pin.sym} 90850 -950 0 0 {name=p90796 lab=_84801_/D }
C {devices/lab_pin.sym} 91030 -970 0 1 {name=p90797 lab=_84801_/Q }
C {sky130_stdcells/dfxtp_4.sym} 90940 -960 0 0 {name=X_84801_ }
C {devices/lab_pin.sym} 90880 -840 0 0 {name=p90798 lab=_69735_/A }
C {devices/lab_pin.sym} 90880 -800 0 0 {name=p90799 lab=_69734_/Y }
C {devices/lab_pin.sym} 91000 -820 0 1 {name=p90800 lab=_69735_/Y }
C {sky130_stdcells/nor2_4.sym} 90940 -820 0 0 {name=X_69735_ }
C {devices/lab_pin.sym} 90880 -700 0 0 {name=p90801 lab=_50084_/A }
C {devices/lab_pin.sym} 90880 -660 0 0 {name=p90802 lab=_48944_/B }
C {devices/lab_pin.sym} 91000 -680 0 1 {name=p90803 lab=_50084_/Y }
C {sky130_stdcells/nand2_4.sym} 90940 -680 0 0 {name=X_50084_ }
C {devices/lab_pin.sym} 91800 -42160 0 0 {name=p90804 lab=_54961_/A }
C {devices/lab_pin.sym} 91800 -42120 0 0 {name=p90805 lab=_47536_/A }
C {devices/lab_pin.sym} 91920 -42140 0 1 {name=p90806 lab=_54961_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -42140 0 0 {name=X_54961_ }
C {devices/lab_pin.sym} 91820 -42010 0 0 {name=p90807 lab=_64608_/A }
C {devices/lab_pin.sym} 91900 -42010 0 1 {name=p90808 lab=_66947_/X }
C {sky130_stdcells/buf_2.sym} 91860 -42010 0 0 {name=X_66947_ }
C {devices/lab_pin.sym} 91770 -41890 0 0 {name=p90809 lab=_82956_/CLK }
C {devices/lab_pin.sym} 91770 -41870 0 0 {name=p90810 lab=_85781_/D }
C {devices/lab_pin.sym} 91950 -41890 0 1 {name=p90811 lab=_85781_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -41880 0 0 {name=X_85781_ }
C {devices/lab_pin.sym} 91770 -41750 0 0 {name=p90812 lab=_82993_/CLK }
C {devices/lab_pin.sym} 91770 -41730 0 0 {name=p90813 lab=_82993_/D }
C {devices/lab_pin.sym} 91950 -41750 0 1 {name=p90814 lab=_82993_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -41740 0 0 {name=X_82993_ }
C {devices/lab_pin.sym} 91800 -41640 0 0 {name=p90815 lab=_56698_/Y }
C {devices/lab_pin.sym} 91800 -41600 0 0 {name=p90816 lab=_56842_/A }
C {devices/lab_pin.sym} 91800 -41560 0 0 {name=p90817 lab=_56700_/C }
C {devices/lab_pin.sym} 91800 -41520 0 0 {name=p90818 lab=_56676_/Y }
C {devices/lab_pin.sym} 91920 -41580 0 1 {name=p90819 lab=_56700_/Y }
C {sky130_stdcells/nor4_4.sym} 91860 -41580 0 0 {name=X_56700_ }
C {devices/lab_pin.sym} 91770 -41430 0 0 {name=p90820 lab=_87520_/CLK }
C {devices/lab_pin.sym} 91770 -41410 0 0 {name=p90821 lab=_43246_/Y }
C {devices/lab_pin.sym} 91950 -41430 0 1 {name=p90822 lab=_87520_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -41420 0 0 {name=X_87520_ }
C {devices/lab_pin.sym} 91800 -41300 0 0 {name=p90823 lab=_53898_/A }
C {devices/lab_pin.sym} 91800 -41260 0 0 {name=p90824 lab=_49144_/A }
C {devices/lab_pin.sym} 91920 -41280 0 1 {name=p90825 lab=_53912_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -41280 0 0 {name=X_53912_ }
C {devices/lab_pin.sym} 91770 -41150 0 0 {name=p90826 lab=_84732_/CLK }
C {devices/lab_pin.sym} 91770 -41130 0 0 {name=p90827 lab=_59441_/X }
C {devices/lab_pin.sym} 91950 -41150 0 1 {name=p90828 lab=_84732_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -41140 0 0 {name=X_84732_ }
C {devices/lab_pin.sym} 91770 -41010 0 0 {name=p90829 lab=_82133_/CLK }
C {devices/lab_pin.sym} 91770 -40990 0 0 {name=p90830 lab=_81944_/D }
C {devices/lab_pin.sym} 91950 -41010 0 1 {name=p90831 lab=_81944_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -41000 0 0 {name=X_81944_ }
C {devices/lab_pin.sym} 91800 -40880 0 0 {name=p90832 lab=_57680_/A }
C {devices/lab_pin.sym} 91800 -40840 0 0 {name=p90833 lab=_57666_/B }
C {devices/lab_pin.sym} 91920 -40860 0 1 {name=p90834 lab=_57680_/Y }
C {sky130_stdcells/nor2_4.sym} 91860 -40860 0 0 {name=X_57680_ }
C {devices/lab_pin.sym} 91800 -40740 0 0 {name=p90835 lab=_69092_/A }
C {devices/lab_pin.sym} 91800 -40700 0 0 {name=p90836 lab=_88332_/Q }
C {devices/lab_pin.sym} 91920 -40720 0 1 {name=p90837 lab=_69666_/X }
C {sky130_stdcells/and2_4.sym} 91860 -40720 0 0 {name=X_69666_ }
C {devices/lab_pin.sym} 91820 -40590 0 0 {name=p90838 lab=_54892_/A }
C {devices/lab_pin.sym} 91900 -40590 0 1 {name=p90839 lab=_54892_/X }
C {sky130_stdcells/buf_2.sym} 91860 -40590 0 0 {name=X_54892_ }
C {devices/lab_pin.sym} 91820 -40470 0 0 {name=p90840 lab=_66642_/A }
C {devices/lab_pin.sym} 91900 -40470 0 1 {name=p90841 lab=_66878_/X }
C {sky130_stdcells/buf_2.sym} 91860 -40470 0 0 {name=X_66878_ }
C {devices/lab_pin.sym} 91780 -40380 0 0 {name=p90842 lab=_56587_/X }
C {devices/lab_pin.sym} 91780 -40340 0 0 {name=p90843 lab=_56630_/X }
C {devices/lab_pin.sym} 91780 -40300 0 0 {name=p90844 lab=_55529_/B }
C {devices/lab_pin.sym} 91780 -40260 0 0 {name=p90845 lab=_56590_/X }
C {devices/lab_pin.sym} 91940 -40320 0 1 {name=p90846 lab=_85142_/D }
C {sky130_stdcells/a2bb2o_4.sym} 91860 -40320 0 0 {name=X_56631_ }
C {devices/lab_pin.sym} 91820 -40170 0 0 {name=p90847 lab=_68617_/A }
C {devices/lab_pin.sym} 91900 -40170 0 1 {name=p90848 lab=_68617_/X }
C {sky130_stdcells/buf_2.sym} 91860 -40170 0 0 {name=X_68617_ }
C {devices/lab_pin.sym} 91770 -40050 0 0 {name=p90849 lab=_87446_/CLK }
C {devices/lab_pin.sym} 91770 -40030 0 0 {name=p90850 lab=_43381_/X }
C {devices/lab_pin.sym} 91950 -40050 0 1 {name=p90851 lab=_87451_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -40040 0 0 {name=X_87451_ }
C {devices/lab_pin.sym} 91820 -39910 0 0 {name=p90852 lab=_53793_/A }
C {devices/lab_pin.sym} 91900 -39910 0 1 {name=p90853 lab=_53844_/A }
C {sky130_stdcells/buf_2.sym} 91860 -39910 0 0 {name=X_53843_ }
C {devices/lab_pin.sym} 91780 -39810 0 0 {name=p90854 lab=_65700_/X }
C {devices/lab_pin.sym} 91780 -39770 0 0 {name=p90855 lab=_65827_/Y }
C {devices/lab_pin.sym} 91780 -39730 0 0 {name=p90856 lab=_65828_/Y }
C {devices/lab_pin.sym} 91940 -39770 0 1 {name=p90857 lab=_65829_/Y }
C {sky130_stdcells/o21ai_4.sym} 91860 -39770 0 0 {name=X_65829_ }
C {devices/lab_pin.sym} 91770 -39630 0 0 {name=p90858 lab=_84672_/CLK }
C {devices/lab_pin.sym} 91770 -39610 0 0 {name=p90859 lab=_60093_/X }
C {devices/lab_pin.sym} 91950 -39630 0 1 {name=p90860 lab=_84663_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -39620 0 0 {name=X_84663_ }
C {devices/lab_pin.sym} 91770 -39490 0 0 {name=p90861 lab=_81857_/CLK }
C {devices/lab_pin.sym} 91770 -39470 0 0 {name=p90862 lab=_78066_/X }
C {devices/lab_pin.sym} 91950 -39490 0 1 {name=p90863 lab=_81875_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -39480 0 0 {name=X_81875_ }
C {devices/lab_pin.sym} 91800 -39360 0 0 {name=p90864 lab=_69586_/A }
C {devices/lab_pin.sym} 91800 -39320 0 0 {name=p90865 lab=_69597_/B }
C {devices/lab_pin.sym} 91920 -39340 0 1 {name=p90866 lab=_69597_/X }
C {sky130_stdcells/and2_4.sym} 91860 -39340 0 0 {name=X_69597_ }
C {devices/lab_pin.sym} 91770 -39210 0 0 {name=p90867 lab=_86733_/CLK }
C {devices/lab_pin.sym} 91770 -39190 0 0 {name=p90868 lab=_86402_/D }
C {devices/lab_pin.sym} 91950 -39210 0 1 {name=p90869 lab=_86402_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -39200 0 0 {name=X_86402_ }
C {devices/lab_pin.sym} 91780 -39090 0 0 {name=p90870 lab=_59286_/X }
C {devices/lab_pin.sym} 91780 -39050 0 0 {name=p90871 lab=_86053_/Q }
C {devices/lab_pin.sym} 91780 -39010 0 0 {name=p90872 lab=_59349_/X }
C {devices/lab_pin.sym} 91940 -39050 0 1 {name=p90873 lab=_59350_/Y }
C {sky130_stdcells/o21ai_4.sym} 91860 -39050 0 0 {name=X_59350_ }
C {devices/lab_pin.sym} 91770 -38910 0 0 {name=p90874 lab=_85558_/CLK }
C {devices/lab_pin.sym} 91770 -38890 0 0 {name=p90875 lab=_71081_/Y }
C {devices/lab_pin.sym} 91950 -38910 0 1 {name=p90876 lab=_83614_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -38900 0 0 {name=X_83614_ }
C {devices/lab_pin.sym} 91820 -38770 0 0 {name=p90877 lab=_44135_/X }
C {devices/lab_pin.sym} 91900 -38770 0 1 {name=p90878 lab=_56774_/C }
C {sky130_stdcells/buf_2.sym} 91860 -38770 0 0 {name=X_56562_ }
C {devices/lab_pin.sym} 91780 -38670 0 0 {name=p90879 lab=_68544_/X }
C {devices/lab_pin.sym} 91780 -38630 0 0 {name=p90880 lab=_68547_/X }
C {devices/lab_pin.sym} 91780 -38590 0 0 {name=p90881 lab=_58002_/A }
C {devices/lab_pin.sym} 91940 -38630 0 1 {name=p90882 lab=_68548_/X }
C {sky130_stdcells/a21o_4.sym} 91860 -38630 0 0 {name=X_68548_ }
C {devices/lab_pin.sym} 91770 -38490 0 0 {name=p90883 lab=_81065_/CLK }
C {devices/lab_pin.sym} 91770 -38470 0 0 {name=p90884 lab=_80826_/D }
C {devices/lab_pin.sym} 91950 -38490 0 1 {name=p90885 lab=_80826_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -38480 0 0 {name=X_80826_ }
C {devices/lab_pin.sym} 91770 -38350 0 0 {name=p90886 lab=_87382_/CLK }
C {devices/lab_pin.sym} 91770 -38330 0 0 {name=p90887 lab=_87382_/D }
C {devices/lab_pin.sym} 91950 -38350 0 1 {name=p90888 lab=_87382_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -38340 0 0 {name=X_87382_ }
C {devices/lab_pin.sym} 91800 -38230 0 0 {name=p90889 lab=_48702_/A }
C {devices/lab_pin.sym} 91800 -38190 0 0 {name=p90890 lab=_53774_/B }
C {devices/lab_pin.sym} 91800 -38150 0 0 {name=p90891 lab=_53774_/C }
C {devices/lab_pin.sym} 91920 -38190 0 1 {name=p90892 lab=_53774_/X }
C {sky130_stdcells/and3_4.sym} 91860 -38190 0 0 {name=X_53774_ }
C {devices/lab_pin.sym} 91770 -38050 0 0 {name=p90893 lab=_84606_/CLK }
C {devices/lab_pin.sym} 91770 -38030 0 0 {name=p90894 lab=_60585_/X }
C {devices/lab_pin.sym} 91950 -38050 0 1 {name=p90895 lab=_79134_/A }
C {sky130_stdcells/dfxtp_4.sym} 91860 -38040 0 0 {name=X_84594_ }
C {devices/lab_pin.sym} 91780 -37930 0 0 {name=p90896 lab=_50982_/Y }
C {devices/lab_pin.sym} 91780 -37890 0 0 {name=p90897 lab=_50983_/X }
C {devices/lab_pin.sym} 91780 -37850 0 0 {name=p90898 lab=_50985_/X }
C {devices/lab_pin.sym} 91940 -37890 0 1 {name=p90899 lab=_86095_/D }
C {sky130_stdcells/a21oi_4.sym} 91860 -37890 0 0 {name=X_50986_ }
C {devices/lab_pin.sym} 91800 -37760 0 0 {name=p90900 lab=_63694_/B }
C {devices/lab_pin.sym} 91800 -37720 0 0 {name=p90901 lab=_58344_/B }
C {devices/lab_pin.sym} 91920 -37740 0 1 {name=p90902 lab=_58301_/Y }
C {sky130_stdcells/nor2_4.sym} 91860 -37740 0 0 {name=X_58301_ }
C {devices/lab_pin.sym} 91820 -37610 0 0 {name=p90903 lab=_55512_/X }
C {devices/lab_pin.sym} 91900 -37610 0 1 {name=p90904 lab=_55513_/X }
C {sky130_stdcells/buf_2.sym} 91860 -37610 0 0 {name=X_55513_ }
C {devices/lab_pin.sym} 91770 -37490 0 0 {name=p90905 lab=_86651_/CLK }
C {devices/lab_pin.sym} 91770 -37470 0 0 {name=p90906 lab=_49735_/Y }
C {devices/lab_pin.sym} 91950 -37490 0 1 {name=p90907 lab=_86333_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -37480 0 0 {name=X_86333_ }
C {devices/lab_pin.sym} 91780 -37370 0 0 {name=p90908 lab=_52723_/Y }
C {devices/lab_pin.sym} 91780 -37330 0 0 {name=p90909 lab=_52702_/X }
C {devices/lab_pin.sym} 91780 -37290 0 0 {name=p90910 lab=_52724_/X }
C {devices/lab_pin.sym} 91940 -37330 0 1 {name=p90911 lab=_52725_/Y }
C {sky130_stdcells/a21oi_4.sym} 91860 -37330 0 0 {name=X_52725_ }
C {devices/lab_pin.sym} 91800 -37200 0 0 {name=p90912 lab=_59256_/A }
C {devices/lab_pin.sym} 91800 -37160 0 0 {name=p90913 lab=_86346_/Q }
C {devices/lab_pin.sym} 91920 -37180 0 1 {name=p90914 lab=_59281_/Y }
C {sky130_stdcells/nor2_4.sym} 91860 -37180 0 0 {name=X_59281_ }
C {devices/lab_pin.sym} 91770 -37050 0 0 {name=p90915 lab=_85630_/CLK }
C {devices/lab_pin.sym} 91770 -37030 0 0 {name=p90916 lab=_83545_/D }
C {devices/lab_pin.sym} 91950 -37050 0 1 {name=p90917 lab=_83545_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -37040 0 0 {name=X_83545_ }
C {devices/lab_pin.sym} 91780 -36930 0 0 {name=p90918 lab=_56060_/X }
C {devices/lab_pin.sym} 91780 -36890 0 0 {name=p90919 lab=_56483_/X }
C {devices/lab_pin.sym} 91780 -36850 0 0 {name=p90920 lab=_56492_/Y }
C {devices/lab_pin.sym} 91940 -36890 0 1 {name=p90921 lab=_85175_/D }
C {sky130_stdcells/o21ai_4.sym} 91860 -36890 0 0 {name=X_56493_ }
C {devices/lab_pin.sym} 91770 -36750 0 0 {name=p90922 lab=_80804_/CLK }
C {devices/lab_pin.sym} 91770 -36730 0 0 {name=p90923 lab=_75358_/X }
C {devices/lab_pin.sym} 91950 -36750 0 1 {name=p90924 lab=_80757_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -36740 0 0 {name=X_80757_ }
C {devices/lab_pin.sym} 91820 -36610 0 0 {name=p90925 lab=_68479_/A }
C {devices/lab_pin.sym} 91900 -36610 0 1 {name=p90926 lab=_68553_/A }
C {sky130_stdcells/buf_2.sym} 91860 -36610 0 0 {name=X_68479_ }
C {devices/lab_pin.sym} 91780 -36510 0 0 {name=p90927 lab=_57651_/Y }
C {devices/lab_pin.sym} 91780 -36470 0 0 {name=p90928 lab=_70501_/X }
C {devices/lab_pin.sym} 91780 -36430 0 0 {name=p90929 lab=_70509_/Y }
C {devices/lab_pin.sym} 91940 -36470 0 1 {name=p90930 lab=_83761_/D }
C {sky130_stdcells/o21ai_4.sym} 91860 -36470 0 0 {name=X_70510_ }
C {devices/lab_pin.sym} 91820 -36330 0 0 {name=p90931 lab=_58232_/A }
C {devices/lab_pin.sym} 91900 -36330 0 1 {name=p90932 lab=_58232_/X }
C {sky130_stdcells/buf_2.sym} 91860 -36330 0 0 {name=X_58232_ }
C {devices/lab_pin.sym} 91780 -36230 0 0 {name=p90933 lab=_55430_/Y }
C {devices/lab_pin.sym} 91780 -36190 0 0 {name=p90934 lab=_55435_/X }
C {devices/lab_pin.sym} 91780 -36150 0 0 {name=p90935 lab=_55443_/Y }
C {devices/lab_pin.sym} 91940 -36190 0 1 {name=p90936 lab=_55444_/Y }
C {sky130_stdcells/a21oi_4.sym} 91860 -36190 0 0 {name=X_55444_ }
C {devices/lab_pin.sym} 91770 -36050 0 0 {name=p90937 lab=_85558_/CLK }
C {devices/lab_pin.sym} 91770 -36030 0 0 {name=p90938 lab=_50102_/Y }
C {devices/lab_pin.sym} 91950 -36050 0 1 {name=p90939 lab=_86264_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -36040 0 0 {name=X_86264_ }
C {devices/lab_pin.sym} 91820 -35910 0 0 {name=p90940 lab=_40585_/A }
C {devices/lab_pin.sym} 91900 -35910 0 1 {name=p90941 lab=_40670_/X }
C {sky130_stdcells/buf_2.sym} 91860 -35910 0 0 {name=X_40670_ }
C {devices/lab_pin.sym} 91820 -35790 0 0 {name=p90942 lab=_52515_/X }
C {devices/lab_pin.sym} 91900 -35790 0 1 {name=p90943 lab=_52656_/X }
C {sky130_stdcells/buf_2.sym} 91860 -35790 0 0 {name=X_52656_ }
C {devices/lab_pin.sym} 91780 -35690 0 0 {name=p90944 lab=_71487_/X }
C {devices/lab_pin.sym} 91780 -35650 0 0 {name=p90945 lab=_83481_/Q }
C {devices/lab_pin.sym} 91780 -35610 0 0 {name=p90946 lab=_71489_/X }
C {devices/lab_pin.sym} 91940 -35650 0 1 {name=p90947 lab=_71490_/X }
C {sky130_stdcells/a21o_4.sym} 91860 -35650 0 0 {name=X_71490_ }
C {devices/lab_pin.sym} 91770 -35510 0 0 {name=p90948 lab=_83476_/CLK }
C {devices/lab_pin.sym} 91770 -35490 0 0 {name=p90949 lab=_83476_/D }
C {devices/lab_pin.sym} 91950 -35510 0 1 {name=p90950 lab=_83476_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -35500 0 0 {name=X_83476_ }
C {sky130_stdcells/decap_3.sym} 91860 -35340 0 0 {name=XPHY_602 }
C {devices/lab_pin.sym} 91770 -35190 0 0 {name=p90951 lab=_81038_/CLK }
C {devices/lab_pin.sym} 91770 -35170 0 0 {name=p90952 lab=_80688_/D }
C {devices/lab_pin.sym} 91950 -35190 0 1 {name=p90953 lab=_75269_/A }
C {sky130_stdcells/dfxtp_4.sym} 91860 -35180 0 0 {name=X_80688_ }
C {sky130_stdcells/decap_3.sym} 91860 -35020 0 0 {name=XPHY_613 }
C {devices/lab_pin.sym} 91770 -34870 0 0 {name=p90954 lab=_88002_/CLK }
C {devices/lab_pin.sym} 91770 -34850 0 0 {name=p90955 lab=_88003_/D }
C {devices/lab_pin.sym} 91950 -34870 0 1 {name=p90956 lab=_88003_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -34860 0 0 {name=X_88003_ }
C {sky130_stdcells/decap_3.sym} 91860 -34700 0 0 {name=XPHY_624 }
C {devices/lab_pin.sym} 91820 -34550 0 0 {name=p90957 lab=clkbuf_9_25_0_CLK/X }
C {devices/lab_pin.sym} 91900 -34550 0 1 {name=p90958 lab=_85039_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 91860 -34550 0 0 {name=Xclkbuf_10_51_0_CLK }
C {devices/lab_pin.sym} 91770 -34430 0 0 {name=p90959 lab=_85249_/CLK }
C {devices/lab_pin.sym} 91770 -34410 0 0 {name=p90960 lab=_85215_/D }
C {devices/lab_pin.sym} 91950 -34430 0 1 {name=p90961 lab=_56381_/C }
C {sky130_stdcells/dfxtp_4.sym} 91860 -34420 0 0 {name=X_85215_ }
C {devices/lab_pin.sym} 91820 -34290 0 0 {name=p90962 lab=_51033_/A }
C {devices/lab_pin.sym} 91900 -34290 0 1 {name=p90963 lab=_51608_/A }
C {sky130_stdcells/buf_2.sym} 91860 -34290 0 0 {name=X_51607_ }
C {devices/lab_pin.sym} 91820 -34170 0 0 {name=p90964 lab=_71196_/A }
C {devices/lab_pin.sym} 91900 -34170 0 1 {name=p90965 lab=_71194_/C }
C {sky130_stdcells/buf_2.sym} 91860 -34170 0 0 {name=X_70441_ }
C {devices/lab_pin.sym} 91820 -34050 0 0 {name=p90966 lab=_63054_/A }
C {devices/lab_pin.sym} 91900 -34050 0 1 {name=p90967 lab=_64257_/A }
C {sky130_stdcells/buf_2.sym} 91860 -34050 0 0 {name=X_58163_ }
C {sky130_stdcells/decap_3.sym} 91860 -33900 0 0 {name=XPHY_635 }
C {devices/lab_pin.sym} 91770 -33750 0 0 {name=p90968 lab=_83507_/CLK }
C {devices/lab_pin.sym} 91770 -33730 0 0 {name=p90969 lab=_82427_/D }
C {devices/lab_pin.sym} 91950 -33750 0 1 {name=p90970 lab=_78680_/A }
C {sky130_stdcells/dfxtp_4.sym} 91860 -33740 0 0 {name=X_82427_ }
C {devices/lab_pin.sym} 91800 -33620 0 0 {name=p90971 lab=_55375_/A }
C {devices/lab_pin.sym} 91800 -33580 0 0 {name=p90972 lab=_55374_/Y }
C {devices/lab_pin.sym} 91920 -33600 0 1 {name=p90973 lab=_55375_/Y }
C {sky130_stdcells/nor2_4.sym} 91860 -33600 0 0 {name=X_55375_ }
C {devices/lab_pin.sym} 91770 -33470 0 0 {name=p90974 lab=_86191_/CLK }
C {devices/lab_pin.sym} 91770 -33450 0 0 {name=p90975 lab=_86195_/D }
C {devices/lab_pin.sym} 91950 -33470 0 1 {name=p90976 lab=_86195_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -33460 0 0 {name=X_86195_ }
C {sky130_stdcells/decap_3.sym} 91860 -33300 0 0 {name=XPHY_646 }
C {devices/lab_pin.sym} 91780 -33170 0 0 {name=p90977 lab=_85791_/Q }
C {devices/lab_pin.sym} 91780 -33130 0 0 {name=p90978 lab=_52575_/X }
C {devices/lab_pin.sym} 91780 -33090 0 0 {name=p90979 lab=_52586_/Y }
C {devices/lab_pin.sym} 91940 -33130 0 1 {name=p90980 lab=_52587_/Y }
C {sky130_stdcells/o21ai_4.sym} 91860 -33130 0 0 {name=X_52587_ }
C {devices/lab_pin.sym} 91820 -32990 0 0 {name=p90981 lab=clkbuf_9_391_0_CLK/A }
C {devices/lab_pin.sym} 91900 -32990 0 1 {name=p90982 lab=clkbuf_9_390_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 91860 -32990 0 0 {name=Xclkbuf_9_390_0_CLK }
C {sky130_stdcells/decap_3.sym} 91860 -32840 0 0 {name=XPHY_657 }
C {sky130_stdcells/decap_3.sym} 91860 -32660 0 0 {name=XPHY_668 }
C {devices/lab_pin.sym} 91780 -32530 0 0 {name=p90983 lab=_56613_/X }
C {devices/lab_pin.sym} 91780 -32490 0 0 {name=p90984 lab=_57106_/X }
C {devices/lab_pin.sym} 91780 -32450 0 0 {name=p90985 lab=_57113_/Y }
C {devices/lab_pin.sym} 91940 -32490 0 1 {name=p90986 lab=_85081_/D }
C {sky130_stdcells/a21oi_4.sym} 91860 -32490 0 0 {name=X_57114_ }
C {devices/lab_pin.sym} 91820 -32350 0 0 {name=p90987 lab=_42340_/A }
C {devices/lab_pin.sym} 91900 -32350 0 1 {name=p90988 lab=_42340_/Y }
C {sky130_stdcells/inv_2.sym} 91860 -32350 0 0 {name=X_42340_ }
C {devices/lab_pin.sym} 91780 -32250 0 0 {name=p90989 lab=_54324_/Y }
C {devices/lab_pin.sym} 91780 -32210 0 0 {name=p90990 lab=_54311_/X }
C {devices/lab_pin.sym} 91780 -32170 0 0 {name=p90991 lab=_54325_/X }
C {devices/lab_pin.sym} 91940 -32210 0 1 {name=p90992 lab=_85463_/D }
C {sky130_stdcells/a21oi_4.sym} 91860 -32210 0 0 {name=X_54326_ }
C {sky130_stdcells/decap_3.sym} 91860 -32040 0 0 {name=XPHY_679 }
C {devices/lab_pin.sym} 91800 -31900 0 0 {name=p90993 lab=_73381_/A }
C {devices/lab_pin.sym} 91800 -31860 0 0 {name=p90994 lab=_86482_/Q }
C {devices/lab_pin.sym} 91920 -31880 0 1 {name=p90995 lab=_73160_/X }
C {sky130_stdcells/and2_4.sym} 91860 -31880 0 0 {name=X_73160_ }
C {devices/lab_pin.sym} 91770 -31750 0 0 {name=p90996 lab=_85144_/CLK }
C {devices/lab_pin.sym} 91770 -31730 0 0 {name=p90997 lab=_85146_/D }
C {devices/lab_pin.sym} 91950 -31750 0 1 {name=p90998 lab=_85146_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -31740 0 0 {name=X_85146_ }
C {devices/lab_pin.sym} 91780 -31630 0 0 {name=p90999 lab=_51536_/Y }
C {devices/lab_pin.sym} 91780 -31590 0 0 {name=p91000 lab=_51531_/X }
C {devices/lab_pin.sym} 91780 -31550 0 0 {name=p91001 lab=_51537_/X }
C {devices/lab_pin.sym} 91940 -31590 0 1 {name=p91002 lab=_85992_/D }
C {sky130_stdcells/a21oi_4.sym} 91860 -31590 0 0 {name=X_51538_ }
C {devices/lab_pin.sym} 91780 -31470 0 0 {name=p91003 lab=_51358_/B }
C {devices/lab_pin.sym} 91780 -31430 0 0 {name=p91004 lab=_70364_/X }
C {devices/lab_pin.sym} 91780 -31390 0 0 {name=p91005 lab=_70371_/Y }
C {devices/lab_pin.sym} 91940 -31430 0 1 {name=p91006 lab=_70372_/Y }
C {sky130_stdcells/o21ai_4.sym} 91860 -31430 0 0 {name=X_70372_ }
C {devices/lab_pin.sym} 91820 -31290 0 0 {name=p91007 lab=_58094_/A }
C {devices/lab_pin.sym} 91900 -31290 0 1 {name=p91008 lab=_58599_/A }
C {sky130_stdcells/buf_2.sym} 91860 -31290 0 0 {name=X_58094_ }
C {devices/lab_pin.sym} 91770 -31170 0 0 {name=p91009 lab=_84981_/CLK }
C {devices/lab_pin.sym} 91770 -31150 0 0 {name=p91010 lab=_77199_/X }
C {devices/lab_pin.sym} 91950 -31170 0 1 {name=p91011 lab=_47955_/A }
C {sky130_stdcells/dfxtp_4.sym} 91860 -31160 0 0 {name=X_82358_ }
C {devices/lab_pin.sym} 91820 -31030 0 0 {name=p91012 lab=clkbuf_9_142_0_CLK/X }
C {devices/lab_pin.sym} 91900 -31030 0 1 {name=p91013 lab=_84945_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 91860 -31030 0 0 {name=Xclkbuf_10_284_0_CLK }
C {devices/lab_pin.sym} 91780 -30930 0 0 {name=p91014 lab=_83282_/Q }
C {devices/lab_pin.sym} 91780 -30890 0 0 {name=p91015 lab=_72066_/X }
C {devices/lab_pin.sym} 91780 -30850 0 0 {name=p91016 lab=_72110_/Y }
C {devices/lab_pin.sym} 91940 -30890 0 1 {name=p91017 lab=_72111_/Y }
C {sky130_stdcells/o21ai_4.sym} 91860 -30890 0 0 {name=X_72111_ }
C {devices/lab_pin.sym} 91820 -30750 0 0 {name=p91018 lab=_57044_/Y }
C {devices/lab_pin.sym} 91900 -30750 0 1 {name=p91019 lab=_85097_/D }
C {sky130_stdcells/inv_2.sym} 91860 -30750 0 0 {name=X_57045_ }
C {devices/lab_pin.sym} 91770 -30630 0 0 {name=p91020 lab=_81627_/CLK }
C {devices/lab_pin.sym} 91770 -30610 0 0 {name=p91021 lab=_76997_/X }
C {devices/lab_pin.sym} 91950 -30630 0 1 {name=p91022 lab=_81277_/D }
C {sky130_stdcells/dfxtp_4.sym} 91860 -30620 0 0 {name=X_81309_ }
C {devices/lab_pin.sym} 91820 -30490 0 0 {name=p91023 lab=_42258_/A }
C {devices/lab_pin.sym} 91900 -30490 0 1 {name=p91024 lab=_42271_/X }
C {sky130_stdcells/buf_2.sym} 91860 -30490 0 0 {name=X_42271_ }
C {devices/lab_pin.sym} 91800 -30380 0 0 {name=p91025 lab=_54961_/A }
C {devices/lab_pin.sym} 91800 -30340 0 0 {name=p91026 lab=_53086_/B }
C {devices/lab_pin.sym} 91920 -30360 0 1 {name=p91027 lab=_54257_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -30360 0 0 {name=X_54257_ }
C {devices/lab_pin.sym} 91780 -30260 0 0 {name=p91028 lab=_73062_/X }
C {devices/lab_pin.sym} 91780 -30220 0 0 {name=p91029 lab=_86197_/Q }
C {devices/lab_pin.sym} 91780 -30180 0 0 {name=p91030 lab=_72955_/X }
C {devices/lab_pin.sym} 91780 -30140 0 0 {name=p91031 lab=_73090_/X }
C {devices/lab_pin.sym} 91940 -30200 0 1 {name=p91032 lab=_73091_/X }
C {sky130_stdcells/a211o_4.sym} 91860 -30200 0 0 {name=X_73091_ }
C {devices/lab_pin.sym} 91770 -30050 0 0 {name=p91033 lab=_85042_/CLK }
C {devices/lab_pin.sym} 91770 -30030 0 0 {name=p91034 lab=_85077_/D }
C {devices/lab_pin.sym} 91950 -30050 0 1 {name=p91035 lab=_85077_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -30040 0 0 {name=X_85077_ }
C {devices/lab_pin.sym} 91800 -29920 0 0 {name=p91036 lab=_51481_/A }
C {devices/lab_pin.sym} 91800 -29880 0 0 {name=p91037 lab=_52995_/B }
C {devices/lab_pin.sym} 91920 -29900 0 1 {name=p91038 lab=_51469_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -29900 0 0 {name=X_51469_ }
C {devices/lab_pin.sym} 91770 -29770 0 0 {name=p91039 lab=_82339_/CLK }
C {devices/lab_pin.sym} 91770 -29750 0 0 {name=p91040 lab=_81913_/Q }
C {devices/lab_pin.sym} 91950 -29770 0 1 {name=p91041 lab=_41026_/A }
C {sky130_stdcells/dfxtp_4.sym} 91860 -29760 0 0 {name=X_82289_ }
C {devices/lab_pin.sym} 91800 -29640 0 0 {name=p91042 lab=_44010_/A }
C {devices/lab_pin.sym} 91800 -29600 0 0 {name=p91043 lab=_44247_/A }
C {devices/lab_pin.sym} 91920 -29620 0 1 {name=p91044 lab=_44152_/A }
C {sky130_stdcells/nand2_4.sym} 91860 -29620 0 0 {name=X_44010_ }
C {devices/lab_pin.sym} 91820 -29490 0 0 {name=p91045 lab=clkbuf_9_33_0_CLK/X }
C {devices/lab_pin.sym} 91900 -29490 0 1 {name=p91046 lab=_83016_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 91860 -29490 0 0 {name=Xclkbuf_10_66_0_CLK }
C {devices/lab_pin.sym} 91780 -29390 0 0 {name=p91047 lab=_53206_/Y }
C {devices/lab_pin.sym} 91780 -29350 0 0 {name=p91048 lab=_53189_/X }
C {devices/lab_pin.sym} 91780 -29310 0 0 {name=p91049 lab=_53207_/X }
C {devices/lab_pin.sym} 91940 -29350 0 1 {name=p91050 lab=_85677_/D }
C {sky130_stdcells/a21oi_4.sym} 91860 -29350 0 0 {name=X_53208_ }
C {devices/lab_pin.sym} 91820 -29210 0 0 {name=p91051 lab=_41221_/Y }
C {devices/lab_pin.sym} 91900 -29210 0 1 {name=p91052 lab=_41222_/Y }
C {sky130_stdcells/inv_2.sym} 91860 -29210 0 0 {name=X_41222_ }
C {devices/lab_pin.sym} 91820 -29090 0 0 {name=p91053 lab=_46610_/A }
C {devices/lab_pin.sym} 91900 -29090 0 1 {name=p91054 lab=_74453_/A }
C {sky130_stdcells/buf_2.sym} 91860 -29090 0 0 {name=X_72042_ }
C {devices/lab_pin.sym} 91770 -28970 0 0 {name=p91055 lab=_86807_/CLK }
C {devices/lab_pin.sym} 91770 -28950 0 0 {name=p91056 lab=_84028_/D }
C {devices/lab_pin.sym} 91950 -28970 0 1 {name=p91057 lab=_84028_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -28960 0 0 {name=X_84028_ }
C {devices/lab_pin.sym} 91800 -28840 0 0 {name=p91058 lab=_54184_/A }
C {devices/lab_pin.sym} 91800 -28800 0 0 {name=p91059 lab=_47394_/Y }
C {devices/lab_pin.sym} 91920 -28820 0 1 {name=p91060 lab=_54188_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -28820 0 0 {name=X_54188_ }
C {devices/lab_pin.sym} 91820 -28690 0 0 {name=p91061 lab=clkbuf_8_213_0_CLK/A }
C {devices/lab_pin.sym} 91900 -28690 0 1 {name=p91062 lab=clkbuf_9_424_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 91860 -28690 0 0 {name=Xclkbuf_8_212_0_CLK }
C {devices/lab_pin.sym} 91820 -28570 0 0 {name=p91063 lab=_40989_/A }
C {devices/lab_pin.sym} 91900 -28570 0 1 {name=p91064 lab=_41153_/X }
C {sky130_stdcells/buf_2.sym} 91860 -28570 0 0 {name=X_41153_ }
C {devices/lab_pin.sym} 91800 -28480 0 0 {name=p91065 lab=_53139_/A }
C {devices/lab_pin.sym} 91800 -28440 0 0 {name=p91066 lab=_53133_/B }
C {devices/lab_pin.sym} 91800 -28400 0 0 {name=p91067 lab=_53133_/C }
C {devices/lab_pin.sym} 91800 -28360 0 0 {name=p91068 lab=_53139_/D }
C {devices/lab_pin.sym} 91920 -28420 0 1 {name=p91069 lab=_53139_/X }
C {sky130_stdcells/and4_4.sym} 91860 -28420 0 0 {name=X_53139_ }
C {devices/lab_pin.sym} 91800 -28280 0 0 {name=p91070 lab=_76837_/A }
C {devices/lab_pin.sym} 91800 -28240 0 0 {name=p91071 lab=_76844_/A }
C {devices/lab_pin.sym} 91920 -28260 0 1 {name=p91072 lab=_76850_/X }
C {sky130_stdcells/and2_4.sym} 91860 -28260 0 0 {name=X_76850_ }
C {devices/lab_pin.sym} 91820 -28130 0 0 {name=p91073 lab=clkbuf_9_149_0_CLK/X }
C {devices/lab_pin.sym} 91900 -28130 0 1 {name=p91074 lab=_84329_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 91860 -28130 0 0 {name=Xclkbuf_10_299_0_CLK }
C {devices/lab_pin.sym} 91800 -28020 0 0 {name=p91075 lab=_58920_/A }
C {devices/lab_pin.sym} 91800 -27980 0 0 {name=p91076 lab=_86369_/Q }
C {devices/lab_pin.sym} 91920 -28000 0 1 {name=p91077 lab=_58996_/Y }
C {sky130_stdcells/nor2_4.sym} 91860 -28000 0 0 {name=X_58996_ }
C {devices/lab_pin.sym} 91800 -27880 0 0 {name=p91078 lab=_81019_/Q }
C {devices/lab_pin.sym} 91800 -27840 0 0 {name=p91079 lab=_80891_/D }
C {devices/lab_pin.sym} 91920 -27860 0 1 {name=p91080 lab=_80987_/D }
C {sky130_stdcells/xor2_4.sym} 91860 -27860 0 0 {name=X_75801_ }
C {devices/lab_pin.sym} 91820 -27730 0 0 {name=p91081 lab=_57947_/A }
C {devices/lab_pin.sym} 91900 -27730 0 1 {name=p91082 lab=_57947_/X }
C {sky130_stdcells/buf_2.sym} 91860 -27730 0 0 {name=X_57947_ }
C {devices/lab_pin.sym} 91820 -27610 0 0 {name=p91083 lab=_45961_/A }
C {devices/lab_pin.sym} 91900 -27610 0 1 {name=p91084 lab=_45961_/Y }
C {sky130_stdcells/inv_2.sym} 91860 -27610 0 0 {name=X_45961_ }
C {devices/lab_pin.sym} 91820 -27490 0 0 {name=p91085 lab=_41084_/A }
C {devices/lab_pin.sym} 91900 -27490 0 1 {name=p91086 lab=_41084_/Y }
C {sky130_stdcells/inv_2.sym} 91860 -27490 0 0 {name=X_41084_ }
C {devices/lab_pin.sym} 91800 -27380 0 0 {name=p91087 lab=_76776_/Y }
C {devices/lab_pin.sym} 91800 -27340 0 0 {name=p91088 lab=_76780_/Y }
C {devices/lab_pin.sym} 91920 -27360 0 1 {name=p91089 lab=_76781_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -27360 0 0 {name=X_76781_ }
C {devices/lab_pin.sym} 91800 -27240 0 0 {name=p91090 lab=_44126_/X }
C {devices/lab_pin.sym} 91800 -27200 0 0 {name=p91091 lab=_66166_/B }
C {devices/lab_pin.sym} 91920 -27220 0 1 {name=p91092 lab=_73993_/X }
C {sky130_stdcells/and2_4.sym} 91860 -27220 0 0 {name=X_73993_ }
C {devices/lab_pin.sym} 91770 -27090 0 0 {name=p91093 lab=_85692_/CLK }
C {devices/lab_pin.sym} 91770 -27070 0 0 {name=p91094 lab=_51610_/Y }
C {devices/lab_pin.sym} 91950 -27090 0 1 {name=p91095 lab=_85979_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -27080 0 0 {name=X_85979_ }
C {devices/lab_pin.sym} 91820 -26950 0 0 {name=p91096 lab=_81231_/Q }
C {devices/lab_pin.sym} 91900 -26950 0 1 {name=p91097 lab=_47701_/A }
C {sky130_stdcells/inv_2.sym} 91860 -26950 0 0 {name=X_47700_ }
C {devices/lab_pin.sym} 91800 -26840 0 0 {name=p91098 lab=_82512_/Q }
C {devices/lab_pin.sym} 91800 -26800 0 0 {name=p91099 lab=_82768_/D }
C {devices/lab_pin.sym} 91920 -26820 0 1 {name=p91100 lab=_78520_/X }
C {sky130_stdcells/xor2_4.sym} 91860 -26820 0 0 {name=X_78520_ }
C {devices/lab_pin.sym} 91780 -26710 0 0 {name=p91101 lab=_55976_/B }
C {devices/lab_pin.sym} 91780 -26670 0 0 {name=p91102 lab=_44874_/X }
C {devices/lab_pin.sym} 91780 -26630 0 0 {name=p91103 lab=_44875_/X }
C {devices/lab_pin.sym} 91940 -26670 0 1 {name=p91104 lab=_44912_/X }
C {sky130_stdcells/o21a_4.sym} 91860 -26670 0 0 {name=X_44912_ }
C {devices/lab_pin.sym} 91820 -26530 0 0 {name=p91105 lab=_75732_/A }
C {devices/lab_pin.sym} 91900 -26530 0 1 {name=p91106 lab=_75734_/A }
C {sky130_stdcells/inv_2.sym} 91860 -26530 0 0 {name=X_75732_ }
C {devices/lab_pin.sym} 91770 -26410 0 0 {name=p91107 lab=_87150_/CLK }
C {devices/lab_pin.sym} 91770 -26390 0 0 {name=p91108 lab=_42789_/X }
C {devices/lab_pin.sym} 91950 -26410 0 1 {name=p91109 lab=_87718_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -26400 0 0 {name=X_87718_ }
C {devices/lab_pin.sym} 91800 -26290 0 0 {name=p91110 lab=_48680_/A }
C {devices/lab_pin.sym} 91800 -26250 0 0 {name=p91111 lab=_48657_/B }
C {devices/lab_pin.sym} 91800 -26210 0 0 {name=p91112 lab=_48894_/C }
C {devices/lab_pin.sym} 91920 -26250 0 1 {name=p91113 lab=_48680_/X }
C {sky130_stdcells/and3_4.sym} 91860 -26250 0 0 {name=X_48680_ }
C {devices/lab_pin.sym} 91820 -26110 0 0 {name=p91114 lab=_72725_/A }
C {devices/lab_pin.sym} 91900 -26110 0 1 {name=p91115 lab=_72944_/X }
C {sky130_stdcells/buf_2.sym} 91860 -26110 0 0 {name=X_72944_ }
C {devices/lab_pin.sym} 91820 -25990 0 0 {name=p91116 lab=_45891_/X }
C {devices/lab_pin.sym} 91900 -25990 0 1 {name=p91117 lab=_45893_/C }
C {sky130_stdcells/buf_2.sym} 91860 -25990 0 0 {name=X_45892_ }
C {devices/lab_pin.sym} 91820 -25870 0 0 {name=p91118 lab=clkbuf_8_227_0_CLK/A }
C {devices/lab_pin.sym} 91900 -25870 0 1 {name=p91119 lab=clkbuf_9_455_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 91860 -25870 0 0 {name=Xclkbuf_8_227_0_CLK }
C {devices/lab_pin.sym} 91820 -25750 0 0 {name=p91120 lab=_58020_/A }
C {devices/lab_pin.sym} 91900 -25750 0 1 {name=p91121 lab=_57878_/X }
C {sky130_stdcells/buf_2.sym} 91860 -25750 0 0 {name=X_57878_ }
C {devices/lab_pin.sym} 91820 -25630 0 0 {name=p91122 lab=clkbuf_9_111_0_CLK/X }
C {devices/lab_pin.sym} 91900 -25630 0 1 {name=p91123 lab=_84559_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 91860 -25630 0 0 {name=Xclkbuf_10_222_0_CLK }
C {devices/lab_pin.sym} 91820 -25510 0 0 {name=p91124 lab=_47631_/A }
C {devices/lab_pin.sym} 91900 -25510 0 1 {name=p91125 lab=_47632_/A }
C {sky130_stdcells/inv_2.sym} 91860 -25510 0 0 {name=X_47631_ }
C {devices/lab_pin.sym} 91820 -25390 0 0 {name=p91126 lab=_59893_/C }
C {devices/lab_pin.sym} 91900 -25390 0 1 {name=p91127 lab=_59905_/B }
C {sky130_stdcells/buf_2.sym} 91860 -25390 0 0 {name=X_59617_ }
C {devices/lab_pin.sym} 91780 -25290 0 0 {name=p91128 lab=_78439_/Y }
C {devices/lab_pin.sym} 91780 -25250 0 0 {name=p91129 lab=_78423_/Y }
C {devices/lab_pin.sym} 91780 -25210 0 0 {name=p91130 lab=_78450_/A }
C {devices/lab_pin.sym} 91940 -25250 0 1 {name=p91131 lab=_78451_/Y }
C {sky130_stdcells/a21oi_4.sym} 91860 -25250 0 0 {name=X_78451_ }
C {devices/lab_pin.sym} 91780 -25140 0 0 {name=p91132 lab=_41730_/Y }
C {devices/lab_pin.sym} 91780 -25100 0 0 {name=p91133 lab=_44838_/X }
C {devices/lab_pin.sym} 91780 -25060 0 0 {name=p91134 lab=_86924_/Q }
C {devices/lab_pin.sym} 91780 -25020 0 0 {name=p91135 lab=_44839_/X }
C {devices/lab_pin.sym} 91940 -25080 0 1 {name=p91136 lab=_86924_/D }
C {sky130_stdcells/a2bb2o_4.sym} 91860 -25080 0 0 {name=X_44843_ }
C {devices/lab_pin.sym} 91780 -24950 0 0 {name=p91137 lab=_56738_/X }
C {devices/lab_pin.sym} 91780 -24910 0 0 {name=p91138 lab=_56828_/Y }
C {devices/lab_pin.sym} 91780 -24870 0 0 {name=p91139 lab=_45888_/A }
C {devices/lab_pin.sym} 91940 -24910 0 1 {name=p91140 lab=_56829_/X }
C {sky130_stdcells/o21a_4.sym} 91860 -24910 0 0 {name=X_56829_ }
C {devices/lab_pin.sym} 91780 -24800 0 0 {name=p91141 lab=_75649_/Y }
C {devices/lab_pin.sym} 91780 -24760 0 0 {name=p91142 lab=_75650_/Y }
C {devices/lab_pin.sym} 91780 -24720 0 0 {name=p91143 lab=_80906_/Q }
C {devices/lab_pin.sym} 91780 -24680 0 0 {name=p91144 lab=_75662_/Y }
C {devices/lab_pin.sym} 91940 -24740 0 1 {name=p91145 lab=_75663_/X }
C {sky130_stdcells/a2bb2o_4.sym} 91860 -24740 0 0 {name=X_75663_ }
C {devices/lab_pin.sym} 91820 -24590 0 0 {name=p91146 lab=clkbuf_9_426_0_CLK/X }
C {devices/lab_pin.sym} 91900 -24590 0 1 {name=p91147 lab=_82961_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 91860 -24590 0 0 {name=Xclkbuf_10_852_0_CLK }
C {devices/lab_pin.sym} 91770 -24470 0 0 {name=p91148 lab=_87646_/CLK }
C {devices/lab_pin.sym} 91770 -24450 0 0 {name=p91149 lab=_87649_/D }
C {devices/lab_pin.sym} 91950 -24470 0 1 {name=p91150 lab=_87649_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -24460 0 0 {name=X_87649_ }
C {devices/lab_pin.sym} 91780 -24360 0 0 {name=p91151 lab=_45931_/X }
C {devices/lab_pin.sym} 91780 -24320 0 0 {name=p91152 lab=_85597_/Q }
C {devices/lab_pin.sym} 91780 -24280 0 0 {name=p91153 lab=_56933_/X }
C {devices/lab_pin.sym} 91780 -24240 0 0 {name=p91154 lab=_72874_/X }
C {devices/lab_pin.sym} 91940 -24300 0 1 {name=p91155 lab=_72875_/X }
C {sky130_stdcells/a211o_4.sym} 91860 -24300 0 0 {name=X_72875_ }
C {devices/lab_pin.sym} 91780 -24170 0 0 {name=p91156 lab=_77397_/Y }
C {devices/lab_pin.sym} 91780 -24130 0 0 {name=p91157 lab=_77374_/B }
C {devices/lab_pin.sym} 91780 -24090 0 0 {name=p91158 lab=_77401_/X }
C {devices/lab_pin.sym} 91940 -24130 0 1 {name=p91159 lab=_77403_/B }
C {sky130_stdcells/o21ai_4.sym} 91860 -24130 0 0 {name=X_77402_ }
C {devices/lab_pin.sym} 91820 -23990 0 0 {name=p91160 lab=_74614_/A }
C {devices/lab_pin.sym} 91900 -23990 0 1 {name=p91161 lab=_74614_/X }
C {sky130_stdcells/buf_2.sym} 91860 -23990 0 0 {name=X_74614_ }
C {devices/lab_pin.sym} 91820 -23870 0 0 {name=p91162 lab=_47561_/Y }
C {devices/lab_pin.sym} 91900 -23870 0 1 {name=p91163 lab=_53122_/B }
C {sky130_stdcells/buf_2.sym} 91860 -23870 0 0 {name=X_47562_ }
C {devices/lab_pin.sym} 91820 -23750 0 0 {name=p91164 lab=_70773_/A }
C {devices/lab_pin.sym} 91900 -23750 0 1 {name=p91165 lab=_71826_/X }
C {sky130_stdcells/buf_2.sym} 91860 -23750 0 0 {name=X_71826_ }
C {devices/lab_pin.sym} 91820 -23630 0 0 {name=p91166 lab=_60183_/A }
C {devices/lab_pin.sym} 91900 -23630 0 1 {name=p91167 lab=_59552_/C }
C {sky130_stdcells/buf_2.sym} 91860 -23630 0 0 {name=X_59548_ }
C {devices/lab_pin.sym} 91800 -23520 0 0 {name=p91168 lab=_78397_/B }
C {devices/lab_pin.sym} 91800 -23480 0 0 {name=p91169 lab=_78382_/B }
C {devices/lab_pin.sym} 91920 -23500 0 1 {name=p91170 lab=_82759_/D }
C {sky130_stdcells/xor2_4.sym} 91860 -23500 0 0 {name=X_78382_ }
C {devices/lab_pin.sym} 91820 -23370 0 0 {name=p91171 lab=_44618_/A }
C {devices/lab_pin.sym} 91900 -23370 0 1 {name=p91172 lab=_44774_/X }
C {sky130_stdcells/buf_2.sym} 91860 -23370 0 0 {name=X_44774_ }
C {devices/lab_pin.sym} 91800 -23270 0 0 {name=p91173 lab=_75590_/X }
C {devices/lab_pin.sym} 91800 -23230 0 0 {name=p91174 lab=_75594_/B }
C {devices/lab_pin.sym} 91800 -23190 0 0 {name=p91175 lab=_75591_/Y }
C {devices/lab_pin.sym} 91920 -23230 0 1 {name=p91176 lab=_75594_/Y }
C {sky130_stdcells/nand3_4.sym} 91860 -23230 0 0 {name=X_75594_ }
C {devices/lab_pin.sym} 91820 -23090 0 0 {name=p91177 lab=clkbuf_9_343_0_CLK/A }
C {devices/lab_pin.sym} 91900 -23090 0 1 {name=p91178 lab=clkbuf_9_343_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 91860 -23090 0 0 {name=Xclkbuf_9_343_0_CLK }
C {devices/lab_pin.sym} 91820 -22970 0 0 {name=p91179 lab=_88081_/Q }
C {devices/lab_pin.sym} 91900 -22970 0 1 {name=p91180 lab=_41986_/Y }
C {sky130_stdcells/inv_2.sym} 91860 -22970 0 0 {name=X_41986_ }
C {devices/lab_pin.sym} 91820 -22850 0 0 {name=p91181 lab=_49205_/A }
C {devices/lab_pin.sym} 91900 -22850 0 1 {name=p91182 lab=_49302_/A }
C {sky130_stdcells/buf_2.sym} 91860 -22850 0 0 {name=X_49301_ }
C {devices/lab_pin.sym} 91780 -22750 0 0 {name=p91183 lab=_86730_/Q }
C {devices/lab_pin.sym} 91780 -22710 0 0 {name=p91184 lab=_46430_/X }
C {devices/lab_pin.sym} 91780 -22670 0 0 {name=p91185 lab=_46512_/Y }
C {devices/lab_pin.sym} 91940 -22710 0 1 {name=p91186 lab=_46513_/Y }
C {sky130_stdcells/o21ai_4.sym} 91860 -22710 0 0 {name=X_46513_ }
C {devices/lab_pin.sym} 91820 -22570 0 0 {name=p91187 lab=_77333_/A }
C {devices/lab_pin.sym} 91900 -22570 0 1 {name=p91188 lab=_77334_/B }
C {sky130_stdcells/inv_2.sym} 91860 -22570 0 0 {name=X_77333_ }
C {devices/lab_pin.sym} 91780 -22480 0 0 {name=p91189 lab=_40873_/X }
C {devices/lab_pin.sym} 91780 -22440 0 0 {name=p91190 lab=_43716_/X }
C {devices/lab_pin.sym} 91780 -22400 0 0 {name=p91191 lab=_69838_/B }
C {devices/lab_pin.sym} 91780 -22360 0 0 {name=p91192 lab=_43718_/X }
C {devices/lab_pin.sym} 91940 -22420 0 1 {name=p91193 lab=_43726_/A }
C {sky130_stdcells/a2bb2o_4.sym} 91860 -22420 0 0 {name=X_43725_ }
C {devices/lab_pin.sym} 91800 -22290 0 0 {name=p91194 lab=_74541_/A }
C {devices/lab_pin.sym} 91800 -22250 0 0 {name=p91195 lab=_46215_/B }
C {devices/lab_pin.sym} 91800 -22210 0 0 {name=p91196 lab=_74545_/C }
C {devices/lab_pin.sym} 91920 -22250 0 1 {name=p91197 lab=_74545_/Y }
C {sky130_stdcells/nand3_4.sym} 91860 -22250 0 0 {name=X_74545_ }
C {devices/lab_pin.sym} 91800 -22120 0 0 {name=p91198 lab=_40937_/A }
C {devices/lab_pin.sym} 91800 -22080 0 0 {name=p91199 lab=_41119_/A }
C {devices/lab_pin.sym} 91920 -22100 0 1 {name=p91200 lab=_40937_/X }
C {sky130_stdcells/or2_4.sym} 91860 -22100 0 0 {name=X_40937_ }
C {devices/lab_pin.sym} 91820 -21970 0 0 {name=p91201 lab=_47493_/A }
C {devices/lab_pin.sym} 91900 -21970 0 1 {name=p91202 lab=_47494_/A }
C {sky130_stdcells/inv_2.sym} 91860 -21970 0 0 {name=X_47493_ }
C {devices/lab_pin.sym} 91780 -21870 0 0 {name=p91203 lab=_52959_/B }
C {devices/lab_pin.sym} 91780 -21830 0 0 {name=p91204 lab=_71736_/X }
C {devices/lab_pin.sym} 91780 -21790 0 0 {name=p91205 lab=_71756_/Y }
C {devices/lab_pin.sym} 91940 -21830 0 1 {name=p91206 lab=_83387_/D }
C {sky130_stdcells/o21ai_4.sym} 91860 -21830 0 0 {name=X_71757_ }
C {devices/lab_pin.sym} 91780 -21710 0 0 {name=p91207 lab=_59462_/X }
C {devices/lab_pin.sym} 91780 -21670 0 0 {name=p91208 lab=_83433_/Q }
C {devices/lab_pin.sym} 91780 -21630 0 0 {name=p91209 lab=_59478_/Y }
C {devices/lab_pin.sym} 91940 -21670 0 1 {name=p91210 lab=_84721_/D }
C {sky130_stdcells/o21a_4.sym} 91860 -21670 0 0 {name=X_59479_ }
C {devices/lab_pin.sym} 91820 -21530 0 0 {name=p91211 lab=clkbuf_9_118_0_CLK/X }
C {devices/lab_pin.sym} 91900 -21530 0 1 {name=p91212 lab=_81834_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 91860 -21530 0 0 {name=Xclkbuf_10_237_0_CLK }
C {devices/lab_pin.sym} 91800 -21420 0 0 {name=p91213 lab=_49232_/A }
C {devices/lab_pin.sym} 91800 -21380 0 0 {name=p91214 lab=_51261_/B }
C {devices/lab_pin.sym} 91920 -21400 0 1 {name=p91215 lab=_49232_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -21400 0 0 {name=X_49232_ }
C {devices/lab_pin.sym} 91820 -21270 0 0 {name=p91216 lab=_84818_/Q }
C {devices/lab_pin.sym} 91900 -21270 0 1 {name=p91217 lab=_61510_/X }
C {sky130_stdcells/buf_2.sym} 91860 -21270 0 0 {name=X_61510_ }
C {devices/lab_pin.sym} 91780 -21170 0 0 {name=p91218 lab=_86736_/Q }
C {devices/lab_pin.sym} 91780 -21130 0 0 {name=p91219 lab=_46292_/X }
C {devices/lab_pin.sym} 91780 -21090 0 0 {name=p91220 lab=_46443_/Y }
C {devices/lab_pin.sym} 91940 -21130 0 1 {name=p91221 lab=_46444_/Y }
C {sky130_stdcells/o21ai_4.sym} 91860 -21130 0 0 {name=X_46444_ }
C {devices/lab_pin.sym} 91820 -20990 0 0 {name=p91222 lab=clkbuf_9_433_0_CLK/X }
C {devices/lab_pin.sym} 91900 -20990 0 1 {name=p91223 lab=_86560_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 91860 -20990 0 0 {name=Xclkbuf_10_867_0_CLK }
C {devices/lab_pin.sym} 91800 -20900 0 0 {name=p91224 lab=_70585_/X }
C {devices/lab_pin.sym} 91800 -20860 0 0 {name=p91225 lab=_70703_/X }
C {devices/lab_pin.sym} 91800 -20820 0 0 {name=p91226 lab=_70710_/C }
C {devices/lab_pin.sym} 91800 -20780 0 0 {name=p91227 lab=_70710_/D }
C {devices/lab_pin.sym} 91920 -20840 0 1 {name=p91228 lab=_70708_/Y }
C {sky130_stdcells/nand4_4.sym} 91860 -20840 0 0 {name=X_70708_ }
C {devices/lab_pin.sym} 91820 -20690 0 0 {name=p91229 lab=_77264_/A }
C {devices/lab_pin.sym} 91900 -20690 0 1 {name=p91230 lab=_77264_/Y }
C {sky130_stdcells/inv_2.sym} 91860 -20690 0 0 {name=X_77264_ }
C {devices/lab_pin.sym} 91820 -20570 0 0 {name=p91231 lab=_43685_/A }
C {devices/lab_pin.sym} 91900 -20570 0 1 {name=p91232 lab=_43656_/X }
C {sky130_stdcells/buf_2.sym} 91860 -20570 0 0 {name=X_43656_ }
C {devices/lab_pin.sym} 91800 -20480 0 0 {name=p91233 lab=_61561_/A }
C {devices/lab_pin.sym} 91800 -20440 0 0 {name=p91234 lab=_62566_/B }
C {devices/lab_pin.sym} 91800 -20400 0 0 {name=p91235 lab=_62490_/C }
C {devices/lab_pin.sym} 91800 -20360 0 0 {name=p91236 lab=_62566_/D }
C {devices/lab_pin.sym} 91920 -20420 0 1 {name=p91237 lab=_62490_/Y }
C {sky130_stdcells/nand4_4.sym} 91860 -20420 0 0 {name=X_62490_ }
C {devices/lab_pin.sym} 91800 -20280 0 0 {name=p91238 lab=_74490_/A }
C {devices/lab_pin.sym} 91800 -20240 0 0 {name=p91239 lab=_48615_/A }
C {devices/lab_pin.sym} 91920 -20260 0 1 {name=p91240 lab=_74476_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -20260 0 0 {name=X_74476_ }
C {devices/lab_pin.sym} 91780 -20170 0 0 {name=p91241 lab=_40835_/X }
C {devices/lab_pin.sym} 91780 -20130 0 0 {name=p91242 lab=_40836_/X }
C {devices/lab_pin.sym} 91780 -20090 0 0 {name=p91243 lab=_40866_/X }
C {devices/lab_pin.sym} 91780 -20050 0 0 {name=p91244 lab=_69826_/B }
C {devices/lab_pin.sym} 91780 -20010 0 0 {name=p91245 lab=_40867_/X }
C {devices/lab_pin.sym} 91940 -20090 0 1 {name=p91246 lab=_40869_/A }
C {sky130_stdcells/o32ai_4.sym} 91860 -20090 0 0 {name=X_40868_ }
C {devices/lab_pin.sym} 91800 -19950 0 0 {name=p91247 lab=_71576_/X }
C {devices/lab_pin.sym} 91800 -19910 0 0 {name=p91248 lab=_71626_/B }
C {devices/lab_pin.sym} 91800 -19870 0 0 {name=p91249 lab=_71289_/B }
C {devices/lab_pin.sym} 91920 -19910 0 1 {name=p91250 lab=_71688_/Y }
C {sky130_stdcells/nor3_4.sym} 91860 -19910 0 0 {name=X_71688_ }
C {devices/lab_pin.sym} 91820 -19770 0 0 {name=p91251 lab=clkbuf_9_9_0_CLK/X }
C {devices/lab_pin.sym} 91900 -19770 0 1 {name=p91252 lab=_83022_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 91860 -19770 0 0 {name=Xclkbuf_10_19_0_CLK }
C {devices/lab_pin.sym} 91800 -19660 0 0 {name=p91253 lab=_82824_/Q }
C {devices/lab_pin.sym} 91800 -19620 0 0 {name=p91254 lab=_82536_/Q }
C {devices/lab_pin.sym} 91920 -19640 0 1 {name=p91255 lab=_79003_/Y }
C {sky130_stdcells/xnor2_4.sym} 91860 -19640 0 0 {name=X_79003_ }
C {devices/lab_pin.sym} 91820 -19510 0 0 {name=p91256 lab=_76215_/A }
C {devices/lab_pin.sym} 91900 -19510 0 1 {name=p91257 lab=_76215_/Y }
C {sky130_stdcells/inv_2.sym} 91860 -19510 0 0 {name=X_76215_ }
C {devices/lab_pin.sym} 91820 -19390 0 0 {name=p91258 lab=_42607_/A }
C {devices/lab_pin.sym} 91900 -19390 0 1 {name=p91259 lab=_42607_/Y }
C {sky130_stdcells/inv_2.sym} 91860 -19390 0 0 {name=X_42607_ }
C {devices/lab_pin.sym} 91820 -19270 0 0 {name=p91260 lab=_61380_/A }
C {devices/lab_pin.sym} 91900 -19270 0 1 {name=p91261 lab=_61452_/D }
C {sky130_stdcells/buf_2.sym} 91860 -19270 0 0 {name=X_61441_ }
C {devices/lab_pin.sym} 91780 -19180 0 0 {name=p91262 lab=_73355_/X }
C {devices/lab_pin.sym} 91780 -19140 0 0 {name=p91263 lab=_85575_/Q }
C {devices/lab_pin.sym} 91780 -19100 0 0 {name=p91264 lab=_73284_/X }
C {devices/lab_pin.sym} 91780 -19060 0 0 {name=p91265 lab=_73426_/X }
C {devices/lab_pin.sym} 91940 -19120 0 1 {name=p91266 lab=_73427_/X }
C {sky130_stdcells/a211o_4.sym} 91860 -19120 0 0 {name=X_73427_ }
C {devices/lab_pin.sym} 91820 -18970 0 0 {name=p91267 lab=_49163_/A }
C {devices/lab_pin.sym} 91900 -18970 0 1 {name=p91268 lab=_53919_/B }
C {sky130_stdcells/buf_2.sym} 91860 -18970 0 0 {name=X_49163_ }
C {devices/lab_pin.sym} 91780 -18870 0 0 {name=p91269 lab=_46370_/Y }
C {devices/lab_pin.sym} 91780 -18830 0 0 {name=p91270 lab=_46346_/X }
C {devices/lab_pin.sym} 91780 -18790 0 0 {name=p91271 lab=_46374_/Y }
C {devices/lab_pin.sym} 91940 -18830 0 1 {name=p91272 lab=_46375_/Y }
C {sky130_stdcells/a21boi_4.sym} 91860 -18830 0 0 {name=X_46375_ }
C {devices/lab_pin.sym} 91800 -18720 0 0 {name=p91273 lab=_70585_/X }
C {devices/lab_pin.sym} 91800 -18680 0 0 {name=p91274 lab=_70639_/B }
C {devices/lab_pin.sym} 91800 -18640 0 0 {name=p91275 lab=_70620_/C }
C {devices/lab_pin.sym} 91800 -18600 0 0 {name=p91276 lab=_70638_/X }
C {devices/lab_pin.sym} 91920 -18660 0 1 {name=p91277 lab=_70639_/Y }
C {sky130_stdcells/nand4_4.sym} 91860 -18660 0 0 {name=X_70639_ }
C {devices/lab_pin.sym} 91820 -18510 0 0 {name=p91278 lab=clkbuf_8_179_0_CLK/X }
C {devices/lab_pin.sym} 91900 -18510 0 1 {name=p91279 lab=clkbuf_9_358_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 91860 -18510 0 0 {name=Xclkbuf_9_358_0_CLK }
C {devices/lab_pin.sym} 91800 -18400 0 0 {name=p91280 lab=_77202_/B }
C {devices/lab_pin.sym} 91800 -18360 0 0 {name=p91281 lab=_77202_/C }
C {devices/lab_pin.sym} 91920 -18380 0 1 {name=p91282 lab=_77198_/A }
C {sky130_stdcells/nand2_4.sym} 91860 -18380 0 0 {name=X_77195_ }
C {devices/lab_pin.sym} 91820 -18250 0 0 {name=p91283 lab=_43587_/A }
C {devices/lab_pin.sym} 91900 -18250 0 1 {name=p91284 lab=_43587_/Y }
C {sky130_stdcells/inv_2.sym} 91860 -18250 0 0 {name=X_43587_ }
C {devices/lab_pin.sym} 91780 -18160 0 0 {name=p91285 lab=_40798_/X }
C {devices/lab_pin.sym} 91780 -18120 0 0 {name=p91286 lab=_40793_/X }
C {devices/lab_pin.sym} 91780 -18080 0 0 {name=p91287 lab=_88333_/Q }
C {devices/lab_pin.sym} 91780 -18040 0 0 {name=p91288 lab=_40794_/X }
C {devices/lab_pin.sym} 91940 -18100 0 1 {name=p91289 lab=_88333_/D }
C {sky130_stdcells/a2bb2o_4.sym} 91860 -18100 0 0 {name=X_40799_ }
C {devices/lab_pin.sym} 91820 -17950 0 0 {name=p91290 lab=_83534_/Q }
C {devices/lab_pin.sym} 91900 -17950 0 1 {name=p91291 lab=_53593_/B }
C {sky130_stdcells/inv_2.sym} 91860 -17950 0 0 {name=X_48114_ }
C {devices/lab_pin.sym} 91820 -17830 0 0 {name=p91292 lab=_45252_/A }
C {devices/lab_pin.sym} 91900 -17830 0 1 {name=p91293 lab=_45326_/X }
C {sky130_stdcells/buf_2.sym} 91860 -17830 0 0 {name=X_45326_ }
C {devices/lab_pin.sym} 91800 -17740 0 0 {name=p91294 lab=_62151_/X }
C {devices/lab_pin.sym} 91800 -17700 0 0 {name=p91295 lab=_64182_/B }
C {devices/lab_pin.sym} 91800 -17660 0 0 {name=p91296 lab=_64095_/C }
C {devices/lab_pin.sym} 91800 -17620 0 0 {name=p91297 lab=_64182_/D }
C {devices/lab_pin.sym} 91920 -17680 0 1 {name=p91298 lab=_64160_/Y }
C {sky130_stdcells/nand4_4.sym} 91860 -17680 0 0 {name=X_64160_ }
C {devices/lab_pin.sym} 91800 -17540 0 0 {name=p91299 lab=_81729_/D }
C {devices/lab_pin.sym} 91800 -17500 0 0 {name=p91300 lab=_76146_/B }
C {devices/lab_pin.sym} 91920 -17520 0 1 {name=p91301 lab=_76149_/C }
C {sky130_stdcells/xnor2_4.sym} 91860 -17520 0 0 {name=X_76146_ }
C {devices/lab_pin.sym} 91820 -17390 0 0 {name=p91302 lab=_42556_/A }
C {devices/lab_pin.sym} 91900 -17390 0 1 {name=p91303 lab=_42538_/X }
C {sky130_stdcells/buf_2.sym} 91860 -17390 0 0 {name=X_42538_ }
C {devices/lab_pin.sym} 91820 -17270 0 0 {name=p91304 lab=_53886_/B }
C {devices/lab_pin.sym} 91900 -17270 0 1 {name=p91305 lab=_52367_/B }
C {sky130_stdcells/buf_2.sym} 91860 -17270 0 0 {name=X_49094_ }
C {devices/lab_pin.sym} 91780 -17170 0 0 {name=p91306 lab=_61370_/X }
C {devices/lab_pin.sym} 91780 -17130 0 0 {name=p91307 lab=_61349_/X }
C {devices/lab_pin.sym} 91780 -17090 0 0 {name=p91308 lab=_61371_/Y }
C {devices/lab_pin.sym} 91940 -17130 0 1 {name=p91309 lab=_84486_/D }
C {sky130_stdcells/a21oi_4.sym} 91860 -17130 0 0 {name=X_61372_ }
C {devices/lab_pin.sym} 91780 -17010 0 0 {name=p91310 lab=_73354_/X }
C {devices/lab_pin.sym} 91780 -16970 0 0 {name=p91311 lab=_73357_/X }
C {devices/lab_pin.sym} 91780 -16930 0 0 {name=p91312 lab=_73262_/X }
C {devices/lab_pin.sym} 91940 -16970 0 1 {name=p91313 lab=_73362_/A }
C {sky130_stdcells/a21o_4.sym} 91860 -16970 0 0 {name=X_73358_ }
C {devices/lab_pin.sym} 91780 -16870 0 0 {name=p91314 lab=_63106_/Y }
C {devices/lab_pin.sym} 91780 -16830 0 0 {name=p91315 lab=_63108_/X }
C {devices/lab_pin.sym} 91780 -16790 0 0 {name=p91316 lab=_63109_/X }
C {devices/lab_pin.sym} 91780 -16750 0 0 {name=p91317 lab=_63110_/X }
C {devices/lab_pin.sym} 91780 -16710 0 0 {name=p91318 lab=_63067_/X }
C {devices/lab_pin.sym} 91940 -16790 0 1 {name=p91319 lab=_63111_/Y }
C {sky130_stdcells/o41ai_4.sym} 91860 -16790 0 0 {name=X_63111_ }
C {devices/lab_pin.sym} 91780 -16650 0 0 {name=p91320 lab=_48043_/X }
C {devices/lab_pin.sym} 91780 -16610 0 0 {name=p91321 lab=_82349_/Q }
C {devices/lab_pin.sym} 91780 -16570 0 0 {name=p91322 lab=_48044_/Y }
C {devices/lab_pin.sym} 91940 -16610 0 1 {name=p91323 lab=_48046_/A }
C {sky130_stdcells/o21ai_4.sym} 91860 -16610 0 0 {name=X_48045_ }
C {devices/lab_pin.sym} 91820 -16470 0 0 {name=p91324 lab=_59756_/A }
C {devices/lab_pin.sym} 91900 -16470 0 1 {name=p91325 lab=_60323_/X }
C {sky130_stdcells/buf_2.sym} 91860 -16470 0 0 {name=X_60323_ }
C {devices/lab_pin.sym} 91780 -16370 0 0 {name=p91326 lab=_72258_/X }
C {devices/lab_pin.sym} 91780 -16330 0 0 {name=p91327 lab=_85682_/Q }
C {devices/lab_pin.sym} 91780 -16290 0 0 {name=p91328 lab=_72308_/X }
C {devices/lab_pin.sym} 91940 -16330 0 1 {name=p91329 lab=_72309_/X }
C {sky130_stdcells/o21a_4.sym} 91860 -16330 0 0 {name=X_72309_ }
C {devices/lab_pin.sym} 91820 -16190 0 0 {name=p91330 lab=_45257_/A }
C {devices/lab_pin.sym} 91900 -16190 0 1 {name=p91331 lab=_45257_/Y }
C {sky130_stdcells/inv_2.sym} 91860 -16190 0 0 {name=X_45257_ }
C {devices/lab_pin.sym} 91800 -16100 0 0 {name=p91332 lab=_64467_/C }
C {devices/lab_pin.sym} 91800 -16060 0 0 {name=p91333 lab=_64091_/B }
C {devices/lab_pin.sym} 91800 -16020 0 0 {name=p91334 lab=_64091_/C }
C {devices/lab_pin.sym} 91800 -15980 0 0 {name=p91335 lab=_64091_/D }
C {devices/lab_pin.sym} 91920 -16040 0 1 {name=p91336 lab=_64094_/B }
C {sky130_stdcells/nand4_4.sym} 91860 -16040 0 0 {name=X_64091_ }
C {devices/lab_pin.sym} 91800 -15900 0 0 {name=p91337 lab=_76067_/Y }
C {devices/lab_pin.sym} 91800 -15860 0 0 {name=p91338 lab=_76076_/X }
C {devices/lab_pin.sym} 91920 -15880 0 1 {name=p91339 lab=_76077_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -15880 0 0 {name=X_76077_ }
C {devices/lab_pin.sym} 91820 -15750 0 0 {name=p91340 lab=_42468_/Y }
C {devices/lab_pin.sym} 91900 -15750 0 1 {name=p91341 lab=_87855_/D }
C {sky130_stdcells/inv_2.sym} 91860 -15750 0 0 {name=X_42469_ }
C {devices/lab_pin.sym} 91780 -15660 0 0 {name=p91342 lab=_73214_/X }
C {devices/lab_pin.sym} 91780 -15620 0 0 {name=p91343 lab=_83061_/Q }
C {devices/lab_pin.sym} 91780 -15580 0 0 {name=p91344 lab=_73238_/X }
C {devices/lab_pin.sym} 91780 -15540 0 0 {name=p91345 lab=_73288_/X }
C {devices/lab_pin.sym} 91940 -15600 0 1 {name=p91346 lab=_73290_/B }
C {sky130_stdcells/a211o_4.sym} 91860 -15600 0 0 {name=X_73289_ }
C {devices/lab_pin.sym} 91800 -15470 0 0 {name=p91347 lab=_44204_/Y }
C {devices/lab_pin.sym} 91800 -15430 0 0 {name=p91348 lab=_44067_/B }
C {devices/lab_pin.sym} 91800 -15390 0 0 {name=p91349 lab=_58547_/A }
C {devices/lab_pin.sym} 91920 -15430 0 1 {name=p91350 lab=_44208_/X }
C {sky130_stdcells/and3_4.sym} 91860 -15430 0 0 {name=X_44208_ }
C {devices/lab_pin.sym} 91800 -15300 0 0 {name=p91351 lab=_80955_/Q }
C {devices/lab_pin.sym} 91800 -15260 0 0 {name=p91352 lab=_75028_/B }
C {devices/lab_pin.sym} 91920 -15280 0 1 {name=p91353 lab=_75028_/X }
C {sky130_stdcells/xor2_4.sym} 91860 -15280 0 0 {name=X_75028_ }
C {devices/lab_pin.sym} 91800 -15160 0 0 {name=p91354 lab=_79903_/Y }
C {devices/lab_pin.sym} 91800 -15120 0 0 {name=p91355 lab=_79911_/A }
C {devices/lab_pin.sym} 91920 -15140 0 1 {name=p91356 lab=_79909_/A }
C {sky130_stdcells/nand2_4.sym} 91860 -15140 0 0 {name=X_79905_ }
C {devices/lab_pin.sym} 91780 -15050 0 0 {name=p91357 lab=_63036_/Y }
C {devices/lab_pin.sym} 91780 -15010 0 0 {name=p91358 lab=_63038_/X }
C {devices/lab_pin.sym} 91780 -14970 0 0 {name=p91359 lab=_63039_/X }
C {devices/lab_pin.sym} 91780 -14930 0 0 {name=p91360 lab=_63041_/X }
C {devices/lab_pin.sym} 91780 -14890 0 0 {name=p91361 lab=_63020_/X }
C {devices/lab_pin.sym} 91940 -14970 0 1 {name=p91362 lab=_63042_/Y }
C {sky130_stdcells/o41ai_4.sym} 91860 -14970 0 0 {name=X_63042_ }
C {devices/lab_pin.sym} 91800 -14820 0 0 {name=p91363 lab=_60159_/A }
C {devices/lab_pin.sym} 91800 -14780 0 0 {name=p91364 lab=_60254_/B }
C {devices/lab_pin.sym} 91920 -14800 0 1 {name=p91365 lab=_60255_/A }
C {sky130_stdcells/nor2_4.sym} 91860 -14800 0 0 {name=X_60254_ }
C {devices/lab_pin.sym} 91780 -14690 0 0 {name=p91366 lab=_56243_/C }
C {devices/lab_pin.sym} 91780 -14650 0 0 {name=p91367 lab=_45147_/X }
C {devices/lab_pin.sym} 91780 -14610 0 0 {name=p91368 lab=_45187_/X }
C {devices/lab_pin.sym} 91940 -14650 0 1 {name=p91369 lab=_45188_/Y }
C {sky130_stdcells/o21ai_4.sym} 91860 -14650 0 0 {name=X_45188_ }
C {devices/lab_pin.sym} 91820 -14510 0 0 {name=p91370 lab=_44024_/A }
C {devices/lab_pin.sym} 91900 -14510 0 1 {name=p91371 lab=_44139_/X }
C {sky130_stdcells/buf_2.sym} 91860 -14510 0 0 {name=X_44139_ }
C {devices/lab_pin.sym} 91780 -14410 0 0 {name=p91372 lab=_67847_/X }
C {devices/lab_pin.sym} 91780 -14370 0 0 {name=p91373 lab=_67849_/X }
C {devices/lab_pin.sym} 91780 -14330 0 0 {name=p91374 lab=_67709_/X }
C {devices/lab_pin.sym} 91940 -14370 0 1 {name=p91375 lab=_67850_/Y }
C {sky130_stdcells/a21oi_4.sym} 91860 -14370 0 0 {name=X_67850_ }
C {devices/lab_pin.sym} 91820 -14230 0 0 {name=p91376 lab=clkbuf_9_402_0_CLK/X }
C {devices/lab_pin.sym} 91900 -14230 0 1 {name=p91377 lab=_82498_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 91860 -14230 0 0 {name=Xclkbuf_10_805_0_CLK }
C {devices/lab_pin.sym} 91800 -14120 0 0 {name=p91378 lab=_79836_/A }
C {devices/lab_pin.sym} 91800 -14080 0 0 {name=p91379 lab=_72165_/A }
C {devices/lab_pin.sym} 91920 -14100 0 1 {name=p91380 lab=_79836_/X }
C {sky130_stdcells/xor2_4.sym} 91860 -14100 0 0 {name=X_79836_ }
C {devices/lab_pin.sym} 91800 -14000 0 0 {name=p91381 lab=_59613_/Y }
C {devices/lab_pin.sym} 91800 -13960 0 0 {name=p91382 lab=_60172_/A }
C {devices/lab_pin.sym} 91800 -13920 0 0 {name=p91383 lab=_60182_/Y }
C {devices/lab_pin.sym} 91800 -13880 0 0 {name=p91384 lab=_61278_/B }
C {devices/lab_pin.sym} 91920 -13940 0 1 {name=p91385 lab=_60185_/X }
C {sky130_stdcells/and4_4.sym} 91860 -13940 0 0 {name=X_60185_ }
C {devices/lab_pin.sym} 91780 -13810 0 0 {name=p91386 lab=_49993_/Y }
C {devices/lab_pin.sym} 91780 -13770 0 0 {name=p91387 lab=_49977_/X }
C {devices/lab_pin.sym} 91780 -13730 0 0 {name=p91388 lab=_49995_/X }
C {devices/lab_pin.sym} 91940 -13770 0 1 {name=p91389 lab=_86285_/D }
C {sky130_stdcells/a21oi_4.sym} 91860 -13770 0 0 {name=X_49996_ }
C {devices/lab_pin.sym} 91820 -13630 0 0 {name=p91390 lab=_57866_/A }
C {devices/lab_pin.sym} 91900 -13630 0 1 {name=p91391 lab=_66801_/X }
C {sky130_stdcells/buf_2.sym} 91860 -13630 0 0 {name=X_66801_ }
C {devices/lab_pin.sym} 91800 -13520 0 0 {name=p91392 lab=_48947_/A }
C {devices/lab_pin.sym} 91800 -13480 0 0 {name=p91393 lab=_48976_/A }
C {devices/lab_pin.sym} 91920 -13500 0 1 {name=p91394 lab=_48947_/Y }
C {sky130_stdcells/nor2_4.sym} 91860 -13500 0 0 {name=X_48947_ }
C {devices/lab_pin.sym} 91800 -13380 0 0 {name=p91395 lab=_79745_/A }
C {devices/lab_pin.sym} 91800 -13340 0 0 {name=p91396 lab=_79767_/B }
C {devices/lab_pin.sym} 91920 -13360 0 1 {name=p91397 lab=_79767_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -13360 0 0 {name=X_79767_ }
C {devices/lab_pin.sym} 91780 -13250 0 0 {name=p91398 lab=_84055_/Q }
C {devices/lab_pin.sym} 91780 -13210 0 0 {name=p91399 lab=_67688_/X }
C {devices/lab_pin.sym} 91780 -13170 0 0 {name=p91400 lab=_67780_/X }
C {devices/lab_pin.sym} 91940 -13210 0 1 {name=p91401 lab=_84055_/D }
C {sky130_stdcells/a21bo_4.sym} 91860 -13210 0 0 {name=X_67781_ }
C {devices/lab_pin.sym} 91780 -13100 0 0 {name=p91402 lab=_64934_/X }
C {devices/lab_pin.sym} 91780 -13060 0 0 {name=p91403 lab=_83299_/Q }
C {devices/lab_pin.sym} 91780 -13020 0 0 {name=p91404 lab=_64991_/X }
C {devices/lab_pin.sym} 91780 -12980 0 0 {name=p91405 lab=_64992_/X }
C {devices/lab_pin.sym} 91940 -13040 0 1 {name=p91406 lab=_64993_/X }
C {sky130_stdcells/a211o_4.sym} 91860 -13040 0 0 {name=X_64993_ }
C {devices/lab_pin.sym} 91800 -12900 0 0 {name=p91407 lab=_84531_/Q }
C {devices/lab_pin.sym} 91800 -12860 0 0 {name=p91408 lab=_62541_/C }
C {devices/lab_pin.sym} 91920 -12880 0 1 {name=p91409 lab=_76979_/X }
C {sky130_stdcells/xor2_4.sym} 91860 -12880 0 0 {name=X_76979_ }
C {devices/lab_pin.sym} 91820 -12750 0 0 {name=p91410 lab=_68300_/X }
C {devices/lab_pin.sym} 91900 -12750 0 1 {name=p91411 lab=_69520_/X }
C {sky130_stdcells/buf_2.sym} 91860 -12750 0 0 {name=X_69520_ }
C {devices/lab_pin.sym} 91800 -12650 0 0 {name=p91412 lab=_78713_/X }
C {devices/lab_pin.sym} 91800 -12610 0 0 {name=p91413 lab=_78716_/Y }
C {devices/lab_pin.sym} 91800 -12570 0 0 {name=p91414 lab=_78718_/C }
C {devices/lab_pin.sym} 91920 -12610 0 1 {name=p91415 lab=_78718_/Y }
C {sky130_stdcells/nand3_4.sym} 91860 -12610 0 0 {name=X_78718_ }
C {devices/lab_pin.sym} 91780 -12490 0 0 {name=p91416 lab=_80923_/D }
C {devices/lab_pin.sym} 91780 -12450 0 0 {name=p91417 lab=_66614_/X }
C {devices/lab_pin.sym} 91780 -12410 0 0 {name=p91418 lab=_66731_/X }
C {devices/lab_pin.sym} 91940 -12450 0 1 {name=p91419 lab=_66732_/X }
C {sky130_stdcells/a21bo_4.sym} 91860 -12450 0 0 {name=X_66732_ }
C {devices/lab_pin.sym} 91800 -12330 0 0 {name=p91420 lab=_63960_/A }
C {devices/lab_pin.sym} 91800 -12290 0 0 {name=p91421 lab=_63960_/B }
C {devices/lab_pin.sym} 91800 -12250 0 0 {name=p91422 lab=_63944_/C }
C {devices/lab_pin.sym} 91920 -12290 0 1 {name=p91423 lab=_63944_/Y }
C {sky130_stdcells/nor3_4.sym} 91860 -12290 0 0 {name=X_63944_ }
C {devices/lab_pin.sym} 91800 -12160 0 0 {name=p91424 lab=_48695_/A }
C {devices/lab_pin.sym} 91800 -12120 0 0 {name=p91425 lab=_48878_/B }
C {devices/lab_pin.sym} 91920 -12140 0 1 {name=p91426 lab=_48878_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -12140 0 0 {name=X_48878_ }
C {devices/lab_pin.sym} 91780 -12030 0 0 {name=p91427 lab=_79692_/A }
C {devices/lab_pin.sym} 91780 -11990 0 0 {name=p91428 lab=_79692_/B }
C {devices/lab_pin.sym} 91780 -11950 0 0 {name=p91429 lab=_79697_/Y }
C {devices/lab_pin.sym} 91940 -11990 0 1 {name=p91430 lab=_79702_/A }
C {sky130_stdcells/a21boi_4.sym} 91860 -11990 0 0 {name=X_79698_ }
C {devices/lab_pin.sym} 91780 -11870 0 0 {name=p91431 lab=_83923_/Q }
C {devices/lab_pin.sym} 91780 -11830 0 0 {name=p91432 lab=_69439_/X }
C {devices/lab_pin.sym} 91780 -11790 0 0 {name=p91433 lab=_69450_/X }
C {devices/lab_pin.sym} 91940 -11830 0 1 {name=p91434 lab=_83923_/D }
C {sky130_stdcells/a21bo_4.sym} 91860 -11830 0 0 {name=X_69451_ }
C {devices/lab_pin.sym} 91820 -11690 0 0 {name=p91435 lab=_47829_/A }
C {devices/lab_pin.sym} 91900 -11690 0 1 {name=p91436 lab=_57491_/C }
C {sky130_stdcells/buf_2.sym} 91860 -11690 0 0 {name=X_47829_ }
C {devices/lab_pin.sym} 91780 -11600 0 0 {name=p91437 lab=_87951_/Q }
C {devices/lab_pin.sym} 91780 -11560 0 0 {name=p91438 lab=_66639_/X }
C {devices/lab_pin.sym} 91780 -11520 0 0 {name=p91439 lab=_66531_/X }
C {devices/lab_pin.sym} 91780 -11480 0 0 {name=p91440 lab=_66662_/X }
C {devices/lab_pin.sym} 91940 -11540 0 1 {name=p91441 lab=_66663_/X }
C {sky130_stdcells/a211o_4.sym} 91860 -11540 0 0 {name=X_66663_ }
C {devices/lab_pin.sym} 91800 -11410 0 0 {name=p91442 lab=_78645_/Y }
C {devices/lab_pin.sym} 91800 -11370 0 0 {name=p91443 lab=_78649_/B }
C {devices/lab_pin.sym} 91800 -11330 0 0 {name=p91444 lab=_78648_/Y }
C {devices/lab_pin.sym} 91920 -11370 0 1 {name=p91445 lab=_78654_/A }
C {sky130_stdcells/or3_4.sym} 91860 -11370 0 0 {name=X_78649_ }
C {devices/lab_pin.sym} 91820 -11230 0 0 {name=p91446 lab=_64032_/A }
C {devices/lab_pin.sym} 91900 -11230 0 1 {name=p91447 lab=_63876_/B }
C {sky130_stdcells/buf_2.sym} 91860 -11230 0 0 {name=X_63875_ }
C {devices/lab_pin.sym} 91820 -11110 0 0 {name=p91448 lab=_68402_/A }
C {devices/lab_pin.sym} 91900 -11110 0 1 {name=p91449 lab=_68402_/X }
C {sky130_stdcells/buf_2.sym} 91860 -11110 0 0 {name=X_68402_ }
C {devices/lab_pin.sym} 91820 -10990 0 0 {name=p91450 lab=_65614_/A }
C {devices/lab_pin.sym} 91900 -10990 0 1 {name=p91451 lab=_65614_/X }
C {sky130_stdcells/buf_2.sym} 91860 -10990 0 0 {name=X_65614_ }
C {devices/lab_pin.sym} 91800 -10890 0 0 {name=p91452 lab=_52533_/A }
C {devices/lab_pin.sym} 91800 -10850 0 0 {name=p91453 lab=_50825_/B }
C {devices/lab_pin.sym} 91800 -10810 0 0 {name=p91454 lab=_50830_/C }
C {devices/lab_pin.sym} 91920 -10850 0 1 {name=p91455 lab=_50840_/X }
C {sky130_stdcells/and3_4.sym} 91860 -10850 0 0 {name=X_50840_ }
C {devices/lab_pin.sym} 91780 -10730 0 0 {name=p91456 lab=_62824_/X }
C {devices/lab_pin.sym} 91780 -10690 0 0 {name=p91457 lab=_62779_/X }
C {devices/lab_pin.sym} 91780 -10650 0 0 {name=p91458 lab=_62825_/Y }
C {devices/lab_pin.sym} 91940 -10690 0 1 {name=p91459 lab=_84379_/D }
C {sky130_stdcells/a21oi_4.sym} 91860 -10690 0 0 {name=X_62826_ }
C {devices/lab_pin.sym} 91770 -10550 0 0 {name=p91460 lab=_81660_/CLK }
C {devices/lab_pin.sym} 91770 -10530 0 0 {name=p91461 lab=_81692_/Q }
C {devices/lab_pin.sym} 91950 -10550 0 1 {name=p91462 lab=_81660_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -10540 0 0 {name=X_81660_ }
C {devices/lab_pin.sym} 91780 -10440 0 0 {name=p91463 lab=_88033_/Q }
C {devices/lab_pin.sym} 91780 -10400 0 0 {name=p91464 lab=_69368_/X }
C {devices/lab_pin.sym} 91780 -10360 0 0 {name=p91465 lab=_69232_/X }
C {devices/lab_pin.sym} 91780 -10320 0 0 {name=p91466 lab=_69381_/X }
C {devices/lab_pin.sym} 91940 -10380 0 1 {name=p91467 lab=_69382_/X }
C {sky130_stdcells/a211o_4.sym} 91860 -10380 0 0 {name=X_69382_ }
C {devices/lab_pin.sym} 91820 -10230 0 0 {name=p91468 lab=_69183_/A }
C {devices/lab_pin.sym} 91900 -10230 0 1 {name=p91469 lab=_66594_/X }
C {sky130_stdcells/buf_2.sym} 91860 -10230 0 0 {name=X_66594_ }
C {devices/lab_pin.sym} 91800 -10120 0 0 {name=p91470 lab=_84775_/Q }
C {devices/lab_pin.sym} 91800 -10080 0 0 {name=p91471 lab=_84167_/Q }
C {devices/lab_pin.sym} 91920 -10100 0 1 {name=p91472 lab=_80611_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -10100 0 0 {name=X_80611_ }
C {devices/lab_pin.sym} 91780 -10000 0 0 {name=p91473 lab=_68301_/X }
C {devices/lab_pin.sym} 91780 -9960 0 0 {name=p91474 lab=_68027_/Y }
C {devices/lab_pin.sym} 91780 -9920 0 0 {name=p91475 lab=_68326_/X }
C {devices/lab_pin.sym} 91780 -9880 0 0 {name=p91476 lab=_68332_/Y }
C {devices/lab_pin.sym} 91940 -9940 0 1 {name=p91477 lab=_68333_/X }
C {sky130_stdcells/a211o_4.sym} 91860 -9940 0 0 {name=X_68333_ }
C {devices/lab_pin.sym} 91780 -9810 0 0 {name=p91478 lab=_65533_/X }
C {devices/lab_pin.sym} 91780 -9770 0 0 {name=p91479 lab=_65543_/Y }
C {devices/lab_pin.sym} 91780 -9730 0 0 {name=p91480 lab=_65544_/Y }
C {devices/lab_pin.sym} 91940 -9770 0 1 {name=p91481 lab=_65545_/Y }
C {sky130_stdcells/o21ai_4.sym} 91860 -9770 0 0 {name=X_65545_ }
C {devices/lab_pin.sym} 91800 -9640 0 0 {name=p91482 lab=_50771_/A }
C {devices/lab_pin.sym} 91800 -9600 0 0 {name=p91483 lab=_46356_/X }
C {devices/lab_pin.sym} 91920 -9620 0 1 {name=p91484 lab=_50771_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -9620 0 0 {name=X_50771_ }
C {devices/lab_pin.sym} 91800 -9510 0 0 {name=p91485 lab=_62766_/A }
C {devices/lab_pin.sym} 91800 -9470 0 0 {name=p91486 lab=_62766_/B }
C {devices/lab_pin.sym} 91800 -9430 0 0 {name=p91487 lab=_75915_/B }
C {devices/lab_pin.sym} 91920 -9470 0 1 {name=p91488 lab=_62757_/Y }
C {sky130_stdcells/nor3_4.sym} 91860 -9470 0 0 {name=X_62757_ }
C {devices/lab_pin.sym} 91770 -9330 0 0 {name=p91489 lab=_81482_/CLK }
C {devices/lab_pin.sym} 91770 -9310 0 0 {name=p91490 lab=_84191_/Q }
C {devices/lab_pin.sym} 91950 -9330 0 1 {name=p91491 lab=_76845_/A }
C {sky130_stdcells/dfxtp_4.sym} 91860 -9320 0 0 {name=X_81591_ }
C {devices/lab_pin.sym} 91780 -9210 0 0 {name=p91492 lab=_52507_/Y }
C {devices/lab_pin.sym} 91780 -9170 0 0 {name=p91493 lab=_52496_/X }
C {devices/lab_pin.sym} 91780 -9130 0 0 {name=p91494 lab=_52509_/X }
C {devices/lab_pin.sym} 91940 -9170 0 1 {name=p91495 lab=_85808_/D }
C {sky130_stdcells/a21oi_4.sym} 91860 -9170 0 0 {name=X_52510_ }
C {devices/lab_pin.sym} 91770 -9030 0 0 {name=p91496 lab=_83753_/CLK }
C {devices/lab_pin.sym} 91770 -9010 0 0 {name=p91497 lab=_71915_/X }
C {devices/lab_pin.sym} 91950 -9030 0 1 {name=p91498 lab=_83330_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -9020 0 0 {name=X_83330_ }
C {devices/lab_pin.sym} 91820 -8890 0 0 {name=p91499 lab=_59664_/C }
C {devices/lab_pin.sym} 91900 -8890 0 1 {name=p91500 lab=_61708_/X }
C {sky130_stdcells/buf_2.sym} 91860 -8890 0 0 {name=X_61708_ }
C {devices/lab_pin.sym} 91800 -8780 0 0 {name=p91501 lab=_80542_/A }
C {devices/lab_pin.sym} 91800 -8740 0 0 {name=p91502 lab=_80527_/Y }
C {devices/lab_pin.sym} 91920 -8760 0 1 {name=p91503 lab=_80542_/X }
C {sky130_stdcells/or2_4.sym} 91860 -8760 0 0 {name=X_80542_ }
C {devices/lab_pin.sym} 91780 -8650 0 0 {name=p91504 lab=_67631_/X }
C {devices/lab_pin.sym} 91780 -8610 0 0 {name=p91505 lab=_67635_/X }
C {devices/lab_pin.sym} 91780 -8570 0 0 {name=p91506 lab=_68260_/X }
C {devices/lab_pin.sym} 91940 -8610 0 1 {name=p91507 lab=_68264_/Y }
C {sky130_stdcells/a21oi_4.sym} 91860 -8610 0 0 {name=X_68264_ }
C {devices/lab_pin.sym} 91780 -8500 0 0 {name=p91508 lab=_65428_/X }
C {devices/lab_pin.sym} 91780 -8460 0 0 {name=p91509 lab=_83078_/Q }
C {devices/lab_pin.sym} 91780 -8420 0 0 {name=p91510 lab=_65407_/X }
C {devices/lab_pin.sym} 91780 -8380 0 0 {name=p91511 lab=_65475_/X }
C {devices/lab_pin.sym} 91940 -8440 0 1 {name=p91512 lab=_65477_/B }
C {sky130_stdcells/a211o_4.sym} 91860 -8440 0 0 {name=X_65476_ }
C {devices/lab_pin.sym} 91800 -8300 0 0 {name=p91513 lab=_53468_/A }
C {devices/lab_pin.sym} 91800 -8260 0 0 {name=p91514 lab=_57523_/B }
C {devices/lab_pin.sym} 91920 -8280 0 1 {name=p91515 lab=_53490_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -8280 0 0 {name=X_53490_ }
C {devices/lab_pin.sym} 91780 -8170 0 0 {name=p91516 lab=_62686_/X }
C {devices/lab_pin.sym} 91780 -8130 0 0 {name=p91517 lab=_62652_/X }
C {devices/lab_pin.sym} 91780 -8090 0 0 {name=p91518 lab=_62687_/Y }
C {devices/lab_pin.sym} 91940 -8130 0 1 {name=p91519 lab=_62688_/Y }
C {sky130_stdcells/a21oi_4.sym} 91860 -8130 0 0 {name=X_62688_ }
C {devices/lab_pin.sym} 91800 -8000 0 0 {name=p91520 lab=_67241_/A }
C {devices/lab_pin.sym} 91800 -7960 0 0 {name=p91521 lab=_67215_/B }
C {devices/lab_pin.sym} 91920 -7980 0 1 {name=p91522 lab=_67215_/X }
C {sky130_stdcells/and2_4.sym} 91860 -7980 0 0 {name=X_67215_ }
C {devices/lab_pin.sym} 91780 -7870 0 0 {name=p91523 lab=_85822_/Q }
C {devices/lab_pin.sym} 91780 -7830 0 0 {name=p91524 lab=_52438_/X }
C {devices/lab_pin.sym} 91780 -7790 0 0 {name=p91525 lab=_52440_/Y }
C {devices/lab_pin.sym} 91940 -7830 0 1 {name=p91526 lab=_52441_/Y }
C {sky130_stdcells/o21ai_4.sym} 91860 -7830 0 0 {name=X_52441_ }
C {devices/lab_pin.sym} 91780 -7710 0 0 {name=p91527 lab=_64418_/Y }
C {devices/lab_pin.sym} 91780 -7670 0 0 {name=p91528 lab=_64426_/X }
C {devices/lab_pin.sym} 91780 -7630 0 0 {name=p91529 lab=_64386_/X }
C {devices/lab_pin.sym} 91940 -7670 0 1 {name=p91530 lab=_64427_/X }
C {sky130_stdcells/o21a_4.sym} 91860 -7670 0 0 {name=X_64427_ }
C {devices/lab_pin.sym} 91770 -7530 0 0 {name=p91531 lab=_81227_/CLK }
C {devices/lab_pin.sym} 91770 -7510 0 0 {name=p91532 lab=_83261_/D }
C {devices/lab_pin.sym} 91950 -7530 0 1 {name=p91533 lab=_72357_/A }
C {sky130_stdcells/dfxtp_4.sym} 91860 -7520 0 0 {name=X_83261_ }
C {devices/lab_pin.sym} 91820 -7390 0 0 {name=p91534 lab=_61342_/X }
C {devices/lab_pin.sym} 91900 -7390 0 1 {name=p91535 lab=_61639_/X }
C {sky130_stdcells/buf_2.sym} 91860 -7390 0 0 {name=X_61639_ }
C {devices/lab_pin.sym} 91780 -7290 0 0 {name=p91536 lab=_59182_/Y }
C {devices/lab_pin.sym} 91780 -7250 0 0 {name=p91537 lab=_66138_/Y }
C {devices/lab_pin.sym} 91780 -7210 0 0 {name=p91538 lab=_80472_/Y }
C {devices/lab_pin.sym} 91940 -7250 0 1 {name=p91539 lab=_80489_/A }
C {sky130_stdcells/o21a_4.sym} 91860 -7250 0 0 {name=X_80473_ }
C {devices/lab_pin.sym} 91780 -7130 0 0 {name=p91540 lab=_82055_/D }
C {devices/lab_pin.sym} 91780 -7090 0 0 {name=p91541 lab=_68180_/X }
C {devices/lab_pin.sym} 91780 -7050 0 0 {name=p91542 lab=_68194_/X }
C {devices/lab_pin.sym} 91940 -7090 0 1 {name=p91543 lab=_68195_/X }
C {sky130_stdcells/a21bo_4.sym} 91860 -7090 0 0 {name=X_68195_ }
C {devices/lab_pin.sym} 91770 -6950 0 0 {name=p91544 lab=_83335_/CLK }
C {devices/lab_pin.sym} 91770 -6930 0 0 {name=p91545 lab=_85000_/D }
C {devices/lab_pin.sym} 91950 -6950 0 1 {name=p91546 lab=_55248_/B }
C {sky130_stdcells/dfxtp_4.sym} 91860 -6940 0 0 {name=X_85000_ }
C {devices/lab_pin.sym} 91770 -6810 0 0 {name=p91547 lab=_81834_/CLK }
C {devices/lab_pin.sym} 91770 -6790 0 0 {name=p91548 lab=_82244_/Q }
C {devices/lab_pin.sym} 91950 -6810 0 1 {name=p91549 lab=_77254_/A }
C {sky130_stdcells/dfxtp_4.sym} 91860 -6800 0 0 {name=X_82212_ }
C {devices/lab_pin.sym} 91780 -6700 0 0 {name=p91550 lab=_82986_/Q }
C {devices/lab_pin.sym} 91780 -6660 0 0 {name=p91551 lab=_55157_/X }
C {devices/lab_pin.sym} 91780 -6620 0 0 {name=p91552 lab=_55172_/A }
C {devices/lab_pin.sym} 91780 -6580 0 0 {name=p91553 lab=_55159_/X }
C {devices/lab_pin.sym} 91940 -6640 0 1 {name=p91554 lab=_55160_/X }
C {sky130_stdcells/a211o_4.sym} 91860 -6640 0 0 {name=X_55160_ }
C {devices/lab_pin.sym} 91780 -6520 0 0 {name=p91555 lab=_87355_/Q }
C {devices/lab_pin.sym} 91780 -6480 0 0 {name=p91556 lab=_67121_/X }
C {devices/lab_pin.sym} 91780 -6440 0 0 {name=p91557 lab=_67122_/X }
C {devices/lab_pin.sym} 91780 -6400 0 0 {name=p91558 lab=_67145_/X }
C {devices/lab_pin.sym} 91940 -6460 0 1 {name=p91559 lab=_67146_/X }
C {sky130_stdcells/a211o_4.sym} 91860 -6460 0 0 {name=X_67146_ }
C {devices/lab_pin.sym} 91820 -6310 0 0 {name=p91560 lab=_52324_/A }
C {devices/lab_pin.sym} 91900 -6310 0 1 {name=p91561 lab=_52372_/X }
C {sky130_stdcells/buf_2.sym} 91860 -6310 0 0 {name=X_52372_ }
C {devices/lab_pin.sym} 91780 -6210 0 0 {name=p91562 lab=_64351_/Y }
C {devices/lab_pin.sym} 91780 -6170 0 0 {name=p91563 lab=_64357_/X }
C {devices/lab_pin.sym} 91780 -6130 0 0 {name=p91564 lab=_64328_/X }
C {devices/lab_pin.sym} 91940 -6170 0 1 {name=p91565 lab=_64358_/X }
C {sky130_stdcells/o21a_4.sym} 91860 -6170 0 0 {name=X_64358_ }
C {devices/lab_pin.sym} 91770 -6030 0 0 {name=p91566 lab=_83191_/CLK }
C {devices/lab_pin.sym} 91770 -6010 0 0 {name=p91567 lab=_72680_/X }
C {devices/lab_pin.sym} 91950 -6030 0 1 {name=p91568 lab=_70221_/C }
C {sky130_stdcells/dfxtp_4.sym} 91860 -6020 0 0 {name=X_83192_ }
C {devices/lab_pin.sym} 91800 -5920 0 0 {name=p91569 lab=_54123_/A }
C {devices/lab_pin.sym} 91800 -5880 0 0 {name=p91570 lab=_54123_/B }
C {devices/lab_pin.sym} 91800 -5840 0 0 {name=p91571 lab=_54111_/C }
C {devices/lab_pin.sym} 91800 -5800 0 0 {name=p91572 lab=_52942_/D }
C {devices/lab_pin.sym} 91920 -5860 0 1 {name=p91573 lab=_54111_/X }
C {sky130_stdcells/and4_4.sym} 91860 -5860 0 0 {name=X_54111_ }
C {devices/lab_pin.sym} 91780 -5730 0 0 {name=p91574 lab=_51321_/Y }
C {devices/lab_pin.sym} 91780 -5690 0 0 {name=p91575 lab=_51313_/X }
C {devices/lab_pin.sym} 91780 -5650 0 0 {name=p91576 lab=_51322_/X }
C {devices/lab_pin.sym} 91940 -5690 0 1 {name=p91577 lab=_86032_/D }
C {sky130_stdcells/a21oi_4.sym} 91860 -5690 0 0 {name=X_51323_ }
C {devices/lab_pin.sym} 91820 -5550 0 0 {name=p91578 lab=_79211_/B }
C {devices/lab_pin.sym} 91900 -5550 0 1 {name=p91579 lab=_79212_/A }
C {sky130_stdcells/inv_2.sym} 91860 -5550 0 0 {name=X_63309_ }
C {devices/lab_pin.sym} 91770 -5430 0 0 {name=p91580 lab=_82575_/CLK }
C {devices/lab_pin.sym} 91770 -5410 0 0 {name=p91581 lab=_78007_/Y }
C {devices/lab_pin.sym} 91950 -5430 0 1 {name=p91582 lab=_77471_/B }
C {sky130_stdcells/dfxtp_4.sym} 91860 -5420 0 0 {name=X_82143_ }
C {devices/lab_pin.sym} 91800 -5320 0 0 {name=p91583 lab=_55083_/A }
C {devices/lab_pin.sym} 91800 -5280 0 0 {name=p91584 lab=_55104_/B }
C {devices/lab_pin.sym} 91800 -5240 0 0 {name=p91585 lab=_55083_/C }
C {devices/lab_pin.sym} 91800 -5200 0 0 {name=p91586 lab=_47768_/A }
C {devices/lab_pin.sym} 91920 -5260 0 1 {name=p91587 lab=_55091_/X }
C {sky130_stdcells/and4_4.sym} 91860 -5260 0 0 {name=X_55091_ }
C {devices/lab_pin.sym} 91780 -5140 0 0 {name=p91588 lab=_88382_/Q }
C {devices/lab_pin.sym} 91780 -5100 0 0 {name=p91589 lab=_67074_/X }
C {devices/lab_pin.sym} 91780 -5060 0 0 {name=p91590 lab=_67075_/X }
C {devices/lab_pin.sym} 91780 -5020 0 0 {name=p91591 lab=_67076_/X }
C {devices/lab_pin.sym} 91940 -5080 0 1 {name=p91592 lab=_67078_/B }
C {sky130_stdcells/a211o_4.sym} 91860 -5080 0 0 {name=X_67077_ }
C {devices/lab_pin.sym} 91780 -4970 0 0 {name=p91593 lab=_64283_/X }
C {devices/lab_pin.sym} 91780 -4930 0 0 {name=p91594 lab=_64284_/X }
C {devices/lab_pin.sym} 91780 -4890 0 0 {name=p91595 lab=_64286_/X }
C {devices/lab_pin.sym} 91780 -4850 0 0 {name=p91596 lab=_64288_/Y }
C {devices/lab_pin.sym} 91780 -4810 0 0 {name=p91597 lab=_64267_/X }
C {devices/lab_pin.sym} 91940 -4890 0 1 {name=p91598 lab=_64289_/X }
C {sky130_stdcells/o41a_4.sym} 91860 -4890 0 0 {name=X_64289_ }
C {devices/lab_pin.sym} 91780 -4750 0 0 {name=p91599 lab=_85517_/Q }
C {devices/lab_pin.sym} 91780 -4710 0 0 {name=p91600 lab=_54035_/X }
C {devices/lab_pin.sym} 91780 -4670 0 0 {name=p91601 lab=_54041_/Y }
C {devices/lab_pin.sym} 91940 -4710 0 1 {name=p91602 lab=_54042_/Y }
C {sky130_stdcells/o21ai_4.sym} 91860 -4710 0 0 {name=X_54042_ }
C {devices/lab_pin.sym} 91800 -4580 0 0 {name=p91603 lab=_65980_/X }
C {devices/lab_pin.sym} 91800 -4540 0 0 {name=p91604 lab=_66028_/B }
C {devices/lab_pin.sym} 91920 -4560 0 1 {name=p91605 lab=_66028_/X }
C {sky130_stdcells/and2_4.sym} 91860 -4560 0 0 {name=X_66028_ }
C {devices/lab_pin.sym} 91780 -4450 0 0 {name=p91606 lab=_86045_/Q }
C {devices/lab_pin.sym} 91780 -4410 0 0 {name=p91607 lab=_51233_/X }
C {devices/lab_pin.sym} 91780 -4370 0 0 {name=p91608 lab=_51253_/Y }
C {devices/lab_pin.sym} 91940 -4410 0 1 {name=p91609 lab=_51254_/Y }
C {sky130_stdcells/o21ai_4.sym} 91860 -4410 0 0 {name=X_51254_ }
C {devices/lab_pin.sym} 91770 -4270 0 0 {name=p91610 lab=_87141_/CLK }
C {devices/lab_pin.sym} 91770 -4250 0 0 {name=p91611 lab=_86951_/D }
C {devices/lab_pin.sym} 91950 -4270 0 1 {name=p91612 lab=_86951_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -4260 0 0 {name=X_86951_ }
C {devices/lab_pin.sym} 91770 -4130 0 0 {name=p91613 lab=_81970_/CLK }
C {devices/lab_pin.sym} 91770 -4110 0 0 {name=p91614 lab=_82074_/D }
C {devices/lab_pin.sym} 91950 -4130 0 1 {name=p91615 lab=_77961_/B }
C {sky130_stdcells/dfxtp_4.sym} 91860 -4120 0 0 {name=X_82074_ }
C {devices/lab_pin.sym} 91800 -4000 0 0 {name=p91616 lab=_51242_/A }
C {devices/lab_pin.sym} 91800 -3960 0 0 {name=p91617 lab=_50719_/B }
C {devices/lab_pin.sym} 91920 -3980 0 1 {name=p91618 lab=_50205_/X }
C {sky130_stdcells/and2_4.sym} 91860 -3980 0 0 {name=X_50205_ }
C {devices/lab_pin.sym} 91770 -3850 0 0 {name=p91619 lab=_86530_/CLK }
C {devices/lab_pin.sym} 91770 -3830 0 0 {name=p91620 lab=_85902_/D }
C {devices/lab_pin.sym} 91950 -3850 0 1 {name=p91621 lab=_85902_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -3840 0 0 {name=X_85902_ }
C {devices/lab_pin.sym} 91770 -3710 0 0 {name=p91622 lab=_84175_/CLK }
C {devices/lab_pin.sym} 91770 -3690 0 0 {name=p91623 lab=_84233_/Q }
C {devices/lab_pin.sym} 91950 -3710 0 1 {name=p91624 lab=_81025_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -3700 0 0 {name=X_81025_ }
C {devices/lab_pin.sym} 91780 -3590 0 0 {name=p91625 lab=_58845_/Y }
C {devices/lab_pin.sym} 91780 -3550 0 0 {name=p91626 lab=_58849_/Y }
C {devices/lab_pin.sym} 91780 -3510 0 0 {name=p91627 lab=_58761_/X }
C {devices/lab_pin.sym} 91940 -3550 0 1 {name=p91628 lab=_58850_/X }
C {sky130_stdcells/a21o_4.sym} 91860 -3550 0 0 {name=X_58850_ }
C {devices/lab_pin.sym} 91800 -3420 0 0 {name=p91629 lab=_51184_/X }
C {devices/lab_pin.sym} 91800 -3380 0 0 {name=p91630 lab=_52876_/B }
C {devices/lab_pin.sym} 91920 -3400 0 1 {name=p91631 lab=_51185_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -3400 0 0 {name=X_51185_ }
C {devices/lab_pin.sym} 91770 -3270 0 0 {name=p91632 lab=_86882_/CLK }
C {devices/lab_pin.sym} 91770 -3250 0 0 {name=p91633 lab=_45353_/Y }
C {devices/lab_pin.sym} 91950 -3270 0 1 {name=p91634 lab=_64535_/B }
C {sky130_stdcells/dfxtp_4.sym} 91860 -3260 0 0 {name=X_86882_ }
C {devices/lab_pin.sym} 91820 -3130 0 0 {name=p91635 lab=_57800_/X }
C {devices/lab_pin.sym} 91900 -3130 0 1 {name=p91636 lab=_57801_/X }
C {sky130_stdcells/buf_2.sym} 91860 -3130 0 0 {name=X_57801_ }
C {devices/lab_pin.sym} 91780 -3030 0 0 {name=p91637 lab=_50134_/Y }
C {devices/lab_pin.sym} 91780 -2990 0 0 {name=p91638 lab=_50117_/X }
C {devices/lab_pin.sym} 91780 -2950 0 0 {name=p91639 lab=_50135_/X }
C {devices/lab_pin.sym} 91940 -2990 0 1 {name=p91640 lab=_86257_/D }
C {sky130_stdcells/a21oi_4.sym} 91860 -2990 0 0 {name=X_50136_ }
C {devices/lab_pin.sym} 91770 -2850 0 0 {name=p91641 lab=_86154_/CLK }
C {devices/lab_pin.sym} 91770 -2830 0 0 {name=p91642 lab=_52386_/Y }
C {devices/lab_pin.sym} 91950 -2850 0 1 {name=p91643 lab=_65225_/B }
C {sky130_stdcells/dfxtp_4.sym} 91860 -2840 0 0 {name=X_85833_ }
C {devices/lab_pin.sym} 91780 -2750 0 0 {name=p91644 lab=_58696_/X }
C {devices/lab_pin.sym} 91780 -2710 0 0 {name=p91645 lab=_58779_/Y }
C {devices/lab_pin.sym} 91780 -2670 0 0 {name=p91646 lab=_58780_/Y }
C {devices/lab_pin.sym} 91780 -2630 0 0 {name=p91647 lab=_58728_/X }
C {devices/lab_pin.sym} 91780 -2590 0 0 {name=p91648 lab=_58701_/X }
C {devices/lab_pin.sym} 91940 -2670 0 1 {name=p91649 lab=_58781_/X }
C {sky130_stdcells/o32a_4.sym} 91860 -2670 0 0 {name=X_58781_ }
C {devices/lab_pin.sym} 91820 -2510 0 0 {name=p91650 lab=_56102_/B }
C {devices/lab_pin.sym} 91900 -2510 0 1 {name=p91651 lab=_55993_/Y }
C {sky130_stdcells/inv_2.sym} 91860 -2510 0 0 {name=X_55993_ }
C {devices/lab_pin.sym} 91800 -2400 0 0 {name=p91652 lab=_68025_/A }
C {devices/lab_pin.sym} 91800 -2360 0 0 {name=p91653 lab=_88216_/Q }
C {devices/lab_pin.sym} 91920 -2380 0 1 {name=p91654 lab=_67979_/X }
C {sky130_stdcells/and2_4.sym} 91860 -2380 0 0 {name=X_67979_ }
C {devices/lab_pin.sym} 91820 -2250 0 0 {name=p91655 lab=_58805_/A }
C {devices/lab_pin.sym} 91900 -2250 0 1 {name=p91656 lab=_59286_/A }
C {sky130_stdcells/buf_2.sym} 91860 -2250 0 0 {name=X_57732_ }
C {devices/lab_pin.sym} 91820 -2130 0 0 {name=p91657 lab=_87815_/Q }
C {devices/lab_pin.sym} 91900 -2130 0 1 {name=p91658 lab=_69719_/B }
C {sky130_stdcells/inv_2.sym} 91860 -2130 0 0 {name=X_69718_ }
C {devices/lab_pin.sym} 91820 -2010 0 0 {name=p91659 lab=_48759_/A }
C {devices/lab_pin.sym} 91900 -2010 0 1 {name=p91660 lab=_50092_/A }
C {sky130_stdcells/buf_2.sym} 91860 -2010 0 0 {name=X_50067_ }
C {devices/lab_pin.sym} 91800 -1900 0 0 {name=p91661 lab=_53460_/A }
C {devices/lab_pin.sym} 91800 -1860 0 0 {name=p91662 lab=_47798_/A }
C {devices/lab_pin.sym} 91920 -1880 0 1 {name=p91663 lab=_54944_/Y }
C {sky130_stdcells/nand2_4.sym} 91860 -1880 0 0 {name=X_54944_ }
C {devices/lab_pin.sym} 91770 -1750 0 0 {name=p91664 lab=_85764_/CLK }
C {devices/lab_pin.sym} 91770 -1730 0 0 {name=p91665 lab=_52736_/Y }
C {devices/lab_pin.sym} 91950 -1750 0 1 {name=p91666 lab=_85764_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -1740 0 0 {name=X_85764_ }
C {devices/lab_pin.sym} 91800 -1630 0 0 {name=p91667 lab=_70990_/A }
C {devices/lab_pin.sym} 91800 -1590 0 0 {name=p91668 lab=_70942_/B }
C {devices/lab_pin.sym} 91800 -1550 0 0 {name=p91669 lab=_70990_/C }
C {devices/lab_pin.sym} 91920 -1590 0 1 {name=p91670 lab=_70990_/Y }
C {sky130_stdcells/nand3_4.sym} 91860 -1590 0 0 {name=X_70990_ }
C {devices/lab_pin.sym} 91770 -1450 0 0 {name=p91671 lab=_82973_/CLK }
C {devices/lab_pin.sym} 91770 -1430 0 0 {name=p91672 lab=_82784_/Q }
C {devices/lab_pin.sym} 91950 -1450 0 1 {name=p91673 lab=_46629_/A }
C {sky130_stdcells/dfxtp_4.sym} 91860 -1440 0 0 {name=X_82976_ }
C {devices/lab_pin.sym} 91770 -1310 0 0 {name=p91674 lab=_87260_/CLK }
C {devices/lab_pin.sym} 91770 -1290 0 0 {name=p91675 lab=_87503_/D }
C {devices/lab_pin.sym} 91950 -1310 0 1 {name=p91676 lab=_87503_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -1300 0 0 {name=X_87503_ }
C {devices/lab_pin.sym} 91770 -1170 0 0 {name=p91677 lab=_84903_/CLK }
C {devices/lab_pin.sym} 91770 -1150 0 0 {name=p91678 lab=_59503_/Y }
C {devices/lab_pin.sym} 91950 -1170 0 1 {name=p91679 lab=_64286_/C }
C {sky130_stdcells/dfxtp_4.sym} 91860 -1160 0 0 {name=X_84715_ }
C {devices/lab_pin.sym} 91820 -1030 0 0 {name=p91680 lab=_83758_/Q }
C {devices/lab_pin.sym} 91900 -1030 0 1 {name=p91681 lab=_57663_/Y }
C {sky130_stdcells/inv_2.sym} 91860 -1030 0 0 {name=X_57663_ }
C {devices/lab_pin.sym} 91770 -910 0 0 {name=p91682 lab=_82124_/CLK }
C {devices/lab_pin.sym} 91770 -890 0 0 {name=p91683 lab=_81927_/D }
C {devices/lab_pin.sym} 91950 -910 0 1 {name=p91684 lab=_81927_/Q }
C {sky130_stdcells/dfxtp_4.sym} 91860 -900 0 0 {name=X_81927_ }
C {devices/lab_pin.sym} 91780 -800 0 0 {name=p91685 lab=_41996_/A }
C {devices/lab_pin.sym} 91780 -760 0 0 {name=p91686 lab=_69607_/X }
C {devices/lab_pin.sym} 91780 -720 0 0 {name=p91687 lab=_68555_/X }
C {devices/lab_pin.sym} 91780 -680 0 0 {name=p91688 lab=_69648_/Y }
C {devices/lab_pin.sym} 91940 -740 0 1 {name=p91689 lab=_69649_/X }
C {sky130_stdcells/a211o_4.sym} 91860 -740 0 0 {name=X_69649_ }
C {devices/lab_pin.sym} 92700 -42170 0 0 {name=p91690 lab=_54872_/Y }
C {devices/lab_pin.sym} 92700 -42130 0 0 {name=p91691 lab=_54856_/X }
C {devices/lab_pin.sym} 92700 -42090 0 0 {name=p91692 lab=_54874_/X }
C {devices/lab_pin.sym} 92860 -42130 0 1 {name=p91693 lab=_54875_/Y }
C {sky130_stdcells/a21oi_4.sym} 92780 -42130 0 0 {name=X_54875_ }
C {devices/lab_pin.sym} 92690 -41990 0 0 {name=p91694 lab=_85697_/CLK }
C {devices/lab_pin.sym} 92690 -41970 0 0 {name=p91695 lab=_85695_/D }
C {devices/lab_pin.sym} 92870 -41990 0 1 {name=p91696 lab=_85695_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -41980 0 0 {name=X_85695_ }
C {devices/lab_pin.sym} 92740 -41850 0 0 {name=p91697 lab=_63139_/A }
C {devices/lab_pin.sym} 92820 -41850 0 1 {name=p91698 lab=_59403_/A }
C {sky130_stdcells/buf_2.sym} 92780 -41850 0 0 {name=X_59402_ }
C {devices/lab_pin.sym} 92720 -41750 0 0 {name=p91699 lab=_56602_/X }
C {devices/lab_pin.sym} 92720 -41710 0 0 {name=p91700 lab=_56614_/B }
C {devices/lab_pin.sym} 92720 -41670 0 0 {name=p91701 lab=_56696_/B }
C {devices/lab_pin.sym} 92840 -41710 0 1 {name=p91702 lab=_56614_/Y }
C {sky130_stdcells/nor3_4.sym} 92780 -41710 0 0 {name=X_56614_ }
C {devices/lab_pin.sym} 92740 -41570 0 0 {name=p91703 lab=clkbuf_6_36_0_CLK/X }
C {devices/lab_pin.sym} 92820 -41570 0 1 {name=p91704 lab=clkbuf_7_73_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 92780 -41570 0 0 {name=Xclkbuf_7_73_0_CLK }
C {devices/lab_pin.sym} 92690 -41450 0 0 {name=p91705 lab=_87484_/CLK }
C {devices/lab_pin.sym} 92690 -41430 0 0 {name=p91706 lab=_43411_/X }
C {devices/lab_pin.sym} 92870 -41450 0 1 {name=p91707 lab=_87434_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -41440 0 0 {name=X_87434_ }
C {devices/lab_pin.sym} 92740 -41310 0 0 {name=p91708 lab=_40637_/A }
C {devices/lab_pin.sym} 92820 -41310 0 1 {name=p91709 lab=_42465_/A }
C {sky130_stdcells/buf_2.sym} 92780 -41310 0 0 {name=X_41840_ }
C {devices/lab_pin.sym} 92700 -41210 0 0 {name=p91710 lab=_53824_/Y }
C {devices/lab_pin.sym} 92700 -41170 0 0 {name=p91711 lab=_53799_/X }
C {devices/lab_pin.sym} 92700 -41130 0 0 {name=p91712 lab=_53825_/Y }
C {devices/lab_pin.sym} 92860 -41170 0 1 {name=p91713 lab=_85561_/D }
C {sky130_stdcells/a21boi_4.sym} 92780 -41170 0 0 {name=X_53826_ }
C {devices/lab_pin.sym} 92740 -41030 0 0 {name=p91714 lab=_44290_/X }
C {devices/lab_pin.sym} 92820 -41030 0 1 {name=p91715 lab=_72688_/A }
C {sky130_stdcells/buf_2.sym} 92780 -41030 0 0 {name=X_72660_ }
C {devices/lab_pin.sym} 92690 -40910 0 0 {name=p91716 lab=_83218_/CLK }
C {devices/lab_pin.sym} 92690 -40890 0 0 {name=p91717 lab=_60248_/Y }
C {devices/lab_pin.sym} 92870 -40910 0 1 {name=p91718 lab=_79846_/A }
C {sky130_stdcells/dfxtp_4.sym} 92780 -40900 0 0 {name=X_84646_ }
C {devices/lab_pin.sym} 92700 -40790 0 0 {name=p91719 lab=_57591_/Y }
C {devices/lab_pin.sym} 92700 -40750 0 0 {name=p91720 lab=_57592_/X }
C {devices/lab_pin.sym} 92700 -40710 0 0 {name=p91721 lab=_57593_/X }
C {devices/lab_pin.sym} 92860 -40750 0 1 {name=p91722 lab=_57594_/Y }
C {sky130_stdcells/a21oi_4.sym} 92780 -40750 0 0 {name=X_57594_ }
C {devices/lab_pin.sym} 92690 -40610 0 0 {name=p91723 lab=_82211_/CLK }
C {devices/lab_pin.sym} 92690 -40590 0 0 {name=p91724 lab=_78049_/X }
C {devices/lab_pin.sym} 92870 -40610 0 1 {name=p91725 lab=_81858_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -40600 0 0 {name=X_81858_ }
C {devices/lab_pin.sym} 92700 -40490 0 0 {name=p91726 lab=_59331_/X }
C {devices/lab_pin.sym} 92700 -40450 0 0 {name=p91727 lab=_85414_/Q }
C {devices/lab_pin.sym} 92700 -40410 0 0 {name=p91728 lab=_59332_/X }
C {devices/lab_pin.sym} 92860 -40450 0 1 {name=p91729 lab=_59333_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -40450 0 0 {name=X_59333_ }
C {devices/lab_pin.sym} 92740 -40310 0 0 {name=p91730 lab=_71215_/C }
C {devices/lab_pin.sym} 92820 -40310 0 1 {name=p91731 lab=_71614_/C }
C {sky130_stdcells/buf_2.sym} 92780 -40310 0 0 {name=X_71611_ }
C {devices/lab_pin.sym} 92720 -40210 0 0 {name=p91732 lab=_56545_/A }
C {devices/lab_pin.sym} 92720 -40170 0 0 {name=p91733 lab=_56177_/B }
C {devices/lab_pin.sym} 92720 -40130 0 0 {name=p91734 lab=_55738_/B }
C {devices/lab_pin.sym} 92840 -40170 0 1 {name=p91735 lab=_56545_/Y }
C {sky130_stdcells/nand3_4.sym} 92780 -40170 0 0 {name=X_56545_ }
C {devices/lab_pin.sym} 92690 -40030 0 0 {name=p91736 lab=_81134_/CLK }
C {devices/lab_pin.sym} 92690 -40010 0 0 {name=p91737 lab=_80809_/D }
C {devices/lab_pin.sym} 92870 -40030 0 1 {name=p91738 lab=_80809_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -40020 0 0 {name=X_80809_ }
C {devices/lab_pin.sym} 92720 -39900 0 0 {name=p91739 lab=_82886_/Q }
C {devices/lab_pin.sym} 92720 -39860 0 0 {name=p91740 lab=_48946_/A }
C {devices/lab_pin.sym} 92840 -39880 0 1 {name=p91741 lab=_41771_/X }
C {sky130_stdcells/or2_4.sym} 92780 -39880 0 0 {name=X_41771_ }
C {devices/lab_pin.sym} 92690 -39750 0 0 {name=p91742 lab=_86824_/CLK }
C {devices/lab_pin.sym} 92690 -39730 0 0 {name=p91743 lab=_43551_/Y }
C {devices/lab_pin.sym} 92870 -39750 0 1 {name=p91744 lab=_87365_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -39740 0 0 {name=X_87365_ }
C {devices/lab_pin.sym} 92700 -39630 0 0 {name=p91745 lab=_85574_/Q }
C {devices/lab_pin.sym} 92700 -39590 0 0 {name=p91746 lab=_53754_/X }
C {devices/lab_pin.sym} 92700 -39550 0 0 {name=p91747 lab=_53756_/Y }
C {devices/lab_pin.sym} 92860 -39590 0 1 {name=p91748 lab=_53757_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -39590 0 0 {name=X_53757_ }
C {devices/lab_pin.sym} 92700 -39480 0 0 {name=p91749 lab=_79343_/B }
C {devices/lab_pin.sym} 92700 -39440 0 0 {name=p91750 lab=_72590_/X }
C {devices/lab_pin.sym} 92700 -39400 0 0 {name=p91751 lab=_61178_/Y }
C {devices/lab_pin.sym} 92700 -39360 0 0 {name=p91752 lab=_72562_/A }
C {devices/lab_pin.sym} 92860 -39420 0 1 {name=p91753 lab=_72591_/X }
C {sky130_stdcells/o22a_4.sym} 92780 -39420 0 0 {name=X_72591_ }
C {devices/lab_pin.sym} 92690 -39270 0 0 {name=p91754 lab=_84562_/CLK }
C {devices/lab_pin.sym} 92690 -39250 0 0 {name=p91755 lab=_84577_/D }
C {devices/lab_pin.sym} 92870 -39270 0 1 {name=p91756 lab=_60744_/C }
C {sky130_stdcells/dfxtp_4.sym} 92780 -39260 0 0 {name=X_84577_ }
C {devices/lab_pin.sym} 92720 -39160 0 0 {name=p91757 lab=_50963_/A }
C {devices/lab_pin.sym} 92720 -39120 0 0 {name=p91758 lab=_50963_/B }
C {devices/lab_pin.sym} 92720 -39080 0 0 {name=p91759 lab=_50963_/C }
C {devices/lab_pin.sym} 92720 -39040 0 0 {name=p91760 lab=_52661_/D }
C {devices/lab_pin.sym} 92840 -39100 0 1 {name=p91761 lab=_50969_/X }
C {sky130_stdcells/and4_4.sym} 92780 -39100 0 0 {name=X_50969_ }
C {devices/lab_pin.sym} 92690 -38950 0 0 {name=p91762 lab=_86753_/CLK }
C {devices/lab_pin.sym} 92690 -38930 0 0 {name=p91763 lab=_75939_/Y }
C {devices/lab_pin.sym} 92870 -38950 0 1 {name=p91764 lab=_48405_/A }
C {sky130_stdcells/dfxtp_4.sym} 92780 -38940 0 0 {name=X_81789_ }
C {devices/lab_pin.sym} 92700 -38850 0 0 {name=p91765 lab=_43495_/X }
C {devices/lab_pin.sym} 92700 -38810 0 0 {name=p91766 lab=_43503_/X }
C {devices/lab_pin.sym} 92700 -38770 0 0 {name=p91767 lab=_41773_/X }
C {devices/lab_pin.sym} 92700 -38730 0 0 {name=p91768 lab=_87384_/Q }
C {devices/lab_pin.sym} 92700 -38690 0 0 {name=p91769 lab=_43506_/X }
C {devices/lab_pin.sym} 92860 -38770 0 1 {name=p91770 lab=_43511_/A }
C {sky130_stdcells/o32ai_4.sym} 92780 -38770 0 0 {name=X_43510_ }
C {devices/lab_pin.sym} 92720 -38630 0 0 {name=p91771 lab=_74338_/A }
C {devices/lab_pin.sym} 92720 -38590 0 0 {name=p91772 lab=_74338_/B }
C {devices/lab_pin.sym} 92720 -38550 0 0 {name=p91773 lab=_56098_/A }
C {devices/lab_pin.sym} 92840 -38590 0 1 {name=p91774 lab=_74330_/Y }
C {sky130_stdcells/nand3_4.sym} 92780 -38590 0 0 {name=X_74330_ }
C {devices/lab_pin.sym} 92690 -38450 0 0 {name=p91775 lab=_86637_/CLK }
C {devices/lab_pin.sym} 92690 -38430 0 0 {name=p91776 lab=_49831_/Y }
C {devices/lab_pin.sym} 92870 -38450 0 1 {name=p91777 lab=_58012_/B }
C {sky130_stdcells/dfxtp_4.sym} 92780 -38440 0 0 {name=X_86316_ }
C {devices/lab_pin.sym} 92740 -38310 0 0 {name=p91778 lab=_52708_/A }
C {devices/lab_pin.sym} 92820 -38310 0 1 {name=p91779 lab=_52708_/X }
C {sky130_stdcells/buf_2.sym} 92780 -38310 0 0 {name=X_52708_ }
C {devices/lab_pin.sym} 92720 -38200 0 0 {name=p91780 lab=_40722_/A }
C {devices/lab_pin.sym} 92720 -38160 0 0 {name=p91781 lab=_40760_/B }
C {devices/lab_pin.sym} 92840 -38180 0 1 {name=p91782 lab=_40722_/X }
C {sky130_stdcells/or2_4.sym} 92780 -38180 0 0 {name=X_40722_ }
C {devices/lab_pin.sym} 92700 -38070 0 0 {name=p91783 lab=_59199_/X }
C {devices/lab_pin.sym} 92700 -38030 0 0 {name=p91784 lab=_85740_/Q }
C {devices/lab_pin.sym} 92700 -37990 0 0 {name=p91785 lab=_59263_/X }
C {devices/lab_pin.sym} 92860 -38030 0 1 {name=p91786 lab=_59264_/X }
C {sky130_stdcells/o21a_4.sym} 92780 -38030 0 0 {name=X_59264_ }
C {devices/lab_pin.sym} 92720 -37910 0 0 {name=p91787 lab=_70676_/A }
C {devices/lab_pin.sym} 92720 -37870 0 0 {name=p91788 lab=_71546_/B }
C {devices/lab_pin.sym} 92720 -37830 0 0 {name=p91789 lab=_71546_/C }
C {devices/lab_pin.sym} 92840 -37870 0 1 {name=p91790 lab=_71542_/Y }
C {sky130_stdcells/nor3_4.sym} 92780 -37870 0 0 {name=X_71542_ }
C {devices/lab_pin.sym} 92690 -37730 0 0 {name=p91791 lab=_83526_/CLK }
C {devices/lab_pin.sym} 92690 -37710 0 0 {name=p91792 lab=_83528_/D }
C {devices/lab_pin.sym} 92870 -37730 0 1 {name=p91793 lab=_83528_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -37720 0 0 {name=X_83528_ }
C {devices/lab_pin.sym} 92740 -37590 0 0 {name=p91794 lab=_44489_/Y }
C {devices/lab_pin.sym} 92820 -37590 0 1 {name=p91795 lab=_44490_/Y }
C {sky130_stdcells/inv_2.sym} 92780 -37590 0 0 {name=X_44490_ }
C {devices/lab_pin.sym} 92700 -37490 0 0 {name=p91796 lab=_56020_/X }
C {devices/lab_pin.sym} 92700 -37450 0 0 {name=p91797 lab=_56468_/X }
C {devices/lab_pin.sym} 92700 -37410 0 0 {name=p91798 lab=_56475_/Y }
C {devices/lab_pin.sym} 92860 -37450 0 1 {name=p91799 lab=_56476_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -37450 0 0 {name=X_56476_ }
C {devices/lab_pin.sym} 92690 -37310 0 0 {name=p91800 lab=_87813_/CLK }
C {devices/lab_pin.sym} 92690 -37290 0 0 {name=p91801 lab=_43723_/Y }
C {devices/lab_pin.sym} 92870 -37310 0 1 {name=p91802 lab=_87296_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -37300 0 0 {name=X_87296_ }
C {devices/lab_pin.sym} 92740 -37170 0 0 {name=p91803 lab=_53755_/A }
C {devices/lab_pin.sym} 92820 -37170 0 1 {name=p91804 lab=_53713_/A }
C {sky130_stdcells/buf_2.sym} 92780 -37170 0 0 {name=X_53688_ }
C {devices/lab_pin.sym} 92740 -37050 0 0 {name=p91805 lab=clkbuf_7_89_0_CLK/A }
C {devices/lab_pin.sym} 92820 -37050 0 1 {name=p91806 lab=clkbuf_7_88_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 92780 -37050 0 0 {name=Xclkbuf_7_88_0_CLK }
C {devices/lab_pin.sym} 92700 -36950 0 0 {name=p91807 lab=_58171_/X }
C {devices/lab_pin.sym} 92700 -36910 0 0 {name=p91808 lab=_83370_/Q }
C {devices/lab_pin.sym} 92700 -36870 0 0 {name=p91809 lab=_58214_/Y }
C {devices/lab_pin.sym} 92860 -36910 0 1 {name=p91810 lab=_84906_/D }
C {sky130_stdcells/o21a_4.sym} 92780 -36910 0 0 {name=X_58215_ }
C {sky130_stdcells/decap_3.sym} 92780 -36740 0 0 {name=XPHY_410 }
C {devices/lab_pin.sym} 92700 -36620 0 0 {name=p91811 lab=_41586_/X }
C {devices/lab_pin.sym} 92700 -36580 0 0 {name=p91812 lab=_43431_/X }
C {devices/lab_pin.sym} 92700 -36540 0 0 {name=p91813 lab=_87419_/Q }
C {devices/lab_pin.sym} 92700 -36500 0 0 {name=p91814 lab=_43432_/X }
C {devices/lab_pin.sym} 92860 -36560 0 1 {name=p91815 lab=_87419_/D }
C {sky130_stdcells/a2bb2o_4.sym} 92780 -36560 0 0 {name=X_43441_ }
C {devices/lab_pin.sym} 92720 -36420 0 0 {name=p91816 lab=_57186_/B }
C {devices/lab_pin.sym} 92720 -36380 0 0 {name=p91817 lab=_55426_/X }
C {devices/lab_pin.sym} 92840 -36400 0 1 {name=p91818 lab=_55427_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -36400 0 0 {name=X_55427_ }
C {devices/lab_pin.sym} 92690 -36270 0 0 {name=p91819 lab=_86154_/CLK }
C {devices/lab_pin.sym} 92690 -36250 0 0 {name=p91820 lab=_50184_/Y }
C {devices/lab_pin.sym} 92870 -36270 0 1 {name=p91821 lab=_65285_/B }
C {sky130_stdcells/dfxtp_4.sym} 92780 -36260 0 0 {name=X_86247_ }
C {devices/lab_pin.sym} 92720 -36150 0 0 {name=p91822 lab=_74259_/X }
C {devices/lab_pin.sym} 92720 -36110 0 0 {name=p91823 lab=_74248_/X }
C {devices/lab_pin.sym} 92720 -36070 0 0 {name=p91824 lab=_74250_/X }
C {devices/lab_pin.sym} 92840 -36110 0 1 {name=p91825 lab=_74261_/Y }
C {sky130_stdcells/nand3_4.sym} 92780 -36110 0 0 {name=X_74261_ }
C {devices/lab_pin.sym} 92700 -36000 0 0 {name=p91826 lab=_40650_/X }
C {devices/lab_pin.sym} 92700 -35960 0 0 {name=p91827 lab=_40651_/X }
C {devices/lab_pin.sym} 92700 -35920 0 0 {name=p91828 lab=_68645_/B }
C {devices/lab_pin.sym} 92700 -35880 0 0 {name=p91829 lab=_40652_/X }
C {devices/lab_pin.sym} 92860 -35940 0 1 {name=p91830 lab=_40653_/X }
C {sky130_stdcells/a2bb2o_4.sym} 92780 -35940 0 0 {name=X_40653_ }
C {sky130_stdcells/decap_3.sym} 92780 -35760 0 0 {name=XPHY_421 }
C {devices/lab_pin.sym} 92720 -35640 0 0 {name=p91831 lab=_52643_/A }
C {devices/lab_pin.sym} 92720 -35600 0 0 {name=p91832 lab=_52654_/B }
C {devices/lab_pin.sym} 92720 -35560 0 0 {name=p91833 lab=_52643_/C }
C {devices/lab_pin.sym} 92720 -35520 0 0 {name=p91834 lab=_46728_/X }
C {devices/lab_pin.sym} 92840 -35580 0 1 {name=p91835 lab=_52639_/X }
C {sky130_stdcells/and4_4.sym} 92780 -35580 0 0 {name=X_52639_ }
C {devices/lab_pin.sym} 92700 -35470 0 0 {name=p91836 lab=_59115_/X }
C {devices/lab_pin.sym} 92700 -35430 0 0 {name=p91837 lab=_59192_/Y }
C {devices/lab_pin.sym} 92700 -35390 0 0 {name=p91838 lab=_59194_/Y }
C {devices/lab_pin.sym} 92700 -35350 0 0 {name=p91839 lab=_59133_/X }
C {devices/lab_pin.sym} 92700 -35310 0 0 {name=p91840 lab=_59119_/X }
C {devices/lab_pin.sym} 92860 -35390 0 1 {name=p91841 lab=_59195_/X }
C {sky130_stdcells/o32a_4.sym} 92780 -35390 0 0 {name=X_59195_ }
C {devices/lab_pin.sym} 92720 -35260 0 0 {name=p91842 lab=_70880_/B }
C {devices/lab_pin.sym} 92720 -35220 0 0 {name=p91843 lab=_71479_/B }
C {devices/lab_pin.sym} 92720 -35180 0 0 {name=p91844 lab=_70778_/A }
C {devices/lab_pin.sym} 92720 -35140 0 0 {name=p91845 lab=_71476_/D }
C {devices/lab_pin.sym} 92840 -35200 0 1 {name=p91846 lab=_71473_/X }
C {sky130_stdcells/and4_4.sym} 92780 -35200 0 0 {name=X_71473_ }
C {devices/lab_pin.sym} 92690 -35050 0 0 {name=p91847 lab=_83495_/CLK }
C {devices/lab_pin.sym} 92690 -35030 0 0 {name=p91848 lab=_83459_/D }
C {devices/lab_pin.sym} 92870 -35050 0 1 {name=p91849 lab=_83459_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -35040 0 0 {name=X_83459_ }
C {sky130_stdcells/decap_3.sym} 92780 -34880 0 0 {name=XPHY_432 }
C {sky130_stdcells/decap_3.sym} 92780 -34700 0 0 {name=XPHY_443 }
C {devices/lab_pin.sym} 92720 -34560 0 0 {name=p91850 lab=_81708_/D }
C {devices/lab_pin.sym} 92720 -34520 0 0 {name=p91851 lab=_81420_/Q }
C {devices/lab_pin.sym} 92840 -34540 0 1 {name=p91852 lab=_76000_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -34540 0 0 {name=X_76000_ }
C {sky130_stdcells/decap_3.sym} 92780 -34380 0 0 {name=XPHY_454 }
C {devices/lab_pin.sym} 92700 -34260 0 0 {name=p91853 lab=_73210_/X }
C {devices/lab_pin.sym} 92700 -34220 0 0 {name=p91854 lab=_85584_/Q }
C {devices/lab_pin.sym} 92700 -34180 0 0 {name=p91855 lab=_73092_/X }
C {devices/lab_pin.sym} 92700 -34140 0 0 {name=p91856 lab=_73211_/X }
C {devices/lab_pin.sym} 92860 -34200 0 1 {name=p91857 lab=_73212_/X }
C {sky130_stdcells/a211o_4.sym} 92780 -34200 0 0 {name=X_73212_ }
C {devices/lab_pin.sym} 92720 -34060 0 0 {name=p91858 lab=_46087_/A }
C {devices/lab_pin.sym} 92720 -34020 0 0 {name=p91859 lab=_46121_/A }
C {devices/lab_pin.sym} 92840 -34040 0 1 {name=p91860 lab=_46162_/C }
C {sky130_stdcells/nor2_4.sym} 92780 -34040 0 0 {name=X_46160_ }
C {devices/lab_pin.sym} 92720 -33940 0 0 {name=p91861 lab=_71162_/B }
C {devices/lab_pin.sym} 92720 -33900 0 0 {name=p91862 lab=_70423_/X }
C {devices/lab_pin.sym} 92720 -33860 0 0 {name=p91863 lab=_70495_/A }
C {devices/lab_pin.sym} 92720 -33820 0 0 {name=p91864 lab=_70609_/A }
C {devices/lab_pin.sym} 92840 -33880 0 1 {name=p91865 lab=_70424_/X }
C {sky130_stdcells/and4_4.sym} 92780 -33880 0 0 {name=X_70424_ }
C {devices/lab_pin.sym} 92740 -33730 0 0 {name=p91866 lab=_61323_/A }
C {devices/lab_pin.sym} 92820 -33730 0 1 {name=p91867 lab=_58147_/A }
C {sky130_stdcells/buf_2.sym} 92780 -33730 0 0 {name=X_58146_ }
C {sky130_stdcells/decap_3.sym} 92780 -33580 0 0 {name=XPHY_465 }
C {devices/lab_pin.sym} 92740 -33430 0 0 {name=p91868 lab=_43302_/A }
C {devices/lab_pin.sym} 92820 -33430 0 1 {name=p91869 lab=_43372_/X }
C {sky130_stdcells/buf_2.sym} 92780 -33430 0 0 {name=X_43372_ }
C {devices/lab_pin.sym} 92720 -33320 0 0 {name=p91870 lab=_55369_/A }
C {devices/lab_pin.sym} 92720 -33280 0 0 {name=p91871 lab=_55369_/B }
C {devices/lab_pin.sym} 92840 -33300 0 1 {name=p91872 lab=_56689_/A }
C {sky130_stdcells/nand2_4.sym} 92780 -33300 0 0 {name=X_55358_ }
C {devices/lab_pin.sym} 92720 -33180 0 0 {name=p91873 lab=_74232_/A }
C {devices/lab_pin.sym} 92720 -33140 0 0 {name=p91874 lab=_66296_/B }
C {devices/lab_pin.sym} 92840 -33160 0 1 {name=p91875 lab=_74192_/X }
C {sky130_stdcells/and2_4.sym} 92780 -33160 0 0 {name=X_74192_ }
C {devices/lab_pin.sym} 92690 -33030 0 0 {name=p91876 lab=_83307_/CLK }
C {devices/lab_pin.sym} 92690 -33010 0 0 {name=p91877 lab=_50557_/Y }
C {devices/lab_pin.sym} 92870 -33030 0 1 {name=p91878 lab=_86178_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -33020 0 0 {name=X_86178_ }
C {sky130_stdcells/decap_3.sym} 92780 -32860 0 0 {name=XPHY_476 }
C {devices/lab_pin.sym} 92740 -32710 0 0 {name=p91879 lab=_40878_/A }
C {devices/lab_pin.sym} 92820 -32710 0 1 {name=p91880 lab=_40585_/A }
C {sky130_stdcells/buf_2.sym} 92780 -32710 0 0 {name=X_40584_ }
C {sky130_stdcells/decap_3.sym} 92780 -32560 0 0 {name=XPHY_487 }
C {devices/lab_pin.sym} 92700 -32430 0 0 {name=p91881 lab=_45052_/X }
C {devices/lab_pin.sym} 92700 -32390 0 0 {name=p91882 lab=_61489_/B }
C {devices/lab_pin.sym} 92700 -32350 0 0 {name=p91883 lab=_45070_/X }
C {devices/lab_pin.sym} 92860 -32390 0 1 {name=p91884 lab=_45111_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -32390 0 0 {name=X_45111_ }
C {sky130_stdcells/decap_3.sym} 92780 -32220 0 0 {name=XPHY_498 }
C {devices/lab_pin.sym} 92720 -32080 0 0 {name=p91885 lab=_54314_/A }
C {devices/lab_pin.sym} 92720 -32040 0 0 {name=p91886 lab=_54309_/B }
C {devices/lab_pin.sym} 92840 -32060 0 1 {name=p91887 lab=_54309_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -32060 0 0 {name=X_54309_ }
C {devices/lab_pin.sym} 92700 -31960 0 0 {name=p91888 lab=_41636_/X }
C {devices/lab_pin.sym} 92700 -31920 0 0 {name=p91889 lab=_42303_/X }
C {devices/lab_pin.sym} 92700 -31880 0 0 {name=p91890 lab=_87922_/Q }
C {devices/lab_pin.sym} 92700 -31840 0 0 {name=p91891 lab=_42305_/X }
C {devices/lab_pin.sym} 92860 -31900 0 1 {name=p91892 lab=_87922_/D }
C {sky130_stdcells/a2bb2o_4.sym} 92780 -31900 0 0 {name=X_42323_ }
C {devices/lab_pin.sym} 92720 -31770 0 0 {name=p91893 lab=_73141_/X }
C {devices/lab_pin.sym} 92720 -31730 0 0 {name=p91894 lab=_73128_/X }
C {devices/lab_pin.sym} 92720 -31690 0 0 {name=p91895 lab=_73131_/Y }
C {devices/lab_pin.sym} 92840 -31730 0 1 {name=p91896 lab=_73143_/Y }
C {sky130_stdcells/nand3_4.sym} 92780 -31730 0 0 {name=X_73143_ }
C {devices/lab_pin.sym} 92690 -31590 0 0 {name=p91897 lab=_85031_/CLK }
C {devices/lab_pin.sym} 92690 -31570 0 0 {name=p91898 lab=_85129_/D }
C {devices/lab_pin.sym} 92870 -31590 0 1 {name=p91899 lab=_85129_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -31580 0 0 {name=X_85129_ }
C {devices/lab_pin.sym} 92740 -31450 0 0 {name=p91900 lab=clkbuf_6_5_0_CLK/X }
C {devices/lab_pin.sym} 92820 -31450 0 1 {name=p91901 lab=clkbuf_8_23_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 92780 -31450 0 0 {name=Xclkbuf_7_11_0_CLK }
C {devices/lab_pin.sym} 92740 -31330 0 0 {name=p91902 lab=_70355_/A }
C {devices/lab_pin.sym} 92820 -31330 0 1 {name=p91903 lab=_71003_/A }
C {sky130_stdcells/buf_2.sym} 92780 -31330 0 0 {name=X_70355_ }
C {devices/lab_pin.sym} 92740 -31210 0 0 {name=p91904 lab=_46111_/A }
C {devices/lab_pin.sym} 92820 -31210 0 1 {name=p91905 lab=_46091_/Y }
C {sky130_stdcells/inv_2.sym} 92780 -31210 0 0 {name=X_46091_ }
C {devices/lab_pin.sym} 92700 -31110 0 0 {name=p91906 lab=_58074_/Y }
C {devices/lab_pin.sym} 92700 -31070 0 0 {name=p91907 lab=_58076_/Y }
C {devices/lab_pin.sym} 92700 -31030 0 0 {name=p91908 lab=_58035_/X }
C {devices/lab_pin.sym} 92860 -31070 0 1 {name=p91909 lab=_58077_/X }
C {sky130_stdcells/a21o_4.sym} 92780 -31070 0 0 {name=X_58077_ }
C {devices/lab_pin.sym} 92700 -30950 0 0 {name=p91910 lab=_55674_/B }
C {devices/lab_pin.sym} 92700 -30910 0 0 {name=p91911 lab=_55286_/Y }
C {devices/lab_pin.sym} 92700 -30870 0 0 {name=p91912 lab=_55284_/X }
C {devices/lab_pin.sym} 92860 -30910 0 1 {name=p91913 lab=_55289_/X }
C {sky130_stdcells/a21bo_4.sym} 92780 -30910 0 0 {name=X_55289_ }
C {devices/lab_pin.sym} 92740 -30770 0 0 {name=p91914 lab=clkbuf_7_75_0_CLK/X }
C {devices/lab_pin.sym} 92820 -30770 0 1 {name=p91915 lab=clkbuf_9_303_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 92780 -30770 0 0 {name=Xclkbuf_8_151_0_CLK }
C {devices/lab_pin.sym} 92700 -30670 0 0 {name=p91916 lab=_85208_/Q }
C {devices/lab_pin.sym} 92700 -30630 0 0 {name=p91917 lab=_45027_/X }
C {devices/lab_pin.sym} 92700 -30590 0 0 {name=p91918 lab=_45041_/X }
C {devices/lab_pin.sym} 92860 -30630 0 1 {name=p91919 lab=_45042_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -30630 0 0 {name=X_45042_ }
C {devices/lab_pin.sym} 92700 -30510 0 0 {name=p91920 lab=_57025_/X }
C {devices/lab_pin.sym} 92700 -30470 0 0 {name=p91921 lab=_46178_/X }
C {devices/lab_pin.sym} 92700 -30430 0 0 {name=p91922 lab=_57027_/Y }
C {devices/lab_pin.sym} 92860 -30470 0 1 {name=p91923 lab=_57028_/Y }
C {sky130_stdcells/a21oi_4.sym} 92780 -30470 0 0 {name=X_57028_ }
C {devices/lab_pin.sym} 92740 -30330 0 0 {name=p91924 lab=_42254_/A }
C {devices/lab_pin.sym} 92820 -30330 0 1 {name=p91925 lab=_42254_/Y }
C {sky130_stdcells/inv_2.sym} 92780 -30330 0 0 {name=X_42254_ }
C {devices/lab_pin.sym} 92700 -30230 0 0 {name=p91926 lab=_73058_/X }
C {devices/lab_pin.sym} 92700 -30190 0 0 {name=p91927 lab=_73075_/C }
C {devices/lab_pin.sym} 92700 -30150 0 0 {name=p91928 lab=_73073_/X }
C {devices/lab_pin.sym} 92860 -30190 0 1 {name=p91929 lab=_73074_/X }
C {sky130_stdcells/a21o_4.sym} 92780 -30190 0 0 {name=X_73074_ }
C {devices/lab_pin.sym} 92720 -30060 0 0 {name=p91930 lab=_82170_/Q }
C {devices/lab_pin.sym} 92720 -30020 0 0 {name=p91931 lab=_77951_/B }
C {devices/lab_pin.sym} 92840 -30040 0 1 {name=p91932 lab=_82138_/D }
C {sky130_stdcells/xor2_4.sym} 92780 -30040 0 0 {name=X_77951_ }
C {devices/lab_pin.sym} 92700 -29930 0 0 {name=p91933 lab=_70269_/X }
C {devices/lab_pin.sym} 92700 -29890 0 0 {name=p91934 lab=_74756_/B }
C {devices/lab_pin.sym} 92700 -29850 0 0 {name=p91935 lab=_70285_/X }
C {devices/lab_pin.sym} 92860 -29890 0 1 {name=p91936 lab=_70286_/X }
C {sky130_stdcells/a21o_4.sym} 92780 -29890 0 0 {name=X_70286_ }
C {devices/lab_pin.sym} 92740 -29750 0 0 {name=p91937 lab=_40999_/A }
C {devices/lab_pin.sym} 92820 -29750 0 1 {name=p91938 lab=_41205_/X }
C {sky130_stdcells/buf_2.sym} 92780 -29750 0 0 {name=X_41205_ }
C {devices/lab_pin.sym} 92720 -29640 0 0 {name=p91939 lab=_72025_/A }
C {devices/lab_pin.sym} 92720 -29600 0 0 {name=p91940 lab=_72025_/B }
C {devices/lab_pin.sym} 92840 -29620 0 1 {name=p91941 lab=_72025_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -29620 0 0 {name=X_72025_ }
C {devices/lab_pin.sym} 92720 -29500 0 0 {name=p91942 lab=_76904_/A }
C {devices/lab_pin.sym} 92720 -29460 0 0 {name=p91943 lab=_76902_/B }
C {devices/lab_pin.sym} 92840 -29480 0 1 {name=p91944 lab=_76902_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -29480 0 0 {name=X_76902_ }
C {devices/lab_pin.sym} 92740 -29350 0 0 {name=p91945 lab=_49794_/X }
C {devices/lab_pin.sym} 92820 -29350 0 1 {name=p91946 lab=_49862_/C }
C {sky130_stdcells/buf_2.sym} 92780 -29350 0 0 {name=X_49850_ }
C {devices/lab_pin.sym} 92700 -29260 0 0 {name=p91947 lab=_41264_/X }
C {devices/lab_pin.sym} 92700 -29220 0 0 {name=p91948 lab=_42183_/X }
C {devices/lab_pin.sym} 92700 -29180 0 0 {name=p91949 lab=_87992_/Q }
C {devices/lab_pin.sym} 92700 -29140 0 0 {name=p91950 lab=_42184_/X }
C {devices/lab_pin.sym} 92860 -29200 0 1 {name=p91951 lab=_42185_/X }
C {sky130_stdcells/a2bb2o_4.sym} 92780 -29200 0 0 {name=X_42185_ }
C {devices/lab_pin.sym} 92740 -29050 0 0 {name=p91952 lab=_82067_/Q }
C {devices/lab_pin.sym} 92820 -29050 0 1 {name=p91953 lab=_77884_/A }
C {sky130_stdcells/inv_2.sym} 92780 -29050 0 0 {name=X_77882_ }
C {devices/lab_pin.sym} 92720 -28940 0 0 {name=p91954 lab=_48801_/A }
C {devices/lab_pin.sym} 92720 -28900 0 0 {name=p91955 lab=_48801_/B }
C {devices/lab_pin.sym} 92840 -28920 0 1 {name=p91956 lab=_48801_/X }
C {sky130_stdcells/and2_4.sym} 92780 -28920 0 0 {name=X_48801_ }
C {devices/lab_pin.sym} 92740 -28790 0 0 {name=p91957 lab=clkbuf_7_26_0_CLK/A }
C {devices/lab_pin.sym} 92820 -28790 0 1 {name=p91958 lab=clkbuf_8_53_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 92780 -28790 0 0 {name=Xclkbuf_7_26_0_CLK }
C {devices/lab_pin.sym} 92720 -28680 0 0 {name=p91959 lab=_79597_/A }
C {devices/lab_pin.sym} 92720 -28640 0 0 {name=p91960 lab=_79611_/Y }
C {devices/lab_pin.sym} 92840 -28660 0 1 {name=p91961 lab=_79621_/Y }
C {sky130_stdcells/nor2_4.sym} 92780 -28660 0 0 {name=X_79621_ }
C {devices/lab_pin.sym} 92740 -28530 0 0 {name=p91962 lab=_41072_/X }
C {devices/lab_pin.sym} 92820 -28530 0 1 {name=p91963 lab=_41136_/X }
C {sky130_stdcells/buf_2.sym} 92780 -28530 0 0 {name=X_41136_ }
C {devices/lab_pin.sym} 92740 -28410 0 0 {name=p91964 lab=_76811_/Y }
C {devices/lab_pin.sym} 92820 -28410 0 1 {name=p91965 lab=_81364_/D }
C {sky130_stdcells/inv_2.sym} 92780 -28410 0 0 {name=X_76833_ }
C {devices/lab_pin.sym} 92720 -28300 0 0 {name=p91966 lab=_49769_/X }
C {devices/lab_pin.sym} 92720 -28260 0 0 {name=p91967 lab=_52995_/B }
C {devices/lab_pin.sym} 92840 -28280 0 1 {name=p91968 lab=_49781_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -28280 0 0 {name=X_49781_ }
C {devices/lab_pin.sym} 92740 -28150 0 0 {name=p91969 lab=_83049_/Q }
C {devices/lab_pin.sym} 92820 -28150 0 1 {name=p91970 lab=_53309_/B }
C {sky130_stdcells/inv_2.sym} 92780 -28150 0 0 {name=X_46993_ }
C {devices/lab_pin.sym} 92720 -28040 0 0 {name=p91971 lab=_58978_/Y }
C {devices/lab_pin.sym} 92720 -28000 0 0 {name=p91972 lab=_58973_/B }
C {devices/lab_pin.sym} 92840 -28020 0 1 {name=p91973 lab=_58979_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -28020 0 0 {name=X_58979_ }
C {devices/lab_pin.sym} 92740 -27890 0 0 {name=p91974 lab=clkbuf_7_83_0_CLK/X }
C {devices/lab_pin.sym} 92820 -27890 0 1 {name=p91975 lab=clkbuf_8_166_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 92780 -27890 0 0 {name=Xclkbuf_8_166_0_CLK }
C {devices/lab_pin.sym} 92740 -27770 0 0 {name=p91976 lab=clkbuf_9_80_0_CLK/X }
C {devices/lab_pin.sym} 92820 -27770 0 1 {name=p91977 lab=_85003_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 92780 -27770 0 0 {name=Xclkbuf_10_161_0_CLK }
C {devices/lab_pin.sym} 92720 -27660 0 0 {name=p91978 lab=_48737_/A }
C {devices/lab_pin.sym} 92720 -27620 0 0 {name=p91979 lab=_48401_/B }
C {devices/lab_pin.sym} 92840 -27640 0 1 {name=p91980 lab=_48732_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -27640 0 0 {name=X_48732_ }
C {devices/lab_pin.sym} 92720 -27520 0 0 {name=p91981 lab=_79552_/A }
C {devices/lab_pin.sym} 92720 -27480 0 0 {name=p91982 lab=_79553_/A }
C {devices/lab_pin.sym} 92840 -27500 0 1 {name=p91983 lab=_79555_/B }
C {sky130_stdcells/nand2_4.sym} 92780 -27500 0 0 {name=X_79552_ }
C {devices/lab_pin.sym} 92740 -27370 0 0 {name=p91984 lab=_64961_/A }
C {devices/lab_pin.sym} 92820 -27370 0 1 {name=p91985 lab=_60150_/A }
C {sky130_stdcells/buf_2.sym} 92780 -27370 0 0 {name=X_45944_ }
C {devices/lab_pin.sym} 92700 -27280 0 0 {name=p91986 lab=_41064_/X }
C {devices/lab_pin.sym} 92700 -27240 0 0 {name=p91987 lab=_41065_/X }
C {devices/lab_pin.sym} 92700 -27200 0 0 {name=p91988 lab=_88284_/Q }
C {devices/lab_pin.sym} 92700 -27160 0 0 {name=p91989 lab=_41066_/X }
C {devices/lab_pin.sym} 92860 -27220 0 1 {name=p91990 lab=_88284_/D }
C {sky130_stdcells/a2bb2o_4.sym} 92780 -27220 0 0 {name=X_41067_ }
C {devices/lab_pin.sym} 92720 -27080 0 0 {name=p91991 lab=_81582_/Q }
C {devices/lab_pin.sym} 92720 -27040 0 0 {name=p91992 lab=_76764_/B }
C {devices/lab_pin.sym} 92840 -27060 0 1 {name=p91993 lab=_81550_/D }
C {sky130_stdcells/xor2_4.sym} 92780 -27060 0 0 {name=X_76764_ }
C {devices/lab_pin.sym} 92700 -26950 0 0 {name=p91994 lab=_61988_/Y }
C {devices/lab_pin.sym} 92700 -26910 0 0 {name=p91995 lab=_61959_/X }
C {devices/lab_pin.sym} 92700 -26870 0 0 {name=p91996 lab=_61989_/Y }
C {devices/lab_pin.sym} 92860 -26910 0 1 {name=p91997 lab=_61990_/Y }
C {sky130_stdcells/a21oi_4.sym} 92780 -26910 0 0 {name=X_61990_ }
C {devices/lab_pin.sym} 92720 -26780 0 0 {name=p91998 lab=_73954_/A }
C {devices/lab_pin.sym} 92720 -26740 0 0 {name=p91999 lab=_66159_/B }
C {devices/lab_pin.sym} 92840 -26760 0 1 {name=p92000 lab=_73976_/X }
C {sky130_stdcells/and2_4.sym} 92780 -26760 0 0 {name=X_73976_ }
C {devices/lab_pin.sym} 92740 -26630 0 0 {name=p92001 lab=clkbuf_9_395_0_CLK/X }
C {devices/lab_pin.sym} 92820 -26630 0 1 {name=p92002 lab=_81019_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 92780 -26630 0 0 {name=Xclkbuf_10_791_0_CLK }
C {devices/lab_pin.sym} 92720 -26520 0 0 {name=p92003 lab=_78503_/A }
C {devices/lab_pin.sym} 92720 -26480 0 0 {name=p92004 lab=_82672_/D }
C {devices/lab_pin.sym} 92840 -26500 0 1 {name=p92005 lab=_78503_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -26500 0 0 {name=X_78503_ }
C {devices/lab_pin.sym} 92720 -26380 0 0 {name=p92006 lab=_75715_/A }
C {devices/lab_pin.sym} 92720 -26340 0 0 {name=p92007 lab=_75714_/Y }
C {devices/lab_pin.sym} 92840 -26360 0 1 {name=p92008 lab=_75723_/A }
C {sky130_stdcells/xor2_4.sym} 92780 -26360 0 0 {name=X_75715_ }
C {devices/lab_pin.sym} 92740 -26230 0 0 {name=p92009 lab=_60940_/Y }
C {devices/lab_pin.sym} 92820 -26230 0 1 {name=p92010 lab=_61024_/B }
C {sky130_stdcells/inv_2.sym} 92780 -26230 0 0 {name=X_60941_ }
C {devices/lab_pin.sym} 92700 -26130 0 0 {name=p92011 lab=_88333_/Q }
C {devices/lab_pin.sym} 92700 -26090 0 0 {name=p92012 lab=_72803_/X }
C {devices/lab_pin.sym} 92700 -26050 0 0 {name=p92013 lab=_72776_/X }
C {devices/lab_pin.sym} 92860 -26090 0 1 {name=p92014 lab=_72927_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -26090 0 0 {name=X_72927_ }
C {devices/lab_pin.sym} 92740 -25950 0 0 {name=p92015 lab=_81766_/Q }
C {devices/lab_pin.sym} 92820 -25950 0 1 {name=p92016 lab=_48664_/A }
C {sky130_stdcells/inv_2.sym} 92780 -25950 0 0 {name=X_48663_ }
C {devices/lab_pin.sym} 92700 -25870 0 0 {name=p92017 lab=_79449_/A }
C {devices/lab_pin.sym} 92700 -25830 0 0 {name=p92018 lab=_79448_/Y }
C {devices/lab_pin.sym} 92700 -25790 0 0 {name=p92019 lab=_79460_/X }
C {devices/lab_pin.sym} 92700 -25750 0 0 {name=p92020 lab=_79481_/A }
C {devices/lab_pin.sym} 92700 -25710 0 0 {name=p92021 lab=_79480_/Y }
C {devices/lab_pin.sym} 92860 -25790 0 1 {name=p92022 lab=_79483_/X }
C {sky130_stdcells/a2111o_4.sym} 92780 -25790 0 0 {name=X_79483_ }
C {devices/lab_pin.sym} 92740 -25630 0 0 {name=p92023 lab=_45875_/A }
C {devices/lab_pin.sym} 92820 -25630 0 1 {name=p92024 lab=_45876_/A }
C {sky130_stdcells/inv_2.sym} 92780 -25630 0 0 {name=X_45875_ }
C {devices/lab_pin.sym} 92720 -25520 0 0 {name=p92025 lab=_76695_/A }
C {devices/lab_pin.sym} 92720 -25480 0 0 {name=p92026 lab=_81447_/D }
C {devices/lab_pin.sym} 92840 -25500 0 1 {name=p92027 lab=_81543_/D }
C {sky130_stdcells/xor2_4.sym} 92780 -25500 0 0 {name=X_76695_ }
C {devices/lab_pin.sym} 92740 -25370 0 0 {name=p92028 lab=clkbuf_9_283_0_CLK/A }
C {devices/lab_pin.sym} 92820 -25370 0 1 {name=p92029 lab=clkbuf_9_282_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 92780 -25370 0 0 {name=Xclkbuf_9_282_0_CLK }
C {devices/lab_pin.sym} 92740 -25250 0 0 {name=p92030 lab=_47661_/A }
C {devices/lab_pin.sym} 92820 -25250 0 1 {name=p92031 lab=_47614_/X }
C {sky130_stdcells/buf_2.sym} 92780 -25250 0 0 {name=X_47614_ }
C {devices/lab_pin.sym} 92720 -25140 0 0 {name=p92032 lab=_78434_/A }
C {devices/lab_pin.sym} 92720 -25100 0 0 {name=p92033 lab=_78434_/B }
C {devices/lab_pin.sym} 92840 -25120 0 1 {name=p92034 lab=_78439_/C }
C {sky130_stdcells/nand2_4.sym} 92780 -25120 0 0 {name=X_78434_ }
C {devices/lab_pin.sym} 92700 -25020 0 0 {name=p92035 lab=_41680_/Y }
C {devices/lab_pin.sym} 92700 -24980 0 0 {name=p92036 lab=_44817_/X }
C {devices/lab_pin.sym} 92700 -24940 0 0 {name=p92037 lab=_67559_/B }
C {devices/lab_pin.sym} 92700 -24900 0 0 {name=p92038 lab=_44818_/X }
C {devices/lab_pin.sym} 92860 -24960 0 1 {name=p92039 lab=_44826_/X }
C {sky130_stdcells/a2bb2o_4.sym} 92780 -24960 0 0 {name=X_44826_ }
C {devices/lab_pin.sym} 92700 -24840 0 0 {name=p92040 lab=_61627_/B }
C {devices/lab_pin.sym} 92700 -24800 0 0 {name=p92041 lab=_63609_/X }
C {devices/lab_pin.sym} 92700 -24760 0 0 {name=p92042 lab=_63657_/X }
C {devices/lab_pin.sym} 92700 -24720 0 0 {name=p92043 lab=_63659_/X }
C {devices/lab_pin.sym} 92860 -24780 0 1 {name=p92044 lab=_63660_/X }
C {sky130_stdcells/a211o_4.sym} 92780 -24780 0 0 {name=X_63660_ }
C {devices/lab_pin.sym} 92700 -24650 0 0 {name=p92045 lab=_75641_/Y }
C {devices/lab_pin.sym} 92700 -24610 0 0 {name=p92046 lab=_75609_/Y }
C {devices/lab_pin.sym} 92700 -24570 0 0 {name=p92047 lab=_75645_/Y }
C {devices/lab_pin.sym} 92860 -24610 0 1 {name=p92048 lab=_75660_/A }
C {sky130_stdcells/o21ai_4.sym} 92780 -24610 0 0 {name=X_75646_ }
C {devices/lab_pin.sym} 92720 -24480 0 0 {name=p92049 lab=_49212_/A }
C {devices/lab_pin.sym} 92720 -24440 0 0 {name=p92050 lab=_48820_/B }
C {devices/lab_pin.sym} 92840 -24460 0 1 {name=p92051 lab=_48594_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -24460 0 0 {name=X_48594_ }
C {devices/lab_pin.sym} 92740 -24330 0 0 {name=p92052 lab=_60871_/Y }
C {devices/lab_pin.sym} 92820 -24330 0 1 {name=p92053 lab=_61003_/A }
C {sky130_stdcells/buf_2.sym} 92780 -24330 0 0 {name=X_60872_ }
C {devices/lab_pin.sym} 92740 -24210 0 0 {name=p92054 lab=_72857_/X }
C {devices/lab_pin.sym} 92820 -24210 0 1 {name=p92055 lab=_72858_/X }
C {sky130_stdcells/buf_2.sym} 92780 -24210 0 0 {name=X_72858_ }
C {devices/lab_pin.sym} 92740 -24090 0 0 {name=p92056 lab=clkbuf_9_88_0_CLK/X }
C {devices/lab_pin.sym} 92820 -24090 0 1 {name=p92057 lab=_83316_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 92780 -24090 0 0 {name=Xclkbuf_10_176_0_CLK }
C {devices/lab_pin.sym} 92720 -24000 0 0 {name=p92058 lab=_61676_/A }
C {devices/lab_pin.sym} 92720 -23960 0 0 {name=p92059 lab=_62631_/B }
C {devices/lab_pin.sym} 92720 -23920 0 0 {name=p92060 lab=_62259_/X }
C {devices/lab_pin.sym} 92720 -23880 0 0 {name=p92061 lab=_62631_/D }
C {devices/lab_pin.sym} 92840 -23940 0 1 {name=p92062 lab=_62614_/B }
C {sky130_stdcells/nand4_4.sym} 92780 -23940 0 0 {name=X_62611_ }
C {devices/lab_pin.sym} 92720 -23800 0 0 {name=p92063 lab=_47553_/A }
C {devices/lab_pin.sym} 92720 -23760 0 0 {name=p92064 lab=_53109_/B }
C {devices/lab_pin.sym} 92840 -23780 0 1 {name=p92065 lab=_47545_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -23780 0 0 {name=X_47545_ }
C {devices/lab_pin.sym} 92700 -23670 0 0 {name=p92066 lab=_71805_/X }
C {devices/lab_pin.sym} 92700 -23630 0 0 {name=p92067 lab=_83368_/Q }
C {devices/lab_pin.sym} 92700 -23590 0 0 {name=p92068 lab=_71808_/X }
C {devices/lab_pin.sym} 92860 -23630 0 1 {name=p92069 lab=_83368_/D }
C {sky130_stdcells/a21o_4.sym} 92780 -23630 0 0 {name=X_71809_ }
C {devices/lab_pin.sym} 92740 -23490 0 0 {name=p92070 lab=_78365_/A }
C {devices/lab_pin.sym} 92820 -23490 0 1 {name=p92071 lab=_78365_/Y }
C {sky130_stdcells/inv_2.sym} 92780 -23490 0 0 {name=X_78365_ }
C {devices/lab_pin.sym} 92700 -23400 0 0 {name=p92072 lab=_41305_/Y }
C {devices/lab_pin.sym} 92700 -23360 0 0 {name=p92073 lab=_44754_/X }
C {devices/lab_pin.sym} 92700 -23320 0 0 {name=p92074 lab=_86971_/Q }
C {devices/lab_pin.sym} 92700 -23280 0 0 {name=p92075 lab=_44755_/X }
C {devices/lab_pin.sym} 92860 -23340 0 1 {name=p92076 lab=_44757_/X }
C {sky130_stdcells/a2bb2o_4.sym} 92780 -23340 0 0 {name=X_44757_ }
C {devices/lab_pin.sym} 92740 -23190 0 0 {name=p92077 lab=_63468_/A }
C {devices/lab_pin.sym} 92820 -23190 0 1 {name=p92078 lab=_63615_/B }
C {sky130_stdcells/buf_2.sym} 92780 -23190 0 0 {name=X_63591_ }
C {devices/lab_pin.sym} 92740 -23070 0 0 {name=p92079 lab=_80819_/Q }
C {devices/lab_pin.sym} 92820 -23070 0 1 {name=p92080 lab=_75577_/Y }
C {sky130_stdcells/inv_2.sym} 92780 -23070 0 0 {name=X_75577_ }
C {devices/lab_pin.sym} 92740 -22950 0 0 {name=p92081 lab=_88088_/Q }
C {devices/lab_pin.sym} 92820 -22950 0 1 {name=p92082 lab=_41969_/Y }
C {sky130_stdcells/inv_2.sym} 92780 -22950 0 0 {name=X_41969_ }
C {devices/lab_pin.sym} 92720 -22840 0 0 {name=p92083 lab=_48367_/Y }
C {devices/lab_pin.sym} 92720 -22800 0 0 {name=p92084 lab=_72789_/B }
C {devices/lab_pin.sym} 92840 -22820 0 1 {name=p92085 lab=_72789_/X }
C {sky130_stdcells/xor2_4.sym} 92780 -22820 0 0 {name=X_72789_ }
C {devices/lab_pin.sym} 92740 -22690 0 0 {name=p92086 lab=_65673_/A }
C {devices/lab_pin.sym} 92820 -22690 0 1 {name=p92087 lab=_65408_/A }
C {sky130_stdcells/buf_2.sym} 92780 -22690 0 0 {name=X_65330_ }
C {devices/lab_pin.sym} 92720 -22580 0 0 {name=p92088 lab=_77316_/A }
C {devices/lab_pin.sym} 92720 -22540 0 0 {name=p92089 lab=_77316_/B }
C {devices/lab_pin.sym} 92840 -22560 0 1 {name=p92090 lab=_77317_/A }
C {sky130_stdcells/and2_4.sym} 92780 -22560 0 0 {name=X_77316_ }
C {devices/lab_pin.sym} 92700 -22450 0 0 {name=p92091 lab=_62539_/Y }
C {devices/lab_pin.sym} 92700 -22410 0 0 {name=p92092 lab=_62540_/X }
C {devices/lab_pin.sym} 92700 -22370 0 0 {name=p92093 lab=_62541_/Y }
C {devices/lab_pin.sym} 92860 -22410 0 1 {name=p92094 lab=_84403_/D }
C {sky130_stdcells/a21oi_4.sym} 92780 -22410 0 0 {name=X_62542_ }
C {devices/lab_pin.sym} 92740 -22270 0 0 {name=p92095 lab=_43707_/X }
C {devices/lab_pin.sym} 92820 -22270 0 1 {name=p92096 lab=_87301_/D }
C {sky130_stdcells/inv_2.sym} 92780 -22270 0 0 {name=X_43708_ }
C {devices/lab_pin.sym} 92700 -22170 0 0 {name=p92097 lab=_52813_/B }
C {devices/lab_pin.sym} 92700 -22130 0 0 {name=p92098 lab=_74517_/X }
C {devices/lab_pin.sym} 92700 -22090 0 0 {name=p92099 lab=_74527_/Y }
C {devices/lab_pin.sym} 92860 -22130 0 1 {name=p92100 lab=_74528_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -22130 0 0 {name=X_74528_ }
C {devices/lab_pin.sym} 92700 -22010 0 0 {name=p92101 lab=_47471_/Y }
C {devices/lab_pin.sym} 92700 -21970 0 0 {name=p92102 lab=_47462_/X }
C {devices/lab_pin.sym} 92700 -21930 0 0 {name=p92103 lab=_47475_/X }
C {devices/lab_pin.sym} 92860 -21970 0 1 {name=p92104 lab=_86631_/D }
C {sky130_stdcells/a21oi_4.sym} 92780 -21970 0 0 {name=X_47476_ }
C {devices/lab_pin.sym} 92740 -21830 0 0 {name=p92105 lab=clkbuf_9_296_0_CLK/A }
C {devices/lab_pin.sym} 92820 -21830 0 1 {name=p92106 lab=clkbuf_9_297_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 92780 -21830 0 0 {name=Xclkbuf_9_297_0_CLK }
C {devices/lab_pin.sym} 92720 -21720 0 0 {name=p92107 lab=_78296_/A }
C {devices/lab_pin.sym} 92720 -21680 0 0 {name=p92108 lab=_78296_/B }
C {devices/lab_pin.sym} 92840 -21700 0 1 {name=p92109 lab=_78296_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -21700 0 0 {name=X_78296_ }
C {devices/lab_pin.sym} 92740 -21570 0 0 {name=p92110 lab=_44688_/A }
C {devices/lab_pin.sym} 92820 -21570 0 1 {name=p92111 lab=_44688_/Y }
C {sky130_stdcells/inv_2.sym} 92780 -21570 0 0 {name=X_44688_ }
C {devices/lab_pin.sym} 92740 -21450 0 0 {name=p92112 lab=clkbuf_7_52_0_CLK/X }
C {devices/lab_pin.sym} 92820 -21450 0 1 {name=p92113 lab=clkbuf_8_104_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 92780 -21450 0 0 {name=Xclkbuf_8_104_0_CLK }
C {devices/lab_pin.sym} 92740 -21330 0 0 {name=p92114 lab=_49215_/A }
C {devices/lab_pin.sym} 92820 -21330 0 1 {name=p92115 lab=_49220_/A }
C {sky130_stdcells/buf_2.sym} 92780 -21330 0 0 {name=X_49215_ }
C {devices/lab_pin.sym} 92740 -21210 0 0 {name=p92116 lab=_46427_/A }
C {devices/lab_pin.sym} 92820 -21210 0 1 {name=p92117 lab=_50802_/A }
C {sky130_stdcells/buf_2.sym} 92780 -21210 0 0 {name=X_46427_ }
C {devices/lab_pin.sym} 92700 -21120 0 0 {name=p92118 lab=_65211_/X }
C {devices/lab_pin.sym} 92700 -21080 0 0 {name=p92119 lab=_85512_/Q }
C {devices/lab_pin.sym} 92700 -21040 0 0 {name=p92120 lab=_65212_/X }
C {devices/lab_pin.sym} 92700 -21000 0 0 {name=p92121 lab=_65260_/X }
C {devices/lab_pin.sym} 92860 -21060 0 1 {name=p92122 lab=_65261_/X }
C {sky130_stdcells/a211o_4.sym} 92780 -21060 0 0 {name=X_65261_ }
C {devices/lab_pin.sym} 92740 -20910 0 0 {name=p92123 lab=_77246_/X }
C {devices/lab_pin.sym} 92820 -20910 0 1 {name=p92124 lab=_82179_/D }
C {sky130_stdcells/buf_2.sym} 92780 -20910 0 0 {name=X_77247_ }
C {devices/lab_pin.sym} 92700 -20820 0 0 {name=p92125 lab=_40673_/X }
C {devices/lab_pin.sym} 92700 -20780 0 0 {name=p92126 lab=_43624_/X }
C {devices/lab_pin.sym} 92700 -20740 0 0 {name=p92127 lab=_73921_/A }
C {devices/lab_pin.sym} 92700 -20700 0 0 {name=p92128 lab=_43625_/X }
C {devices/lab_pin.sym} 92860 -20760 0 1 {name=p92129 lab=_87332_/D }
C {sky130_stdcells/a2bb2o_4.sym} 92780 -20760 0 0 {name=X_43639_ }
C {devices/lab_pin.sym} 92740 -20610 0 0 {name=p92130 lab=_62203_/Y }
C {devices/lab_pin.sym} 92820 -20610 0 1 {name=p92131 lab=_62533_/A }
C {sky130_stdcells/buf_2.sym} 92780 -20610 0 0 {name=X_62473_ }
C {devices/lab_pin.sym} 92720 -20510 0 0 {name=p92132 lab=_48578_/A }
C {devices/lab_pin.sym} 92720 -20470 0 0 {name=p92133 lab=_74478_/B }
C {devices/lab_pin.sym} 92720 -20430 0 0 {name=p92134 lab=_74478_/C }
C {devices/lab_pin.sym} 92840 -20470 0 1 {name=p92135 lab=_74459_/X }
C {sky130_stdcells/and3_4.sym} 92780 -20470 0 0 {name=X_74459_ }
C {devices/lab_pin.sym} 92700 -20360 0 0 {name=p92136 lab=_87361_/Q }
C {devices/lab_pin.sym} 92700 -20320 0 0 {name=p92137 lab=_66997_/X }
C {devices/lab_pin.sym} 92700 -20280 0 0 {name=p92138 lab=_66998_/X }
C {devices/lab_pin.sym} 92700 -20240 0 0 {name=p92139 lab=_66999_/X }
C {devices/lab_pin.sym} 92860 -20300 0 1 {name=p92140 lab=_67000_/X }
C {sky130_stdcells/a211o_4.sym} 92780 -20300 0 0 {name=X_67000_ }
C {devices/lab_pin.sym} 92700 -20170 0 0 {name=p92141 lab=_63355_/A }
C {devices/lab_pin.sym} 92700 -20130 0 0 {name=p92142 lab=_61226_/X }
C {devices/lab_pin.sym} 92700 -20090 0 0 {name=p92143 lab=_64211_/Y }
C {devices/lab_pin.sym} 92860 -20130 0 1 {name=p92144 lab=_64212_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -20130 0 0 {name=X_64212_ }
C {devices/lab_pin.sym} 92700 -20010 0 0 {name=p92145 lab=_65289_/B }
C {devices/lab_pin.sym} 92700 -19970 0 0 {name=p92146 lab=_49104_/X }
C {devices/lab_pin.sym} 92700 -19930 0 0 {name=p92147 lab=_49145_/Y }
C {devices/lab_pin.sym} 92860 -19970 0 1 {name=p92148 lab=_49146_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -19970 0 0 {name=X_49146_ }
C {devices/lab_pin.sym} 92700 -19870 0 0 {name=p92149 lab=_61417_/Y }
C {devices/lab_pin.sym} 92700 -19830 0 0 {name=p92150 lab=_61420_/Y }
C {devices/lab_pin.sym} 92700 -19790 0 0 {name=p92151 lab=_61403_/X }
C {devices/lab_pin.sym} 92700 -19750 0 0 {name=p92152 lab=_61421_/Y }
C {devices/lab_pin.sym} 92700 -19720 0 0 {name=p92153 lab=_61423_/Y }
C {devices/lab_pin.sym} 92860 -19790 0 1 {name=p92154 lab=_61424_/X }
C {sky130_stdcells/a41o_4.sym} 92780 -19790 0 0 {name=X_61424_ }
C {devices/lab_pin.sym} 92700 -19650 0 0 {name=p92155 lab=_86744_/Q }
C {devices/lab_pin.sym} 92700 -19610 0 0 {name=p92156 lab=_46279_/X }
C {devices/lab_pin.sym} 92700 -19570 0 0 {name=p92157 lab=_46357_/Y }
C {devices/lab_pin.sym} 92860 -19610 0 1 {name=p92158 lab=_46358_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -19610 0 0 {name=X_46358_ }
C {devices/lab_pin.sym} 92720 -19490 0 0 {name=p92159 lab=_65188_/X }
C {devices/lab_pin.sym} 92720 -19450 0 0 {name=p92160 lab=_65192_/B }
C {devices/lab_pin.sym} 92720 -19410 0 0 {name=p92161 lab=_65191_/X }
C {devices/lab_pin.sym} 92840 -19450 0 1 {name=p92162 lab=_65192_/Y }
C {sky130_stdcells/nand3_4.sym} 92780 -19450 0 0 {name=X_65192_ }
C {devices/lab_pin.sym} 92720 -19320 0 0 {name=p92163 lab=_82106_/Q }
C {devices/lab_pin.sym} 92720 -19280 0 0 {name=p92164 lab=_77178_/B }
C {devices/lab_pin.sym} 92840 -19300 0 1 {name=p92165 lab=_77178_/X }
C {sky130_stdcells/xor2_4.sym} 92780 -19300 0 0 {name=X_77178_ }
C {devices/lab_pin.sym} 92740 -19170 0 0 {name=p92166 lab=clkbuf_9_220_0_CLK/A }
C {devices/lab_pin.sym} 92820 -19170 0 1 {name=p92167 lab=clkbuf_9_220_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 92780 -19170 0 0 {name=Xclkbuf_9_220_0_CLK }
C {devices/lab_pin.sym} 92700 -19070 0 0 {name=p92168 lab=_45277_/X }
C {devices/lab_pin.sym} 92700 -19030 0 0 {name=p92169 lab=_61636_/B }
C {devices/lab_pin.sym} 92700 -18990 0 0 {name=p92170 lab=_45294_/X }
C {devices/lab_pin.sym} 92860 -19030 0 1 {name=p92171 lab=_45309_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -19030 0 0 {name=X_45309_ }
C {devices/lab_pin.sym} 92720 -18900 0 0 {name=p92172 lab=_76122_/X }
C {devices/lab_pin.sym} 92720 -18860 0 0 {name=p92173 lab=_76129_/B }
C {devices/lab_pin.sym} 92840 -18880 0 1 {name=p92174 lab=_76130_/B }
C {sky130_stdcells/xor2_4.sym} 92780 -18880 0 0 {name=X_76129_ }
C {devices/lab_pin.sym} 92740 -18750 0 0 {name=p92175 lab=_64026_/A }
C {devices/lab_pin.sym} 92820 -18750 0 1 {name=p92176 lab=_64190_/B }
C {sky130_stdcells/buf_2.sym} 92780 -18750 0 0 {name=X_64143_ }
C {devices/lab_pin.sym} 92720 -18640 0 0 {name=p92177 lab=_49077_/A }
C {devices/lab_pin.sym} 92720 -18600 0 0 {name=p92178 lab=_49029_/B }
C {devices/lab_pin.sym} 92840 -18620 0 1 {name=p92179 lab=_49077_/Y }
C {sky130_stdcells/nor2_4.sym} 92780 -18620 0 0 {name=X_49077_ }
C {devices/lab_pin.sym} 92740 -18490 0 0 {name=p92180 lab=_61355_/A }
C {devices/lab_pin.sym} 92820 -18490 0 1 {name=p92181 lab=_61377_/A }
C {sky130_stdcells/buf_2.sym} 92780 -18490 0 0 {name=X_61355_ }
C {devices/lab_pin.sym} 92700 -18390 0 0 {name=p92182 lab=_46284_/Y }
C {devices/lab_pin.sym} 92700 -18350 0 0 {name=p92183 lab=_46258_/X }
C {devices/lab_pin.sym} 92700 -18310 0 0 {name=p92184 lab=_46288_/Y }
C {devices/lab_pin.sym} 92860 -18350 0 1 {name=p92185 lab=_46289_/Y }
C {sky130_stdcells/a21boi_4.sym} 92780 -18350 0 0 {name=X_46289_ }
C {devices/lab_pin.sym} 92740 -18210 0 0 {name=p92186 lab=clkbuf_7_59_0_CLK/X }
C {devices/lab_pin.sym} 92820 -18210 0 1 {name=p92187 lab=clkbuf_9_239_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 92780 -18210 0 0 {name=Xclkbuf_8_119_0_CLK }
C {devices/lab_pin.sym} 92740 -18090 0 0 {name=p92188 lab=clkbuf_9_57_0_CLK/X }
C {devices/lab_pin.sym} 92820 -18090 0 1 {name=p92189 lab=_84424_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 92780 -18090 0 0 {name=Xclkbuf_10_114_0_CLK }
C {devices/lab_pin.sym} 92720 -17980 0 0 {name=p92190 lab=_47981_/X }
C {devices/lab_pin.sym} 92720 -17940 0 0 {name=p92191 lab=_48028_/B }
C {devices/lab_pin.sym} 92840 -17960 0 1 {name=p92192 lab=_48028_/X }
C {sky130_stdcells/and2_4.sym} 92780 -17960 0 0 {name=X_48028_ }
C {devices/lab_pin.sym} 92700 -17850 0 0 {name=p92193 lab=_60263_/A }
C {devices/lab_pin.sym} 92700 -17810 0 0 {name=p92194 lab=_60367_/C }
C {devices/lab_pin.sym} 92700 -17770 0 0 {name=p92195 lab=_60241_/A }
C {devices/lab_pin.sym} 92860 -17810 0 1 {name=p92196 lab=_60306_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -17810 0 0 {name=X_60306_ }
C {devices/lab_pin.sym} 92700 -17690 0 0 {name=p92197 lab=_68946_/X }
C {devices/lab_pin.sym} 92700 -17650 0 0 {name=p92198 lab=_68950_/X }
C {devices/lab_pin.sym} 92700 -17610 0 0 {name=p92199 lab=_68878_/X }
C {devices/lab_pin.sym} 92860 -17650 0 1 {name=p92200 lab=_68951_/Y }
C {sky130_stdcells/a21oi_4.sym} 92780 -17650 0 0 {name=X_68951_ }
C {devices/lab_pin.sym} 92720 -17530 0 0 {name=p92201 lab=_64074_/A }
C {devices/lab_pin.sym} 92720 -17490 0 0 {name=p92202 lab=_64074_/B }
C {devices/lab_pin.sym} 92720 -17450 0 0 {name=p92203 lab=_80040_/B }
C {devices/lab_pin.sym} 92840 -17490 0 1 {name=p92204 lab=_64074_/Y }
C {sky130_stdcells/nor3_4.sym} 92780 -17490 0 0 {name=X_64074_ }
C {devices/lab_pin.sym} 92740 -17350 0 0 {name=p92205 lab=clkbuf_9_372_0_CLK/X }
C {devices/lab_pin.sym} 92820 -17350 0 1 {name=p92206 lab=_87995_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 92780 -17350 0 0 {name=Xclkbuf_10_744_0_CLK }
C {devices/lab_pin.sym} 92720 -17240 0 0 {name=p92207 lab=_61286_/A }
C {devices/lab_pin.sym} 92720 -17200 0 0 {name=p92208 lab=_61286_/B }
C {devices/lab_pin.sym} 92840 -17220 0 1 {name=p92209 lab=_61287_/D }
C {sky130_stdcells/nor2_4.sym} 92780 -17220 0 0 {name=X_61286_ }
C {devices/lab_pin.sym} 92700 -17120 0 0 {name=p92210 lab=_87963_/Q }
C {devices/lab_pin.sym} 92700 -17080 0 0 {name=p92211 lab=_67831_/X }
C {devices/lab_pin.sym} 92700 -17040 0 0 {name=p92212 lab=_67879_/X }
C {devices/lab_pin.sym} 92700 -17000 0 0 {name=p92213 lab=_67901_/X }
C {devices/lab_pin.sym} 92860 -17060 0 1 {name=p92214 lab=_67902_/X }
C {sky130_stdcells/a211o_4.sym} 92780 -17060 0 0 {name=X_67902_ }
C {devices/lab_pin.sym} 92700 -16950 0 0 {name=p92215 lab=_58412_/A }
C {devices/lab_pin.sym} 92700 -16910 0 0 {name=p92216 lab=_63010_/X }
C {devices/lab_pin.sym} 92700 -16870 0 0 {name=p92217 lab=_60523_/X }
C {devices/lab_pin.sym} 92700 -16830 0 0 {name=p92218 lab=_59456_/Y }
C {devices/lab_pin.sym} 92700 -16790 0 0 {name=p92219 lab=_60412_/X }
C {devices/lab_pin.sym} 92860 -16870 0 1 {name=p92220 lab=_63025_/Y }
C {sky130_stdcells/o32ai_4.sym} 92780 -16870 0 0 {name=X_63025_ }
C {devices/lab_pin.sym} 92720 -16720 0 0 {name=p92221 lab=_60254_/B }
C {devices/lab_pin.sym} 92720 -16680 0 0 {name=p92222 lab=_60255_/B }
C {devices/lab_pin.sym} 92840 -16700 0 1 {name=p92223 lab=_60350_/A }
C {sky130_stdcells/nor2_4.sym} 92780 -16700 0 0 {name=X_60237_ }
C {devices/lab_pin.sym} 92740 -16570 0 0 {name=p92224 lab=_60111_/X }
C {devices/lab_pin.sym} 92820 -16570 0 1 {name=p92225 lab=_68882_/X }
C {sky130_stdcells/buf_2.sym} 92780 -16570 0 0 {name=X_68882_ }
C {devices/lab_pin.sym} 92740 -16450 0 0 {name=p92226 lab=clkbuf_9_235_0_CLK/A }
C {devices/lab_pin.sym} 92820 -16450 0 1 {name=p92227 lab=clkbuf_9_235_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 92780 -16450 0 0 {name=Xclkbuf_9_235_0_CLK }
C {devices/lab_pin.sym} 92720 -16340 0 0 {name=p92228 lab=_79819_/A }
C {devices/lab_pin.sym} 92720 -16300 0 0 {name=p92229 lab=_79818_/Y }
C {devices/lab_pin.sym} 92840 -16320 0 1 {name=p92230 lab=_79829_/B }
C {sky130_stdcells/xor2_4.sym} 92780 -16320 0 0 {name=X_79819_ }
C {devices/lab_pin.sym} 92700 -16220 0 0 {name=p92231 lab=_87902_/Q }
C {devices/lab_pin.sym} 92700 -16180 0 0 {name=p92232 lab=_67831_/X }
C {devices/lab_pin.sym} 92700 -16140 0 0 {name=p92233 lab=_67761_/X }
C {devices/lab_pin.sym} 92700 -16100 0 0 {name=p92234 lab=_67832_/X }
C {devices/lab_pin.sym} 92860 -16160 0 1 {name=p92235 lab=_67833_/X }
C {sky130_stdcells/a211o_4.sym} 92780 -16160 0 0 {name=X_67833_ }
C {devices/lab_pin.sym} 92740 -16010 0 0 {name=p92236 lab=_60168_/A }
C {devices/lab_pin.sym} 92820 -16010 0 1 {name=p92237 lab=_60239_/A }
C {sky130_stdcells/buf_2.sym} 92780 -16010 0 0 {name=X_60168_ }
C {devices/lab_pin.sym} 92740 -15890 0 0 {name=p92238 lab=clkbuf_9_64_0_CLK/X }
C {devices/lab_pin.sym} 92820 -15890 0 1 {name=p92239 lab=_83819_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 92780 -15890 0 0 {name=Xclkbuf_10_129_0_CLK }
C {devices/lab_pin.sym} 92720 -15800 0 0 {name=p92240 lab=_49995_/A }
C {devices/lab_pin.sym} 92720 -15760 0 0 {name=p92241 lab=_49973_/B }
C {devices/lab_pin.sym} 92720 -15720 0 0 {name=p92242 lab=_49973_/C }
C {devices/lab_pin.sym} 92720 -15680 0 0 {name=p92243 lab=_53191_/D }
C {devices/lab_pin.sym} 92840 -15740 0 1 {name=p92244 lab=_49979_/X }
C {sky130_stdcells/and4_4.sym} 92780 -15740 0 0 {name=X_49979_ }
C {devices/lab_pin.sym} 92740 -15590 0 0 {name=p92245 lab=clkbuf_9_379_0_CLK/X }
C {devices/lab_pin.sym} 92820 -15590 0 1 {name=p92246 lab=_88087_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 92780 -15590 0 0 {name=Xclkbuf_10_759_0_CLK }
C {devices/lab_pin.sym} 92690 -15470 0 0 {name=p92247 lab=_82425_/CLK }
C {devices/lab_pin.sym} 92690 -15450 0 0 {name=p92248 lab=_82830_/D }
C {devices/lab_pin.sym} 92870 -15470 0 1 {name=p92249 lab=_82830_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -15460 0 0 {name=X_82830_ }
C {devices/lab_pin.sym} 92720 -15340 0 0 {name=p92250 lab=_67739_/X }
C {devices/lab_pin.sym} 92720 -15300 0 0 {name=p92251 lab=_87201_/Q }
C {devices/lab_pin.sym} 92840 -15320 0 1 {name=p92252 lab=_67764_/X }
C {sky130_stdcells/and2_4.sym} 92780 -15320 0 0 {name=X_67764_ }
C {devices/lab_pin.sym} 92720 -15200 0 0 {name=p92253 lab=_58785_/A }
C {devices/lab_pin.sym} 92720 -15160 0 0 {name=p92254 lab=_86035_/Q }
C {devices/lab_pin.sym} 92840 -15180 0 1 {name=p92255 lab=_64976_/X }
C {sky130_stdcells/and2_4.sym} 92780 -15180 0 0 {name=X_64976_ }
C {devices/lab_pin.sym} 92700 -15070 0 0 {name=p92256 lab=_52987_/Y }
C {devices/lab_pin.sym} 92700 -15030 0 0 {name=p92257 lab=_52975_/X }
C {devices/lab_pin.sym} 92700 -14990 0 0 {name=p92258 lab=_52989_/X }
C {devices/lab_pin.sym} 92860 -15030 0 1 {name=p92259 lab=_52990_/Y }
C {sky130_stdcells/a21oi_4.sym} 92780 -15030 0 0 {name=X_52990_ }
C {devices/lab_pin.sym} 92720 -14910 0 0 {name=p92260 lab=_60042_/D }
C {devices/lab_pin.sym} 92720 -14870 0 0 {name=p92261 lab=_59951_/B }
C {devices/lab_pin.sym} 92720 -14830 0 0 {name=p92262 lab=_60087_/Y }
C {devices/lab_pin.sym} 92840 -14870 0 1 {name=p92263 lab=_60099_/X }
C {sky130_stdcells/and3_4.sym} 92780 -14870 0 0 {name=X_60099_ }
C {devices/lab_pin.sym} 92700 -14750 0 0 {name=p92264 lab=_81383_/D }
C {devices/lab_pin.sym} 92700 -14710 0 0 {name=p92265 lab=_69439_/X }
C {devices/lab_pin.sym} 92700 -14670 0 0 {name=p92266 lab=_69502_/X }
C {devices/lab_pin.sym} 92860 -14710 0 1 {name=p92267 lab=_83919_/D }
C {sky130_stdcells/a21bo_4.sym} 92780 -14710 0 0 {name=X_69503_ }
C {devices/lab_pin.sym} 92740 -14570 0 0 {name=p92268 lab=_69457_/A }
C {devices/lab_pin.sym} 92820 -14570 0 1 {name=p92269 lab=_66715_/X }
C {sky130_stdcells/buf_2.sym} 92780 -14570 0 0 {name=X_66715_ }
C {devices/lab_pin.sym} 92720 -14460 0 0 {name=p92270 lab=_51941_/A }
C {devices/lab_pin.sym} 92720 -14420 0 0 {name=p92271 lab=_50234_/B }
C {devices/lab_pin.sym} 92840 -14440 0 1 {name=p92272 lab=_51941_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -14440 0 0 {name=X_51941_ }
C {devices/lab_pin.sym} 92700 -14350 0 0 {name=p92273 lab=_63922_/X }
C {devices/lab_pin.sym} 92700 -14310 0 0 {name=p92274 lab=_63890_/X }
C {devices/lab_pin.sym} 92700 -14270 0 0 {name=p92275 lab=_63923_/Y }
C {devices/lab_pin.sym} 92700 -14230 0 0 {name=p92276 lab=_63924_/Y }
C {devices/lab_pin.sym} 92700 -14200 0 0 {name=p92277 lab=_63926_/X }
C {devices/lab_pin.sym} 92860 -14270 0 1 {name=p92278 lab=_63927_/X }
C {sky130_stdcells/a41o_4.sym} 92780 -14270 0 0 {name=X_63927_ }
C {devices/lab_pin.sym} 92690 -14110 0 0 {name=p92279 lab=_82774_/CLK }
C {devices/lab_pin.sym} 92690 -14090 0 0 {name=p92280 lab=_82761_/D }
C {devices/lab_pin.sym} 92870 -14110 0 1 {name=p92281 lab=_82953_/D }
C {sky130_stdcells/dfxtp_4.sym} 92780 -14100 0 0 {name=X_82761_ }
C {devices/lab_pin.sym} 92700 -13990 0 0 {name=p92282 lab=_67692_/X }
C {devices/lab_pin.sym} 92700 -13950 0 0 {name=p92283 lab=_67694_/X }
C {devices/lab_pin.sym} 92700 -13910 0 0 {name=p92284 lab=_67619_/X }
C {devices/lab_pin.sym} 92860 -13950 0 1 {name=p92285 lab=_67698_/A }
C {sky130_stdcells/a21o_4.sym} 92780 -13950 0 0 {name=X_67695_ }
C {devices/lab_pin.sym} 92690 -13810 0 0 {name=p92286 lab=_84501_/CLK }
C {devices/lab_pin.sym} 92690 -13790 0 0 {name=p92287 lab=_61242_/Y }
C {devices/lab_pin.sym} 92870 -13810 0 1 {name=p92288 lab=_75902_/A }
C {sky130_stdcells/dfxtp_4.sym} 92780 -13800 0 0 {name=X_84500_ }
C {devices/lab_pin.sym} 92690 -13670 0 0 {name=p92289 lab=_81749_/CLK }
C {devices/lab_pin.sym} 92690 -13650 0 0 {name=p92290 lab=_81712_/D }
C {devices/lab_pin.sym} 92870 -13670 0 1 {name=p92291 lab=_81712_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -13660 0 0 {name=X_81712_ }
C {devices/lab_pin.sym} 92700 -13550 0 0 {name=p92292 lab=_69429_/X }
C {devices/lab_pin.sym} 92700 -13510 0 0 {name=p92293 lab=_69432_/X }
C {devices/lab_pin.sym} 92700 -13470 0 0 {name=p92294 lab=_69433_/X }
C {devices/lab_pin.sym} 92860 -13510 0 1 {name=p92295 lab=_69434_/Y }
C {sky130_stdcells/a21oi_4.sym} 92780 -13510 0 0 {name=X_69434_ }
C {devices/lab_pin.sym} 92720 -13380 0 0 {name=p92296 lab=_54649_/X }
C {devices/lab_pin.sym} 92720 -13340 0 0 {name=p92297 lab=_47297_/Y }
C {devices/lab_pin.sym} 92840 -13360 0 1 {name=p92298 lab=_54660_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -13360 0 0 {name=X_54660_ }
C {devices/lab_pin.sym} 92700 -13250 0 0 {name=p92299 lab=_66641_/X }
C {devices/lab_pin.sym} 92700 -13210 0 0 {name=p92300 lab=_66645_/X }
C {devices/lab_pin.sym} 92700 -13170 0 0 {name=p92301 lab=_66547_/X }
C {devices/lab_pin.sym} 92860 -13210 0 1 {name=p92302 lab=_66646_/X }
C {sky130_stdcells/a21o_4.sym} 92780 -13210 0 0 {name=X_66646_ }
C {devices/lab_pin.sym} 92690 -13070 0 0 {name=p92303 lab=_84926_/CLK }
C {devices/lab_pin.sym} 92690 -13050 0 0 {name=p92304 lab=_54233_/Y }
C {devices/lab_pin.sym} 92870 -13070 0 1 {name=p92305 lab=_85480_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -13060 0 0 {name=X_85480_ }
C {devices/lab_pin.sym} 92740 -12930 0 0 {name=p92306 lab=_48808_/A }
C {devices/lab_pin.sym} 92820 -12930 0 1 {name=p92307 lab=_51900_/A }
C {sky130_stdcells/buf_2.sym} 92780 -12930 0 0 {name=X_51872_ }
C {devices/lab_pin.sym} 92720 -12840 0 0 {name=p92308 lab=_58248_/A }
C {devices/lab_pin.sym} 92720 -12800 0 0 {name=p92309 lab=_63858_/B }
C {devices/lab_pin.sym} 92720 -12760 0 0 {name=p92310 lab=_63858_/C }
C {devices/lab_pin.sym} 92720 -12720 0 0 {name=p92311 lab=_63793_/D }
C {devices/lab_pin.sym} 92840 -12780 0 1 {name=p92312 lab=_63859_/D }
C {sky130_stdcells/nand4_4.sym} 92780 -12780 0 0 {name=X_63858_ }
C {devices/lab_pin.sym} 92690 -12630 0 0 {name=p92313 lab=_82692_/CLK }
C {devices/lab_pin.sym} 92690 -12610 0 0 {name=p92314 lab=_78831_/X }
C {devices/lab_pin.sym} 92870 -12630 0 1 {name=p92315 lab=_82692_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -12620 0 0 {name=X_82692_ }
C {devices/lab_pin.sym} 92740 -12490 0 0 {name=p92316 lab=_53723_/A }
C {devices/lab_pin.sym} 92820 -12490 0 1 {name=p92317 lab=_53611_/X }
C {sky130_stdcells/buf_2.sym} 92780 -12490 0 0 {name=X_53611_ }
C {devices/lab_pin.sym} 92690 -12370 0 0 {name=p92318 lab=_84430_/CLK }
C {devices/lab_pin.sym} 92690 -12350 0 0 {name=p92319 lab=_84431_/D }
C {devices/lab_pin.sym} 92870 -12370 0 1 {name=p92320 lab=_78054_/B }
C {sky130_stdcells/dfxtp_4.sym} 92780 -12360 0 0 {name=X_84431_ }
C {devices/lab_pin.sym} 92700 -12250 0 0 {name=p92321 lab=_86126_/Q }
C {devices/lab_pin.sym} 92700 -12210 0 0 {name=p92322 lab=_50820_/X }
C {devices/lab_pin.sym} 92700 -12170 0 0 {name=p92323 lab=_50822_/Y }
C {devices/lab_pin.sym} 92860 -12210 0 1 {name=p92324 lab=_50823_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -12210 0 0 {name=X_50823_ }
C {devices/lab_pin.sym} 92720 -12100 0 0 {name=p92325 lab=_62819_/A }
C {devices/lab_pin.sym} 92720 -12060 0 0 {name=p92326 lab=_84828_/Q }
C {devices/lab_pin.sym} 92720 -12020 0 0 {name=p92327 lab=_62819_/C }
C {devices/lab_pin.sym} 92720 -11980 0 0 {name=p92328 lab=_62782_/X }
C {devices/lab_pin.sym} 92840 -12040 0 1 {name=p92329 lab=_62809_/X }
C {sky130_stdcells/and4_4.sym} 92780 -12040 0 0 {name=X_62809_ }
C {devices/lab_pin.sym} 92690 -11890 0 0 {name=p92330 lab=_81660_/CLK }
C {devices/lab_pin.sym} 92690 -11870 0 0 {name=p92331 lab=_76874_/A }
C {devices/lab_pin.sym} 92870 -11890 0 1 {name=p92332 lab=_81643_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -11880 0 0 {name=X_81643_ }
C {devices/lab_pin.sym} 92700 -11780 0 0 {name=p92333 lab=_69329_/X }
C {devices/lab_pin.sym} 92700 -11740 0 0 {name=p92334 lab=_68777_/Y }
C {devices/lab_pin.sym} 92700 -11700 0 0 {name=p92335 lab=_69325_/X }
C {devices/lab_pin.sym} 92700 -11660 0 0 {name=p92336 lab=_69364_/Y }
C {devices/lab_pin.sym} 92860 -11720 0 1 {name=p92337 lab=_69365_/X }
C {sky130_stdcells/a211o_4.sym} 92780 -11720 0 0 {name=X_69365_ }
C {devices/lab_pin.sym} 92720 -11600 0 0 {name=p92338 lab=_54589_/X }
C {devices/lab_pin.sym} 92720 -11560 0 0 {name=p92339 lab=_54585_/B }
C {devices/lab_pin.sym} 92720 -11520 0 0 {name=p92340 lab=_54591_/C }
C {devices/lab_pin.sym} 92720 -11480 0 0 {name=p92341 lab=_47180_/A }
C {devices/lab_pin.sym} 92840 -11540 0 1 {name=p92342 lab=_54591_/X }
C {sky130_stdcells/and4_4.sym} 92780 -11540 0 0 {name=X_54591_ }
C {devices/lab_pin.sym} 92720 -11400 0 0 {name=p92343 lab=_69223_/A }
C {devices/lab_pin.sym} 92720 -11360 0 0 {name=p92344 lab=_66577_/B }
C {devices/lab_pin.sym} 92840 -11380 0 1 {name=p92345 lab=_66577_/X }
C {sky130_stdcells/and2_4.sym} 92780 -11380 0 0 {name=X_66577_ }
C {devices/lab_pin.sym} 92720 -11280 0 0 {name=p92346 lab=_63396_/B }
C {devices/lab_pin.sym} 92720 -11240 0 0 {name=p92347 lab=_63820_/B }
C {devices/lab_pin.sym} 92720 -11200 0 0 {name=p92348 lab=_63753_/C }
C {devices/lab_pin.sym} 92720 -11160 0 0 {name=p92349 lab=_63820_/D }
C {devices/lab_pin.sym} 92840 -11220 0 1 {name=p92350 lab=_63789_/Y }
C {sky130_stdcells/nand4_4.sym} 92780 -11220 0 0 {name=X_63789_ }
C {devices/lab_pin.sym} 92720 -11090 0 0 {name=p92351 lab=_56332_/A }
C {devices/lab_pin.sym} 92720 -11050 0 0 {name=p92352 lab=_56335_/B }
C {devices/lab_pin.sym} 92720 -11010 0 0 {name=p92353 lab=_85233_/Q }
C {devices/lab_pin.sym} 92840 -11050 0 1 {name=p92354 lab=_56330_/Y }
C {sky130_stdcells/nand3_4.sym} 92780 -11050 0 0 {name=X_56330_ }
C {devices/lab_pin.sym} 92700 -10940 0 0 {name=p92355 lab=_68301_/X }
C {devices/lab_pin.sym} 92700 -10900 0 0 {name=p92356 lab=_67934_/Y }
C {devices/lab_pin.sym} 92700 -10860 0 0 {name=p92357 lab=_68308_/X }
C {devices/lab_pin.sym} 92700 -10820 0 0 {name=p92358 lab=_68315_/Y }
C {devices/lab_pin.sym} 92860 -10880 0 1 {name=p92359 lab=_68316_/X }
C {sky130_stdcells/a211o_4.sym} 92780 -10880 0 0 {name=X_68316_ }
C {devices/lab_pin.sym} 92690 -10730 0 0 {name=p92360 lab=_87150_/CLK }
C {devices/lab_pin.sym} 92690 -10710 0 0 {name=p92361 lab=_44357_/X }
C {devices/lab_pin.sym} 92870 -10730 0 1 {name=p92362 lab=_87150_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -10720 0 0 {name=X_87150_ }
C {devices/lab_pin.sym} 92720 -10600 0 0 {name=p92363 lab=_53548_/A }
C {devices/lab_pin.sym} 92720 -10560 0 0 {name=p92364 lab=_48014_/Y }
C {devices/lab_pin.sym} 92840 -10580 0 1 {name=p92365 lab=_53542_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -10580 0 0 {name=X_53542_ }
C {devices/lab_pin.sym} 92700 -10470 0 0 {name=p92366 lab=_65516_/X }
C {devices/lab_pin.sym} 92700 -10430 0 0 {name=p92367 lab=_64775_/Y }
C {devices/lab_pin.sym} 92700 -10390 0 0 {name=p92368 lab=_65527_/Y }
C {devices/lab_pin.sym} 92860 -10430 0 1 {name=p92369 lab=_65528_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -10430 0 0 {name=X_65528_ }
C {devices/lab_pin.sym} 92690 -10290 0 0 {name=p92370 lab=_83216_/CLK }
C {devices/lab_pin.sym} 92690 -10270 0 0 {name=p92371 lab=_84362_/D }
C {devices/lab_pin.sym} 92870 -10290 0 1 {name=p92372 lab=_62995_/C }
C {sky130_stdcells/dfxtp_4.sym} 92780 -10280 0 0 {name=X_84362_ }
C {devices/lab_pin.sym} 92700 -10170 0 0 {name=p92373 lab=_86140_/Q }
C {devices/lab_pin.sym} 92700 -10130 0 0 {name=p92374 lab=_50727_/X }
C {devices/lab_pin.sym} 92700 -10090 0 0 {name=p92375 lab=_50753_/Y }
C {devices/lab_pin.sym} 92860 -10130 0 1 {name=p92376 lab=_50754_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -10130 0 0 {name=X_50754_ }
C {devices/lab_pin.sym} 92690 -9990 0 0 {name=p92377 lab=_81412_/CLK }
C {devices/lab_pin.sym} 92690 -9970 0 0 {name=p92378 lab=_84174_/Q }
C {devices/lab_pin.sym} 92870 -9990 0 1 {name=p92379 lab=_76689_/A }
C {sky130_stdcells/dfxtp_4.sym} 92780 -9980 0 0 {name=X_81574_ }
C {devices/lab_pin.sym} 92700 -9870 0 0 {name=p92380 lab=_68656_/X }
C {devices/lab_pin.sym} 92700 -9830 0 0 {name=p92381 lab=_68659_/X }
C {devices/lab_pin.sym} 92700 -9790 0 0 {name=p92382 lab=_69295_/X }
C {devices/lab_pin.sym} 92860 -9830 0 1 {name=p92383 lab=_69296_/Y }
C {sky130_stdcells/a21oi_4.sym} 92780 -9830 0 0 {name=X_69296_ }
C {devices/lab_pin.sym} 92690 -9690 0 0 {name=p92384 lab=_86104_/CLK }
C {devices/lab_pin.sym} 92690 -9670 0 0 {name=p92385 lab=_86101_/D }
C {devices/lab_pin.sym} 92870 -9690 0 1 {name=p92386 lab=_86101_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -9680 0 0 {name=X_86101_ }
C {devices/lab_pin.sym} 92690 -9550 0 0 {name=p92387 lab=_83313_/CLK }
C {devices/lab_pin.sym} 92690 -9530 0 0 {name=p92388 lab=_71961_/Y }
C {devices/lab_pin.sym} 92870 -9550 0 1 {name=p92389 lab=_83313_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -9540 0 0 {name=X_83313_ }
C {devices/lab_pin.sym} 92720 -9430 0 0 {name=p92390 lab=_56263_/A }
C {devices/lab_pin.sym} 92720 -9390 0 0 {name=p92391 lab=_56263_/B }
C {devices/lab_pin.sym} 92720 -9350 0 0 {name=p92392 lab=_85255_/Q }
C {devices/lab_pin.sym} 92840 -9390 0 1 {name=p92393 lab=_56261_/Y }
C {sky130_stdcells/nand3_4.sym} 92780 -9390 0 0 {name=X_56261_ }
C {devices/lab_pin.sym} 92720 -9260 0 0 {name=p92394 lab=_84768_/Q }
C {devices/lab_pin.sym} 92720 -9220 0 0 {name=p92395 lab=_84160_/Q }
C {devices/lab_pin.sym} 92840 -9240 0 1 {name=p92396 lab=_80525_/X }
C {sky130_stdcells/xor2_4.sym} 92780 -9240 0 0 {name=X_80525_ }
C {devices/lab_pin.sym} 92740 -9110 0 0 {name=p92397 lab=_68168_/A }
C {devices/lab_pin.sym} 92820 -9110 0 1 {name=p92398 lab=_68247_/X }
C {sky130_stdcells/buf_2.sym} 92780 -9110 0 0 {name=X_68247_ }
C {devices/lab_pin.sym} 92690 -8990 0 0 {name=p92399 lab=_87086_/CLK }
C {devices/lab_pin.sym} 92690 -8970 0 0 {name=p92400 lab=_87081_/D }
C {devices/lab_pin.sym} 92870 -8990 0 1 {name=p92401 lab=_87081_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -8980 0 0 {name=X_87081_ }
C {devices/lab_pin.sym} 92740 -8850 0 0 {name=p92402 lab=_50724_/A }
C {devices/lab_pin.sym} 92820 -8850 0 1 {name=p92403 lab=_53474_/B }
C {sky130_stdcells/buf_2.sym} 92780 -8850 0 0 {name=X_53473_ }
C {devices/lab_pin.sym} 92720 -8740 0 0 {name=p92404 lab=_65408_/A }
C {devices/lab_pin.sym} 92720 -8700 0 0 {name=p92405 lab=_72817_/B }
C {devices/lab_pin.sym} 92840 -8720 0 1 {name=p92406 lab=_65459_/X }
C {sky130_stdcells/and2_4.sym} 92780 -8720 0 0 {name=X_65459_ }
C {devices/lab_pin.sym} 92690 -8590 0 0 {name=p92407 lab=_84293_/CLK }
C {devices/lab_pin.sym} 92690 -8570 0 0 {name=p92408 lab=_84293_/D }
C {devices/lab_pin.sym} 92870 -8590 0 1 {name=p92409 lab=_80206_/B }
C {sky130_stdcells/dfxtp_4.sym} 92780 -8580 0 0 {name=X_84293_ }
C {devices/lab_pin.sym} 92700 -8470 0 0 {name=p92410 lab=_50683_/Y }
C {devices/lab_pin.sym} 92700 -8430 0 0 {name=p92411 lab=_50644_/X }
C {devices/lab_pin.sym} 92700 -8390 0 0 {name=p92412 lab=_50684_/Y }
C {devices/lab_pin.sym} 92860 -8430 0 1 {name=p92413 lab=_50685_/Y }
C {sky130_stdcells/a21boi_4.sym} 92780 -8430 0 0 {name=X_50685_ }
C {devices/lab_pin.sym} 92700 -8310 0 0 {name=p92414 lab=_57947_/X }
C {devices/lab_pin.sym} 92700 -8270 0 0 {name=p92415 lab=_85709_/Q }
C {devices/lab_pin.sym} 92700 -8230 0 0 {name=p92416 lab=_57948_/X }
C {devices/lab_pin.sym} 92860 -8270 0 1 {name=p92417 lab=_58000_/X }
C {sky130_stdcells/o21a_4.sym} 92780 -8270 0 0 {name=X_58000_ }
C {devices/lab_pin.sym} 92700 -8160 0 0 {name=p92418 lab=_85090_/Q }
C {devices/lab_pin.sym} 92700 -8120 0 0 {name=p92419 lab=_55152_/A }
C {devices/lab_pin.sym} 92700 -8080 0 0 {name=p92420 lab=_55133_/X }
C {devices/lab_pin.sym} 92700 -8040 0 0 {name=p92421 lab=_55211_/X }
C {devices/lab_pin.sym} 92860 -8100 0 1 {name=p92422 lab=_55212_/X }
C {sky130_stdcells/a211o_4.sym} 92780 -8100 0 0 {name=X_55212_ }
C {devices/lab_pin.sym} 92690 -7950 0 0 {name=p92423 lab=_86030_/CLK }
C {devices/lab_pin.sym} 92690 -7930 0 0 {name=p92424 lab=_86032_/D }
C {devices/lab_pin.sym} 92870 -7950 0 1 {name=p92425 lab=_65051_/B }
C {sky130_stdcells/dfxtp_4.sym} 92780 -7940 0 0 {name=X_86032_ }
C {devices/lab_pin.sym} 92720 -7820 0 0 {name=p92426 lab=_52448_/A }
C {devices/lab_pin.sym} 92720 -7780 0 0 {name=p92427 lab=_51235_/B }
C {devices/lab_pin.sym} 92840 -7800 0 1 {name=p92428 lab=_52424_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -7800 0 0 {name=X_52424_ }
C {devices/lab_pin.sym} 92690 -7670 0 0 {name=p92429 lab=_84555_/CLK }
C {devices/lab_pin.sym} 92690 -7650 0 0 {name=p92430 lab=_72497_/X }
C {devices/lab_pin.sym} 92870 -7670 0 1 {name=p92431 lab=_62055_/B }
C {sky130_stdcells/dfxtp_4.sym} 92780 -7660 0 0 {name=X_83244_ }
C {devices/lab_pin.sym} 92720 -7540 0 0 {name=p92432 lab=_80456_/A }
C {devices/lab_pin.sym} 92720 -7500 0 0 {name=p92433 lab=_80456_/B }
C {devices/lab_pin.sym} 92840 -7520 0 1 {name=p92434 lab=_80456_/Y }
C {sky130_stdcells/xnor2_4.sym} 92780 -7520 0 0 {name=X_80456_ }
C {devices/lab_pin.sym} 92720 -7410 0 0 {name=p92435 lab=_56280_/A }
C {devices/lab_pin.sym} 92720 -7370 0 0 {name=p92436 lab=_56192_/B }
C {devices/lab_pin.sym} 92720 -7330 0 0 {name=p92437 lab=_56192_/C }
C {devices/lab_pin.sym} 92840 -7370 0 1 {name=p92438 lab=_56192_/Y }
C {sky130_stdcells/nand3_4.sym} 92780 -7370 0 0 {name=X_56192_ }
C {devices/lab_pin.sym} 92700 -7260 0 0 {name=p92439 lab=_68144_/X }
C {devices/lab_pin.sym} 92700 -7220 0 0 {name=p92440 lab=_67102_/Y }
C {devices/lab_pin.sym} 92700 -7180 0 0 {name=p92441 lab=_68168_/X }
C {devices/lab_pin.sym} 92700 -7140 0 0 {name=p92442 lab=_68177_/Y }
C {devices/lab_pin.sym} 92860 -7200 0 1 {name=p92443 lab=_68178_/X }
C {sky130_stdcells/a211o_4.sym} 92780 -7200 0 0 {name=X_68178_ }
C {devices/lab_pin.sym} 92740 -7050 0 0 {name=p92444 lab=_55278_/A }
C {devices/lab_pin.sym} 92820 -7050 0 1 {name=p92445 lab=_55145_/A }
C {sky130_stdcells/buf_2.sym} 92780 -7050 0 0 {name=X_55143_ }
C {devices/lab_pin.sym} 92700 -6960 0 0 {name=p92446 lab=_87112_/Q }
C {devices/lab_pin.sym} 92700 -6920 0 0 {name=p92447 lab=_67074_/X }
C {devices/lab_pin.sym} 92700 -6880 0 0 {name=p92448 lab=_67075_/X }
C {devices/lab_pin.sym} 92700 -6840 0 0 {name=p92449 lab=_67128_/X }
C {devices/lab_pin.sym} 92860 -6900 0 1 {name=p92450 lab=_67129_/X }
C {sky130_stdcells/a211o_4.sym} 92780 -6900 0 0 {name=X_67129_ }
C {devices/lab_pin.sym} 92720 -6770 0 0 {name=p92451 lab=_52355_/A }
C {devices/lab_pin.sym} 92720 -6730 0 0 {name=p92452 lab=_52310_/B }
C {devices/lab_pin.sym} 92720 -6690 0 0 {name=p92453 lab=_52291_/C }
C {devices/lab_pin.sym} 92840 -6730 0 1 {name=p92454 lab=_52355_/X }
C {sky130_stdcells/and3_4.sym} 92780 -6730 0 0 {name=X_52355_ }
C {devices/lab_pin.sym} 92690 -6590 0 0 {name=p92455 lab=_83161_/CLK }
C {devices/lab_pin.sym} 92690 -6570 0 0 {name=p92456 lab=_83175_/D }
C {devices/lab_pin.sym} 92870 -6590 0 1 {name=p92457 lab=_83175_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -6580 0 0 {name=X_83175_ }
C {devices/lab_pin.sym} 92720 -6460 0 0 {name=p92458 lab=_80404_/B }
C {devices/lab_pin.sym} 92720 -6420 0 0 {name=p92459 lab=_80386_/Y }
C {devices/lab_pin.sym} 92840 -6440 0 1 {name=p92460 lab=_80387_/X }
C {sky130_stdcells/xor2_4.sym} 92780 -6440 0 0 {name=X_80387_ }
C {devices/lab_pin.sym} 92740 -6310 0 0 {name=p92461 lab=_51282_/A }
C {devices/lab_pin.sym} 92820 -6310 0 1 {name=p92462 lab=_51306_/X }
C {sky130_stdcells/buf_2.sym} 92780 -6310 0 0 {name=X_51306_ }
C {devices/lab_pin.sym} 92700 -6220 0 0 {name=p92463 lab=_83518_/Q }
C {devices/lab_pin.sym} 92700 -6180 0 0 {name=p92464 lab=_83166_/Q }
C {devices/lab_pin.sym} 92700 -6140 0 0 {name=p92465 lab=_83515_/Q }
C {devices/lab_pin.sym} 92700 -6100 0 0 {name=p92466 lab=_83163_/Q }
C {devices/lab_pin.sym} 92860 -6160 0 1 {name=p92467 lab=_70144_/A }
C {sky130_stdcells/a22oi_4.sym} 92780 -6160 0 0 {name=X_70140_ }
C {devices/lab_pin.sym} 92690 -6010 0 0 {name=p92468 lab=_83906_/CLK }
C {devices/lab_pin.sym} 92690 -5990 0 0 {name=p92469 lab=_77843_/X }
C {devices/lab_pin.sym} 92870 -6010 0 1 {name=p92470 lab=_82082_/D }
C {sky130_stdcells/dfxtp_4.sym} 92780 -6000 0 0 {name=X_82126_ }
C {devices/lab_pin.sym} 92720 -5880 0 0 {name=p92471 lab=_55093_/A }
C {devices/lab_pin.sym} 92720 -5840 0 0 {name=p92472 lab=_54907_/B }
C {devices/lab_pin.sym} 92840 -5860 0 1 {name=p92473 lab=_55074_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -5860 0 0 {name=X_55074_ }
C {devices/lab_pin.sym} 92720 -5760 0 0 {name=p92474 lab=_60042_/D }
C {devices/lab_pin.sym} 92720 -5720 0 0 {name=p92475 lab=_59951_/B }
C {devices/lab_pin.sym} 92720 -5680 0 0 {name=p92476 lab=_59951_/C }
C {devices/lab_pin.sym} 92720 -5640 0 0 {name=p92477 lab=_59951_/D }
C {devices/lab_pin.sym} 92840 -5700 0 1 {name=p92478 lab=_59951_/Y }
C {sky130_stdcells/nand4_4.sym} 92780 -5700 0 0 {name=X_59951_ }
C {devices/lab_pin.sym} 92700 -5570 0 0 {name=p92479 lab=_52284_/Y }
C {devices/lab_pin.sym} 92700 -5530 0 0 {name=p92480 lab=_52262_/X }
C {devices/lab_pin.sym} 92700 -5490 0 0 {name=p92481 lab=_52285_/X }
C {devices/lab_pin.sym} 92860 -5530 0 1 {name=p92482 lab=_85853_/D }
C {sky130_stdcells/a21oi_4.sym} 92780 -5530 0 0 {name=X_52286_ }
C {devices/lab_pin.sym} 92690 -5390 0 0 {name=p92483 lab=_87471_/CLK }
C {devices/lab_pin.sym} 92690 -5370 0 0 {name=p92484 lab=_87983_/D }
C {devices/lab_pin.sym} 92870 -5390 0 1 {name=p92485 lab=_87983_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -5380 0 0 {name=X_87983_ }
C {devices/lab_pin.sym} 92700 -5270 0 0 {name=p92486 lab=_58835_/X }
C {devices/lab_pin.sym} 92700 -5230 0 0 {name=p92487 lab=_85447_/Q }
C {devices/lab_pin.sym} 92700 -5190 0 0 {name=p92488 lab=_58901_/X }
C {devices/lab_pin.sym} 92860 -5230 0 1 {name=p92489 lab=_58902_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -5230 0 0 {name=X_58902_ }
C {devices/lab_pin.sym} 92700 -5110 0 0 {name=p92490 lab=_85520_/Q }
C {devices/lab_pin.sym} 92700 -5070 0 0 {name=p92491 lab=_53940_/X }
C {devices/lab_pin.sym} 92700 -5030 0 0 {name=p92492 lab=_54024_/Y }
C {devices/lab_pin.sym} 92860 -5070 0 1 {name=p92493 lab=_54025_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -5070 0 0 {name=X_54025_ }
C {devices/lab_pin.sym} 92740 -4930 0 0 {name=p92494 lab=_51263_/A }
C {devices/lab_pin.sym} 92820 -4930 0 1 {name=p92495 lab=_51237_/X }
C {sky130_stdcells/buf_2.sym} 92780 -4930 0 0 {name=X_51237_ }
C {devices/lab_pin.sym} 92690 -4810 0 0 {name=p92496 lab=_86934_/CLK }
C {devices/lab_pin.sym} 92690 -4790 0 0 {name=p92497 lab=_44826_/X }
C {devices/lab_pin.sym} 92870 -4810 0 1 {name=p92498 lab=_67559_/B }
C {sky130_stdcells/dfxtp_4.sym} 92780 -4800 0 0 {name=X_86934_ }
C {devices/lab_pin.sym} 92690 -4670 0 0 {name=p92499 lab=_84014_/CLK }
C {devices/lab_pin.sym} 92690 -4650 0 0 {name=p92500 lab=_82057_/D }
C {devices/lab_pin.sym} 92870 -4670 0 1 {name=p92501 lab=_77787_/A }
C {sky130_stdcells/dfxtp_4.sym} 92780 -4660 0 0 {name=X_82057_ }
C {devices/lab_pin.sym} 92700 -4550 0 0 {name=p92502 lab=_68961_/X }
C {devices/lab_pin.sym} 92700 -4510 0 0 {name=p92503 lab=_68963_/X }
C {devices/lab_pin.sym} 92700 -4470 0 0 {name=p92504 lab=_70044_/X }
C {devices/lab_pin.sym} 92860 -4510 0 1 {name=p92505 lab=_70071_/Y }
C {sky130_stdcells/a21oi_4.sym} 92780 -4510 0 0 {name=X_70071_ }
C {devices/lab_pin.sym} 92720 -4390 0 0 {name=p92506 lab=_59741_/A }
C {devices/lab_pin.sym} 92720 -4350 0 0 {name=p92507 lab=_59544_/B }
C {devices/lab_pin.sym} 92720 -4310 0 0 {name=p92508 lab=_59581_/C }
C {devices/lab_pin.sym} 92840 -4350 0 1 {name=p92509 lab=_59882_/X }
C {sky130_stdcells/and3_4.sym} 92780 -4350 0 0 {name=X_59882_ }
C {devices/lab_pin.sym} 92690 -4210 0 0 {name=p92510 lab=_84228_/CLK }
C {devices/lab_pin.sym} 92690 -4190 0 0 {name=p92511 lab=_84216_/Q }
C {devices/lab_pin.sym} 92870 -4210 0 1 {name=p92512 lab=_81008_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -4200 0 0 {name=X_81008_ }
C {devices/lab_pin.sym} 92700 -4110 0 0 {name=p92513 lab=_58828_/X }
C {devices/lab_pin.sym} 92700 -4070 0 0 {name=p92514 lab=_58830_/Y }
C {devices/lab_pin.sym} 92700 -4030 0 0 {name=p92515 lab=_58831_/Y }
C {devices/lab_pin.sym} 92700 -3990 0 0 {name=p92516 lab=_58728_/X }
C {devices/lab_pin.sym} 92700 -3950 0 0 {name=p92517 lab=_58832_/X }
C {devices/lab_pin.sym} 92860 -4030 0 1 {name=p92518 lab=_58833_/X }
C {sky130_stdcells/o32a_4.sym} 92780 -4030 0 0 {name=X_58833_ }
C {devices/lab_pin.sym} 92700 -3890 0 0 {name=p92519 lab=_86061_/Q }
C {devices/lab_pin.sym} 92700 -3850 0 0 {name=p92520 lab=_51156_/X }
C {devices/lab_pin.sym} 92700 -3810 0 0 {name=p92521 lab=_51167_/Y }
C {devices/lab_pin.sym} 92860 -3850 0 1 {name=p92522 lab=_51168_/Y }
C {sky130_stdcells/o21ai_4.sym} 92780 -3850 0 0 {name=X_51168_ }
C {devices/lab_pin.sym} 92690 -3710 0 0 {name=p92523 lab=_84408_/CLK }
C {devices/lab_pin.sym} 92690 -3690 0 0 {name=p92524 lab=_86865_/D }
C {devices/lab_pin.sym} 92870 -3710 0 1 {name=p92525 lab=_63168_/B }
C {sky130_stdcells/dfxtp_4.sym} 92780 -3700 0 0 {name=X_86865_ }
C {devices/lab_pin.sym} 92700 -3590 0 0 {name=p92526 lab=_50116_/Y }
C {devices/lab_pin.sym} 92700 -3550 0 0 {name=p92527 lab=_50117_/X }
C {devices/lab_pin.sym} 92700 -3510 0 0 {name=p92528 lab=_50118_/X }
C {devices/lab_pin.sym} 92860 -3550 0 1 {name=p92529 lab=_86261_/D }
C {sky130_stdcells/a21oi_4.sym} 92780 -3550 0 0 {name=X_50119_ }
C {devices/lab_pin.sym} 92720 -3420 0 0 {name=p92530 lab=_73829_/X }
C {devices/lab_pin.sym} 92720 -3380 0 0 {name=p92531 lab=_73830_/B }
C {devices/lab_pin.sym} 92840 -3400 0 1 {name=p92532 lab=_73830_/X }
C {sky130_stdcells/and2_4.sym} 92780 -3400 0 0 {name=X_73830_ }
C {devices/lab_pin.sym} 92690 -3270 0 0 {name=p92533 lab=_85529_/CLK }
C {devices/lab_pin.sym} 92690 -3250 0 0 {name=p92534 lab=_52469_/Y }
C {devices/lab_pin.sym} 92870 -3270 0 1 {name=p92535 lab=_85816_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -3260 0 0 {name=X_85816_ }
C {devices/lab_pin.sym} 92720 -3140 0 0 {name=p92536 lab=_86706_/Q }
C {devices/lab_pin.sym} 92720 -3100 0 0 {name=p92537 lab=_58764_/B }
C {devices/lab_pin.sym} 92840 -3120 0 1 {name=p92538 lab=_58764_/Y }
C {sky130_stdcells/nor2_4.sym} 92780 -3120 0 0 {name=X_58764_ }
C {devices/lab_pin.sym} 92740 -2990 0 0 {name=p92539 lab=_86842_/Q }
C {devices/lab_pin.sym} 92820 -2990 0 1 {name=p92540 lab=_43990_/Y }
C {sky130_stdcells/inv_2.sym} 92780 -2990 0 0 {name=X_43990_ }
C {devices/lab_pin.sym} 92720 -2900 0 0 {name=p92541 lab=_51084_/A }
C {devices/lab_pin.sym} 92720 -2860 0 0 {name=p92542 lab=_51115_/B }
C {devices/lab_pin.sym} 92720 -2820 0 0 {name=p92543 lab=_51110_/C }
C {devices/lab_pin.sym} 92720 -2780 0 0 {name=p92544 lab=_52790_/D }
C {devices/lab_pin.sym} 92840 -2840 0 1 {name=p92545 lab=_51099_/X }
C {sky130_stdcells/and4_4.sym} 92780 -2840 0 0 {name=X_51099_ }
C {devices/lab_pin.sym} 92720 -2700 0 0 {name=p92546 lab=_55695_/A }
C {devices/lab_pin.sym} 92720 -2660 0 0 {name=p92547 lab=_55976_/B }
C {devices/lab_pin.sym} 92840 -2680 0 1 {name=p92548 lab=_55976_/X }
C {sky130_stdcells/and2_4.sym} 92780 -2680 0 0 {name=X_55976_ }
C {devices/lab_pin.sym} 92690 -2550 0 0 {name=p92549 lab=_86796_/CLK }
C {devices/lab_pin.sym} 92690 -2530 0 0 {name=p92550 lab=_86796_/D }
C {devices/lab_pin.sym} 92870 -2550 0 1 {name=p92551 lab=_66819_/B }
C {sky130_stdcells/dfxtp_4.sym} 92780 -2540 0 0 {name=X_86796_ }
C {devices/lab_pin.sym} 92740 -2410 0 0 {name=p92552 lab=_64850_/A }
C {devices/lab_pin.sym} 92820 -2410 0 1 {name=p92553 lab=_57716_/A }
C {sky130_stdcells/buf_2.sym} 92780 -2410 0 0 {name=X_57715_ }
C {devices/lab_pin.sym} 92740 -2290 0 0 {name=p92554 lab=_42940_/Y }
C {devices/lab_pin.sym} 92820 -2290 0 1 {name=p92555 lab=_42941_/Y }
C {sky130_stdcells/inv_2.sym} 92780 -2290 0 0 {name=X_42941_ }
C {devices/lab_pin.sym} 92740 -2170 0 0 {name=p92556 lab=_54927_/A }
C {devices/lab_pin.sym} 92820 -2170 0 1 {name=p92557 lab=_54942_/B }
C {sky130_stdcells/buf_2.sym} 92780 -2170 0 0 {name=X_54927_ }
C {devices/lab_pin.sym} 92690 -2050 0 0 {name=p92558 lab=_85748_/CLK }
C {devices/lab_pin.sym} 92690 -2030 0 0 {name=p92559 lab=_52832_/Y }
C {devices/lab_pin.sym} 92870 -2050 0 1 {name=p92560 lab=_85747_/Q }
C {sky130_stdcells/dfxtp_4.sym} 92780 -2040 0 0 {name=X_85747_ }
C {devices/lab_pin.sym} 92700 -1930 0 0 {name=p92561 lab=_73758_/X }
C {devices/lab_pin.sym} 92700 -1890 0 0 {name=p92562 lab=_73760_/X }
C {devices/lab_pin.sym} 92700 -1850 0 0 {name=p92563 lab=_73738_/X }
C {devices/lab_pin.sym} 92860 -1890 0 1 {name=p92564 lab=_73764_/A }
C {sky130_stdcells/a21o_4.sym} 92780 -1890 0 0 {name=X_73761_ }
C {devices/lab_pin.sym} 92700 -1770 0 0 {name=p92565 lab=_49265_/B }
C {devices/lab_pin.sym} 92700 -1730 0 0 {name=p92566 lab=_70961_/X }
C {devices/lab_pin.sym} 92700 -1690 0 0 {name=p92567 lab=_70972_/Y }
C {devices/lab_pin.sym} 92860 -1730 0 1 {name=p92568 lab=_83645_/D }
C {sky130_stdcells/o21ai_4.sym} 92780 -1730 0 0 {name=X_70973_ }
C {devices/lab_pin.sym} 92700 -1620 0 0 {name=p92569 lab=_84807_/Q }
C {devices/lab_pin.sym} 92700 -1580 0 0 {name=p92570 lab=_58599_/X }
C {devices/lab_pin.sym} 92700 -1540 0 0 {name=p92571 lab=_58689_/X }
C {devices/lab_pin.sym} 92700 -1500 0 0 {name=p92572 lab=_58694_/X }
C {devices/lab_pin.sym} 92860 -1560 0 1 {name=p92573 lab=_58695_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 92780 -1560 0 0 {name=X_58695_ }
C {devices/lab_pin.sym} 92690 -1410 0 0 {name=p92574 lab=_82769_/CLK }
C {devices/lab_pin.sym} 92690 -1390 0 0 {name=p92575 lab=_82767_/Q }
C {devices/lab_pin.sym} 92870 -1410 0 1 {name=p92576 lab=_46790_/A }
C {sky130_stdcells/dfxtp_4.sym} 92780 -1400 0 0 {name=X_82959_ }
C {devices/lab_pin.sym} 92700 -1290 0 0 {name=p92577 lab=_75477_/A }
C {devices/lab_pin.sym} 92700 -1250 0 0 {name=p92578 lab=_75477_/B }
C {devices/lab_pin.sym} 92700 -1210 0 0 {name=p92579 lab=_75475_/Y }
C {devices/lab_pin.sym} 92860 -1250 0 1 {name=p92580 lab=_75500_/X }
C {sky130_stdcells/o21a_4.sym} 92780 -1250 0 0 {name=X_75500_ }
C {devices/lab_pin.sym} 92720 -1140 0 0 {name=p92581 lab=_72710_/A }
C {devices/lab_pin.sym} 92720 -1100 0 0 {name=p92582 lab=_44907_/A }
C {devices/lab_pin.sym} 92720 -1060 0 0 {name=p92583 lab=_72712_/C }
C {devices/lab_pin.sym} 92720 -1020 0 0 {name=p92584 lab=_55209_/X }
C {devices/lab_pin.sym} 92840 -1080 0 1 {name=p92585 lab=_72712_/X }
C {sky130_stdcells/and4_4.sym} 92780 -1080 0 0 {name=X_72712_ }
C {devices/lab_pin.sym} 92720 -940 0 0 {name=p92586 lab=_56989_/B }
C {devices/lab_pin.sym} 92720 -900 0 0 {name=p92587 lab=_45793_/B }
C {devices/lab_pin.sym} 92840 -920 0 1 {name=p92588 lab=_45660_/Y }
C {sky130_stdcells/nor2_4.sym} 92780 -920 0 0 {name=X_45660_ }
C {devices/lab_pin.sym} 92720 -800 0 0 {name=p92589 lab=_71972_/A }
C {devices/lab_pin.sym} 92720 -760 0 0 {name=p92590 lab=_48153_/A }
C {devices/lab_pin.sym} 92840 -780 0 1 {name=p92591 lab=_57646_/Y }
C {sky130_stdcells/nand2_4.sym} 92780 -780 0 0 {name=X_57646_ }
C {devices/lab_pin.sym} 93640 -42160 0 0 {name=p92592 lab=_76478_/X }
C {devices/lab_pin.sym} 93640 -42120 0 0 {name=p92593 lab=_76513_/C }
C {devices/lab_pin.sym} 93760 -42140 0 1 {name=p92594 lab=_76481_/A }
C {sky130_stdcells/and2_4.sym} 93700 -42140 0 0 {name=X_76480_ }
C {devices/lab_pin.sym} 93620 -42040 0 0 {name=p92595 lab=_41586_/X }
C {devices/lab_pin.sym} 93620 -42000 0 0 {name=p92596 lab=_42866_/X }
C {devices/lab_pin.sym} 93620 -41960 0 0 {name=p92597 lab=_87675_/Q }
C {devices/lab_pin.sym} 93620 -41920 0 0 {name=p92598 lab=_42867_/X }
C {devices/lab_pin.sym} 93780 -41980 0 1 {name=p92599 lab=_87675_/D }
C {sky130_stdcells/a2bb2o_4.sym} 93700 -41980 0 0 {name=X_42872_ }
C {devices/lab_pin.sym} 93620 -41850 0 0 {name=p92600 lab=_54855_/Y }
C {devices/lab_pin.sym} 93620 -41810 0 0 {name=p92601 lab=_54856_/X }
C {devices/lab_pin.sym} 93620 -41770 0 0 {name=p92602 lab=_54857_/X }
C {devices/lab_pin.sym} 93780 -41810 0 1 {name=p92603 lab=_54858_/Y }
C {sky130_stdcells/a21oi_4.sym} 93700 -41810 0 0 {name=X_54858_ }
C {devices/lab_pin.sym} 93640 -41680 0 0 {name=p92604 lab=_73692_/A }
C {devices/lab_pin.sym} 93640 -41640 0 0 {name=p92605 lab=_73692_/B }
C {devices/lab_pin.sym} 93760 -41660 0 1 {name=p92606 lab=_73692_/X }
C {sky130_stdcells/xor2_4.sym} 93700 -41660 0 0 {name=X_73692_ }
C {devices/lab_pin.sym} 93610 -41530 0 0 {name=p92607 lab=_84802_/CLK }
C {devices/lab_pin.sym} 93610 -41510 0 0 {name=p92608 lab=_85678_/D }
C {devices/lab_pin.sym} 93790 -41530 0 1 {name=p92609 lab=_85678_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -41520 0 0 {name=X_85678_ }
C {devices/lab_pin.sym} 93620 -41420 0 0 {name=p92610 lab=_40964_/A }
C {devices/lab_pin.sym} 93620 -41380 0 0 {name=p92611 lab=_44602_/X }
C {devices/lab_pin.sym} 93620 -41340 0 0 {name=p92612 lab=_87034_/Q }
C {devices/lab_pin.sym} 93620 -41300 0 0 {name=p92613 lab=_44603_/X }
C {devices/lab_pin.sym} 93780 -41360 0 1 {name=p92614 lab=_87034_/D }
C {sky130_stdcells/a2bb2o_4.sym} 93700 -41360 0 0 {name=X_44611_ }
C {devices/lab_pin.sym} 93620 -41230 0 0 {name=p92615 lab=_75427_/X }
C {devices/lab_pin.sym} 93620 -41190 0 0 {name=p92616 lab=_75432_/C }
C {devices/lab_pin.sym} 93620 -41150 0 0 {name=p92617 lab=_75430_/Y }
C {devices/lab_pin.sym} 93780 -41190 0 1 {name=p92618 lab=_75431_/X }
C {sky130_stdcells/a21o_4.sym} 93700 -41190 0 0 {name=X_75431_ }
C {devices/lab_pin.sym} 93610 -41050 0 0 {name=p92619 lab=_87417_/CLK }
C {devices/lab_pin.sym} 93610 -41030 0 0 {name=p92620 lab=_43444_/Y }
C {devices/lab_pin.sym} 93790 -41050 0 1 {name=p92621 lab=_87417_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -41040 0 0 {name=X_87417_ }
C {devices/lab_pin.sym} 93620 -40930 0 0 {name=p92622 lab=_85564_/Q }
C {devices/lab_pin.sym} 93620 -40890 0 0 {name=p92623 lab=_53784_/X }
C {devices/lab_pin.sym} 93620 -40850 0 0 {name=p92624 lab=_53808_/Y }
C {devices/lab_pin.sym} 93780 -40890 0 1 {name=p92625 lab=_53809_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -40890 0 0 {name=X_53809_ }
C {devices/lab_pin.sym} 93660 -40750 0 0 {name=p92626 lab=_41822_/Y }
C {devices/lab_pin.sym} 93740 -40750 0 1 {name=p92627 lab=_88135_/D }
C {sky130_stdcells/inv_2.sym} 93700 -40750 0 0 {name=X_41823_ }
C {devices/lab_pin.sym} 93640 -40650 0 0 {name=p92628 lab=_72633_/X }
C {devices/lab_pin.sym} 93640 -40610 0 0 {name=p92629 lab=_72643_/B }
C {devices/lab_pin.sym} 93640 -40570 0 0 {name=p92630 lab=_72643_/C }
C {devices/lab_pin.sym} 93760 -40610 0 1 {name=p92631 lab=_72643_/Y }
C {sky130_stdcells/nand3_4.sym} 93700 -40610 0 0 {name=X_72643_ }
C {devices/lab_pin.sym} 93610 -40470 0 0 {name=p92632 lab=_84590_/CLK }
C {devices/lab_pin.sym} 93610 -40450 0 0 {name=p92633 lab=_60338_/X }
C {devices/lab_pin.sym} 93790 -40470 0 1 {name=p92634 lab=_79671_/A }
C {sky130_stdcells/dfxtp_4.sym} 93700 -40460 0 0 {name=X_84629_ }
C {devices/lab_pin.sym} 93660 -40330 0 0 {name=p92635 lab=_45668_/A }
C {devices/lab_pin.sym} 93740 -40330 0 1 {name=p92636 lab=_45591_/X }
C {sky130_stdcells/buf_2.sym} 93700 -40330 0 0 {name=X_45591_ }
C {devices/lab_pin.sym} 93620 -40230 0 0 {name=p92637 lab=_57575_/Y }
C {devices/lab_pin.sym} 93620 -40190 0 0 {name=p92638 lab=_57543_/X }
C {devices/lab_pin.sym} 93620 -40150 0 0 {name=p92639 lab=_57576_/Y }
C {devices/lab_pin.sym} 93780 -40190 0 1 {name=p92640 lab=_57577_/Y }
C {sky130_stdcells/a21boi_4.sym} 93700 -40190 0 0 {name=X_57577_ }
C {devices/lab_pin.sym} 93610 -40050 0 0 {name=p92641 lab=_86834_/CLK }
C {devices/lab_pin.sym} 93610 -40030 0 0 {name=p92642 lab=_88397_/D }
C {devices/lab_pin.sym} 93790 -40050 0 1 {name=p92643 lab=_88397_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -40040 0 0 {name=X_88397_ }
C {devices/lab_pin.sym} 93620 -39930 0 0 {name=p92644 lab=_54787_/Y }
C {devices/lab_pin.sym} 93620 -39890 0 0 {name=p92645 lab=_54774_/X }
C {devices/lab_pin.sym} 93620 -39850 0 0 {name=p92646 lab=_54788_/X }
C {devices/lab_pin.sym} 93780 -39890 0 1 {name=p92647 lab=_54789_/Y }
C {sky130_stdcells/a21oi_4.sym} 93700 -39890 0 0 {name=X_54789_ }
C {devices/lab_pin.sym} 93640 -39780 0 0 {name=p92648 lab=_47330_/A }
C {devices/lab_pin.sym} 93640 -39740 0 0 {name=p92649 lab=_47349_/B }
C {devices/lab_pin.sym} 93640 -39700 0 0 {name=p92650 lab=_47370_/C }
C {devices/lab_pin.sym} 93640 -39660 0 0 {name=p92651 lab=_52989_/D }
C {devices/lab_pin.sym} 93760 -39720 0 1 {name=p92652 lab=_47330_/X }
C {sky130_stdcells/and4_4.sym} 93700 -39720 0 0 {name=X_47330_ }
C {devices/lab_pin.sym} 93640 -39580 0 0 {name=p92653 lab=_59256_/A }
C {devices/lab_pin.sym} 93640 -39540 0 0 {name=p92654 lab=_86343_/Q }
C {devices/lab_pin.sym} 93760 -39560 0 1 {name=p92655 lab=_59316_/Y }
C {sky130_stdcells/nor2_4.sym} 93700 -39560 0 0 {name=X_59316_ }
C {devices/lab_pin.sym} 93620 -39450 0 0 {name=p92656 lab=_78141_/Y }
C {devices/lab_pin.sym} 93620 -39410 0 0 {name=p92657 lab=_78148_/Y }
C {devices/lab_pin.sym} 93620 -39370 0 0 {name=p92658 lab=_78149_/Y }
C {devices/lab_pin.sym} 93780 -39410 0 1 {name=p92659 lab=_78150_/X }
C {sky130_stdcells/o21a_4.sym} 93700 -39410 0 0 {name=X_78150_ }
C {devices/lab_pin.sym} 93660 -39270 0 0 {name=p92660 lab=_44542_/A }
C {devices/lab_pin.sym} 93740 -39270 0 1 {name=p92661 lab=_44542_/Y }
C {sky130_stdcells/inv_2.sym} 93700 -39270 0 0 {name=X_44542_ }
C {devices/lab_pin.sym} 93660 -39150 0 0 {name=p92662 lab=_56528_/A }
C {devices/lab_pin.sym} 93740 -39150 0 1 {name=p92663 lab=_56528_/X }
C {sky130_stdcells/buf_2.sym} 93700 -39150 0 0 {name=X_56528_ }
C {devices/lab_pin.sym} 93640 -39040 0 0 {name=p92664 lab=_75362_/A }
C {devices/lab_pin.sym} 93640 -39000 0 0 {name=p92665 lab=_75362_/B }
C {devices/lab_pin.sym} 93760 -39020 0 1 {name=p92666 lab=_75362_/X }
C {sky130_stdcells/xor2_4.sym} 93700 -39020 0 0 {name=X_75362_ }
C {devices/lab_pin.sym} 93660 -38890 0 0 {name=p92667 lab=_41825_/A }
C {devices/lab_pin.sym} 93740 -38890 0 1 {name=p92668 lab=_41754_/X }
C {sky130_stdcells/buf_2.sym} 93700 -38890 0 0 {name=X_41754_ }
C {devices/lab_pin.sym} 93610 -38770 0 0 {name=p92669 lab=_87348_/CLK }
C {devices/lab_pin.sym} 93610 -38750 0 0 {name=p92670 lab=_87348_/D }
C {devices/lab_pin.sym} 93790 -38770 0 1 {name=p92671 lab=_87348_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -38760 0 0 {name=X_87348_ }
C {devices/lab_pin.sym} 93620 -38670 0 0 {name=p92672 lab=_72517_/B }
C {devices/lab_pin.sym} 93620 -38630 0 0 {name=p92673 lab=_72546_/Y }
C {devices/lab_pin.sym} 93620 -38590 0 0 {name=p92674 lab=_72572_/X }
C {devices/lab_pin.sym} 93620 -38550 0 0 {name=p92675 lab=_72537_/Y }
C {devices/lab_pin.sym} 93620 -38520 0 0 {name=p92676 lab=_72573_/Y }
C {devices/lab_pin.sym} 93780 -38590 0 1 {name=p92677 lab=_72574_/Y }
C {sky130_stdcells/a41oi_4.sym} 93700 -38590 0 0 {name=X_72574_ }
C {devices/lab_pin.sym} 93640 -38440 0 0 {name=p92678 lab=_77097_/Y }
C {devices/lab_pin.sym} 93640 -38400 0 0 {name=p92679 lab=_77100_/X }
C {devices/lab_pin.sym} 93760 -38420 0 1 {name=p92680 lab=_77113_/A }
C {sky130_stdcells/nand2_4.sym} 93700 -38420 0 0 {name=X_77101_ }
C {devices/lab_pin.sym} 93620 -38310 0 0 {name=p92681 lab=_83102_/Q }
C {devices/lab_pin.sym} 93620 -38270 0 0 {name=p92682 lab=_74301_/X }
C {devices/lab_pin.sym} 93620 -38230 0 0 {name=p92683 lab=_74312_/Y }
C {devices/lab_pin.sym} 93780 -38270 0 1 {name=p92684 lab=_83102_/D }
C {sky130_stdcells/a21bo_4.sym} 93700 -38270 0 0 {name=X_74313_ }
C {devices/lab_pin.sym} 93640 -38140 0 0 {name=p92685 lab=_40705_/A }
C {devices/lab_pin.sym} 93640 -38100 0 0 {name=p92686 lab=_40760_/B }
C {devices/lab_pin.sym} 93760 -38120 0 1 {name=p92687 lab=_40705_/X }
C {sky130_stdcells/or2_4.sym} 93700 -38120 0 0 {name=X_40705_ }
C {devices/lab_pin.sym} 93640 -38000 0 0 {name=p92688 lab=_47241_/X }
C {devices/lab_pin.sym} 93640 -37960 0 0 {name=p92689 lab=_52944_/B }
C {devices/lab_pin.sym} 93760 -37980 0 1 {name=p92690 lab=_47261_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -37980 0 0 {name=X_47261_ }
C {devices/lab_pin.sym} 93620 -37870 0 0 {name=p92691 lab=_59135_/X }
C {devices/lab_pin.sym} 93620 -37830 0 0 {name=p92692 lab=_85645_/Q }
C {devices/lab_pin.sym} 93620 -37790 0 0 {name=p92693 lab=_59196_/X }
C {devices/lab_pin.sym} 93780 -37830 0 1 {name=p92694 lab=_59247_/X }
C {sky130_stdcells/o21a_4.sym} 93700 -37830 0 0 {name=X_59247_ }
C {devices/lab_pin.sym} 93640 -37700 0 0 {name=p92695 lab=_71525_/A }
C {devices/lab_pin.sym} 93640 -37660 0 0 {name=p92696 lab=_70727_/A }
C {devices/lab_pin.sym} 93760 -37680 0 1 {name=p92697 lab=_71525_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -37680 0 0 {name=X_71525_ }
C {devices/lab_pin.sym} 93640 -37560 0 0 {name=p92698 lab=_78083_/A }
C {devices/lab_pin.sym} 93640 -37520 0 0 {name=p92699 lab=_78083_/B }
C {devices/lab_pin.sym} 93760 -37540 0 1 {name=p92700 lab=_78082_/B }
C {sky130_stdcells/xor2_4.sym} 93700 -37540 0 0 {name=X_78081_ }
C {devices/lab_pin.sym} 93640 -37420 0 0 {name=p92701 lab=_56459_/A }
C {devices/lab_pin.sym} 93640 -37380 0 0 {name=p92702 lab=_56458_/Y }
C {devices/lab_pin.sym} 93760 -37400 0 1 {name=p92703 lab=_56459_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -37400 0 0 {name=X_56459_ }
C {devices/lab_pin.sym} 93620 -37300 0 0 {name=p92704 lab=_41178_/Y }
C {devices/lab_pin.sym} 93620 -37260 0 0 {name=p92705 lab=_44464_/X }
C {devices/lab_pin.sym} 93620 -37220 0 0 {name=p92706 lab=_87090_/Q }
C {devices/lab_pin.sym} 93620 -37180 0 0 {name=p92707 lab=_44466_/X }
C {devices/lab_pin.sym} 93780 -37240 0 1 {name=p92708 lab=_44473_/X }
C {sky130_stdcells/a2bb2o_4.sym} 93700 -37240 0 0 {name=X_44473_ }
C {devices/lab_pin.sym} 93640 -37100 0 0 {name=p92709 lab=_75291_/X }
C {devices/lab_pin.sym} 93640 -37060 0 0 {name=p92710 lab=_75292_/Y }
C {devices/lab_pin.sym} 93760 -37080 0 1 {name=p92711 lab=_75293_/X }
C {sky130_stdcells/and2_4.sym} 93700 -37080 0 0 {name=X_75293_ }
C {devices/lab_pin.sym} 93610 -36950 0 0 {name=p92712 lab=_88056_/CLK }
C {devices/lab_pin.sym} 93610 -36930 0 0 {name=p92713 lab=_43762_/Y }
C {devices/lab_pin.sym} 93790 -36950 0 1 {name=p92714 lab=_87279_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -36940 0 0 {name=X_87279_ }
C {devices/lab_pin.sym} 93620 -36840 0 0 {name=p92715 lab=_41681_/X }
C {devices/lab_pin.sym} 93620 -36800 0 0 {name=p92716 lab=_41682_/X }
C {devices/lab_pin.sym} 93620 -36760 0 0 {name=p92717 lab=_67563_/B }
C {devices/lab_pin.sym} 93620 -36720 0 0 {name=p92718 lab=_41684_/X }
C {devices/lab_pin.sym} 93780 -36780 0 1 {name=p92719 lab=_88170_/D }
C {sky130_stdcells/a2bb2o_4.sym} 93700 -36780 0 0 {name=X_41685_ }
C {devices/lab_pin.sym} 93620 -36650 0 0 {name=p92720 lab=_48994_/Y }
C {devices/lab_pin.sym} 93620 -36610 0 0 {name=p92721 lab=_48985_/X }
C {devices/lab_pin.sym} 93620 -36570 0 0 {name=p92722 lab=_48999_/X }
C {devices/lab_pin.sym} 93780 -36610 0 1 {name=p92723 lab=_49000_/Y }
C {sky130_stdcells/a21oi_4.sym} 93700 -36610 0 0 {name=X_49000_ }
C {devices/lab_pin.sym} 93660 -36470 0 0 {name=p92724 lab=_46212_/A }
C {devices/lab_pin.sym} 93740 -36470 0 1 {name=p92725 lab=_59325_/A }
C {sky130_stdcells/buf_2.sym} 93700 -36470 0 0 {name=X_46212_ }
C {sky130_stdcells/decap_3.sym} 93700 -36320 0 0 {name=XPHY_240 }
C {devices/lab_pin.sym} 93640 -36180 0 0 {name=p92726 lab=_77034_/C }
C {devices/lab_pin.sym} 93640 -36140 0 0 {name=p92727 lab=_77031_/Y }
C {devices/lab_pin.sym} 93760 -36160 0 1 {name=p92728 lab=_77033_/B }
C {sky130_stdcells/xnor2_4.sym} 93700 -36160 0 0 {name=X_77032_ }
C {devices/lab_pin.sym} 93660 -36030 0 0 {name=p92729 lab=_43424_/A }
C {devices/lab_pin.sym} 93740 -36030 0 1 {name=p92730 lab=_87428_/D }
C {sky130_stdcells/inv_2.sym} 93700 -36030 0 0 {name=X_43424_ }
C {devices/lab_pin.sym} 93640 -35920 0 0 {name=p92731 lab=_87829_/Q }
C {devices/lab_pin.sym} 93640 -35880 0 0 {name=p92732 lab=_74244_/B }
C {devices/lab_pin.sym} 93760 -35900 0 1 {name=p92733 lab=_74244_/Y }
C {sky130_stdcells/nor2_4.sym} 93700 -35900 0 0 {name=X_74244_ }
C {sky130_stdcells/decap_3.sym} 93700 -35740 0 0 {name=XPHY_251 }
C {devices/lab_pin.sym} 93660 -35590 0 0 {name=p92734 lab=_40636_/A }
C {devices/lab_pin.sym} 93740 -35590 0 1 {name=p92735 lab=_40637_/A }
C {sky130_stdcells/buf_2.sym} 93700 -35590 0 0 {name=X_40636_ }
C {devices/lab_pin.sym} 93660 -35470 0 0 {name=p92736 lab=_47004_/A }
C {devices/lab_pin.sym} 93740 -35470 0 1 {name=p92737 lab=_47192_/X }
C {sky130_stdcells/buf_2.sym} 93700 -35470 0 0 {name=X_47192_ }
C {devices/lab_pin.sym} 93620 -35370 0 0 {name=p92738 lab=_59073_/X }
C {devices/lab_pin.sym} 93620 -35330 0 0 {name=p92739 lab=_85747_/Q }
C {devices/lab_pin.sym} 93620 -35290 0 0 {name=p92740 lab=_59124_/X }
C {devices/lab_pin.sym} 93780 -35330 0 1 {name=p92741 lab=_59178_/X }
C {sky130_stdcells/o21a_4.sym} 93700 -35330 0 0 {name=X_59178_ }
C {devices/lab_pin.sym} 93640 -35210 0 0 {name=p92742 lab=_71411_/A }
C {devices/lab_pin.sym} 93640 -35170 0 0 {name=p92743 lab=_71446_/X }
C {devices/lab_pin.sym} 93640 -35130 0 0 {name=p92744 lab=_71458_/C }
C {devices/lab_pin.sym} 93760 -35170 0 1 {name=p92745 lab=_71456_/Y }
C {sky130_stdcells/nor3_4.sym} 93700 -35170 0 0 {name=X_71456_ }
C {sky130_stdcells/decap_3.sym} 93700 -35000 0 0 {name=XPHY_262 }
C {devices/lab_pin.sym} 93660 -34850 0 0 {name=p92746 lab=clkbuf_9_500_0_CLK/X }
C {devices/lab_pin.sym} 93740 -34850 0 1 {name=p92747 lab=_85599_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 93700 -34850 0 0 {name=Xclkbuf_10_1001_0_CLK }
C {sky130_stdcells/decap_3.sym} 93700 -34700 0 0 {name=XPHY_273 }
C {sky130_stdcells/decap_3.sym} 93700 -34520 0 0 {name=XPHY_284 }
C {devices/lab_pin.sym} 93640 -34400 0 0 {name=p92748 lab=_46143_/A }
C {devices/lab_pin.sym} 93640 -34360 0 0 {name=p92749 lab=_46143_/B }
C {devices/lab_pin.sym} 93640 -34320 0 0 {name=p92750 lab=_46121_/Y }
C {devices/lab_pin.sym} 93640 -34280 0 0 {name=p92751 lab=_46143_/D }
C {devices/lab_pin.sym} 93760 -34340 0 1 {name=p92752 lab=_46143_/Y }
C {sky130_stdcells/nand4_4.sym} 93700 -34340 0 0 {name=X_46143_ }
C {devices/lab_pin.sym} 93640 -34210 0 0 {name=p92753 lab=_70942_/A }
C {devices/lab_pin.sym} 93640 -34170 0 0 {name=p92754 lab=_74533_/A }
C {devices/lab_pin.sym} 93640 -34130 0 0 {name=p92755 lab=_70407_/C }
C {devices/lab_pin.sym} 93760 -34170 0 1 {name=p92756 lab=_70407_/Y }
C {sky130_stdcells/nand3_4.sym} 93700 -34170 0 0 {name=X_70407_ }
C {devices/lab_pin.sym} 93620 -34050 0 0 {name=p92757 lab=_58122_/Y }
C {devices/lab_pin.sym} 93620 -34010 0 0 {name=p92758 lab=_58128_/Y }
C {devices/lab_pin.sym} 93620 -33970 0 0 {name=p92759 lab=_58003_/X }
C {devices/lab_pin.sym} 93780 -34010 0 1 {name=p92760 lab=_58129_/X }
C {sky130_stdcells/a21o_4.sym} 93700 -34010 0 0 {name=X_58129_ }
C {sky130_stdcells/decap_3.sym} 93700 -33840 0 0 {name=XPHY_295 }
C {devices/lab_pin.sym} 93660 -33690 0 0 {name=p92761 lab=_43355_/A }
C {devices/lab_pin.sym} 93740 -33690 0 1 {name=p92762 lab=_87464_/D }
C {sky130_stdcells/inv_2.sym} 93700 -33690 0 0 {name=X_43355_ }
C {devices/lab_pin.sym} 93620 -33600 0 0 {name=p92763 lab=_74106_/X }
C {devices/lab_pin.sym} 93620 -33560 0 0 {name=p92764 lab=_85607_/Q }
C {devices/lab_pin.sym} 93620 -33520 0 0 {name=p92765 lab=_74107_/X }
C {devices/lab_pin.sym} 93620 -33480 0 0 {name=p92766 lab=_74174_/X }
C {devices/lab_pin.sym} 93780 -33540 0 1 {name=p92767 lab=_74175_/X }
C {sky130_stdcells/a211o_4.sym} 93700 -33540 0 0 {name=X_74175_ }
C {devices/lab_pin.sym} 93660 -33390 0 0 {name=p92768 lab=_40567_/A }
C {devices/lab_pin.sym} 93740 -33390 0 1 {name=p92769 lab=_40568_/A }
C {sky130_stdcells/buf_2.sym} 93700 -33390 0 0 {name=X_40567_ }
C {devices/lab_pin.sym} 93620 -33290 0 0 {name=p92770 lab=_71373_/X }
C {devices/lab_pin.sym} 93620 -33250 0 0 {name=p92771 lab=_83517_/Q }
C {devices/lab_pin.sym} 93620 -33210 0 0 {name=p92772 lab=_71386_/Y }
C {devices/lab_pin.sym} 93780 -33250 0 1 {name=p92773 lab=_83517_/D }
C {sky130_stdcells/a21o_4.sym} 93700 -33250 0 0 {name=X_71387_ }
C {devices/lab_pin.sym} 93620 -33140 0 0 {name=p92774 lab=_41592_/X }
C {devices/lab_pin.sym} 93620 -33100 0 0 {name=p92775 lab=_42303_/X }
C {devices/lab_pin.sym} 93620 -33060 0 0 {name=p92776 lab=_87930_/Q }
C {devices/lab_pin.sym} 93620 -33020 0 0 {name=p92777 lab=_42305_/X }
C {devices/lab_pin.sym} 93780 -33080 0 1 {name=p92778 lab=_87930_/D }
C {sky130_stdcells/a2bb2o_4.sym} 93700 -33080 0 0 {name=X_42306_ }
C {devices/lab_pin.sym} 93660 -32930 0 0 {name=p92779 lab=_64243_/A }
C {devices/lab_pin.sym} 93740 -32930 0 1 {name=p92780 lab=_61140_/X }
C {sky130_stdcells/buf_2.sym} 93700 -32930 0 0 {name=X_61140_ }
C {devices/lab_pin.sym} 93640 -32820 0 0 {name=p92781 lab=_73126_/A }
C {devices/lab_pin.sym} 93640 -32780 0 0 {name=p92782 lab=_73198_/B }
C {devices/lab_pin.sym} 93760 -32800 0 1 {name=p92783 lab=_73126_/Y }
C {sky130_stdcells/nor2_4.sym} 93700 -32800 0 0 {name=X_73126_ }
C {devices/lab_pin.sym} 93640 -32700 0 0 {name=p92784 lab=_70338_/A }
C {devices/lab_pin.sym} 93640 -32660 0 0 {name=p92785 lab=_70333_/B }
C {devices/lab_pin.sym} 93640 -32620 0 0 {name=p92786 lab=_83088_/Q }
C {devices/lab_pin.sym} 93640 -32580 0 0 {name=p92787 lab=_70332_/X }
C {devices/lab_pin.sym} 93760 -32640 0 1 {name=p92788 lab=_70338_/X }
C {sky130_stdcells/and4_4.sym} 93700 -32640 0 0 {name=X_70338_ }
C {devices/lab_pin.sym} 93620 -32530 0 0 {name=p92789 lab=_46067_/X }
C {devices/lab_pin.sym} 93620 -32490 0 0 {name=p92790 lab=_46054_/X }
C {devices/lab_pin.sym} 93620 -32450 0 0 {name=p92791 lab=_41595_/X }
C {devices/lab_pin.sym} 93620 -32410 0 0 {name=p92792 lab=_86780_/Q }
C {devices/lab_pin.sym} 93620 -32370 0 0 {name=p92793 lab=_46068_/X }
C {devices/lab_pin.sym} 93780 -32450 0 1 {name=p92794 lab=_46075_/A }
C {sky130_stdcells/o32ai_4.sym} 93700 -32450 0 0 {name=X_46074_ }
C {devices/lab_pin.sym} 93660 -32290 0 0 {name=p92795 lab=_43178_/X }
C {devices/lab_pin.sym} 93740 -32290 0 1 {name=p92796 lab=_43287_/A }
C {sky130_stdcells/buf_2.sym} 93700 -32290 0 0 {name=X_43286_ }
C {devices/lab_pin.sym} 93660 -32170 0 0 {name=p92797 lab=_82646_/Q }
C {devices/lab_pin.sym} 93740 -32170 0 1 {name=p92798 lab=_78998_/A }
C {sky130_stdcells/inv_2.sym} 93700 -32170 0 0 {name=X_78983_ }
C {devices/lab_pin.sym} 93620 -32080 0 0 {name=p92799 lab=_40497_/X }
C {devices/lab_pin.sym} 93620 -32040 0 0 {name=p92800 lab=_40410_/X }
C {devices/lab_pin.sym} 93620 -32000 0 0 {name=p92801 lab=_88382_/Q }
C {devices/lab_pin.sym} 93620 -31960 0 0 {name=p92802 lab=_40411_/X }
C {devices/lab_pin.sym} 93780 -32020 0 1 {name=p92803 lab=_40498_/X }
C {sky130_stdcells/a2bb2o_4.sym} 93700 -32020 0 0 {name=X_40498_ }
C {devices/lab_pin.sym} 93620 -31890 0 0 {name=p92804 lab=_72160_/B }
C {devices/lab_pin.sym} 93620 -31850 0 0 {name=p92805 lab=_49880_/X }
C {devices/lab_pin.sym} 93620 -31810 0 0 {name=p92806 lab=_49901_/Y }
C {devices/lab_pin.sym} 93780 -31850 0 1 {name=p92807 lab=_49902_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -31850 0 0 {name=X_49902_ }
C {devices/lab_pin.sym} 93620 -31730 0 0 {name=p92808 lab=_85241_/Q }
C {devices/lab_pin.sym} 93620 -31690 0 0 {name=p92809 lab=_44979_/X }
C {devices/lab_pin.sym} 93620 -31650 0 0 {name=p92810 lab=_45012_/X }
C {devices/lab_pin.sym} 93780 -31690 0 1 {name=p92811 lab=_45025_/X }
C {sky130_stdcells/o21a_4.sym} 93700 -31690 0 0 {name=X_45025_ }
C {devices/lab_pin.sym} 93620 -31580 0 0 {name=p92812 lab=_41397_/X }
C {devices/lab_pin.sym} 93620 -31540 0 0 {name=p92813 lab=_42222_/X }
C {devices/lab_pin.sym} 93620 -31500 0 0 {name=p92814 lab=_87966_/Q }
C {devices/lab_pin.sym} 93620 -31460 0 0 {name=p92815 lab=_42224_/X }
C {devices/lab_pin.sym} 93780 -31520 0 1 {name=p92816 lab=_42237_/X }
C {sky130_stdcells/a2bb2o_4.sym} 93700 -31520 0 0 {name=X_42237_ }
C {devices/lab_pin.sym} 93640 -31380 0 0 {name=p92817 lab=_82168_/Q }
C {devices/lab_pin.sym} 93640 -31340 0 0 {name=p92818 lab=_77934_/B }
C {devices/lab_pin.sym} 93760 -31360 0 1 {name=p92819 lab=_82136_/D }
C {sky130_stdcells/xor2_4.sym} 93700 -31360 0 0 {name=X_77934_ }
C {devices/lab_pin.sym} 93640 -31260 0 0 {name=p92820 lab=_61071_/A }
C {devices/lab_pin.sym} 93640 -31220 0 0 {name=p92821 lab=_59602_/A }
C {devices/lab_pin.sym} 93640 -31180 0 0 {name=p92822 lab=_61071_/C }
C {devices/lab_pin.sym} 93640 -31140 0 0 {name=p92823 lab=_59532_/A }
C {devices/lab_pin.sym} 93760 -31200 0 1 {name=p92824 lab=_61071_/X }
C {sky130_stdcells/and4_4.sym} 93700 -31200 0 0 {name=X_61071_ }
C {devices/lab_pin.sym} 93620 -31080 0 0 {name=p92825 lab=_43141_/Y }
C {devices/lab_pin.sym} 93620 -31040 0 0 {name=p92826 lab=_72830_/X }
C {devices/lab_pin.sym} 93620 -31000 0 0 {name=p92827 lab=_73055_/X }
C {devices/lab_pin.sym} 93620 -30960 0 0 {name=p92828 lab=_73056_/Y }
C {devices/lab_pin.sym} 93780 -31020 0 1 {name=p92829 lab=_73057_/X }
C {sky130_stdcells/a211o_4.sym} 93700 -31020 0 0 {name=X_73057_ }
C {devices/lab_pin.sym} 93660 -30870 0 0 {name=p92830 lab=clkbuf_9_508_0_CLK/X }
C {devices/lab_pin.sym} 93740 -30870 0 1 {name=p92831 lab=_86191_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 93700 -30870 0 0 {name=Xclkbuf_10_1016_0_CLK }
C {devices/lab_pin.sym} 93660 -30750 0 0 {name=p92832 lab=_70238_/A }
C {devices/lab_pin.sym} 93740 -30750 0 1 {name=p92833 lab=_70269_/X }
C {sky130_stdcells/buf_2.sym} 93700 -30750 0 0 {name=X_70269_ }
C {devices/lab_pin.sym} 93620 -30670 0 0 {name=p92834 lab=_60009_/Y }
C {devices/lab_pin.sym} 93620 -30630 0 0 {name=p92835 lab=_60015_/Y }
C {devices/lab_pin.sym} 93620 -30590 0 0 {name=p92836 lab=_60019_/Y }
C {devices/lab_pin.sym} 93620 -30550 0 0 {name=p92837 lab=_59998_/B }
C {devices/lab_pin.sym} 93620 -30520 0 0 {name=p92838 lab=_60021_/Y }
C {devices/lab_pin.sym} 93780 -30590 0 1 {name=p92839 lab=_84674_/D }
C {sky130_stdcells/a41oi_4.sym} 93700 -30590 0 0 {name=X_60022_ }
C {devices/lab_pin.sym} 93620 -30450 0 0 {name=p92840 lab=_83303_/Q }
C {devices/lab_pin.sym} 93620 -30410 0 0 {name=p92841 lab=_71985_/X }
C {devices/lab_pin.sym} 93620 -30370 0 0 {name=p92842 lab=_72007_/Y }
C {devices/lab_pin.sym} 93780 -30410 0 1 {name=p92843 lab=_72008_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -30410 0 0 {name=X_72008_ }
C {devices/lab_pin.sym} 93620 -30290 0 0 {name=p92844 lab=_58026_/B }
C {devices/lab_pin.sym} 93620 -30250 0 0 {name=p92845 lab=_49825_/X }
C {devices/lab_pin.sym} 93620 -30210 0 0 {name=p92846 lab=_49832_/Y }
C {devices/lab_pin.sym} 93780 -30250 0 1 {name=p92847 lab=_49833_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -30250 0 0 {name=X_49833_ }
C {devices/lab_pin.sym} 93660 -30110 0 0 {name=p92848 lab=_42167_/Y }
C {devices/lab_pin.sym} 93740 -30110 0 1 {name=p92849 lab=_88000_/D }
C {sky130_stdcells/inv_2.sym} 93700 -30110 0 0 {name=X_42168_ }
C {devices/lab_pin.sym} 93640 -30000 0 0 {name=p92850 lab=_77863_/Y }
C {devices/lab_pin.sym} 93640 -29960 0 0 {name=p92851 lab=_77864_/Y }
C {devices/lab_pin.sym} 93760 -29980 0 1 {name=p92852 lab=_77869_/A }
C {sky130_stdcells/xor2_4.sym} 93700 -29980 0 0 {name=X_77865_ }
C {devices/lab_pin.sym} 93640 -29870 0 0 {name=p92853 lab=_79601_/X }
C {devices/lab_pin.sym} 93640 -29830 0 0 {name=p92854 lab=_79602_/X }
C {devices/lab_pin.sym} 93640 -29790 0 0 {name=p92855 lab=_79603_/Y }
C {devices/lab_pin.sym} 93760 -29830 0 1 {name=p92856 lab=_79609_/A }
C {sky130_stdcells/nand3_4.sym} 93700 -29830 0 0 {name=X_79604_ }
C {devices/lab_pin.sym} 93640 -29700 0 0 {name=p92857 lab=_41119_/A }
C {devices/lab_pin.sym} 93640 -29660 0 0 {name=p92858 lab=_41102_/B }
C {devices/lab_pin.sym} 93760 -29680 0 1 {name=p92859 lab=_41119_/X }
C {sky130_stdcells/or2_4.sym} 93700 -29680 0 0 {name=X_41119_ }
C {devices/lab_pin.sym} 93640 -29560 0 0 {name=p92860 lab=_64883_/A }
C {devices/lab_pin.sym} 93640 -29520 0 0 {name=p92861 lab=_86265_/Q }
C {devices/lab_pin.sym} 93760 -29540 0 1 {name=p92862 lab=_64830_/X }
C {sky130_stdcells/and2_4.sym} 93700 -29540 0 0 {name=X_64830_ }
C {devices/lab_pin.sym} 93620 -29430 0 0 {name=p92863 lab=_76805_/A }
C {devices/lab_pin.sym} 93620 -29390 0 0 {name=p92864 lab=_76804_/Y }
C {devices/lab_pin.sym} 93620 -29350 0 0 {name=p92865 lab=_76815_/X }
C {devices/lab_pin.sym} 93780 -29390 0 1 {name=p92866 lab=_76816_/Y }
C {sky130_stdcells/a21oi_4.sym} 93700 -29390 0 0 {name=X_76816_ }
C {devices/lab_pin.sym} 93620 -29270 0 0 {name=p92867 lab=_57870_/B }
C {devices/lab_pin.sym} 93620 -29230 0 0 {name=p92868 lab=_49742_/X }
C {devices/lab_pin.sym} 93620 -29190 0 0 {name=p92869 lab=_49763_/Y }
C {devices/lab_pin.sym} 93780 -29230 0 1 {name=p92870 lab=_49764_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -29230 0 0 {name=X_49764_ }
C {devices/lab_pin.sym} 93660 -29090 0 0 {name=p92871 lab=_54473_/B }
C {devices/lab_pin.sym} 93740 -29090 0 1 {name=p92872 lab=_52781_/B }
C {sky130_stdcells/buf_2.sym} 93700 -29090 0 0 {name=X_46976_ }
C {devices/lab_pin.sym} 93660 -28970 0 0 {name=p92873 lab=_42083_/A }
C {devices/lab_pin.sym} 93740 -28970 0 1 {name=p92874 lab=_42099_/X }
C {sky130_stdcells/buf_2.sym} 93700 -28970 0 0 {name=X_42099_ }
C {devices/lab_pin.sym} 93640 -28860 0 0 {name=p92875 lab=_77796_/A }
C {devices/lab_pin.sym} 93640 -28820 0 0 {name=p92876 lab=_77796_/B }
C {devices/lab_pin.sym} 93760 -28840 0 1 {name=p92877 lab=_77796_/Y }
C {sky130_stdcells/nor2_4.sym} 93700 -28840 0 0 {name=X_77796_ }
C {devices/lab_pin.sym} 93640 -28730 0 0 {name=p92878 lab=_53620_/A }
C {devices/lab_pin.sym} 93640 -28690 0 0 {name=p92879 lab=_48099_/X }
C {devices/lab_pin.sym} 93640 -28650 0 0 {name=p92880 lab=_48723_/C }
C {devices/lab_pin.sym} 93760 -28690 0 1 {name=p92881 lab=_48715_/X }
C {sky130_stdcells/and3_4.sym} 93700 -28690 0 0 {name=X_48715_ }
C {devices/lab_pin.sym} 93640 -28560 0 0 {name=p92882 lab=_84203_/Q }
C {devices/lab_pin.sym} 93640 -28520 0 0 {name=p92883 lab=_72465_/A }
C {devices/lab_pin.sym} 93760 -28540 0 1 {name=p92884 lab=_79542_/A }
C {sky130_stdcells/nand2_4.sym} 93700 -28540 0 0 {name=X_79535_ }
C {devices/lab_pin.sym} 93620 -28450 0 0 {name=p92885 lab=_45922_/X }
C {devices/lab_pin.sym} 93620 -28410 0 0 {name=p92886 lab=_45923_/X }
C {devices/lab_pin.sym} 93620 -28370 0 0 {name=p92887 lab=_65880_/A }
C {devices/lab_pin.sym} 93620 -28330 0 0 {name=p92888 lab=_45926_/X }
C {devices/lab_pin.sym} 93620 -28300 0 0 {name=p92889 lab=_44184_/A }
C {devices/lab_pin.sym} 93780 -28370 0 1 {name=p92890 lab=_45927_/X }
C {sky130_stdcells/a41o_4.sym} 93700 -28370 0 0 {name=X_45927_ }
C {devices/lab_pin.sym} 93640 -28230 0 0 {name=p92891 lab=_64757_/X }
C {devices/lab_pin.sym} 93640 -28190 0 0 {name=p92892 lab=_64761_/B }
C {devices/lab_pin.sym} 93640 -28150 0 0 {name=p92893 lab=_64760_/X }
C {devices/lab_pin.sym} 93760 -28190 0 1 {name=p92894 lab=_64761_/Y }
C {sky130_stdcells/nand3_4.sym} 93700 -28190 0 0 {name=X_64761_ }
C {devices/lab_pin.sym} 93640 -28060 0 0 {name=p92895 lab=_81693_/Q }
C {devices/lab_pin.sym} 93640 -28020 0 0 {name=p92896 lab=_76747_/B }
C {devices/lab_pin.sym} 93760 -28040 0 1 {name=p92897 lab=_76747_/Y }
C {sky130_stdcells/xnor2_4.sym} 93700 -28040 0 0 {name=X_76747_ }
C {devices/lab_pin.sym} 93620 -27930 0 0 {name=p92898 lab=_59360_/B }
C {devices/lab_pin.sym} 93620 -27890 0 0 {name=p92899 lab=_49687_/X }
C {devices/lab_pin.sym} 93620 -27850 0 0 {name=p92900 lab=_49694_/Y }
C {devices/lab_pin.sym} 93780 -27890 0 1 {name=p92901 lab=_49695_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -27890 0 0 {name=X_49695_ }
C {devices/lab_pin.sym} 93660 -27750 0 0 {name=p92902 lab=_61719_/A }
C {devices/lab_pin.sym} 93740 -27750 0 1 {name=p92903 lab=_61973_/X }
C {sky130_stdcells/buf_2.sym} 93700 -27750 0 0 {name=X_61973_ }
C {devices/lab_pin.sym} 93640 -27650 0 0 {name=p92904 lab=_73957_/X }
C {devices/lab_pin.sym} 93640 -27610 0 0 {name=p92905 lab=_73945_/X }
C {devices/lab_pin.sym} 93640 -27570 0 0 {name=p92906 lab=_73947_/X }
C {devices/lab_pin.sym} 93760 -27610 0 1 {name=p92907 lab=_73959_/Y }
C {sky130_stdcells/nand3_4.sym} 93700 -27610 0 0 {name=X_73959_ }
C {devices/lab_pin.sym} 93620 -27490 0 0 {name=p92908 lab=_60110_/X }
C {devices/lab_pin.sym} 93620 -27450 0 0 {name=p92909 lab=_65281_/Y }
C {devices/lab_pin.sym} 93620 -27410 0 0 {name=p92910 lab=_66499_/Y }
C {devices/lab_pin.sym} 93780 -27450 0 1 {name=p92911 lab=_66500_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -27450 0 0 {name=X_66500_ }
C {devices/lab_pin.sym} 93620 -27350 0 0 {name=p92912 lab=_58993_/Y }
C {devices/lab_pin.sym} 93620 -27310 0 0 {name=p92913 lab=_60748_/X }
C {devices/lab_pin.sym} 93620 -27270 0 0 {name=p92914 lab=_60654_/X }
C {devices/lab_pin.sym} 93620 -27230 0 0 {name=p92915 lab=_62629_/Y }
C {devices/lab_pin.sym} 93620 -27190 0 0 {name=p92916 lab=_60671_/B }
C {devices/lab_pin.sym} 93780 -27270 0 1 {name=p92917 lab=_63712_/Y }
C {sky130_stdcells/o32ai_4.sym} 93700 -27270 0 0 {name=X_63712_ }
C {devices/lab_pin.sym} 93620 -27130 0 0 {name=p92918 lab=_48641_/Y }
C {devices/lab_pin.sym} 93620 -27090 0 0 {name=p92919 lab=_48585_/X }
C {devices/lab_pin.sym} 93620 -27050 0 0 {name=p92920 lab=_48645_/X }
C {devices/lab_pin.sym} 93780 -27090 0 1 {name=p92921 lab=_48646_/Y }
C {sky130_stdcells/a21oi_4.sym} 93700 -27090 0 0 {name=X_48646_ }
C {devices/lab_pin.sym} 93640 -26970 0 0 {name=p92922 lab=_60826_/A }
C {devices/lab_pin.sym} 93640 -26930 0 0 {name=p92923 lab=_60838_/X }
C {devices/lab_pin.sym} 93640 -26890 0 0 {name=p92924 lab=_76999_/A }
C {devices/lab_pin.sym} 93760 -26930 0 1 {name=p92925 lab=_60924_/Y }
C {sky130_stdcells/nor3_4.sym} 93700 -26930 0 0 {name=X_60924_ }
C {devices/lab_pin.sym} 93620 -26810 0 0 {name=p92926 lab=_67475_/X }
C {devices/lab_pin.sym} 93620 -26770 0 0 {name=p92927 lab=_67479_/X }
C {devices/lab_pin.sym} 93620 -26730 0 0 {name=p92928 lab=_67383_/X }
C {devices/lab_pin.sym} 93780 -26770 0 1 {name=p92929 lab=_67484_/A }
C {sky130_stdcells/a21o_4.sym} 93700 -26770 0 0 {name=X_67480_ }
C {devices/lab_pin.sym} 93640 -26640 0 0 {name=p92930 lab=_84813_/Q }
C {devices/lab_pin.sym} 93640 -26600 0 0 {name=p92931 lab=_84133_/Q }
C {devices/lab_pin.sym} 93760 -26620 0 1 {name=p92932 lab=_79466_/X }
C {sky130_stdcells/xor2_4.sym} 93700 -26620 0 0 {name=X_79466_ }
C {devices/lab_pin.sym} 93620 -26520 0 0 {name=p92933 lab=_45856_/Y }
C {devices/lab_pin.sym} 93620 -26480 0 0 {name=p92934 lab=_44968_/X }
C {devices/lab_pin.sym} 93620 -26440 0 0 {name=p92935 lab=_44875_/X }
C {devices/lab_pin.sym} 93620 -26400 0 0 {name=p92936 lab=_45857_/Y }
C {devices/lab_pin.sym} 93780 -26460 0 1 {name=p92937 lab=_45858_/X }
C {sky130_stdcells/a211o_4.sym} 93700 -26460 0 0 {name=X_45858_ }
C {devices/lab_pin.sym} 93660 -26310 0 0 {name=p92938 lab=_64766_/A }
C {devices/lab_pin.sym} 93740 -26310 0 1 {name=p92939 lab=_64692_/X }
C {sky130_stdcells/buf_2.sym} 93700 -26310 0 0 {name=X_64692_ }
C {devices/lab_pin.sym} 93640 -26200 0 0 {name=p92940 lab=_76686_/A }
C {devices/lab_pin.sym} 93640 -26160 0 0 {name=p92941 lab=_76969_/A }
C {devices/lab_pin.sym} 93760 -26180 0 1 {name=p92942 lab=_76678_/X }
C {sky130_stdcells/xor2_4.sym} 93700 -26180 0 0 {name=X_76678_ }
C {devices/lab_pin.sym} 93640 -26070 0 0 {name=p92943 lab=_64960_/X }
C {devices/lab_pin.sym} 93640 -26030 0 0 {name=p92944 lab=_66417_/B }
C {devices/lab_pin.sym} 93640 -25990 0 0 {name=p92945 lab=_64964_/X }
C {devices/lab_pin.sym} 93760 -26030 0 1 {name=p92946 lab=_66431_/Y }
C {sky130_stdcells/nand3_4.sym} 93700 -26030 0 0 {name=X_66431_ }
C {devices/lab_pin.sym} 93640 -25900 0 0 {name=p92947 lab=_78417_/A }
C {devices/lab_pin.sym} 93640 -25860 0 0 {name=p92948 lab=_82710_/Q }
C {devices/lab_pin.sym} 93760 -25880 0 1 {name=p92949 lab=_78418_/B }
C {sky130_stdcells/xor2_4.sym} 93700 -25880 0 0 {name=X_78417_ }
C {devices/lab_pin.sym} 93620 -25790 0 0 {name=p92950 lab=_44807_/X }
C {devices/lab_pin.sym} 93620 -25750 0 0 {name=p92951 lab=_43924_/X }
C {devices/lab_pin.sym} 93620 -25710 0 0 {name=p92952 lab=_41630_/X }
C {devices/lab_pin.sym} 93620 -25670 0 0 {name=p92953 lab=_86943_/Q }
C {devices/lab_pin.sym} 93620 -25630 0 0 {name=p92954 lab=_44808_/X }
C {devices/lab_pin.sym} 93780 -25710 0 1 {name=p92955 lab=_44810_/A }
C {sky130_stdcells/o32ai_4.sym} 93700 -25710 0 0 {name=X_44809_ }
C {devices/lab_pin.sym} 93640 -25560 0 0 {name=p92956 lab=_81113_/Q }
C {devices/lab_pin.sym} 93640 -25520 0 0 {name=p92957 lab=_80825_/Q }
C {devices/lab_pin.sym} 93760 -25540 0 1 {name=p92958 lab=_75629_/X }
C {sky130_stdcells/xor2_4.sym} 93700 -25540 0 0 {name=X_75629_ }
C {devices/lab_pin.sym} 93660 -25410 0 0 {name=p92959 lab=_44173_/X }
C {devices/lab_pin.sym} 93740 -25410 0 1 {name=p92960 lab=_63644_/A }
C {sky130_stdcells/buf_2.sym} 93700 -25410 0 0 {name=X_63643_ }
C {devices/lab_pin.sym} 93620 -25310 0 0 {name=p92961 lab=_48563_/X }
C {devices/lab_pin.sym} 93620 -25270 0 0 {name=p92962 lab=_82350_/Q }
C {devices/lab_pin.sym} 93620 -25230 0 0 {name=p92963 lab=_48576_/Y }
C {devices/lab_pin.sym} 93780 -25270 0 1 {name=p92964 lab=_48578_/A }
C {sky130_stdcells/o21ai_4.sym} 93700 -25270 0 0 {name=X_48577_ }
C {devices/lab_pin.sym} 93660 -25130 0 0 {name=p92965 lab=_60854_/Y }
C {devices/lab_pin.sym} 93740 -25130 0 1 {name=p92966 lab=_60855_/X }
C {sky130_stdcells/buf_2.sym} 93700 -25130 0 0 {name=X_60855_ }
C {devices/lab_pin.sym} 93640 -25020 0 0 {name=p92967 lab=_79374_/X }
C {devices/lab_pin.sym} 93640 -24980 0 0 {name=p92968 lab=_79387_/X }
C {devices/lab_pin.sym} 93760 -25000 0 1 {name=p92969 lab=_79397_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -25000 0 0 {name=X_79397_ }
C {devices/lab_pin.sym} 93660 -24870 0 0 {name=p92970 lab=_63292_/B }
C {devices/lab_pin.sym} 93740 -24870 0 1 {name=p92971 lab=_61630_/A }
C {sky130_stdcells/buf_2.sym} 93700 -24870 0 0 {name=X_45789_ }
C {devices/lab_pin.sym} 93640 -24760 0 0 {name=p92972 lab=_69755_/A }
C {devices/lab_pin.sym} 93640 -24720 0 0 {name=p92973 lab=_87282_/Q }
C {devices/lab_pin.sym} 93760 -24740 0 1 {name=p92974 lab=_69150_/X }
C {sky130_stdcells/and2_4.sym} 93700 -24740 0 0 {name=X_69150_ }
C {devices/lab_pin.sym} 93640 -24620 0 0 {name=p92975 lab=_47553_/A }
C {devices/lab_pin.sym} 93640 -24580 0 0 {name=p92976 lab=_53101_/B }
C {devices/lab_pin.sym} 93760 -24600 0 1 {name=p92977 lab=_47528_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -24600 0 0 {name=X_47528_ }
C {devices/lab_pin.sym} 93620 -24490 0 0 {name=p92978 lab=_66294_/X }
C {devices/lab_pin.sym} 93620 -24450 0 0 {name=p92979 lab=_64582_/Y }
C {devices/lab_pin.sym} 93620 -24410 0 0 {name=p92980 lab=_66361_/Y }
C {devices/lab_pin.sym} 93780 -24450 0 1 {name=p92981 lab=_66362_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -24450 0 0 {name=X_66362_ }
C {devices/lab_pin.sym} 93660 -24310 0 0 {name=p92982 lab=_78347_/X }
C {devices/lab_pin.sym} 93740 -24310 0 1 {name=p92983 lab=_78350_/A }
C {sky130_stdcells/inv_2.sym} 93700 -24310 0 0 {name=X_78348_ }
C {devices/lab_pin.sym} 93620 -24220 0 0 {name=p92984 lab=_61538_/B }
C {devices/lab_pin.sym} 93620 -24180 0 0 {name=p92985 lab=_63548_/X }
C {devices/lab_pin.sym} 93620 -24140 0 0 {name=p92986 lab=_63571_/X }
C {devices/lab_pin.sym} 93620 -24100 0 0 {name=p92987 lab=_63573_/Y }
C {devices/lab_pin.sym} 93780 -24160 0 1 {name=p92988 lab=_63574_/X }
C {sky130_stdcells/a211o_4.sym} 93700 -24160 0 0 {name=X_63574_ }
C {devices/lab_pin.sym} 93640 -24030 0 0 {name=p92989 lab=_60761_/A }
C {devices/lab_pin.sym} 93640 -23990 0 0 {name=p92990 lab=_60761_/B }
C {devices/lab_pin.sym} 93640 -23950 0 0 {name=p92991 lab=_84568_/Q }
C {devices/lab_pin.sym} 93760 -23990 0 1 {name=p92992 lab=_60786_/Y }
C {sky130_stdcells/nor3_4.sym} 93700 -23990 0 0 {name=X_60786_ }
C {devices/lab_pin.sym} 93660 -23850 0 0 {name=p92993 lab=_68120_/A }
C {devices/lab_pin.sym} 93740 -23850 0 1 {name=p92994 lab=_68101_/X }
C {sky130_stdcells/buf_2.sym} 93700 -23850 0 0 {name=X_68101_ }
C {devices/lab_pin.sym} 93640 -23740 0 0 {name=p92995 lab=_57788_/X }
C {devices/lab_pin.sym} 93640 -23700 0 0 {name=p92996 lab=_65313_/B }
C {devices/lab_pin.sym} 93760 -23720 0 1 {name=p92997 lab=_65313_/X }
C {sky130_stdcells/and2_4.sym} 93700 -23720 0 0 {name=X_65313_ }
C {devices/lab_pin.sym} 93620 -23620 0 0 {name=p92998 lab=_60085_/A }
C {devices/lab_pin.sym} 93620 -23580 0 0 {name=p92999 lab=_61582_/A }
C {devices/lab_pin.sym} 93620 -23540 0 0 {name=p93000 lab=_62522_/X }
C {devices/lab_pin.sym} 93620 -23500 0 0 {name=p93001 lab=_62524_/X }
C {devices/lab_pin.sym} 93780 -23560 0 1 {name=p93002 lab=_62525_/X }
C {sky130_stdcells/a211o_4.sym} 93700 -23560 0 0 {name=X_62525_ }
C {devices/lab_pin.sym} 93640 -23420 0 0 {name=p93003 lab=_69059_/A }
C {devices/lab_pin.sym} 93640 -23380 0 0 {name=p93004 lab=_88246_/Q }
C {devices/lab_pin.sym} 93760 -23400 0 1 {name=p93005 lab=_69081_/X }
C {sky130_stdcells/and2_4.sym} 93700 -23400 0 0 {name=X_69081_ }
C {devices/lab_pin.sym} 93660 -23270 0 0 {name=p93006 lab=_47459_/A }
C {devices/lab_pin.sym} 93740 -23270 0 1 {name=p93007 lab=_53060_/B }
C {sky130_stdcells/buf_2.sym} 93700 -23270 0 0 {name=X_47459_ }
C {devices/lab_pin.sym} 93620 -23170 0 0 {name=p93008 lab=_66291_/Y }
C {devices/lab_pin.sym} 93620 -23130 0 0 {name=p93009 lab=_66278_/X }
C {devices/lab_pin.sym} 93620 -23090 0 0 {name=p93010 lab=_66292_/X }
C {devices/lab_pin.sym} 93780 -23130 0 1 {name=p93011 lab=_84143_/D }
C {sky130_stdcells/a21o_4.sym} 93700 -23130 0 0 {name=X_66293_ }
C {devices/lab_pin.sym} 93640 -23000 0 0 {name=p93012 lab=_82590_/Q }
C {devices/lab_pin.sym} 93640 -22960 0 0 {name=p93013 lab=_78290_/B }
C {devices/lab_pin.sym} 93760 -22980 0 1 {name=p93014 lab=_78279_/X }
C {sky130_stdcells/xor2_4.sym} 93700 -22980 0 0 {name=X_78279_ }
C {devices/lab_pin.sym} 93620 -22880 0 0 {name=p93015 lab=_87446_/Q }
C {devices/lab_pin.sym} 93620 -22840 0 0 {name=p93016 lab=_67987_/X }
C {devices/lab_pin.sym} 93620 -22800 0 0 {name=p93017 lab=_67938_/X }
C {devices/lab_pin.sym} 93620 -22760 0 0 {name=p93018 lab=_68031_/X }
C {devices/lab_pin.sym} 93780 -22820 0 1 {name=p93019 lab=_68032_/X }
C {sky130_stdcells/a211o_4.sym} 93700 -22820 0 0 {name=X_68032_ }
C {devices/lab_pin.sym} 93640 -22680 0 0 {name=p93020 lab=_80309_/Y }
C {devices/lab_pin.sym} 93640 -22640 0 0 {name=p93021 lab=_80310_/B }
C {devices/lab_pin.sym} 93760 -22660 0 1 {name=p93022 lab=_80310_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -22660 0 0 {name=X_80310_ }
C {devices/lab_pin.sym} 93660 -22530 0 0 {name=p93023 lab=_64967_/X }
C {devices/lab_pin.sym} 93740 -22530 0 1 {name=p93024 lab=_65268_/A }
C {sky130_stdcells/buf_2.sym} 93700 -22530 0 0 {name=X_65244_ }
C {devices/lab_pin.sym} 93620 -22430 0 0 {name=p93025 lab=_50467_/Y }
C {devices/lab_pin.sym} 93620 -22390 0 0 {name=p93026 lab=_50455_/X }
C {devices/lab_pin.sym} 93620 -22350 0 0 {name=p93027 lab=_50469_/X }
C {devices/lab_pin.sym} 93780 -22390 0 1 {name=p93028 lab=_86195_/D }
C {sky130_stdcells/a21oi_4.sym} 93700 -22390 0 0 {name=X_50470_ }
C {devices/lab_pin.sym} 93620 -22270 0 0 {name=p93029 lab=_62454_/Y }
C {devices/lab_pin.sym} 93620 -22230 0 0 {name=p93030 lab=_62396_/X }
C {devices/lab_pin.sym} 93620 -22190 0 0 {name=p93031 lab=_62455_/Y }
C {devices/lab_pin.sym} 93780 -22230 0 1 {name=p93032 lab=_84409_/D }
C {sky130_stdcells/a21oi_4.sym} 93700 -22230 0 0 {name=X_62456_ }
C {devices/lab_pin.sym} 93610 -22090 0 0 {name=p93033 lab=_81275_/CLK }
C {devices/lab_pin.sym} 93610 -22070 0 0 {name=p93034 lab=_76978_/X }
C {devices/lab_pin.sym} 93790 -22090 0 1 {name=p93035 lab=_81258_/D }
C {sky130_stdcells/dfxtp_4.sym} 93700 -22080 0 0 {name=X_81290_ }
C {devices/lab_pin.sym} 93640 -21960 0 0 {name=p93036 lab=_49129_/A }
C {devices/lab_pin.sym} 93640 -21920 0 0 {name=p93037 lab=_49029_/B }
C {devices/lab_pin.sym} 93760 -21940 0 1 {name=p93038 lab=_49129_/Y }
C {sky130_stdcells/nor2_4.sym} 93700 -21940 0 0 {name=X_49129_ }
C {devices/lab_pin.sym} 93660 -21810 0 0 {name=p93039 lab=_61340_/A }
C {devices/lab_pin.sym} 93740 -21810 0 1 {name=p93040 lab=_61452_/B }
C {sky130_stdcells/buf_2.sym} 93700 -21810 0 0 {name=X_61407_ }
C {devices/lab_pin.sym} 93640 -21700 0 0 {name=p93041 lab=_80241_/A }
C {devices/lab_pin.sym} 93640 -21660 0 0 {name=p93042 lab=_80241_/B }
C {devices/lab_pin.sym} 93760 -21680 0 1 {name=p93043 lab=_80241_/X }
C {sky130_stdcells/xor2_4.sym} 93700 -21680 0 0 {name=X_80241_ }
C {devices/lab_pin.sym} 93640 -21560 0 0 {name=p93044 lab=_65159_/A }
C {devices/lab_pin.sym} 93640 -21520 0 0 {name=p93045 lab=_86027_/Q }
C {devices/lab_pin.sym} 93760 -21540 0 1 {name=p93046 lab=_65175_/X }
C {sky130_stdcells/and2_4.sym} 93700 -21540 0 0 {name=X_65175_ }
C {devices/lab_pin.sym} 93640 -21430 0 0 {name=p93047 lab=_62319_/A }
C {devices/lab_pin.sym} 93640 -21390 0 0 {name=p93048 lab=_58520_/A }
C {devices/lab_pin.sym} 93640 -21350 0 0 {name=p93049 lab=_62375_/C }
C {devices/lab_pin.sym} 93760 -21390 0 1 {name=p93050 lab=_62387_/Y }
C {sky130_stdcells/nand3_4.sym} 93700 -21390 0 0 {name=X_62387_ }
C {devices/lab_pin.sym} 93660 -21250 0 0 {name=p93051 lab=clkbuf_9_341_0_CLK/X }
C {devices/lab_pin.sym} 93740 -21250 0 1 {name=p93052 lab=_87210_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 93700 -21250 0 0 {name=Xclkbuf_10_683_0_CLK }
C {devices/lab_pin.sym} 93660 -21130 0 0 {name=p93053 lab=_52198_/A }
C {devices/lab_pin.sym} 93740 -21130 0 1 {name=p93054 lab=_52140_/X }
C {sky130_stdcells/buf_2.sym} 93700 -21130 0 0 {name=X_52140_ }
C {devices/lab_pin.sym} 93640 -21040 0 0 {name=p93055 lab=_61629_/B }
C {devices/lab_pin.sym} 93640 -21000 0 0 {name=p93056 lab=_64161_/B }
C {devices/lab_pin.sym} 93640 -20960 0 0 {name=p93057 lab=_64150_/C }
C {devices/lab_pin.sym} 93640 -20920 0 0 {name=p93058 lab=_64161_/D }
C {devices/lab_pin.sym} 93760 -20980 0 1 {name=p93059 lab=_64126_/Y }
C {sky130_stdcells/nand4_4.sym} 93700 -20980 0 0 {name=X_64126_ }
C {devices/lab_pin.sym} 93640 -20860 0 0 {name=p93060 lab=_61338_/A }
C {devices/lab_pin.sym} 93640 -20820 0 0 {name=p93061 lab=_61367_/B }
C {devices/lab_pin.sym} 93640 -20780 0 0 {name=p93062 lab=_61367_/C }
C {devices/lab_pin.sym} 93640 -20740 0 0 {name=p93063 lab=_61367_/D }
C {devices/lab_pin.sym} 93760 -20800 0 1 {name=p93064 lab=_61338_/Y }
C {sky130_stdcells/nand4_4.sym} 93700 -20800 0 0 {name=X_61338_ }
C {devices/lab_pin.sym} 93640 -20660 0 0 {name=p93065 lab=_84945_/Q }
C {devices/lab_pin.sym} 93640 -20620 0 0 {name=p93066 lab=_65559_/C }
C {devices/lab_pin.sym} 93760 -20640 0 1 {name=p93067 lab=_80172_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -20640 0 0 {name=X_80172_ }
C {devices/lab_pin.sym} 93620 -20530 0 0 {name=p93068 lab=_82560_/D }
C {devices/lab_pin.sym} 93620 -20490 0 0 {name=p93069 lab=_69955_/X }
C {devices/lab_pin.sym} 93620 -20450 0 0 {name=p93070 lab=_69982_/X }
C {devices/lab_pin.sym} 93780 -20490 0 1 {name=p93071 lab=_69983_/X }
C {sky130_stdcells/a21bo_4.sym} 93700 -20490 0 0 {name=X_69983_ }
C {devices/lab_pin.sym} 93660 -20350 0 0 {name=p93072 lab=clkbuf_8_87_0_CLK/X }
C {devices/lab_pin.sym} 93740 -20350 0 1 {name=p93073 lab=clkbuf_9_174_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 93700 -20350 0 0 {name=Xclkbuf_9_174_0_CLK }
C {devices/lab_pin.sym} 93620 -20250 0 0 {name=p93074 lab=_66296_/B }
C {devices/lab_pin.sym} 93620 -20210 0 0 {name=p93075 lab=_52041_/X }
C {devices/lab_pin.sym} 93620 -20170 0 0 {name=p93076 lab=_52070_/Y }
C {devices/lab_pin.sym} 93780 -20210 0 1 {name=p93077 lab=_52071_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -20210 0 0 {name=X_52071_ }
C {devices/lab_pin.sym} 93660 -20070 0 0 {name=p93078 lab=_60855_/X }
C {devices/lab_pin.sym} 93740 -20070 0 1 {name=p93079 lab=_64155_/C }
C {sky130_stdcells/buf_2.sym} 93700 -20070 0 0 {name=X_64057_ }
C {devices/lab_pin.sym} 93660 -19950 0 0 {name=p93080 lab=_65117_/A }
C {devices/lab_pin.sym} 93740 -19950 0 1 {name=p93081 lab=_68934_/X }
C {sky130_stdcells/buf_2.sym} 93700 -19950 0 0 {name=X_68934_ }
C {devices/lab_pin.sym} 93620 -19870 0 0 {name=p93082 lab=_61190_/X }
C {devices/lab_pin.sym} 93620 -19830 0 0 {name=p93083 lab=_61170_/Y }
C {devices/lab_pin.sym} 93620 -19790 0 0 {name=p93084 lab=_61267_/Y }
C {devices/lab_pin.sym} 93620 -19750 0 0 {name=p93085 lab=_64210_/A }
C {devices/lab_pin.sym} 93620 -19720 0 0 {name=p93086 lab=_61268_/Y }
C {devices/lab_pin.sym} 93780 -19790 0 1 {name=p93087 lab=_61269_/Y }
C {sky130_stdcells/a41oi_4.sym} 93700 -19790 0 0 {name=X_61269_ }
C {devices/lab_pin.sym} 93610 -19630 0 0 {name=p93088 lab=_84980_/CLK }
C {devices/lab_pin.sym} 93610 -19610 0 0 {name=p93089 lab=_84980_/D }
C {devices/lab_pin.sym} 93790 -19630 0 1 {name=p93090 lab=_84980_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -19620 0 0 {name=X_84980_ }
C {devices/lab_pin.sym} 93640 -19500 0 0 {name=p93091 lab=_51022_/A }
C {devices/lab_pin.sym} 93640 -19460 0 0 {name=p93092 lab=_51022_/B }
C {devices/lab_pin.sym} 93760 -19480 0 1 {name=p93093 lab=_51022_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -19480 0 0 {name=X_51022_ }
C {devices/lab_pin.sym} 93660 -19350 0 0 {name=p93094 lab=_63130_/A }
C {devices/lab_pin.sym} 93740 -19350 0 1 {name=p93095 lab=_63008_/X }
C {sky130_stdcells/buf_2.sym} 93700 -19350 0 0 {name=X_63008_ }
