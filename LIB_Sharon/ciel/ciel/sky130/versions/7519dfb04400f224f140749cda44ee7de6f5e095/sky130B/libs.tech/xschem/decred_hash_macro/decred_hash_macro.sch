C {devices/lab_pin.sym} 93610 -19230 0 0 {name=p93096 lab=_83932_/CLK }
C {devices/lab_pin.sym} 93610 -19210 0 0 {name=p93097 lab=_69339_/X }
C {devices/lab_pin.sym} 93790 -19230 0 1 {name=p93098 lab=_83931_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -19220 0 0 {name=X_83931_ }
C {devices/lab_pin.sym} 93660 -19090 0 0 {name=p93099 lab=clkbuf_9_349_0_CLK/X }
C {devices/lab_pin.sym} 93740 -19090 0 1 {name=p93100 lab=_87221_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 93700 -19090 0 0 {name=Xclkbuf_10_698_0_CLK }
C {devices/lab_pin.sym} 93640 -18980 0 0 {name=p93101 lab=_68750_/A }
C {devices/lab_pin.sym} 93640 -18940 0 0 {name=p93102 lab=_88351_/Q }
C {devices/lab_pin.sym} 93760 -18960 0 1 {name=p93103 lab=_68865_/X }
C {sky130_stdcells/and2_4.sym} 93700 -18960 0 0 {name=X_68865_ }
C {devices/lab_pin.sym} 93660 -18830 0 0 {name=p93104 lab=_55830_/A }
C {devices/lab_pin.sym} 93740 -18830 0 1 {name=p93105 lab=_55830_/X }
C {sky130_stdcells/buf_2.sym} 93700 -18830 0 0 {name=X_55830_ }
C {devices/lab_pin.sym} 93660 -18710 0 0 {name=p93106 lab=_67816_/A }
C {devices/lab_pin.sym} 93740 -18710 0 1 {name=p93107 lab=_68479_/A }
C {sky130_stdcells/buf_2.sym} 93700 -18710 0 0 {name=X_67816_ }
C {devices/lab_pin.sym} 93610 -18590 0 0 {name=p93108 lab=_86647_/CLK }
C {devices/lab_pin.sym} 93610 -18570 0 0 {name=p93109 lab=_86650_/D }
C {devices/lab_pin.sym} 93790 -18590 0 1 {name=p93110 lab=_86650_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -18580 0 0 {name=X_86650_ }
C {devices/lab_pin.sym} 93610 -18450 0 0 {name=p93111 lab=_82553_/CLK }
C {devices/lab_pin.sym} 93610 -18430 0 0 {name=p93112 lab=_83862_/D }
C {devices/lab_pin.sym} 93790 -18450 0 1 {name=p93113 lab=_83862_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -18440 0 0 {name=X_83862_ }
C {devices/lab_pin.sym} 93660 -18310 0 0 {name=p93114 lab=clkbuf_8_94_0_CLK/X }
C {devices/lab_pin.sym} 93740 -18310 0 1 {name=p93115 lab=clkbuf_9_189_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 93700 -18310 0 0 {name=Xclkbuf_9_189_0_CLK }
C {devices/lab_pin.sym} 93640 -18200 0 0 {name=p93116 lab=_68938_/A }
C {devices/lab_pin.sym} 93640 -18160 0 0 {name=p93117 lab=_68796_/B }
C {devices/lab_pin.sym} 93760 -18180 0 1 {name=p93118 lab=_68796_/X }
C {sky130_stdcells/and2_4.sym} 93700 -18180 0 0 {name=X_68796_ }
C {devices/lab_pin.sym} 93610 -18050 0 0 {name=p93119 lab=_85601_/CLK }
C {devices/lab_pin.sym} 93610 -18030 0 0 {name=p93120 lab=_53621_/Y }
C {devices/lab_pin.sym} 93790 -18050 0 1 {name=p93121 lab=_85601_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -18040 0 0 {name=X_85601_ }
C {devices/lab_pin.sym} 93610 -17910 0 0 {name=p93122 lab=_81019_/CLK }
C {devices/lab_pin.sym} 93610 -17890 0 0 {name=p93123 lab=_82845_/Q }
C {devices/lab_pin.sym} 93790 -17910 0 1 {name=p93124 lab=_82813_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -17900 0 0 {name=X_82813_ }
C {devices/lab_pin.sym} 93640 -17780 0 0 {name=p93125 lab=_55761_/A }
C {devices/lab_pin.sym} 93640 -17740 0 0 {name=p93126 lab=_55761_/B }
C {devices/lab_pin.sym} 93760 -17760 0 1 {name=p93127 lab=_55761_/X }
C {sky130_stdcells/and2_4.sym} 93700 -17760 0 0 {name=X_55761_ }
C {devices/lab_pin.sym} 93660 -17630 0 0 {name=p93128 lab=_67863_/A }
C {devices/lab_pin.sym} 93740 -17630 0 1 {name=p93129 lab=_67747_/X }
C {sky130_stdcells/buf_2.sym} 93700 -17630 0 0 {name=X_67747_ }
C {devices/lab_pin.sym} 93610 -17510 0 0 {name=p93130 lab=_86582_/CLK }
C {devices/lab_pin.sym} 93610 -17490 0 0 {name=p93131 lab=_47966_/Y }
C {devices/lab_pin.sym} 93790 -17510 0 1 {name=p93132 lab=_66084_/B }
C {sky130_stdcells/dfxtp_4.sym} 93700 -17500 0 0 {name=X_86581_ }
C {devices/lab_pin.sym} 93640 -17380 0 0 {name=p93133 lab=_52979_/A }
C {devices/lab_pin.sym} 93640 -17340 0 0 {name=p93134 lab=_52973_/B }
C {devices/lab_pin.sym} 93760 -17360 0 1 {name=p93135 lab=_52973_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -17360 0 0 {name=X_52973_ }
C {devices/lab_pin.sym} 93660 -17230 0 0 {name=p93136 lab=_64807_/A }
C {devices/lab_pin.sym} 93740 -17230 0 1 {name=p93137 lab=_64959_/X }
C {sky130_stdcells/buf_2.sym} 93700 -17230 0 0 {name=X_64959_ }
C {devices/lab_pin.sym} 93610 -17110 0 0 {name=p93138 lab=_81620_/CLK }
C {devices/lab_pin.sym} 93610 -17090 0 0 {name=p93139 lab=_83793_/D }
C {devices/lab_pin.sym} 93790 -17110 0 1 {name=p93140 lab=_83793_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -17100 0 0 {name=X_83793_ }
C {devices/lab_pin.sym} 93660 -16970 0 0 {name=p93141 lab=clkbuf_9_310_0_CLK/X }
C {devices/lab_pin.sym} 93740 -16970 0 1 {name=p93142 lab=_83974_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 93700 -16970 0 0 {name=Xclkbuf_10_621_0_CLK }
C {devices/lab_pin.sym} 93620 -16870 0 0 {name=p93143 lab=_84991_/Q }
C {devices/lab_pin.sym} 93620 -16830 0 0 {name=p93144 lab=_57493_/X }
C {devices/lab_pin.sym} 93620 -16790 0 0 {name=p93145 lab=_57499_/Y }
C {devices/lab_pin.sym} 93780 -16830 0 1 {name=p93146 lab=_57500_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -16830 0 0 {name=X_57500_ }
C {devices/lab_pin.sym} 93610 -16690 0 0 {name=p93147 lab=_87813_/CLK }
C {devices/lab_pin.sym} 93610 -16670 0 0 {name=p93148 lab=_40869_/Y }
C {devices/lab_pin.sym} 93790 -16690 0 1 {name=p93149 lab=_69826_/B }
C {sky130_stdcells/dfxtp_4.sym} 93700 -16680 0 0 {name=X_88320_ }
C {devices/lab_pin.sym} 93640 -16580 0 0 {name=p93150 lab=_54699_/X }
C {devices/lab_pin.sym} 93640 -16540 0 0 {name=p93151 lab=_54734_/B }
C {devices/lab_pin.sym} 93640 -16500 0 0 {name=p93152 lab=_54721_/C }
C {devices/lab_pin.sym} 93640 -16460 0 0 {name=p93153 lab=_47391_/A }
C {devices/lab_pin.sym} 93760 -16520 0 1 {name=p93154 lab=_54712_/X }
C {sky130_stdcells/and4_4.sym} 93700 -16520 0 0 {name=X_54712_ }
C {devices/lab_pin.sym} 93610 -16370 0 0 {name=p93155 lab=_86045_/CLK }
C {devices/lab_pin.sym} 93610 -16350 0 0 {name=p93156 lab=_53970_/Y }
C {devices/lab_pin.sym} 93790 -16370 0 1 {name=p93157 lab=_85532_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -16360 0 0 {name=X_85532_ }
C {devices/lab_pin.sym} 93620 -16250 0 0 {name=p93158 lab=_52021_/A }
C {devices/lab_pin.sym} 93620 -16210 0 0 {name=p93159 lab=_57491_/C }
C {devices/lab_pin.sym} 93620 -16170 0 0 {name=p93160 lab=_51923_/Y }
C {devices/lab_pin.sym} 93780 -16210 0 1 {name=p93161 lab=_51924_/X }
C {sky130_stdcells/o21a_4.sym} 93700 -16210 0 0 {name=X_51924_ }
C {devices/lab_pin.sym} 93660 -16070 0 0 {name=p93162 lab=_58480_/A }
C {devices/lab_pin.sym} 93740 -16070 0 1 {name=p93163 lab=_58480_/Y }
C {sky130_stdcells/inv_2.sym} 93700 -16070 0 0 {name=X_58480_ }
C {devices/lab_pin.sym} 93610 -15950 0 0 {name=p93164 lab=_82152_/CLK }
C {devices/lab_pin.sym} 93610 -15930 0 0 {name=p93165 lab=_66415_/C }
C {devices/lab_pin.sym} 93790 -15950 0 1 {name=p93166 lab=_79011_/A }
C {sky130_stdcells/dfxtp_4.sym} 93700 -15940 0 0 {name=X_82744_ }
C {devices/lab_pin.sym} 93640 -15820 0 0 {name=p93167 lab=_55698_/A }
C {devices/lab_pin.sym} 93640 -15780 0 0 {name=p93168 lab=_56287_/C }
C {devices/lab_pin.sym} 93760 -15800 0 1 {name=p93169 lab=_55692_/X }
C {sky130_stdcells/and2_4.sym} 93700 -15800 0 0 {name=X_55692_ }
C {devices/lab_pin.sym} 93660 -15670 0 0 {name=p93170 lab=_68451_/A }
C {devices/lab_pin.sym} 93740 -15670 0 1 {name=p93171 lab=_67678_/X }
C {sky130_stdcells/buf_2.sym} 93700 -15670 0 0 {name=X_67678_ }
C {devices/lab_pin.sym} 93660 -15550 0 0 {name=p93172 lab=clkbuf_8_56_0_CLK/X }
C {devices/lab_pin.sym} 93740 -15550 0 1 {name=p93173 lab=clkbuf_9_112_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 93700 -15550 0 0 {name=Xclkbuf_9_112_0_CLK }
C {devices/lab_pin.sym} 93620 -15450 0 0 {name=p93174 lab=_44292_/A }
C {devices/lab_pin.sym} 93620 -15410 0 0 {name=p93175 lab=_57010_/A }
C {devices/lab_pin.sym} 93620 -15370 0 0 {name=p93176 lab=_57430_/X }
C {devices/lab_pin.sym} 93780 -15410 0 1 {name=p93177 lab=_57431_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -15410 0 0 {name=X_57431_ }
C {devices/lab_pin.sym} 93620 -15290 0 0 {name=p93178 lab=_69413_/X }
C {devices/lab_pin.sym} 93620 -15250 0 0 {name=p93179 lab=_69416_/X }
C {devices/lab_pin.sym} 93620 -15210 0 0 {name=p93180 lab=_69171_/X }
C {devices/lab_pin.sym} 93780 -15250 0 1 {name=p93181 lab=_69417_/Y }
C {sky130_stdcells/a21oi_4.sym} 93700 -15250 0 0 {name=X_69417_ }
C {devices/lab_pin.sym} 93610 -15110 0 0 {name=p93182 lab=_87073_/CLK }
C {devices/lab_pin.sym} 93610 -15090 0 0 {name=p93183 lab=_41247_/Y }
C {devices/lab_pin.sym} 93790 -15110 0 1 {name=p93184 lab=_68970_/B }
C {sky130_stdcells/dfxtp_4.sym} 93700 -15100 0 0 {name=X_88251_ }
C {devices/lab_pin.sym} 93660 -14970 0 0 {name=p93185 lab=_54616_/X }
C {devices/lab_pin.sym} 93740 -14970 0 1 {name=p93186 lab=_54667_/A }
C {sky130_stdcells/buf_2.sym} 93700 -14970 0 0 {name=X_54643_ }
C {devices/lab_pin.sym} 93660 -14850 0 0 {name=p93187 lab=_66628_/X }
C {devices/lab_pin.sym} 93740 -14850 0 1 {name=p93188 lab=_66629_/X }
C {sky130_stdcells/buf_2.sym} 93700 -14850 0 0 {name=X_66629_ }
C {devices/lab_pin.sym} 93610 -14730 0 0 {name=p93189 lab=_82769_/CLK }
C {devices/lab_pin.sym} 93610 -14710 0 0 {name=p93190 lab=_85463_/D }
C {devices/lab_pin.sym} 93790 -14730 0 1 {name=p93191 lab=_85463_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -14720 0 0 {name=X_85463_ }
C {devices/lab_pin.sym} 93640 -14620 0 0 {name=p93192 lab=_51851_/A }
C {devices/lab_pin.sym} 93640 -14580 0 0 {name=p93193 lab=_51851_/B }
C {devices/lab_pin.sym} 93640 -14540 0 0 {name=p93194 lab=_51851_/C }
C {devices/lab_pin.sym} 93640 -14500 0 0 {name=p93195 lab=_52681_/D }
C {devices/lab_pin.sym} 93760 -14560 0 1 {name=p93196 lab=_51855_/X }
C {sky130_stdcells/and4_4.sym} 93700 -14560 0 0 {name=X_51855_ }
C {devices/lab_pin.sym} 93610 -14410 0 0 {name=p93197 lab=_82675_/CLK }
C {devices/lab_pin.sym} 93610 -14390 0 0 {name=p93198 lab=_82675_/D }
C {devices/lab_pin.sym} 93790 -14410 0 1 {name=p93199 lab=_78202_/A }
C {sky130_stdcells/dfxtp_4.sym} 93700 -14400 0 0 {name=X_82675_ }
C {devices/lab_pin.sym} 93610 -14270 0 0 {name=p93200 lab=_87720_/CLK }
C {devices/lab_pin.sym} 93610 -14250 0 0 {name=p93201 lab=_87202_/D }
C {devices/lab_pin.sym} 93790 -14270 0 1 {name=p93202 lab=_67752_/B }
C {sky130_stdcells/dfxtp_4.sym} 93700 -14260 0 0 {name=X_87202_ }
C {devices/lab_pin.sym} 93610 -14130 0 0 {name=p93203 lab=_84414_/CLK }
C {devices/lab_pin.sym} 93610 -14110 0 0 {name=p93204 lab=_84414_/D }
C {devices/lab_pin.sym} 93790 -14130 0 1 {name=p93205 lab=_84414_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -14120 0 0 {name=X_84414_ }
C {devices/lab_pin.sym} 93640 -14000 0 0 {name=p93206 lab=_50806_/A }
C {devices/lab_pin.sym} 93640 -13960 0 0 {name=p93207 lab=_51316_/B }
C {devices/lab_pin.sym} 93760 -13980 0 1 {name=p93208 lab=_50806_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -13980 0 0 {name=X_50806_ }
C {devices/lab_pin.sym} 93620 -13870 0 0 {name=p93209 lab=_56900_/X }
C {devices/lab_pin.sym} 93620 -13830 0 0 {name=p93210 lab=_56703_/X }
C {devices/lab_pin.sym} 93620 -13790 0 0 {name=p93211 lab=_57361_/Y }
C {devices/lab_pin.sym} 93780 -13830 0 1 {name=p93212 lab=_57362_/X }
C {sky130_stdcells/a21bo_4.sym} 93700 -13830 0 0 {name=X_57362_ }
C {devices/lab_pin.sym} 93610 -13690 0 0 {name=p93213 lab=_81279_/CLK }
C {devices/lab_pin.sym} 93610 -13670 0 0 {name=p93214 lab=_76518_/B }
C {devices/lab_pin.sym} 93790 -13690 0 1 {name=p93215 lab=_81626_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -13680 0 0 {name=X_81626_ }
C {devices/lab_pin.sym} 93640 -13560 0 0 {name=p93216 lab=_69309_/A }
C {devices/lab_pin.sym} 93640 -13520 0 0 {name=p93217 lab=_88292_/Q }
C {devices/lab_pin.sym} 93760 -13540 0 1 {name=p93218 lab=_69348_/X }
C {sky130_stdcells/and2_4.sym} 93700 -13540 0 0 {name=X_69348_ }
C {devices/lab_pin.sym} 93610 -13410 0 0 {name=p93219 lab=_87926_/CLK }
C {devices/lab_pin.sym} 93610 -13390 0 0 {name=p93220 lab=_88182_/D }
C {devices/lab_pin.sym} 93790 -13410 0 1 {name=p93221 lab=_67279_/B }
C {sky130_stdcells/dfxtp_4.sym} 93700 -13400 0 0 {name=X_88182_ }
C {devices/lab_pin.sym} 93620 -13290 0 0 {name=p93222 lab=_85417_/Q }
C {devices/lab_pin.sym} 93620 -13250 0 0 {name=p93223 lab=_54567_/X }
C {devices/lab_pin.sym} 93620 -13210 0 0 {name=p93224 lab=_54573_/Y }
C {devices/lab_pin.sym} 93780 -13250 0 1 {name=p93225 lab=_54574_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -13250 0 0 {name=X_54574_ }
C {devices/lab_pin.sym} 93610 -13110 0 0 {name=p93226 lab=_85491_/CLK }
C {devices/lab_pin.sym} 93610 -13090 0 0 {name=p93227 lab=_85394_/D }
C {devices/lab_pin.sym} 93790 -13110 0 1 {name=p93228 lab=_85394_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -13100 0 0 {name=X_85394_ }
C {devices/lab_pin.sym} 93660 -12970 0 0 {name=p93229 lab=clkbuf_9_318_0_CLK/X }
C {devices/lab_pin.sym} 93740 -12970 0 1 {name=p93230 lab=_82005_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 93700 -12970 0 0 {name=Xclkbuf_10_636_0_CLK }
C {devices/lab_pin.sym} 93660 -12850 0 0 {name=p93231 lab=_51814_/A }
C {devices/lab_pin.sym} 93740 -12850 0 1 {name=p93232 lab=_51794_/B }
C {sky130_stdcells/buf_2.sym} 93700 -12850 0 0 {name=X_51786_ }
C {devices/lab_pin.sym} 93620 -12760 0 0 {name=p93233 lab=_84769_/Q }
C {devices/lab_pin.sym} 93620 -12720 0 0 {name=p93234 lab=_59043_/X }
C {devices/lab_pin.sym} 93620 -12680 0 0 {name=p93235 lab=_59095_/X }
C {devices/lab_pin.sym} 93620 -12640 0 0 {name=p93236 lab=_59100_/X }
C {devices/lab_pin.sym} 93780 -12700 0 1 {name=p93237 lab=_84769_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 93700 -12700 0 0 {name=X_59101_ }
C {devices/lab_pin.sym} 93640 -12570 0 0 {name=p93238 lab=_56309_/A }
C {devices/lab_pin.sym} 93640 -12530 0 0 {name=p93239 lab=_56312_/X }
C {devices/lab_pin.sym} 93640 -12490 0 0 {name=p93240 lab=_55908_/B }
C {devices/lab_pin.sym} 93760 -12530 0 1 {name=p93241 lab=_56313_/Y }
C {sky130_stdcells/nand3_4.sym} 93700 -12530 0 0 {name=X_56313_ }
C {devices/lab_pin.sym} 93610 -12390 0 0 {name=p93242 lab=_87484_/CLK }
C {devices/lab_pin.sym} 93610 -12370 0 0 {name=p93243 lab=_44390_/X }
C {devices/lab_pin.sym} 93790 -12390 0 1 {name=p93244 lab=_87133_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -12380 0 0 {name=X_87133_ }
C {devices/lab_pin.sym} 93640 -12260 0 0 {name=p93245 lab=_53503_/X }
C {devices/lab_pin.sym} 93640 -12220 0 0 {name=p93246 lab=_50300_/B }
C {devices/lab_pin.sym} 93760 -12240 0 1 {name=p93247 lab=_53525_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -12240 0 0 {name=X_53525_ }
C {devices/lab_pin.sym} 93610 -12110 0 0 {name=p93248 lab=_84849_/CLK }
C {devices/lab_pin.sym} 93610 -12090 0 0 {name=p93249 lab=_63200_/X }
C {devices/lab_pin.sym} 93790 -12110 0 1 {name=p93250 lab=_79343_/A }
C {sky130_stdcells/dfxtp_4.sym} 93700 -12100 0 0 {name=X_84345_ }
C {devices/lab_pin.sym} 93620 -11990 0 0 {name=p93251 lab=_50734_/Y }
C {devices/lab_pin.sym} 93620 -11950 0 0 {name=p93252 lab=_50735_/X }
C {devices/lab_pin.sym} 93620 -11910 0 0 {name=p93253 lab=_50736_/Y }
C {devices/lab_pin.sym} 93780 -11950 0 1 {name=p93254 lab=_50737_/Y }
C {sky130_stdcells/a21boi_4.sym} 93700 -11950 0 0 {name=X_50737_ }
C {devices/lab_pin.sym} 93640 -11820 0 0 {name=p93255 lab=_56824_/X }
C {devices/lab_pin.sym} 93640 -11780 0 0 {name=p93256 lab=_85039_/Q }
C {devices/lab_pin.sym} 93760 -11800 0 1 {name=p93257 lab=_57293_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -11800 0 0 {name=X_57293_ }
C {devices/lab_pin.sym} 93610 -11670 0 0 {name=p93258 lab=_84087_/CLK }
C {devices/lab_pin.sym} 93610 -11650 0 0 {name=p93259 lab=_76826_/X }
C {devices/lab_pin.sym} 93790 -11670 0 1 {name=p93260 lab=_81513_/D }
C {sky130_stdcells/dfxtp_4.sym} 93700 -11660 0 0 {name=X_81557_ }
C {devices/lab_pin.sym} 93640 -11540 0 0 {name=p93261 lab=_69253_/A }
C {devices/lab_pin.sym} 93640 -11500 0 0 {name=p93262 lab=_69279_/B }
C {devices/lab_pin.sym} 93760 -11520 0 1 {name=p93263 lab=_69279_/X }
C {sky130_stdcells/and2_4.sym} 93700 -11520 0 0 {name=X_69279_ }
C {devices/lab_pin.sym} 93660 -11390 0 0 {name=p93264 lab=clkbuf_8_63_0_CLK/X }
C {devices/lab_pin.sym} 93740 -11390 0 1 {name=p93265 lab=clkbuf_9_127_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 93700 -11390 0 0 {name=Xclkbuf_9_127_0_CLK }
C {devices/lab_pin.sym} 93660 -11270 0 0 {name=p93266 lab=clkbuf_9_55_0_CLK/A }
C {devices/lab_pin.sym} 93740 -11270 0 1 {name=p93267 lab=clkbuf_9_54_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 93700 -11270 0 0 {name=Xclkbuf_9_54_0_CLK }
C {devices/lab_pin.sym} 93620 -11190 0 0 {name=p93268 lab=_59027_/X }
C {devices/lab_pin.sym} 93620 -11150 0 0 {name=p93269 lab=_59029_/Y }
C {devices/lab_pin.sym} 93620 -11110 0 0 {name=p93270 lab=_59030_/Y }
C {devices/lab_pin.sym} 93620 -11070 0 0 {name=p93271 lab=_58959_/X }
C {devices/lab_pin.sym} 93620 -11030 0 0 {name=p93272 lab=_59031_/X }
C {devices/lab_pin.sym} 93780 -11110 0 1 {name=p93273 lab=_59032_/X }
C {sky130_stdcells/o32a_4.sym} 93700 -11110 0 0 {name=X_59032_ }
C {devices/lab_pin.sym} 93660 -10950 0 0 {name=p93274 lab=_70819_/A }
C {devices/lab_pin.sym} 93740 -10950 0 1 {name=p93275 lab=_71333_/C }
C {sky130_stdcells/buf_2.sym} 93700 -10950 0 0 {name=X_71310_ }
C {devices/lab_pin.sym} 93640 -10840 0 0 {name=p93276 lab=_80504_/X }
C {devices/lab_pin.sym} 93640 -10800 0 0 {name=p93277 lab=_80520_/B }
C {devices/lab_pin.sym} 93760 -10820 0 1 {name=p93278 lab=_80513_/A }
C {sky130_stdcells/xor2_4.sym} 93700 -10820 0 0 {name=X_80508_ }
C {devices/lab_pin.sym} 93620 -10710 0 0 {name=p93279 lab=_56109_/X }
C {devices/lab_pin.sym} 93620 -10670 0 0 {name=p93280 lab=_56242_/X }
C {devices/lab_pin.sym} 93620 -10630 0 0 {name=p93281 lab=_56243_/Y }
C {devices/lab_pin.sym} 93780 -10670 0 1 {name=p93282 lab=_85262_/D }
C {sky130_stdcells/o21ai_4.sym} 93700 -10670 0 0 {name=X_56244_ }
C {devices/lab_pin.sym} 93620 -10560 0 0 {name=p93283 lab=_41469_/X }
C {devices/lab_pin.sym} 93620 -10520 0 0 {name=p93284 lab=_41455_/X }
C {devices/lab_pin.sym} 93620 -10480 0 0 {name=p93285 lab=_66634_/B }
C {devices/lab_pin.sym} 93620 -10440 0 0 {name=p93286 lab=_41457_/X }
C {devices/lab_pin.sym} 93780 -10500 0 1 {name=p93287 lab=_41470_/X }
C {sky130_stdcells/a2bb2o_4.sym} 93700 -10500 0 0 {name=X_41470_ }
C {devices/lab_pin.sym} 93610 -10350 0 0 {name=p93288 lab=_87063_/CLK }
C {devices/lab_pin.sym} 93610 -10330 0 0 {name=p93289 lab=_44536_/Y }
C {devices/lab_pin.sym} 93790 -10350 0 1 {name=p93290 lab=_87064_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -10340 0 0 {name=X_87064_ }
C {devices/lab_pin.sym} 93660 -10210 0 0 {name=p93291 lab=_53900_/A }
C {devices/lab_pin.sym} 93740 -10210 0 1 {name=p93292 lab=_53821_/B }
C {sky130_stdcells/buf_2.sym} 93700 -10210 0 0 {name=X_53456_ }
C {devices/lab_pin.sym} 93620 -10110 0 0 {name=p93293 lab=_72240_/X }
C {devices/lab_pin.sym} 93620 -10070 0 0 {name=p93294 lab=_85683_/Q }
C {devices/lab_pin.sym} 93620 -10030 0 0 {name=p93295 lab=_72241_/X }
C {devices/lab_pin.sym} 93780 -10070 0 1 {name=p93296 lab=_72290_/X }
C {sky130_stdcells/o21a_4.sym} 93700 -10070 0 0 {name=X_72290_ }
C {devices/lab_pin.sym} 93610 -9930 0 0 {name=p93297 lab=_84276_/CLK }
C {devices/lab_pin.sym} 93610 -9910 0 0 {name=p93298 lab=_84276_/D }
C {devices/lab_pin.sym} 93790 -9930 0 1 {name=p93299 lab=_64088_/C }
C {sky130_stdcells/dfxtp_4.sym} 93700 -9920 0 0 {name=X_84276_ }
C {devices/lab_pin.sym} 93640 -9810 0 0 {name=p93300 lab=_52365_/A }
C {devices/lab_pin.sym} 93640 -9770 0 0 {name=p93301 lab=_50651_/X }
C {devices/lab_pin.sym} 93640 -9730 0 0 {name=p93302 lab=_50668_/C }
C {devices/lab_pin.sym} 93760 -9770 0 1 {name=p93303 lab=_50668_/X }
C {sky130_stdcells/and3_4.sym} 93700 -9770 0 0 {name=X_50668_ }
C {devices/lab_pin.sym} 93610 -9630 0 0 {name=p93304 lab=_81361_/CLK }
C {devices/lab_pin.sym} 93610 -9610 0 0 {name=p93305 lab=_84056_/Q }
C {devices/lab_pin.sym} 93790 -9630 0 1 {name=p93306 lab=_81488_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -9620 0 0 {name=X_81488_ }
C {devices/lab_pin.sym} 93610 -9490 0 0 {name=p93307 lab=_85727_/CLK }
C {devices/lab_pin.sym} 93610 -9470 0 0 {name=p93308 lab=_86015_/D }
C {devices/lab_pin.sym} 93790 -9490 0 1 {name=p93309 lab=_86015_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -9480 0 0 {name=X_86015_ }
C {devices/lab_pin.sym} 93660 -9350 0 0 {name=p93310 lab=_47867_/A }
C {devices/lab_pin.sym} 93740 -9350 0 1 {name=p93311 lab=_40421_/X }
C {sky130_stdcells/buf_2.sym} 93700 -9350 0 0 {name=X_40421_ }
C {devices/lab_pin.sym} 93640 -9240 0 0 {name=p93312 lab=_52407_/A }
C {devices/lab_pin.sym} 93640 -9200 0 0 {name=p93313 lab=_49172_/A }
C {devices/lab_pin.sym} 93760 -9220 0 1 {name=p93314 lab=_52407_/X }
C {sky130_stdcells/and2_4.sym} 93700 -9220 0 0 {name=X_52407_ }
C {devices/lab_pin.sym} 93660 -9090 0 0 {name=p93315 lab=_71241_/A }
C {devices/lab_pin.sym} 93740 -9090 0 1 {name=p93316 lab=_71252_/A }
C {sky130_stdcells/buf_2.sym} 93700 -9090 0 0 {name=X_71241_ }
C {devices/lab_pin.sym} 93610 -8970 0 0 {name=p93317 lab=_83227_/CLK }
C {devices/lab_pin.sym} 93610 -8950 0 0 {name=p93318 lab=_72586_/Y }
C {devices/lab_pin.sym} 93790 -8970 0 1 {name=p93319 lab=_79363_/B }
C {sky130_stdcells/dfxtp_4.sym} 93700 -8960 0 0 {name=X_83227_ }
C {devices/lab_pin.sym} 93640 -8850 0 0 {name=p93320 lab=_56175_/A }
C {devices/lab_pin.sym} 93640 -8810 0 0 {name=p93321 lab=_56175_/B }
C {devices/lab_pin.sym} 93640 -8770 0 0 {name=p93322 lab=_56174_/X }
C {devices/lab_pin.sym} 93760 -8810 0 1 {name=p93323 lab=_56175_/Y }
C {sky130_stdcells/nand3_4.sym} 93700 -8810 0 0 {name=X_56175_ }
C {devices/lab_pin.sym} 93640 -8680 0 0 {name=p93324 lab=_80432_/X }
C {devices/lab_pin.sym} 93640 -8640 0 0 {name=p93325 lab=_80434_/B }
C {devices/lab_pin.sym} 93760 -8660 0 1 {name=p93326 lab=_80439_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -8660 0 0 {name=X_80439_ }
C {devices/lab_pin.sym} 93620 -8550 0 0 {name=p93327 lab=_85643_/Q }
C {devices/lab_pin.sym} 93620 -8510 0 0 {name=p93328 lab=_53378_/X }
C {devices/lab_pin.sym} 93620 -8470 0 0 {name=p93329 lab=_53386_/Y }
C {devices/lab_pin.sym} 93780 -8510 0 1 {name=p93330 lab=_53387_/Y }
C {sky130_stdcells/o21ai_4.sym} 93700 -8510 0 0 {name=X_53387_ }
C {devices/lab_pin.sym} 93640 -8380 0 0 {name=p93331 lab=_50599_/A }
C {devices/lab_pin.sym} 93640 -8340 0 0 {name=p93332 lab=_50599_/B }
C {devices/lab_pin.sym} 93760 -8360 0 1 {name=p93333 lab=_50599_/X }
C {sky130_stdcells/or2_4.sym} 93700 -8360 0 0 {name=X_50599_ }
C {devices/lab_pin.sym} 93660 -8230 0 0 {name=p93334 lab=_43140_/A }
C {devices/lab_pin.sym} 93740 -8230 0 1 {name=p93335 lab=_43140_/Y }
C {sky130_stdcells/inv_2.sym} 93700 -8230 0 0 {name=X_43140_ }
C {devices/lab_pin.sym} 93660 -8110 0 0 {name=p93336 lab=_55126_/A }
C {devices/lab_pin.sym} 93740 -8110 0 1 {name=p93337 lab=_55126_/X }
C {sky130_stdcells/buf_2.sym} 93700 -8110 0 0 {name=X_55126_ }
C {devices/lab_pin.sym} 93660 -7990 0 0 {name=p93338 lab=_40352_/A }
C {devices/lab_pin.sym} 93740 -7990 0 1 {name=p93339 lab=_46290_/A }
C {sky130_stdcells/buf_2.sym} 93700 -7990 0 0 {name=X_40352_ }
C {devices/lab_pin.sym} 93640 -7880 0 0 {name=p93340 lab=_52334_/A }
C {devices/lab_pin.sym} 93640 -7840 0 0 {name=p93341 lab=_52338_/B }
C {devices/lab_pin.sym} 93760 -7860 0 1 {name=p93342 lab=_52338_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -7860 0 0 {name=X_52338_ }
C {devices/lab_pin.sym} 93620 -7750 0 0 {name=p93343 lab=_50440_/B }
C {devices/lab_pin.sym} 93620 -7710 0 0 {name=p93344 lab=_71165_/X }
C {devices/lab_pin.sym} 93620 -7670 0 0 {name=p93345 lab=_71171_/Y }
C {devices/lab_pin.sym} 93780 -7710 0 1 {name=p93346 lab=_83584_/D }
C {sky130_stdcells/o21ai_4.sym} 93700 -7710 0 0 {name=X_71172_ }
C {devices/lab_pin.sym} 93610 -7570 0 0 {name=p93347 lab=_83158_/CLK }
C {devices/lab_pin.sym} 93610 -7550 0 0 {name=p93348 lab=_73272_/X }
C {devices/lab_pin.sym} 93790 -7570 0 1 {name=p93349 lab=_83158_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -7560 0 0 {name=X_83158_ }
C {devices/lab_pin.sym} 93660 -7430 0 0 {name=p93350 lab=clkbuf_9_69_0_CLK/A }
C {devices/lab_pin.sym} 93740 -7430 0 1 {name=p93351 lab=clkbuf_9_69_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 93700 -7430 0 0 {name=Xclkbuf_9_69_0_CLK }
C {devices/lab_pin.sym} 93660 -7310 0 0 {name=p93352 lab=_70123_/A }
C {devices/lab_pin.sym} 93740 -7310 0 1 {name=p93353 lab=_70125_/C }
C {sky130_stdcells/inv_2.sym} 93700 -7310 0 0 {name=X_70123_ }
C {devices/lab_pin.sym} 93610 -7190 0 0 {name=p93354 lab=_82860_/CLK }
C {devices/lab_pin.sym} 93610 -7170 0 0 {name=p93355 lab=_82109_/D }
C {devices/lab_pin.sym} 93790 -7190 0 1 {name=p93356 lab=_82109_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -7180 0 0 {name=X_82109_ }
C {devices/lab_pin.sym} 93620 -7090 0 0 {name=p93357 lab=_43053_/X }
C {devices/lab_pin.sym} 93620 -7050 0 0 {name=p93358 lab=_43054_/X }
C {devices/lab_pin.sym} 93620 -7010 0 0 {name=p93359 lab=_40678_/X }
C {devices/lab_pin.sym} 93620 -6970 0 0 {name=p93360 lab=_43070_/Y }
C {devices/lab_pin.sym} 93620 -6930 0 0 {name=p93361 lab=_43058_/X }
C {devices/lab_pin.sym} 93780 -7010 0 1 {name=p93362 lab=_87587_/D }
C {sky130_stdcells/o32ai_4.sym} 93700 -7010 0 0 {name=X_43071_ }
C {devices/lab_pin.sym} 93640 -6880 0 0 {name=p93363 lab=_55043_/X }
C {devices/lab_pin.sym} 93640 -6840 0 0 {name=p93364 lab=_55056_/X }
C {devices/lab_pin.sym} 93640 -6800 0 0 {name=p93365 lab=_55070_/C }
C {devices/lab_pin.sym} 93640 -6760 0 0 {name=p93366 lab=_47701_/A }
C {devices/lab_pin.sym} 93760 -6820 0 1 {name=p93367 lab=_55057_/X }
C {sky130_stdcells/and4_4.sym} 93700 -6820 0 0 {name=X_55057_ }
C {devices/lab_pin.sym} 93660 -6670 0 0 {name=p93368 lab=_59917_/X }
C {devices/lab_pin.sym} 93740 -6670 0 1 {name=p93369 lab=_59943_/A }
C {sky130_stdcells/buf_2.sym} 93700 -6670 0 0 {name=X_59934_ }
C {devices/lab_pin.sym} 93660 -6550 0 0 {name=p93370 lab=_52214_/A }
C {devices/lab_pin.sym} 93740 -6550 0 1 {name=p93371 lab=_52269_/X }
C {sky130_stdcells/buf_2.sym} 93700 -6550 0 0 {name=X_52269_ }
C {devices/lab_pin.sym} 93640 -6440 0 0 {name=p93372 lab=_75980_/A }
C {devices/lab_pin.sym} 93640 -6400 0 0 {name=p93373 lab=_75980_/B }
C {devices/lab_pin.sym} 93760 -6420 0 1 {name=p93374 lab=_75980_/Y }
C {sky130_stdcells/nand2_4.sym} 93700 -6420 0 0 {name=X_75980_ }
C {devices/lab_pin.sym} 93610 -6290 0 0 {name=p93375 lab=_81627_/CLK }
C {devices/lab_pin.sym} 93610 -6270 0 0 {name=p93376 lab=_83089_/D }
C {devices/lab_pin.sym} 93790 -6290 0 1 {name=p93377 lab=_83089_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -6280 0 0 {name=X_83089_ }
C {devices/lab_pin.sym} 93610 -6150 0 0 {name=p93378 lab=_87720_/CLK }
C {devices/lab_pin.sym} 93610 -6130 0 0 {name=p93379 lab=_42237_/X }
C {devices/lab_pin.sym} 93790 -6150 0 1 {name=p93380 lab=_87966_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -6140 0 0 {name=X_87966_ }
C {devices/lab_pin.sym} 93620 -6050 0 0 {name=p93381 lab=_42013_/X }
C {devices/lab_pin.sym} 93620 -6010 0 0 {name=p93382 lab=_42006_/X }
C {devices/lab_pin.sym} 93620 -5970 0 0 {name=p93383 lab=_40849_/X }
C {devices/lab_pin.sym} 93620 -5930 0 0 {name=p93384 lab=_73175_/A }
C {devices/lab_pin.sym} 93620 -5890 0 0 {name=p93385 lab=_42007_/X }
C {devices/lab_pin.sym} 93780 -5970 0 1 {name=p93386 lab=_42023_/A }
C {sky130_stdcells/o32ai_4.sym} 93700 -5970 0 0 {name=X_42022_ }
C {devices/lab_pin.sym} 93620 -5830 0 0 {name=p93387 lab=_54005_/Y }
C {devices/lab_pin.sym} 93620 -5790 0 0 {name=p93388 lab=_54006_/X }
C {devices/lab_pin.sym} 93620 -5750 0 0 {name=p93389 lab=_54007_/Y }
C {devices/lab_pin.sym} 93780 -5790 0 1 {name=p93390 lab=_54008_/Y }
C {sky130_stdcells/a21boi_4.sym} 93700 -5790 0 0 {name=X_54008_ }
C {devices/lab_pin.sym} 93640 -5670 0 0 {name=p93391 lab=_74923_/A }
C {devices/lab_pin.sym} 93640 -5630 0 0 {name=p93392 lab=_81132_/D }
C {devices/lab_pin.sym} 93640 -5590 0 0 {name=p93393 lab=_74912_/B }
C {devices/lab_pin.sym} 93760 -5630 0 1 {name=p93394 lab=_74931_/Y }
C {sky130_stdcells/nand3_4.sym} 93700 -5630 0 0 {name=X_74931_ }
C {devices/lab_pin.sym} 93640 -5510 0 0 {name=p93395 lab=_70054_/A }
C {devices/lab_pin.sym} 93640 -5470 0 0 {name=p93396 lab=_70053_/X }
C {devices/lab_pin.sym} 93640 -5430 0 0 {name=p93397 lab=_70021_/C }
C {devices/lab_pin.sym} 93760 -5470 0 1 {name=p93398 lab=_70054_/Y }
C {sky130_stdcells/nand3_4.sym} 93700 -5470 0 0 {name=X_70054_ }
C {devices/lab_pin.sym} 93610 -5330 0 0 {name=p93399 lab=_86914_/CLK }
C {devices/lab_pin.sym} 93610 -5310 0 0 {name=p93400 lab=_86917_/D }
C {devices/lab_pin.sym} 93790 -5330 0 1 {name=p93401 lab=_67964_/B }
C {sky130_stdcells/dfxtp_4.sym} 93700 -5320 0 0 {name=X_86917_ }
C {devices/lab_pin.sym} 93620 -5230 0 0 {name=p93402 lab=_59811_/Y }
C {devices/lab_pin.sym} 93620 -5190 0 0 {name=p93403 lab=_59758_/X }
C {devices/lab_pin.sym} 93620 -5150 0 0 {name=p93404 lab=_59862_/X }
C {devices/lab_pin.sym} 93620 -5110 0 0 {name=p93405 lab=_59783_/Y }
C {devices/lab_pin.sym} 93620 -5080 0 0 {name=p93406 lab=_59864_/Y }
C {devices/lab_pin.sym} 93780 -5150 0 1 {name=p93407 lab=_59865_/Y }
C {sky130_stdcells/a41oi_4.sym} 93700 -5150 0 0 {name=X_59865_ }
C {devices/lab_pin.sym} 93610 -4990 0 0 {name=p93408 lab=_87195_/CLK }
C {devices/lab_pin.sym} 93610 -4970 0 0 {name=p93409 lab=_87897_/D }
C {devices/lab_pin.sym} 93790 -4990 0 1 {name=p93410 lab=_87897_/Q }
C {sky130_stdcells/dfxtp_4.sym} 93700 -4980 0 0 {name=X_87897_ }
C {devices/lab_pin.sym} 93640 -4880 0 0 {name=p93411 lab=_46830_/A }
C {devices/lab_pin.sym} 93640 -4840 0 0 {name=p93412 lab=_46830_/B }
C {devices/lab_pin.sym} 93640 -4800 0 0 {name=p93413 lab=_46830_/C }
C {devices/lab_pin.sym} 93640 -4760 0 0 {name=p93414 lab=_52698_/D }
C {devices/lab_pin.sym} 93760 -4820 0 1 {name=p93415 lab=_46830_/X }
C {sky130_stdcells/and4_4.sym} 93700 -4820 0 0 {name=X_46830_ }
C {devices/lab_pin.sym} 93620 -4690 0 0 {name=p93416 lab=_58812_/Y }
C {devices/lab_pin.sym} 93620 -4650 0 0 {name=p93417 lab=_58815_/Y }
C {devices/lab_pin.sym} 93620 -4610 0 0 {name=p93418 lab=_58735_/X }
C {devices/lab_pin.sym} 93780 -4650 0 1 {name=p93419 lab=_58816_/X }
C {sky130_stdcells/a21o_4.sym} 93700 -4650 0 0 {name=X_58816_ }
C {devices/lab_pin.sym} 93640 -4520 0 0 {name=p93420 lab=_77650_/A }
C {devices/lab_pin.sym} 93640 -4480 0 0 {name=p93421 lab=_77650_/B }
C {devices/lab_pin.sym} 93760 -4500 0 1 {name=p93422 lab=_77650_/Y }
C {sky130_stdcells/nor2_4.sym} 93700 -4500 0 0 {name=X_77650_ }
C {devices/lab_pin.sym} 93660 -4370 0 0 {name=p93423 lab=_74863_/B }
C {devices/lab_pin.sym} 93740 -4370 0 1 {name=p93424 lab=_81156_/D }
C {sky130_stdcells/inv_2.sym} 93700 -4370 0 0 {name=X_74862_ }
C {devices/lab_pin.sym} 93610 -4250 0 0 {name=p93425 lab=_84420_/CLK }
C {devices/lab_pin.sym} 93610 -4230 0 0 {name=p93426 lab=_45880_/Y }
C {devices/lab_pin.sym} 93790 -4250 0 1 {name=p93427 lab=_64190_/A }
C {sky130_stdcells/dfxtp_4.sym} 93700 -4240 0 0 {name=X_86848_ }
C {devices/lab_pin.sym} 93620 -4150 0 0 {name=p93428 lab=_59727_/X }
C {devices/lab_pin.sym} 93620 -4110 0 0 {name=p93429 lab=_59790_/X }
C {devices/lab_pin.sym} 93620 -4070 0 0 {name=p93430 lab=_59745_/X }
C {devices/lab_pin.sym} 93620 -4030 0 0 {name=p93431 lab=_59794_/X }
C {devices/lab_pin.sym} 93620 -4000 0 0 {name=p93432 lab=_59795_/Y }
C {devices/lab_pin.sym} 93780 -4070 0 1 {name=p93433 lab=_84699_/D }
C {sky130_stdcells/a41oi_4.sym} 93700 -4070 0 0 {name=X_59796_ }
C {devices/lab_pin.sym} 93620 -3930 0 0 {name=p93434 lab=_76597_/X }
C {devices/lab_pin.sym} 93620 -3890 0 0 {name=p93435 lab=_76598_/Y }
C {devices/lab_pin.sym} 93620 -3850 0 0 {name=p93436 lab=_76602_/B }
C {devices/lab_pin.sym} 93780 -3890 0 1 {name=p93437 lab=_76614_/B }
C {sky130_stdcells/a21o_4.sym} 93700 -3890 0 0 {name=X_76601_ }
C {devices/lab_pin.sym} 93640 -3760 0 0 {name=p93438 lab=_57537_/B }
C {devices/lab_pin.sym} 93640 -3720 0 0 {name=p93439 lab=_73813_/B }
C {devices/lab_pin.sym} 93760 -3740 0 1 {name=p93440 lab=_73813_/X }
C {sky130_stdcells/xor2_4.sym} 93700 -3740 0 0 {name=X_73813_ }
C {devices/lab_pin.sym} 93660 -3610 0 0 {name=p93441 lab=_46667_/A }
C {devices/lab_pin.sym} 93740 -3610 0 1 {name=p93442 lab=_46784_/C }
C {sky130_stdcells/buf_2.sym} 93700 -3610 0 0 {name=X_46761_ }
C {devices/lab_pin.sym} 93660 -3490 0 0 {name=p93443 lab=_64600_/A }
C {devices/lab_pin.sym} 93740 -3490 0 1 {name=p93444 lab=_58864_/A }
C {sky130_stdcells/buf_2.sym} 93700 -3490 0 0 {name=X_58747_ }
C {devices/lab_pin.sym} 93640 -3380 0 0 {name=p93445 lab=_77582_/A }
C {devices/lab_pin.sym} 93640 -3340 0 0 {name=p93446 lab=_82118_/Q }
C {devices/lab_pin.sym} 93760 -3360 0 1 {name=p93447 lab=_77584_/B }
C {sky130_stdcells/nor2_4.sym} 93700 -3360 0 0 {name=X_77581_ }
C {devices/lab_pin.sym} 93620 -3260 0 0 {name=p93448 lab=_44067_/B }
C {devices/lab_pin.sym} 93620 -3220 0 0 {name=p93449 lab=_43944_/A }
C {devices/lab_pin.sym} 93620 -3180 0 0 {name=p93450 lab=_43945_/Y }
C {devices/lab_pin.sym} 93620 -3140 0 0 {name=p93451 lab=_43972_/Y }
C {devices/lab_pin.sym} 93780 -3200 0 1 {name=p93452 lab=_43973_/X }
C {sky130_stdcells/a211o_4.sym} 93700 -3200 0 0 {name=X_43973_ }
C {devices/lab_pin.sym} 93620 -3080 0 0 {name=p93453 lab=_85278_/Q }
C {devices/lab_pin.sym} 93620 -3040 0 0 {name=p93454 lab=_55689_/A }
C {devices/lab_pin.sym} 93620 -3000 0 0 {name=p93455 lab=_44052_/X }
C {devices/lab_pin.sym} 93620 -2960 0 0 {name=p93456 lab=_55958_/X }
C {devices/lab_pin.sym} 93780 -3020 0 1 {name=p93457 lab=_55959_/X }
C {sky130_stdcells/a211o_4.sym} 93700 -3020 0 0 {name=X_55959_ }
C {devices/lab_pin.sym} 93620 -2910 0 0 {name=p93458 lab=_83807_/Q }
C {devices/lab_pin.sym} 93620 -2870 0 0 {name=p93459 lab=_74738_/A }
C {devices/lab_pin.sym} 93620 -2830 0 0 {name=p93460 lab=_74787_/Y }
C {devices/lab_pin.sym} 93620 -2790 0 0 {name=p93461 lab=_74788_/Y }
C {devices/lab_pin.sym} 93620 -2750 0 0 {name=p93462 lab=_74792_/X }
C {devices/lab_pin.sym} 93780 -2830 0 1 {name=p93463 lab=_74793_/X }
C {sky130_stdcells/a2111o_4.sym} 93700 -2830 0 0 {name=X_74793_ }
C {devices/lab_pin.sym} 93610 -2670 0 0 {name=p93464 lab=_81182_/CLK }
C {devices/lab_pin.sym} 93610 -2650 0 0 {name=p93465 lab=_86779_/D }
C {devices/lab_pin.sym} 93790 -2670 0 1 {name=p93466 lab=_67227_/B }
C {sky130_stdcells/dfxtp_4.sym} 93700 -2660 0 0 {name=X_86779_ }
C {devices/lab_pin.sym} 93660 -2530 0 0 {name=p93467 lab=_48635_/A }
C {devices/lab_pin.sym} 93740 -2530 0 1 {name=p93468 lab=_48500_/X }
C {sky130_stdcells/buf_2.sym} 93700 -2530 0 0 {name=X_48500_ }
C {devices/lab_pin.sym} 93640 -2420 0 0 {name=p93469 lab=_84799_/Q }
C {devices/lab_pin.sym} 93640 -2380 0 0 {name=p93470 lab=_82735_/D }
C {devices/lab_pin.sym} 93760 -2400 0 1 {name=p93471 lab=_79320_/X }
C {sky130_stdcells/xor2_4.sym} 93700 -2400 0 0 {name=X_79320_ }
C {devices/lab_pin.sym} 93660 -2270 0 0 {name=p93472 lab=_45272_/A }
C {devices/lab_pin.sym} 93740 -2270 0 1 {name=p93473 lab=_45746_/B }
C {sky130_stdcells/buf_2.sym} 93700 -2270 0 0 {name=X_45712_ }
C {devices/lab_pin.sym} 93640 -2160 0 0 {name=p93474 lab=_81276_/Q }
C {devices/lab_pin.sym} 93640 -2120 0 0 {name=p93475 lab=_76533_/B }
C {devices/lab_pin.sym} 93760 -2140 0 1 {name=p93476 lab=_76535_/B }
C {sky130_stdcells/nor2_4.sym} 93700 -2140 0 0 {name=X_76532_ }
C {devices/lab_pin.sym} 93620 -2040 0 0 {name=p93477 lab=_41721_/X }
C {devices/lab_pin.sym} 93620 -2000 0 0 {name=p93478 lab=_42920_/X }
C {devices/lab_pin.sym} 93620 -1960 0 0 {name=p93479 lab=_87650_/Q }
C {devices/lab_pin.sym} 93620 -1920 0 0 {name=p93480 lab=_42922_/X }
C {devices/lab_pin.sym} 93780 -1980 0 1 {name=p93481 lab=_87650_/D }
C {sky130_stdcells/a2bb2o_4.sym} 93700 -1980 0 0 {name=X_42924_ }
C {devices/lab_pin.sym} 93620 -1850 0 0 {name=p93482 lab=_49477_/Y }
C {devices/lab_pin.sym} 93620 -1810 0 0 {name=p93483 lab=_49460_/X }
C {devices/lab_pin.sym} 93620 -1770 0 0 {name=p93484 lab=_49479_/X }
C {devices/lab_pin.sym} 93780 -1810 0 1 {name=p93485 lab=_49480_/Y }
C {sky130_stdcells/a21oi_4.sym} 93700 -1810 0 0 {name=X_49480_ }
C {devices/lab_pin.sym} 93640 -1680 0 0 {name=p93486 lab=_73739_/X }
C {devices/lab_pin.sym} 93640 -1640 0 0 {name=p93487 lab=_73743_/X }
C {devices/lab_pin.sym} 93760 -1660 0 1 {name=p93488 lab=_73745_/B }
C {sky130_stdcells/nand2_4.sym} 93700 -1660 0 0 {name=X_73744_ }
C {devices/lab_pin.sym} 93660 -1530 0 0 {name=p93489 lab=_83681_/Q }
C {devices/lab_pin.sym} 93740 -1530 0 1 {name=p93490 lab=_54309_/B }
C {sky130_stdcells/inv_2.sym} 93700 -1530 0 0 {name=X_46692_ }
C {devices/lab_pin.sym} 93660 -1410 0 0 {name=p93491 lab=_70944_/A }
C {devices/lab_pin.sym} 93740 -1410 0 1 {name=p93492 lab=_70969_/A }
C {sky130_stdcells/buf_2.sym} 93700 -1410 0 0 {name=X_70956_ }
C {devices/lab_pin.sym} 93620 -1330 0 0 {name=p93493 lab=_58585_/X }
C {devices/lab_pin.sym} 93620 -1290 0 0 {name=p93494 lab=_58675_/Y }
C {devices/lab_pin.sym} 93620 -1250 0 0 {name=p93495 lab=_58677_/Y }
C {devices/lab_pin.sym} 93620 -1210 0 0 {name=p93496 lab=_58603_/X }
C {devices/lab_pin.sym} 93620 -1170 0 0 {name=p93497 lab=_58589_/X }
C {devices/lab_pin.sym} 93780 -1250 0 1 {name=p93498 lab=_58678_/X }
C {sky130_stdcells/o32a_4.sym} 93700 -1250 0 0 {name=X_58678_ }
C {devices/lab_pin.sym} 93640 -1110 0 0 {name=p93499 lab=_48744_/A }
C {devices/lab_pin.sym} 93640 -1070 0 0 {name=p93500 lab=_48364_/X }
C {devices/lab_pin.sym} 93640 -1030 0 0 {name=p93501 lab=_48476_/C }
C {devices/lab_pin.sym} 93760 -1070 0 1 {name=p93502 lab=_48431_/X }
C {sky130_stdcells/and3_4.sym} 93700 -1070 0 0 {name=X_48431_ }
C {devices/lab_pin.sym} 93640 -940 0 0 {name=p93503 lab=_79251_/A }
C {devices/lab_pin.sym} 93640 -900 0 0 {name=p93504 lab=_79251_/B }
C {devices/lab_pin.sym} 93760 -920 0 1 {name=p93505 lab=_79251_/Y }
C {sky130_stdcells/nor2_4.sym} 93700 -920 0 0 {name=X_79251_ }
C {devices/lab_pin.sym} 93660 -790 0 0 {name=p93506 lab=_85105_/Q }
C {devices/lab_pin.sym} 93740 -790 0 1 {name=p93507 lab=_45643_/Y }
C {sky130_stdcells/inv_2.sym} 93700 -790 0 0 {name=X_45643_ }
C {devices/lab_pin.sym} 93620 -690 0 0 {name=p93508 lab=_57626_/Y }
C {devices/lab_pin.sym} 93620 -650 0 0 {name=p93509 lab=_57627_/X }
C {devices/lab_pin.sym} 93620 -610 0 0 {name=p93510 lab=_57628_/Y }
C {devices/lab_pin.sym} 93780 -650 0 1 {name=p93511 lab=_84966_/D }
C {sky130_stdcells/a21boi_4.sym} 93700 -650 0 0 {name=X_57629_ }
C {devices/lab_pin.sym} 94540 -42180 0 0 {name=p93512 lab=_76458_/Y }
C {devices/lab_pin.sym} 94540 -42140 0 0 {name=p93513 lab=_76459_/Y }
C {devices/lab_pin.sym} 94540 -42100 0 0 {name=p93514 lab=_76454_/X }
C {devices/lab_pin.sym} 94540 -42060 0 0 {name=p93515 lab=_76457_/Y }
C {devices/lab_pin.sym} 94700 -42120 0 1 {name=p93516 lab=_76463_/X }
C {sky130_stdcells/a211o_4.sym} 94620 -42120 0 0 {name=X_76463_ }
C {devices/lab_pin.sym} 94540 -42000 0 0 {name=p93517 lab=_41529_/X }
C {devices/lab_pin.sym} 94540 -41960 0 0 {name=p93518 lab=_42852_/X }
C {devices/lab_pin.sym} 94540 -41920 0 0 {name=p93519 lab=_66900_/B }
C {devices/lab_pin.sym} 94540 -41880 0 0 {name=p93520 lab=_42853_/X }
C {devices/lab_pin.sym} 94700 -41940 0 1 {name=p93521 lab=_87685_/D }
C {sky130_stdcells/a2bb2o_4.sym} 94620 -41940 0 0 {name=X_42855_ }
C {devices/lab_pin.sym} 94560 -41800 0 0 {name=p93522 lab=_73675_/A }
C {devices/lab_pin.sym} 94560 -41760 0 0 {name=p93523 lab=_73649_/X }
C {devices/lab_pin.sym} 94680 -41780 0 1 {name=p93524 lab=_73675_/Y }
C {sky130_stdcells/nor2_4.sym} 94620 -41780 0 0 {name=X_73675_ }
C {devices/lab_pin.sym} 94580 -41650 0 0 {name=p93525 lab=_70905_/D }
C {devices/lab_pin.sym} 94660 -41650 0 1 {name=p93526 lab=_70890_/D }
C {sky130_stdcells/buf_2.sym} 94620 -41650 0 0 {name=X_70887_ }
C {devices/lab_pin.sym} 94560 -41540 0 0 {name=p93527 lab=_78202_/A }
C {devices/lab_pin.sym} 94560 -41500 0 0 {name=p93528 lab=_78202_/B }
C {devices/lab_pin.sym} 94680 -41520 0 1 {name=p93529 lab=_78202_/X }
C {sky130_stdcells/xor2_4.sym} 94620 -41520 0 0 {name=X_78202_ }
C {devices/lab_pin.sym} 94540 -41410 0 0 {name=p93530 lab=_75413_/B }
C {devices/lab_pin.sym} 94540 -41370 0 0 {name=p93531 lab=_75413_/C }
C {devices/lab_pin.sym} 94540 -41330 0 0 {name=p93532 lab=_75413_/A }
C {devices/lab_pin.sym} 94700 -41370 0 1 {name=p93533 lab=_75414_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -41370 0 0 {name=X_75414_ }
C {devices/lab_pin.sym} 94540 -41260 0 0 {name=p93534 lab=_40387_/X }
C {devices/lab_pin.sym} 94540 -41220 0 0 {name=p93535 lab=_41799_/X }
C {devices/lab_pin.sym} 94540 -41180 0 0 {name=p93536 lab=_88144_/Q }
C {devices/lab_pin.sym} 94540 -41140 0 0 {name=p93537 lab=_41800_/X }
C {devices/lab_pin.sym} 94700 -41200 0 1 {name=p93538 lab=_88144_/D }
C {sky130_stdcells/a2bb2o_4.sym} 94620 -41200 0 0 {name=X_41806_ }
C {devices/lab_pin.sym} 94540 -41070 0 0 {name=p93539 lab=_48043_/X }
C {devices/lab_pin.sym} 94540 -41030 0 0 {name=p93540 lab=_81793_/Q }
C {devices/lab_pin.sym} 94540 -40990 0 0 {name=p93541 lab=_48361_/Y }
C {devices/lab_pin.sym} 94700 -41030 0 1 {name=p93542 lab=_74366_/A }
C {sky130_stdcells/o21ai_4.sym} 94620 -41030 0 0 {name=X_48362_ }
C {devices/lab_pin.sym} 94560 -40910 0 0 {name=p93543 lab=_59613_/Y }
C {devices/lab_pin.sym} 94560 -40870 0 0 {name=p93544 lab=_60183_/A }
C {devices/lab_pin.sym} 94560 -40830 0 0 {name=p93545 lab=_61075_/C }
C {devices/lab_pin.sym} 94680 -40870 0 1 {name=p93546 lab=_60641_/A }
C {sky130_stdcells/nand3_4.sym} 94620 -40870 0 0 {name=X_60640_ }
C {devices/lab_pin.sym} 94560 -40750 0 0 {name=p93547 lab=_72581_/A }
C {devices/lab_pin.sym} 94560 -40710 0 0 {name=p93548 lab=_72604_/B }
C {devices/lab_pin.sym} 94560 -40670 0 0 {name=p93549 lab=_79168_/A }
C {devices/lab_pin.sym} 94680 -40710 0 1 {name=p93550 lab=_72626_/Y }
C {sky130_stdcells/nor3_4.sym} 94620 -40710 0 0 {name=X_72626_ }
C {devices/lab_pin.sym} 94560 -40580 0 0 {name=p93551 lab=_79180_/Y }
C {devices/lab_pin.sym} 94560 -40540 0 0 {name=p93552 lab=_79181_/Y }
C {devices/lab_pin.sym} 94680 -40560 0 1 {name=p93553 lab=_79185_/A }
C {sky130_stdcells/nand2_4.sym} 94620 -40560 0 0 {name=X_79182_ }
C {devices/lab_pin.sym} 94540 -40450 0 0 {name=p93554 lab=_45568_/X }
C {devices/lab_pin.sym} 94540 -40410 0 0 {name=p93555 lab=_45573_/X }
C {devices/lab_pin.sym} 94540 -40370 0 0 {name=p93556 lab=_45523_/X }
C {devices/lab_pin.sym} 94700 -40410 0 1 {name=p93557 lab=_45574_/X }
C {sky130_stdcells/a21o_4.sym} 94620 -40410 0 0 {name=X_45574_ }
C {devices/lab_pin.sym} 94580 -40270 0 0 {name=p93558 lab=_76394_/A }
C {devices/lab_pin.sym} 94660 -40270 0 1 {name=p93559 lab=_76394_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -40270 0 0 {name=X_76394_ }
C {devices/lab_pin.sym} 94540 -40180 0 0 {name=p93560 lab=_41352_/X }
C {devices/lab_pin.sym} 94540 -40140 0 0 {name=p93561 lab=_42767_/X }
C {devices/lab_pin.sym} 94540 -40100 0 0 {name=p93562 lab=_67613_/B }
C {devices/lab_pin.sym} 94540 -40060 0 0 {name=p93563 lab=_42768_/X }
C {devices/lab_pin.sym} 94700 -40120 0 1 {name=p93564 lab=_42786_/X }
C {sky130_stdcells/a2bb2o_4.sym} 94620 -40120 0 0 {name=X_42786_ }
C {devices/lab_pin.sym} 94580 -39970 0 0 {name=p93565 lab=_47313_/A }
C {devices/lab_pin.sym} 94660 -39970 0 1 {name=p93566 lab=_47313_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -39970 0 0 {name=X_47313_ }
C {devices/lab_pin.sym} 94560 -39860 0 0 {name=p93567 lab=_82569_/Q }
C {devices/lab_pin.sym} 94560 -39820 0 0 {name=p93568 lab=_78124_/B }
C {devices/lab_pin.sym} 94680 -39840 0 1 {name=p93569 lab=_78134_/B }
C {sky130_stdcells/nor2_4.sym} 94620 -39840 0 0 {name=X_78133_ }
C {devices/lab_pin.sym} 94580 -39710 0 0 {name=p93570 lab=_44524_/Y }
C {devices/lab_pin.sym} 94660 -39710 0 1 {name=p93571 lab=_87067_/D }
C {sky130_stdcells/inv_2.sym} 94620 -39710 0 0 {name=X_44525_ }
C {devices/lab_pin.sym} 94560 -39600 0 0 {name=p93572 lab=_75364_/A }
C {devices/lab_pin.sym} 94560 -39560 0 0 {name=p93573 lab=_75345_/B }
C {devices/lab_pin.sym} 94680 -39580 0 1 {name=p93574 lab=_75345_/X }
C {sky130_stdcells/xor2_4.sym} 94620 -39580 0 0 {name=X_75345_ }
C {devices/lab_pin.sym} 94540 -39490 0 0 {name=p93575 lab=_41672_/X }
C {devices/lab_pin.sym} 94540 -39450 0 0 {name=p93576 lab=_41673_/X }
C {devices/lab_pin.sym} 94540 -39410 0 0 {name=p93577 lab=_41735_/X }
C {devices/lab_pin.sym} 94540 -39370 0 0 {name=p93578 lab=_67826_/B }
C {devices/lab_pin.sym} 94540 -39330 0 0 {name=p93579 lab=_41736_/X }
C {devices/lab_pin.sym} 94700 -39410 0 1 {name=p93580 lab=_41737_/Y }
C {sky130_stdcells/o32ai_4.sym} 94620 -39410 0 0 {name=X_41737_ }
C {devices/lab_pin.sym} 94580 -39250 0 0 {name=p93581 lab=_48169_/X }
C {devices/lab_pin.sym} 94660 -39250 0 1 {name=p93582 lab=_48293_/X }
C {sky130_stdcells/buf_2.sym} 94620 -39250 0 0 {name=X_48293_ }
C {devices/lab_pin.sym} 94560 -39140 0 0 {name=p93583 lab=_60413_/X }
C {devices/lab_pin.sym} 94560 -39100 0 0 {name=p93584 lab=_60571_/B }
C {devices/lab_pin.sym} 94680 -39120 0 1 {name=p93585 lab=_60571_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -39120 0 0 {name=X_60571_ }
C {devices/lab_pin.sym} 94580 -38990 0 0 {name=p93586 lab=_72517_/A }
C {devices/lab_pin.sym} 94660 -38990 0 1 {name=p93587 lab=_72557_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -38990 0 0 {name=X_72557_ }
C {devices/lab_pin.sym} 94560 -38900 0 0 {name=p93588 lab=_62634_/A }
C {devices/lab_pin.sym} 94560 -38860 0 0 {name=p93589 lab=_62307_/Y }
C {devices/lab_pin.sym} 94560 -38820 0 0 {name=p93590 lab=_62310_/C }
C {devices/lab_pin.sym} 94560 -38780 0 0 {name=p93591 lab=_62310_/D }
C {devices/lab_pin.sym} 94680 -38840 0 1 {name=p93592 lab=_62310_/Y }
C {sky130_stdcells/nand4_4.sym} 94620 -38840 0 0 {name=X_62310_ }
C {devices/lab_pin.sym} 94560 -38700 0 0 {name=p93593 lab=_47241_/X }
C {devices/lab_pin.sym} 94560 -38660 0 0 {name=p93594 lab=_52936_/B }
C {devices/lab_pin.sym} 94680 -38680 0 1 {name=p93595 lab=_47244_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -38680 0 0 {name=X_47244_ }
C {devices/lab_pin.sym} 94580 -38550 0 0 {name=p93596 lab=_71525_/A }
C {devices/lab_pin.sym} 94660 -38550 0 1 {name=p93597 lab=_71508_/X }
C {sky130_stdcells/buf_2.sym} 94620 -38550 0 0 {name=X_71508_ }
C {devices/lab_pin.sym} 94560 -38440 0 0 {name=p93598 lab=_78064_/A }
C {devices/lab_pin.sym} 94560 -38400 0 0 {name=p93599 lab=_78064_/B }
C {devices/lab_pin.sym} 94680 -38420 0 1 {name=p93600 lab=_78064_/X }
C {sky130_stdcells/xor2_4.sym} 94620 -38420 0 0 {name=X_78064_ }
C {devices/lab_pin.sym} 94540 -38330 0 0 {name=p93601 lab=_44447_/X }
C {devices/lab_pin.sym} 94540 -38290 0 0 {name=p93602 lab=_44448_/X }
C {devices/lab_pin.sym} 94540 -38250 0 0 {name=p93603 lab=_41124_/X }
C {devices/lab_pin.sym} 94540 -38210 0 0 {name=p93604 lab=_87101_/Q }
C {devices/lab_pin.sym} 94540 -38170 0 0 {name=p93605 lab=_44449_/X }
C {devices/lab_pin.sym} 94700 -38250 0 1 {name=p93606 lab=_44457_/A }
C {sky130_stdcells/o32ai_4.sym} 94620 -38250 0 0 {name=X_44456_ }
C {devices/lab_pin.sym} 94580 -38090 0 0 {name=p93607 lab=_60606_/X }
C {devices/lab_pin.sym} 94660 -38090 0 1 {name=p93608 lab=_63341_/C }
C {sky130_stdcells/buf_2.sym} 94620 -38090 0 0 {name=X_63290_ }
C {devices/lab_pin.sym} 94560 -37990 0 0 {name=p93609 lab=_75271_/X }
C {devices/lab_pin.sym} 94560 -37950 0 0 {name=p93610 lab=_75274_/Y }
C {devices/lab_pin.sym} 94560 -37910 0 0 {name=p93611 lab=_75272_/Y }
C {devices/lab_pin.sym} 94680 -37950 0 1 {name=p93612 lab=_75276_/Y }
C {sky130_stdcells/nand3_4.sym} 94620 -37950 0 0 {name=X_75276_ }
C {devices/lab_pin.sym} 94580 -37810 0 0 {name=p93613 lab=_41607_/X }
C {devices/lab_pin.sym} 94660 -37810 0 1 {name=p93614 lab=_41668_/X }
C {sky130_stdcells/buf_2.sym} 94620 -37810 0 0 {name=X_41668_ }
C {devices/lab_pin.sym} 94560 -37700 0 0 {name=p93615 lab=_63573_/A }
C {devices/lab_pin.sym} 94560 -37660 0 0 {name=p93616 lab=_72488_/B }
C {devices/lab_pin.sym} 94680 -37680 0 1 {name=p93617 lab=_72488_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -37680 0 0 {name=X_72488_ }
C {devices/lab_pin.sym} 94560 -37560 0 0 {name=p93618 lab=_77015_/A }
C {devices/lab_pin.sym} 94560 -37520 0 0 {name=p93619 lab=_77014_/Y }
C {devices/lab_pin.sym} 94680 -37540 0 1 {name=p93620 lab=_77017_/B }
C {sky130_stdcells/xnor2_4.sym} 94620 -37540 0 0 {name=X_77015_ }
C {devices/lab_pin.sym} 94580 -37410 0 0 {name=p93621 lab=_43329_/X }
C {devices/lab_pin.sym} 94660 -37410 0 1 {name=p93622 lab=_43407_/X }
C {sky130_stdcells/buf_2.sym} 94620 -37410 0 0 {name=X_43407_ }
C {devices/lab_pin.sym} 94560 -37310 0 0 {name=p93623 lab=_62181_/A }
C {devices/lab_pin.sym} 94560 -37270 0 0 {name=p93624 lab=_62181_/B }
C {devices/lab_pin.sym} 94560 -37230 0 0 {name=p93625 lab=_84424_/Q }
C {devices/lab_pin.sym} 94680 -37270 0 1 {name=p93626 lab=_62241_/Y }
C {sky130_stdcells/nor3_4.sym} 94620 -37270 0 0 {name=X_62241_ }
C {devices/lab_pin.sym} 94540 -37160 0 0 {name=p93627 lab=_43103_/Y }
C {devices/lab_pin.sym} 94540 -37120 0 0 {name=p93628 lab=_56273_/X }
C {devices/lab_pin.sym} 94540 -37080 0 0 {name=p93629 lab=_73035_/X }
C {devices/lab_pin.sym} 94540 -37040 0 0 {name=p93630 lab=_74226_/Y }
C {devices/lab_pin.sym} 94700 -37100 0 1 {name=p93631 lab=_74227_/X }
C {sky130_stdcells/a211o_4.sym} 94620 -37100 0 0 {name=X_74227_ }
C {devices/lab_pin.sym} 94580 -36950 0 0 {name=p93632 lab=_40413_/X }
C {devices/lab_pin.sym} 94660 -36950 0 1 {name=p93633 lab=_48461_/A }
C {sky130_stdcells/buf_2.sym} 94620 -36950 0 0 {name=X_40619_ }
C {devices/lab_pin.sym} 94560 -36840 0 0 {name=p93634 lab=_47150_/A }
C {devices/lab_pin.sym} 94560 -36800 0 0 {name=p93635 lab=_47174_/X }
C {devices/lab_pin.sym} 94680 -36820 0 1 {name=p93636 lab=_47175_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -36820 0 0 {name=X_47175_ }
C {devices/lab_pin.sym} 94560 -36720 0 0 {name=p93637 lab=_70370_/A }
C {devices/lab_pin.sym} 94560 -36680 0 0 {name=p93638 lab=_71435_/B }
C {devices/lab_pin.sym} 94560 -36640 0 0 {name=p93639 lab=_71439_/C }
C {devices/lab_pin.sym} 94560 -36600 0 0 {name=p93640 lab=_71432_/D }
C {devices/lab_pin.sym} 94680 -36660 0 1 {name=p93641 lab=_71439_/X }
C {sky130_stdcells/and4_4.sym} 94620 -36660 0 0 {name=X_71439_ }
C {devices/lab_pin.sym} 94580 -36510 0 0 {name=p93642 lab=_44387_/A }
C {devices/lab_pin.sym} 94660 -36510 0 1 {name=p93643 lab=_44387_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -36510 0 0 {name=X_44387_ }
C {devices/lab_pin.sym} 94560 -36400 0 0 {name=p93644 lab=_41358_/X }
C {devices/lab_pin.sym} 94560 -36360 0 0 {name=p93645 lab=_82310_/Q }
C {devices/lab_pin.sym} 94680 -36380 0 1 {name=p93646 lab=_41599_/X }
C {sky130_stdcells/or2_4.sym} 94620 -36380 0 0 {name=X_41599_ }
C {devices/lab_pin.sym} 94560 -36260 0 0 {name=p93647 lab=_46092_/X }
C {devices/lab_pin.sym} 94560 -36220 0 0 {name=p93648 lab=_46121_/A }
C {devices/lab_pin.sym} 94680 -36240 0 1 {name=p93649 lab=_46128_/A }
C {sky130_stdcells/nor2_4.sym} 94620 -36240 0 0 {name=X_46126_ }
C {devices/lab_pin.sym} 94540 -36140 0 0 {name=p93650 lab=_41298_/X }
C {devices/lab_pin.sym} 94540 -36100 0 0 {name=p93651 lab=_43336_/X }
C {devices/lab_pin.sym} 94540 -36060 0 0 {name=p93652 lab=_87473_/Q }
C {devices/lab_pin.sym} 94540 -36020 0 0 {name=p93653 lab=_43337_/X }
C {devices/lab_pin.sym} 94700 -36080 0 1 {name=p93654 lab=_87473_/D }
C {sky130_stdcells/a2bb2o_4.sym} 94620 -36080 0 0 {name=X_43338_ }
C {devices/lab_pin.sym} 94560 -35960 0 0 {name=p93655 lab=_61683_/X }
C {devices/lab_pin.sym} 94560 -35920 0 0 {name=p93656 lab=_62149_/B }
C {devices/lab_pin.sym} 94560 -35880 0 0 {name=p93657 lab=_61765_/C }
C {devices/lab_pin.sym} 94560 -35840 0 0 {name=p93658 lab=_61749_/B }
C {devices/lab_pin.sym} 94680 -35900 0 1 {name=p93659 lab=_62172_/Y }
C {sky130_stdcells/nand4_4.sym} 94620 -35900 0 0 {name=X_62172_ }
C {devices/lab_pin.sym} 94540 -35780 0 0 {name=p93660 lab=_74155_/X }
C {devices/lab_pin.sym} 94540 -35740 0 0 {name=p93661 lab=_84968_/Q }
C {devices/lab_pin.sym} 94540 -35700 0 0 {name=p93662 lab=_74087_/X }
C {devices/lab_pin.sym} 94540 -35660 0 0 {name=p93663 lab=_74157_/X }
C {devices/lab_pin.sym} 94700 -35720 0 1 {name=p93664 lab=_74158_/X }
C {sky130_stdcells/a211o_4.sym} 94620 -35720 0 0 {name=X_74158_ }
C {devices/lab_pin.sym} 94580 -35570 0 0 {name=p93665 lab=_64421_/A }
C {devices/lab_pin.sym} 94660 -35570 0 1 {name=p93666 lab=_64306_/A }
C {sky130_stdcells/buf_2.sym} 94620 -35570 0 0 {name=X_61123_ }
C {devices/lab_pin.sym} 94540 -35480 0 0 {name=p93667 lab=_69737_/B }
C {devices/lab_pin.sym} 94540 -35440 0 0 {name=p93668 lab=_73227_/A }
C {devices/lab_pin.sym} 94540 -35400 0 0 {name=p93669 lab=_72979_/X }
C {devices/lab_pin.sym} 94540 -35360 0 0 {name=p93670 lab=_73108_/Y }
C {devices/lab_pin.sym} 94700 -35420 0 1 {name=p93671 lab=_73109_/X }
C {sky130_stdcells/a211o_4.sym} 94620 -35420 0 0 {name=X_73109_ }
C {devices/lab_pin.sym} 94540 -35310 0 0 {name=p93672 lab=_46046_/X }
C {devices/lab_pin.sym} 94540 -35270 0 0 {name=p93673 lab=_46054_/X }
C {devices/lab_pin.sym} 94540 -35230 0 0 {name=p93674 lab=_41544_/X }
C {devices/lab_pin.sym} 94540 -35190 0 0 {name=p93675 lab=_66962_/B }
C {devices/lab_pin.sym} 94540 -35150 0 0 {name=p93676 lab=_46047_/X }
C {devices/lab_pin.sym} 94700 -35230 0 1 {name=p93677 lab=_46058_/A }
C {sky130_stdcells/o32ai_4.sym} 94620 -35230 0 0 {name=X_46057_ }
C {devices/lab_pin.sym} 94580 -35070 0 0 {name=p93678 lab=_43167_/A }
C {devices/lab_pin.sym} 94660 -35070 0 1 {name=p93679 lab=_43269_/X }
C {sky130_stdcells/buf_2.sym} 94620 -35070 0 0 {name=X_43269_ }
C {devices/lab_pin.sym} 94560 -34960 0 0 {name=p93680 lab=_66977_/X }
C {devices/lab_pin.sym} 94560 -34920 0 0 {name=p93681 lab=_66979_/X }
C {devices/lab_pin.sym} 94680 -34940 0 1 {name=p93682 lab=_66980_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -34940 0 0 {name=X_66980_ }
C {devices/lab_pin.sym} 94540 -34840 0 0 {name=p93683 lab=_73566_/X }
C {devices/lab_pin.sym} 94540 -34800 0 0 {name=p93684 lab=_84971_/Q }
C {devices/lab_pin.sym} 94540 -34760 0 0 {name=p93685 lab=_74087_/X }
C {devices/lab_pin.sym} 94540 -34720 0 0 {name=p93686 lab=_74088_/X }
C {devices/lab_pin.sym} 94700 -34780 0 1 {name=p93687 lab=_74090_/B }
C {sky130_stdcells/a211o_4.sym} 94620 -34780 0 0 {name=X_74089_ }
C {devices/lab_pin.sym} 94580 -34630 0 0 {name=p93688 lab=_78966_/A }
C {devices/lab_pin.sym} 94660 -34630 0 1 {name=p93689 lab=_78968_/A }
C {sky130_stdcells/inv_2.sym} 94620 -34630 0 0 {name=X_78966_ }
C {devices/lab_pin.sym} 94540 -34530 0 0 {name=p93690 lab=_45005_/X }
C {devices/lab_pin.sym} 94540 -34490 0 0 {name=p93691 lab=_45007_/Y }
C {devices/lab_pin.sym} 94540 -34450 0 0 {name=p93692 lab=_44973_/X }
C {devices/lab_pin.sym} 94700 -34490 0 1 {name=p93693 lab=_45008_/Y }
C {sky130_stdcells/a21oi_4.sym} 94620 -34490 0 0 {name=X_45008_ }
C {devices/lab_pin.sym} 94540 -34370 0 0 {name=p93694 lab=_65928_/Y }
C {devices/lab_pin.sym} 94540 -34330 0 0 {name=p93695 lab=_65915_/X }
C {devices/lab_pin.sym} 94540 -34290 0 0 {name=p93696 lab=_65930_/X }
C {devices/lab_pin.sym} 94700 -34330 0 1 {name=p93697 lab=_84168_/D }
C {sky130_stdcells/a21o_4.sym} 94620 -34330 0 0 {name=X_65931_ }
C {devices/lab_pin.sym} 94540 -34230 0 0 {name=p93698 lab=_60599_/A }
C {devices/lab_pin.sym} 94540 -34190 0 0 {name=p93699 lab=_61051_/Y }
C {devices/lab_pin.sym} 94540 -34150 0 0 {name=p93700 lab=_60403_/B }
C {devices/lab_pin.sym} 94540 -34110 0 0 {name=p93701 lab=_60980_/Y }
C {devices/lab_pin.sym} 94540 -34080 0 0 {name=p93702 lab=_61053_/Y }
C {devices/lab_pin.sym} 94700 -34150 0 1 {name=p93703 lab=_84527_/D }
C {sky130_stdcells/a41oi_4.sym} 94620 -34150 0 0 {name=X_61054_ }
C {devices/lab_pin.sym} 94560 -34000 0 0 {name=p93704 lab=_82166_/Q }
C {devices/lab_pin.sym} 94560 -33960 0 0 {name=p93705 lab=_82038_/D }
C {devices/lab_pin.sym} 94680 -33980 0 1 {name=p93706 lab=_82134_/D }
C {sky130_stdcells/xor2_4.sym} 94620 -33980 0 0 {name=X_77917_ }
C {devices/lab_pin.sym} 94540 -33880 0 0 {name=p93707 lab=_78885_/A }
C {devices/lab_pin.sym} 94540 -33840 0 0 {name=p93708 lab=_78885_/B }
C {devices/lab_pin.sym} 94540 -33800 0 0 {name=p93709 lab=_78870_/A }
C {devices/lab_pin.sym} 94540 -33760 0 0 {name=p93710 lab=_82506_/D }
C {devices/lab_pin.sym} 94700 -33820 0 1 {name=p93711 lab=_78897_/X }
C {sky130_stdcells/a2bb2o_4.sym} 94620 -33820 0 0 {name=X_78897_ }
C {devices/lab_pin.sym} 94540 -33710 0 0 {name=p93712 lab=_59913_/X }
C {devices/lab_pin.sym} 94540 -33670 0 0 {name=p93713 lab=_59985_/X }
C {devices/lab_pin.sym} 94540 -33630 0 0 {name=p93714 lab=_59881_/X }
C {devices/lab_pin.sym} 94540 -33590 0 0 {name=p93715 lab=_59884_/X }
C {devices/lab_pin.sym} 94540 -33560 0 0 {name=p93716 lab=_65842_/A }
C {devices/lab_pin.sym} 94700 -33630 0 1 {name=p93717 lab=_60005_/Y }
C {sky130_stdcells/a41oi_4.sym} 94620 -33630 0 0 {name=X_60005_ }
C {devices/lab_pin.sym} 94580 -33470 0 0 {name=p93718 lab=_48499_/A }
C {devices/lab_pin.sym} 94660 -33470 0 1 {name=p93719 lab=_49925_/A }
C {sky130_stdcells/buf_2.sym} 94620 -33470 0 0 {name=X_49816_ }
C {devices/lab_pin.sym} 94580 -33350 0 0 {name=p93720 lab=_69007_/A }
C {devices/lab_pin.sym} 94660 -33350 0 1 {name=p93721 lab=_68650_/X }
C {sky130_stdcells/buf_2.sym} 94620 -33350 0 0 {name=X_68650_ }
C {devices/lab_pin.sym} 94540 -33260 0 0 {name=p93722 lab=_65859_/X }
C {devices/lab_pin.sym} 94540 -33220 0 0 {name=p93723 lab=_85572_/Q }
C {devices/lab_pin.sym} 94540 -33180 0 0 {name=p93724 lab=_65860_/X }
C {devices/lab_pin.sym} 94540 -33140 0 0 {name=p93725 lab=_65861_/X }
C {devices/lab_pin.sym} 94700 -33200 0 1 {name=p93726 lab=_65862_/X }
C {sky130_stdcells/a211o_4.sym} 94620 -33200 0 0 {name=X_65862_ }
C {devices/lab_pin.sym} 94540 -33070 0 0 {name=p93727 lab=_77841_/Y }
C {devices/lab_pin.sym} 94540 -33030 0 0 {name=p93728 lab=_77842_/A }
C {devices/lab_pin.sym} 94540 -32990 0 0 {name=p93729 lab=_77847_/Y }
C {devices/lab_pin.sym} 94700 -33030 0 1 {name=p93730 lab=_77849_/B }
C {sky130_stdcells/a21oi_4.sym} 94620 -33030 0 0 {name=X_77848_ }
C {devices/lab_pin.sym} 94540 -32920 0 0 {name=p93731 lab=_86964_/Q }
C {devices/lab_pin.sym} 94540 -32880 0 0 {name=p93732 lab=_67551_/X }
C {devices/lab_pin.sym} 94540 -32840 0 0 {name=p93733 lab=_67552_/X }
C {devices/lab_pin.sym} 94540 -32800 0 0 {name=p93734 lab=_67600_/X }
C {devices/lab_pin.sym} 94700 -32860 0 1 {name=p93735 lab=_67602_/B }
C {sky130_stdcells/a211o_4.sym} 94620 -32860 0 0 {name=X_67601_ }
C {devices/lab_pin.sym} 94540 -32730 0 0 {name=p93736 lab=_64561_/X }
C {devices/lab_pin.sym} 94540 -32690 0 0 {name=p93737 lab=_64800_/Y }
C {devices/lab_pin.sym} 94540 -32650 0 0 {name=p93738 lab=_64812_/Y }
C {devices/lab_pin.sym} 94700 -32690 0 1 {name=p93739 lab=_64813_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -32690 0 0 {name=X_64813_ }
C {devices/lab_pin.sym} 94540 -32570 0 0 {name=p93740 lab=_49745_/Y }
C {devices/lab_pin.sym} 94540 -32530 0 0 {name=p93741 lab=_49732_/X }
C {devices/lab_pin.sym} 94540 -32490 0 0 {name=p93742 lab=_49746_/X }
C {devices/lab_pin.sym} 94700 -32530 0 1 {name=p93743 lab=_86331_/D }
C {sky130_stdcells/a21oi_4.sym} 94620 -32530 0 0 {name=X_49747_ }
C {devices/lab_pin.sym} 94560 -32400 0 0 {name=p93744 lab=_68560_/A }
C {devices/lab_pin.sym} 94560 -32360 0 0 {name=p93745 lab=_88267_/Q }
C {devices/lab_pin.sym} 94680 -32380 0 1 {name=p93746 lab=_68581_/X }
C {sky130_stdcells/and2_4.sym} 94620 -32380 0 0 {name=X_68581_ }
C {devices/lab_pin.sym} 94560 -32260 0 0 {name=p93747 lab=_46959_/A }
C {devices/lab_pin.sym} 94560 -32220 0 0 {name=p93748 lab=_52773_/B }
C {devices/lab_pin.sym} 94680 -32240 0 1 {name=p93749 lab=_46959_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -32240 0 0 {name=X_46959_ }
C {devices/lab_pin.sym} 94540 -32140 0 0 {name=p93750 lab=_65623_/X }
C {devices/lab_pin.sym} 94540 -32100 0 0 {name=p93751 lab=_86185_/Q }
C {devices/lab_pin.sym} 94540 -32060 0 0 {name=p93752 lab=_65790_/X }
C {devices/lab_pin.sym} 94540 -32020 0 0 {name=p93753 lab=_65792_/X }
C {devices/lab_pin.sym} 94700 -32080 0 1 {name=p93754 lab=_65793_/X }
C {sky130_stdcells/a211o_4.sym} 94620 -32080 0 0 {name=X_65793_ }
C {devices/lab_pin.sym} 94580 -31930 0 0 {name=p93755 lab=_77771_/Y }
C {devices/lab_pin.sym} 94660 -31930 0 1 {name=p93756 lab=_77779_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -31930 0 0 {name=X_77779_ }
C {devices/lab_pin.sym} 94560 -31820 0 0 {name=p93757 lab=_67532_/A }
C {devices/lab_pin.sym} 94560 -31780 0 0 {name=p93758 lab=_67531_/X }
C {devices/lab_pin.sym} 94680 -31800 0 1 {name=p93759 lab=_67532_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -31800 0 0 {name=X_67532_ }
C {devices/lab_pin.sym} 94560 -31680 0 0 {name=p93760 lab=_79513_/X }
C {devices/lab_pin.sym} 94560 -31640 0 0 {name=p93761 lab=_79518_/B }
C {devices/lab_pin.sym} 94680 -31660 0 1 {name=p93762 lab=_79519_/A }
C {sky130_stdcells/xnor2_4.sym} 94620 -31660 0 0 {name=X_79518_ }
C {devices/lab_pin.sym} 94540 -31560 0 0 {name=p93763 lab=_64650_/X }
C {devices/lab_pin.sym} 94540 -31520 0 0 {name=p93764 lab=_86140_/Q }
C {devices/lab_pin.sym} 94540 -31480 0 0 {name=p93765 lab=_64583_/X }
C {devices/lab_pin.sym} 94540 -31440 0 0 {name=p93766 lab=_64743_/X }
C {devices/lab_pin.sym} 94700 -31500 0 1 {name=p93767 lab=_64744_/X }
C {sky130_stdcells/a211o_4.sym} 94620 -31500 0 0 {name=X_64744_ }
C {devices/lab_pin.sym} 94580 -31350 0 0 {name=p93768 lab=_49406_/A }
C {devices/lab_pin.sym} 94660 -31350 0 1 {name=p93769 lab=_49678_/X }
C {sky130_stdcells/buf_2.sym} 94620 -31350 0 0 {name=X_49678_ }
C {devices/lab_pin.sym} 94560 -31260 0 0 {name=p93770 lab=_61954_/X }
C {devices/lab_pin.sym} 94560 -31220 0 0 {name=p93771 lab=_61924_/B }
C {devices/lab_pin.sym} 94560 -31180 0 0 {name=p93772 lab=_61971_/C }
C {devices/lab_pin.sym} 94560 -31140 0 0 {name=p93773 lab=_61910_/D }
C {devices/lab_pin.sym} 94680 -31200 0 1 {name=p93774 lab=_61956_/Y }
C {sky130_stdcells/nand4_4.sym} 94620 -31200 0 0 {name=X_61956_ }
C {devices/lab_pin.sym} 94530 -31050 0 0 {name=p93775 lab=_80931_/CLK }
C {devices/lab_pin.sym} 94530 -31030 0 0 {name=p93776 lab=_75883_/Y }
C {devices/lab_pin.sym} 94710 -31050 0 1 {name=p93777 lab=_75371_/A }
C {sky130_stdcells/dfxtp_4.sym} 94620 -31040 0 0 {name=X_80790_ }
C {devices/lab_pin.sym} 94540 -30930 0 0 {name=p93778 lab=_86505_/Q }
C {devices/lab_pin.sym} 94540 -30890 0 0 {name=p93779 lab=_48612_/X }
C {devices/lab_pin.sym} 94540 -30850 0 0 {name=p93780 lab=_48628_/Y }
C {devices/lab_pin.sym} 94700 -30890 0 1 {name=p93781 lab=_48629_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -30890 0 0 {name=X_48629_ }
C {devices/lab_pin.sym} 94580 -30750 0 0 {name=p93782 lab=_60906_/X }
C {devices/lab_pin.sym} 94660 -30750 0 1 {name=p93783 lab=_60908_/A }
C {sky130_stdcells/buf_2.sym} 94620 -30750 0 0 {name=X_60907_ }
C {devices/lab_pin.sym} 94560 -30640 0 0 {name=p93784 lab=_67513_/A }
C {devices/lab_pin.sym} 94560 -30600 0 0 {name=p93785 lab=_86938_/Q }
C {devices/lab_pin.sym} 94680 -30620 0 1 {name=p93786 lab=_67463_/X }
C {sky130_stdcells/and2_4.sym} 94620 -30620 0 0 {name=X_67463_ }
C {devices/lab_pin.sym} 94560 -30500 0 0 {name=p93787 lab=_79449_/A }
C {devices/lab_pin.sym} 94560 -30460 0 0 {name=p93788 lab=_79448_/Y }
C {devices/lab_pin.sym} 94680 -30480 0 1 {name=p93789 lab=_79459_/B }
C {sky130_stdcells/xor2_4.sym} 94620 -30480 0 0 {name=X_79449_ }
C {devices/lab_pin.sym} 94560 -30360 0 0 {name=p93790 lab=_64672_/X }
C {devices/lab_pin.sym} 94560 -30320 0 0 {name=p93791 lab=_64674_/X }
C {devices/lab_pin.sym} 94680 -30340 0 1 {name=p93792 lab=_64675_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -30340 0 0 {name=X_64675_ }
C {devices/lab_pin.sym} 94540 -30250 0 0 {name=p93793 lab=_57660_/X }
C {devices/lab_pin.sym} 94540 -30210 0 0 {name=p93794 lab=_61824_/X }
C {devices/lab_pin.sym} 94540 -30170 0 0 {name=p93795 lab=_61838_/X }
C {devices/lab_pin.sym} 94540 -30130 0 0 {name=p93796 lab=_61870_/X }
C {devices/lab_pin.sym} 94540 -30100 0 0 {name=p93797 lab=_61886_/X }
C {devices/lab_pin.sym} 94700 -30170 0 1 {name=p93798 lab=_61887_/X }
C {sky130_stdcells/a41o_4.sym} 94620 -30170 0 0 {name=X_61887_ }
C {devices/lab_pin.sym} 94580 -30010 0 0 {name=p93799 lab=_69088_/A }
C {devices/lab_pin.sym} 94660 -30010 0 1 {name=p93800 lab=_69202_/X }
C {sky130_stdcells/buf_2.sym} 94620 -30010 0 0 {name=X_69202_ }
C {devices/lab_pin.sym} 94580 -29890 0 0 {name=p93801 lab=_66377_/A }
C {devices/lab_pin.sym} 94660 -29890 0 1 {name=p93802 lab=_66414_/X }
C {sky130_stdcells/buf_2.sym} 94620 -29890 0 0 {name=X_66414_ }
C {devices/lab_pin.sym} 94580 -29770 0 0 {name=p93803 lab=_51694_/A }
C {devices/lab_pin.sym} 94660 -29770 0 1 {name=p93804 lab=_51651_/B }
C {sky130_stdcells/buf_2.sym} 94620 -29770 0 0 {name=X_51640_ }
C {devices/lab_pin.sym} 94580 -29650 0 0 {name=p93805 lab=_63436_/A }
C {devices/lab_pin.sym} 94660 -29650 0 1 {name=p93806 lab=_63626_/X }
C {sky130_stdcells/buf_2.sym} 94620 -29650 0 0 {name=X_63626_ }
C {devices/lab_pin.sym} 94530 -29530 0 0 {name=p93807 lab=_84187_/CLK }
C {devices/lab_pin.sym} 94530 -29510 0 0 {name=p93808 lab=_79152_/X }
C {devices/lab_pin.sym} 94710 -29530 0 1 {name=p93809 lab=_82428_/D }
C {sky130_stdcells/dfxtp_4.sym} 94620 -29520 0 0 {name=X_82460_ }
C {devices/lab_pin.sym} 94580 -29390 0 0 {name=p93810 lab=_60715_/X }
C {devices/lab_pin.sym} 94660 -29390 0 1 {name=p93811 lab=_60838_/X }
C {sky130_stdcells/buf_2.sym} 94620 -29390 0 0 {name=X_60838_ }
C {devices/lab_pin.sym} 94580 -29270 0 0 {name=p93812 lab=_66915_/A }
C {devices/lab_pin.sym} 94660 -29270 0 1 {name=p93813 lab=_67394_/X }
C {sky130_stdcells/buf_2.sym} 94620 -29270 0 0 {name=X_67394_ }
C {devices/lab_pin.sym} 94530 -29150 0 0 {name=p93814 lab=_84014_/CLK }
C {devices/lab_pin.sym} 94530 -29130 0 0 {name=p93815 lab=_81443_/Q }
C {devices/lab_pin.sym} 94710 -29150 0 1 {name=p93816 lab=_75927_/B }
C {sky130_stdcells/dfxtp_4.sym} 94620 -29140 0 0 {name=X_81411_ }
C {devices/lab_pin.sym} 94540 -29030 0 0 {name=p93817 lab=_80802_/D }
C {devices/lab_pin.sym} 94540 -28990 0 0 {name=p93818 lab=_69066_/X }
C {devices/lab_pin.sym} 94540 -28950 0 0 {name=p93819 lab=_69132_/X }
C {devices/lab_pin.sym} 94700 -28990 0 1 {name=p93820 lab=_83946_/D }
C {sky130_stdcells/a21bo_4.sym} 94620 -28990 0 0 {name=X_69133_ }
C {devices/lab_pin.sym} 94560 -28870 0 0 {name=p93821 lab=_66177_/A }
C {devices/lab_pin.sym} 94560 -28830 0 0 {name=p93822 lab=_66389_/B }
C {devices/lab_pin.sym} 94560 -28790 0 0 {name=p93823 lab=_66345_/C }
C {devices/lab_pin.sym} 94680 -28830 0 1 {name=p93824 lab=_66345_/Y }
C {sky130_stdcells/nor3_4.sym} 94620 -28830 0 0 {name=X_66345_ }
C {devices/lab_pin.sym} 94540 -28710 0 0 {name=p93825 lab=_51569_/Y }
C {devices/lab_pin.sym} 94540 -28670 0 0 {name=p93826 lab=_51557_/X }
C {devices/lab_pin.sym} 94540 -28630 0 0 {name=p93827 lab=_51570_/X }
C {devices/lab_pin.sym} 94700 -28670 0 1 {name=p93828 lab=_51571_/Y }
C {sky130_stdcells/a21oi_4.sym} 94620 -28670 0 0 {name=X_51571_ }
C {devices/lab_pin.sym} 94560 -28560 0 0 {name=p93829 lab=_63546_/A }
C {devices/lab_pin.sym} 94560 -28520 0 0 {name=p93830 lab=_63557_/B }
C {devices/lab_pin.sym} 94560 -28480 0 0 {name=p93831 lab=_63520_/C }
C {devices/lab_pin.sym} 94560 -28440 0 0 {name=p93832 lab=_63546_/D }
C {devices/lab_pin.sym} 94680 -28500 0 1 {name=p93833 lab=_63557_/X }
C {sky130_stdcells/and4_4.sym} 94620 -28500 0 0 {name=X_63557_ }
C {devices/lab_pin.sym} 94530 -28350 0 0 {name=p93834 lab=_82390_/CLK }
C {devices/lab_pin.sym} 94530 -28330 0 0 {name=p93835 lab=_82391_/D }
C {devices/lab_pin.sym} 94710 -28350 0 1 {name=p93836 lab=_82391_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -28340 0 0 {name=X_82391_ }
C {devices/lab_pin.sym} 94540 -28250 0 0 {name=p93837 lab=_60376_/X }
C {devices/lab_pin.sym} 94540 -28210 0 0 {name=p93838 lab=_60765_/Y }
C {devices/lab_pin.sym} 94540 -28170 0 0 {name=p93839 lab=_60767_/X }
C {devices/lab_pin.sym} 94540 -28130 0 0 {name=p93840 lab=_60690_/X }
C {devices/lab_pin.sym} 94540 -28090 0 0 {name=p93841 lab=_60768_/X }
C {devices/lab_pin.sym} 94700 -28170 0 1 {name=p93842 lab=_60769_/X }
C {sky130_stdcells/o41a_4.sym} 94620 -28170 0 0 {name=X_60769_ }
C {devices/lab_pin.sym} 94540 -28030 0 0 {name=p93843 lab=_85657_/Q }
C {devices/lab_pin.sym} 94540 -27990 0 0 {name=p93844 lab=_53295_/X }
C {devices/lab_pin.sym} 94540 -27950 0 0 {name=p93845 lab=_53309_/Y }
C {devices/lab_pin.sym} 94700 -27990 0 1 {name=p93846 lab=_53310_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -27990 0 0 {name=X_53310_ }
C {devices/lab_pin.sym} 94530 -27850 0 0 {name=p93847 lab=_84175_/CLK }
C {devices/lab_pin.sym} 94530 -27830 0 0 {name=p93848 lab=_84130_/D }
C {devices/lab_pin.sym} 94710 -27850 0 1 {name=p93849 lab=_79435_/B }
C {sky130_stdcells/dfxtp_4.sym} 94620 -27840 0 0 {name=X_84130_ }
C {devices/lab_pin.sym} 94540 -27730 0 0 {name=p93850 lab=_86184_/Q }
C {devices/lab_pin.sym} 94540 -27690 0 0 {name=p93851 lab=_50506_/X }
C {devices/lab_pin.sym} 94540 -27650 0 0 {name=p93852 lab=_50521_/Y }
C {devices/lab_pin.sym} 94700 -27690 0 1 {name=p93853 lab=_50522_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -27690 0 0 {name=X_50522_ }
C {devices/lab_pin.sym} 94580 -27550 0 0 {name=p93854 lab=_62276_/X }
C {devices/lab_pin.sym} 94660 -27550 0 1 {name=p93855 lab=_62601_/C }
C {sky130_stdcells/buf_2.sym} 94620 -27550 0 0 {name=X_62508_ }
C {devices/lab_pin.sym} 94530 -27430 0 0 {name=p93856 lab=_81473_/CLK }
C {devices/lab_pin.sym} 94530 -27410 0 0 {name=p93857 lab=_76592_/X }
C {devices/lab_pin.sym} 94710 -27430 0 1 {name=p93858 lab=_81718_/D }
C {sky130_stdcells/dfxtp_4.sym} 94620 -27420 0 0 {name=X_81342_ }
C {devices/lab_pin.sym} 94540 -27310 0 0 {name=p93859 lab=_83949_/Q }
C {devices/lab_pin.sym} 94540 -27270 0 0 {name=p93860 lab=_68954_/X }
C {devices/lab_pin.sym} 94540 -27230 0 0 {name=p93861 lab=_69063_/X }
C {devices/lab_pin.sym} 94700 -27270 0 1 {name=p93862 lab=_83949_/D }
C {sky130_stdcells/a21bo_4.sym} 94620 -27270 0 0 {name=X_69064_ }
C {devices/lab_pin.sym} 94580 -27130 0 0 {name=p93863 lab=_54316_/A }
C {devices/lab_pin.sym} 94660 -27130 0 1 {name=p93864 lab=_54312_/A }
C {sky130_stdcells/buf_2.sym} 94620 -27130 0 0 {name=X_54290_ }
C {devices/lab_pin.sym} 94560 -27030 0 0 {name=p93865 lab=_65810_/X }
C {devices/lab_pin.sym} 94560 -26990 0 0 {name=p93866 lab=_66276_/B }
C {devices/lab_pin.sym} 94560 -26950 0 0 {name=p93867 lab=_65813_/X }
C {devices/lab_pin.sym} 94680 -26990 0 1 {name=p93868 lab=_66276_/Y }
C {sky130_stdcells/nand3_4.sym} 94620 -26990 0 0 {name=X_66276_ }
C {devices/lab_pin.sym} 94560 -26860 0 0 {name=p93869 lab=_63488_/A }
C {devices/lab_pin.sym} 94560 -26820 0 0 {name=p93870 lab=_61891_/X }
C {devices/lab_pin.sym} 94680 -26840 0 1 {name=p93871 lab=_63488_/X }
C {sky130_stdcells/and2_4.sym} 94620 -26840 0 0 {name=X_63488_ }
C {devices/lab_pin.sym} 94540 -26730 0 0 {name=p93872 lab=_68011_/X }
C {devices/lab_pin.sym} 94540 -26690 0 0 {name=p93873 lab=_68014_/X }
C {devices/lab_pin.sym} 94540 -26650 0 0 {name=p93874 lab=_67875_/X }
C {devices/lab_pin.sym} 94700 -26690 0 1 {name=p93875 lab=_68015_/Y }
C {sky130_stdcells/a21oi_4.sym} 94620 -26690 0 0 {name=X_68015_ }
C {devices/lab_pin.sym} 94560 -26560 0 0 {name=p93876 lab=_65227_/A }
C {devices/lab_pin.sym} 94560 -26520 0 0 {name=p93877 lab=_86249_/Q }
C {devices/lab_pin.sym} 94680 -26540 0 1 {name=p93878 lab=_65227_/X }
C {sky130_stdcells/and2_4.sym} 94620 -26540 0 0 {name=X_65227_ }
C {devices/lab_pin.sym} 94540 -26430 0 0 {name=p93879 lab=_85670_/Q }
C {devices/lab_pin.sym} 94540 -26390 0 0 {name=p93880 lab=_53225_/X }
C {devices/lab_pin.sym} 94540 -26350 0 0 {name=p93881 lab=_53240_/Y }
C {devices/lab_pin.sym} 94700 -26390 0 1 {name=p93882 lab=_53241_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -26390 0 0 {name=X_53241_ }
C {devices/lab_pin.sym} 94530 -26250 0 0 {name=p93883 lab=_82648_/CLK }
C {devices/lab_pin.sym} 94530 -26230 0 0 {name=p93884 lab=_84061_/D }
C {devices/lab_pin.sym} 94710 -26250 0 1 {name=p93885 lab=_84061_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -26240 0 0 {name=X_84061_ }
C {devices/lab_pin.sym} 94560 -26120 0 0 {name=p93886 lab=_50439_/X }
C {devices/lab_pin.sym} 94560 -26080 0 0 {name=p93887 lab=_52158_/B }
C {devices/lab_pin.sym} 94680 -26100 0 1 {name=p93888 lab=_50453_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -26100 0 0 {name=X_50453_ }
C {devices/lab_pin.sym} 94540 -26010 0 0 {name=p93889 lab=_61509_/B }
C {devices/lab_pin.sym} 94540 -25970 0 0 {name=p93890 lab=_62390_/X }
C {devices/lab_pin.sym} 94540 -25930 0 0 {name=p93891 lab=_62436_/X }
C {devices/lab_pin.sym} 94540 -25890 0 0 {name=p93892 lab=_62407_/X }
C {devices/lab_pin.sym} 94540 -25860 0 0 {name=p93893 lab=_62438_/X }
C {devices/lab_pin.sym} 94700 -25930 0 1 {name=p93894 lab=_62439_/X }
C {sky130_stdcells/a41o_4.sym} 94620 -25930 0 0 {name=X_62439_ }
C {devices/lab_pin.sym} 94530 -25770 0 0 {name=p93895 lab=_81304_/CLK }
C {devices/lab_pin.sym} 94530 -25750 0 0 {name=p93896 lab=_81305_/Q }
C {devices/lab_pin.sym} 94710 -25770 0 1 {name=p93897 lab=_76489_/A }
C {sky130_stdcells/dfxtp_4.sym} 94620 -25760 0 0 {name=X_81273_ }
C {devices/lab_pin.sym} 94530 -25630 0 0 {name=p93898 lab=_83012_/CLK }
C {devices/lab_pin.sym} 94530 -25610 0 0 {name=p93899 lab=_83012_/D }
C {devices/lab_pin.sym} 94710 -25630 0 1 {name=p93900 lab=_45345_/A }
C {sky130_stdcells/dfxtp_4.sym} 94620 -25620 0 0 {name=X_83012_ }
C {devices/lab_pin.sym} 94540 -25520 0 0 {name=p93901 lab=_80207_/Y }
C {devices/lab_pin.sym} 94540 -25480 0 0 {name=p93902 lab=_80204_/Y }
C {devices/lab_pin.sym} 94540 -25440 0 0 {name=p93903 lab=_80209_/A }
C {devices/lab_pin.sym} 94540 -25400 0 0 {name=p93904 lab=_80209_/B }
C {devices/lab_pin.sym} 94700 -25460 0 1 {name=p93905 lab=_80224_/X }
C {sky130_stdcells/a211o_4.sym} 94620 -25460 0 0 {name=X_80224_ }
C {devices/lab_pin.sym} 94580 -25310 0 0 {name=p93906 lab=_53172_/A }
C {devices/lab_pin.sym} 94660 -25310 0 1 {name=p93907 lab=_53172_/X }
C {sky130_stdcells/buf_2.sym} 94620 -25310 0 0 {name=X_53172_ }
C {devices/lab_pin.sym} 94580 -25190 0 0 {name=p93908 lab=_65158_/A }
C {devices/lab_pin.sym} 94660 -25190 0 1 {name=p93909 lab=_65159_/A }
C {sky130_stdcells/buf_2.sym} 94620 -25190 0 0 {name=X_65158_ }
C {devices/lab_pin.sym} 94540 -25090 0 0 {name=p93910 lab=_86211_/Q }
C {devices/lab_pin.sym} 94540 -25050 0 0 {name=p93911 lab=_50363_/X }
C {devices/lab_pin.sym} 94540 -25010 0 0 {name=p93912 lab=_50383_/Y }
C {devices/lab_pin.sym} 94700 -25050 0 1 {name=p93913 lab=_50384_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -25050 0 0 {name=X_50384_ }
C {devices/lab_pin.sym} 94560 -24920 0 0 {name=p93914 lab=_52188_/A }
C {devices/lab_pin.sym} 94560 -24880 0 0 {name=p93915 lab=_52123_/B }
C {devices/lab_pin.sym} 94680 -24900 0 1 {name=p93916 lab=_52123_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -24900 0 0 {name=X_52123_ }
C {devices/lab_pin.sym} 94540 -24790 0 0 {name=p93917 lab=_64107_/Y }
C {devices/lab_pin.sym} 94540 -24750 0 0 {name=p93918 lab=_64073_/X }
C {devices/lab_pin.sym} 94540 -24710 0 0 {name=p93919 lab=_64108_/Y }
C {devices/lab_pin.sym} 94700 -24750 0 1 {name=p93920 lab=_84274_/D }
C {sky130_stdcells/a21oi_4.sym} 94620 -24750 0 0 {name=X_64109_ }
C {devices/lab_pin.sym} 94530 -24610 0 0 {name=p93921 lab=_87820_/CLK }
C {devices/lab_pin.sym} 94530 -24590 0 0 {name=p93922 lab=_87820_/D }
C {devices/lab_pin.sym} 94710 -24610 0 1 {name=p93923 lab=_72945_/A }
C {sky130_stdcells/dfxtp_4.sym} 94620 -24600 0 0 {name=X_87820_ }
C {devices/lab_pin.sym} 94560 -24480 0 0 {name=p93924 lab=_80151_/Y }
C {devices/lab_pin.sym} 94560 -24440 0 0 {name=p93925 lab=_80169_/B }
C {devices/lab_pin.sym} 94680 -24460 0 1 {name=p93926 lab=_80178_/A }
C {sky130_stdcells/xor2_4.sym} 94620 -24460 0 0 {name=X_80155_ }
C {devices/lab_pin.sym} 94560 -24350 0 0 {name=p93927 lab=_65086_/X }
C {devices/lab_pin.sym} 94560 -24310 0 0 {name=p93928 lab=_65192_/B }
C {devices/lab_pin.sym} 94560 -24270 0 0 {name=p93929 lab=_65088_/X }
C {devices/lab_pin.sym} 94680 -24310 0 1 {name=p93930 lab=_65089_/Y }
C {sky130_stdcells/nand3_4.sym} 94620 -24310 0 0 {name=X_65089_ }
C {devices/lab_pin.sym} 94580 -24170 0 0 {name=p93931 lab=_84934_/Q }
C {devices/lab_pin.sym} 94660 -24170 0 1 {name=p93932 lab=_57980_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -24170 0 0 {name=X_57980_ }
C {devices/lab_pin.sym} 94540 -24070 0 0 {name=p93933 lab=_83883_/Q }
C {devices/lab_pin.sym} 94540 -24030 0 0 {name=p93934 lab=_69955_/X }
C {devices/lab_pin.sym} 94540 -23990 0 0 {name=p93935 lab=_69965_/X }
C {devices/lab_pin.sym} 94700 -24030 0 1 {name=p93936 lab=_83883_/D }
C {sky130_stdcells/a21bo_4.sym} 94620 -24030 0 0 {name=X_69966_ }
C {devices/lab_pin.sym} 94560 -23900 0 0 {name=p93937 lab=_52058_/A }
C {devices/lab_pin.sym} 94560 -23860 0 0 {name=p93938 lab=_57609_/B }
C {devices/lab_pin.sym} 94680 -23880 0 1 {name=p93939 lab=_52054_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -23880 0 0 {name=X_52054_ }
C {devices/lab_pin.sym} 94580 -23750 0 0 {name=p93940 lab=_56931_/A }
C {devices/lab_pin.sym} 94660 -23750 0 1 {name=p93941 lab=_56931_/X }
C {sky130_stdcells/buf_2.sym} 94620 -23750 0 0 {name=X_56931_ }
C {devices/lab_pin.sym} 94580 -23630 0 0 {name=p93942 lab=_69233_/A }
C {devices/lab_pin.sym} 94660 -23630 0 1 {name=p93943 lab=_68987_/A }
C {sky130_stdcells/buf_2.sym} 94620 -23630 0 0 {name=X_68917_ }
C {devices/lab_pin.sym} 94530 -23510 0 0 {name=p93944 lab=_87758_/CLK }
C {devices/lab_pin.sym} 94530 -23490 0 0 {name=p93945 lab=_42725_/Y }
C {devices/lab_pin.sym} 94710 -23510 0 1 {name=p93946 lab=_87751_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -23500 0 0 {name=X_87751_ }
C {devices/lab_pin.sym} 94530 -23370 0 0 {name=p93947 lab=_85599_/CLK }
C {devices/lab_pin.sym} 94530 -23350 0 0 {name=p93948 lab=_57645_/Y }
C {devices/lab_pin.sym} 94710 -23370 0 1 {name=p93949 lab=_84963_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -23360 0 0 {name=X_84963_ }
C {devices/lab_pin.sym} 94540 -23250 0 0 {name=p93950 lab=_80072_/Y }
C {devices/lab_pin.sym} 94540 -23210 0 0 {name=p93951 lab=_80077_/Y }
C {devices/lab_pin.sym} 94540 -23170 0 0 {name=p93952 lab=_80085_/X }
C {devices/lab_pin.sym} 94700 -23210 0 1 {name=p93953 lab=_80087_/B }
C {sky130_stdcells/o21ai_4.sym} 94620 -23210 0 0 {name=X_80086_ }
C {devices/lab_pin.sym} 94560 -23080 0 0 {name=p93954 lab=_69897_/A }
C {devices/lab_pin.sym} 94560 -23040 0 0 {name=p93955 lab=_69897_/B }
C {devices/lab_pin.sym} 94680 -23060 0 1 {name=p93956 lab=_69897_/Y }
C {sky130_stdcells/nor2_4.sym} 94620 -23060 0 0 {name=X_69897_ }
C {devices/lab_pin.sym} 94580 -22930 0 0 {name=p93957 lab=_50952_/A }
C {devices/lab_pin.sym} 94660 -22930 0 1 {name=p93958 lab=_51029_/C }
C {sky130_stdcells/buf_2.sym} 94620 -22930 0 0 {name=X_51005_ }
C {devices/lab_pin.sym} 94530 -22810 0 0 {name=p93959 lab=_86381_/CLK }
C {devices/lab_pin.sym} 94530 -22790 0 0 {name=p93960 lab=_86702_/D }
C {devices/lab_pin.sym} 94710 -22810 0 1 {name=p93961 lab=_58807_/A }
C {sky130_stdcells/dfxtp_4.sym} 94620 -22800 0 0 {name=X_86702_ }
C {devices/lab_pin.sym} 94580 -22670 0 0 {name=p93962 lab=_59649_/Y }
C {devices/lab_pin.sym} 94660 -22670 0 1 {name=p93963 lab=_59651_/C }
C {sky130_stdcells/inv_2.sym} 94620 -22670 0 0 {name=X_59650_ }
C {devices/lab_pin.sym} 94530 -22550 0 0 {name=p93964 lab=_83914_/CLK }
C {devices/lab_pin.sym} 94530 -22530 0 0 {name=p93965 lab=_83914_/D }
C {devices/lab_pin.sym} 94710 -22550 0 1 {name=p93966 lab=_83914_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -22540 0 0 {name=X_83914_ }
C {devices/lab_pin.sym} 94560 -22430 0 0 {name=p93967 lab=_57346_/C }
C {devices/lab_pin.sym} 94560 -22390 0 0 {name=p93968 lab=_56860_/X }
C {devices/lab_pin.sym} 94560 -22350 0 0 {name=p93969 lab=_56893_/B }
C {devices/lab_pin.sym} 94680 -22390 0 1 {name=p93970 lab=_56862_/Y }
C {sky130_stdcells/nand3_4.sym} 94620 -22390 0 0 {name=X_56862_ }
C {devices/lab_pin.sym} 94560 -22260 0 0 {name=p93971 lab=_68779_/A }
C {devices/lab_pin.sym} 94560 -22220 0 0 {name=p93972 lab=_68848_/B }
C {devices/lab_pin.sym} 94680 -22240 0 1 {name=p93973 lab=_68848_/X }
C {sky130_stdcells/and2_4.sym} 94620 -22240 0 0 {name=X_68848_ }
C {devices/lab_pin.sym} 94530 -22110 0 0 {name=p93974 lab=_88128_/CLK }
C {devices/lab_pin.sym} 94530 -22090 0 0 {name=p93975 lab=_42861_/X }
C {devices/lab_pin.sym} 94710 -22110 0 1 {name=p93976 lab=_66982_/B }
C {sky130_stdcells/dfxtp_4.sym} 94620 -22100 0 0 {name=X_87682_ }
C {devices/lab_pin.sym} 94530 -21970 0 0 {name=p93977 lab=_84894_/CLK }
C {devices/lab_pin.sym} 94530 -21950 0 0 {name=p93978 lab=_84894_/D }
C {devices/lab_pin.sym} 94710 -21970 0 1 {name=p93979 lab=_62027_/A }
C {sky130_stdcells/dfxtp_4.sym} 94620 -21960 0 0 {name=X_84894_ }
C {devices/lab_pin.sym} 94580 -21830 0 0 {name=p93980 lab=clkbuf_9_280_0_CLK/X }
C {devices/lab_pin.sym} 94660 -21830 0 1 {name=p93981 lab=_81703_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 94620 -21830 0 0 {name=Xclkbuf_10_560_0_CLK }
C {devices/lab_pin.sym} 94560 -21720 0 0 {name=p93982 lab=_58601_/A }
C {devices/lab_pin.sym} 94560 -21680 0 0 {name=p93983 lab=_58614_/B }
C {devices/lab_pin.sym} 94680 -21700 0 1 {name=p93984 lab=_58601_/Y }
C {sky130_stdcells/nor2_4.sym} 94620 -21700 0 0 {name=X_58601_ }
C {devices/lab_pin.sym} 94580 -21570 0 0 {name=p93985 lab=clkbuf_6_51_0_CLK/A }
C {devices/lab_pin.sym} 94660 -21570 0 1 {name=p93986 lab=clkbuf_6_51_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 94620 -21570 0 0 {name=Xclkbuf_6_51_0_CLK }
C {devices/lab_pin.sym} 94540 -21480 0 0 {name=p93987 lab=_56243_/C }
C {devices/lab_pin.sym} 94540 -21440 0 0 {name=p93988 lab=_55311_/X }
C {devices/lab_pin.sym} 94540 -21400 0 0 {name=p93989 lab=_44046_/X }
C {devices/lab_pin.sym} 94540 -21360 0 0 {name=p93990 lab=_55812_/X }
C {devices/lab_pin.sym} 94700 -21420 0 1 {name=p93991 lab=_55813_/X }
C {sky130_stdcells/a211o_4.sym} 94620 -21420 0 0 {name=X_55813_ }
C {devices/lab_pin.sym} 94530 -21270 0 0 {name=p93992 lab=_85993_/CLK }
C {devices/lab_pin.sym} 94530 -21250 0 0 {name=p93993 lab=_47457_/Y }
C {devices/lab_pin.sym} 94710 -21270 0 1 {name=p93994 lab=_86633_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -21260 0 0 {name=X_86633_ }
C {devices/lab_pin.sym} 94530 -21130 0 0 {name=p93995 lab=_83843_/CLK }
C {devices/lab_pin.sym} 94530 -21110 0 0 {name=p93996 lab=_83845_/D }
C {devices/lab_pin.sym} 94710 -21130 0 1 {name=p93997 lab=_83845_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -21120 0 0 {name=X_83845_ }
C {devices/lab_pin.sym} 94560 -21010 0 0 {name=p93998 lab=_59546_/A }
C {devices/lab_pin.sym} 94560 -20970 0 0 {name=p93999 lab=_59563_/A }
C {devices/lab_pin.sym} 94560 -20930 0 0 {name=p94000 lab=_59581_/C }
C {devices/lab_pin.sym} 94680 -20970 0 1 {name=p94001 lab=_59582_/B }
C {sky130_stdcells/nand3_4.sym} 94620 -20970 0 0 {name=X_59581_ }
C {devices/lab_pin.sym} 94560 -20850 0 0 {name=p94002 lab=_55399_/X }
C {devices/lab_pin.sym} 94560 -20810 0 0 {name=p94003 lab=_56707_/X }
C {devices/lab_pin.sym} 94560 -20770 0 0 {name=p94004 lab=_55409_/Y }
C {devices/lab_pin.sym} 94680 -20810 0 1 {name=p94005 lab=_56797_/A }
C {sky130_stdcells/nand3_4.sym} 94620 -20810 0 0 {name=X_56793_ }
C {devices/lab_pin.sym} 94560 -20680 0 0 {name=p94006 lab=_68779_/A }
C {devices/lab_pin.sym} 94560 -20640 0 0 {name=p94007 lab=_87331_/Q }
C {devices/lab_pin.sym} 94680 -20660 0 1 {name=p94008 lab=_68779_/X }
C {sky130_stdcells/and2_4.sym} 94620 -20660 0 0 {name=X_68779_ }
C {devices/lab_pin.sym} 94560 -20550 0 0 {name=p94009 lab=_70810_/A }
C {devices/lab_pin.sym} 94560 -20510 0 0 {name=p94010 lab=_70942_/B }
C {devices/lab_pin.sym} 94560 -20470 0 0 {name=p94011 lab=_70810_/C }
C {devices/lab_pin.sym} 94680 -20510 0 1 {name=p94012 lab=_70810_/Y }
C {sky130_stdcells/nand3_4.sym} 94620 -20510 0 0 {name=X_70810_ }
C {devices/lab_pin.sym} 94580 -20370 0 0 {name=p94013 lab=_57673_/A }
C {devices/lab_pin.sym} 94660 -20370 0 1 {name=p94014 lab=_58532_/X }
C {sky130_stdcells/buf_2.sym} 94620 -20370 0 0 {name=X_58532_ }
C {devices/lab_pin.sym} 94540 -20270 0 0 {name=p94015 lab=_55740_/Y }
C {devices/lab_pin.sym} 94540 -20230 0 0 {name=p94016 lab=_44095_/A }
C {devices/lab_pin.sym} 94540 -20190 0 0 {name=p94017 lab=_55743_/Y }
C {devices/lab_pin.sym} 94700 -20230 0 1 {name=p94018 lab=_55745_/D }
C {sky130_stdcells/a21oi_4.sym} 94620 -20230 0 0 {name=X_55744_ }
C {devices/lab_pin.sym} 94530 -20090 0 0 {name=p94019 lab=_86490_/CLK }
C {devices/lab_pin.sym} 94530 -20070 0 0 {name=p94020 lab=_86564_/D }
C {devices/lab_pin.sym} 94710 -20090 0 1 {name=p94021 lab=_74234_/B }
C {sky130_stdcells/dfxtp_4.sym} 94620 -20080 0 0 {name=X_86564_ }
C {devices/lab_pin.sym} 94560 -19960 0 0 {name=p94022 lab=_40800_/B }
C {devices/lab_pin.sym} 94560 -19920 0 0 {name=p94023 lab=_40970_/B }
C {devices/lab_pin.sym} 94680 -19940 0 1 {name=p94024 lab=_40970_/X }
C {sky130_stdcells/or2_4.sym} 94620 -19940 0 0 {name=X_40970_ }
C {devices/lab_pin.sym} 94580 -19810 0 0 {name=p94025 lab=_52515_/A }
C {devices/lab_pin.sym} 94660 -19810 0 1 {name=p94026 lab=_53065_/A }
C {sky130_stdcells/buf_2.sym} 94620 -19810 0 0 {name=X_52956_ }
C {devices/lab_pin.sym} 94560 -19710 0 0 {name=p94027 lab=_71235_/A }
C {devices/lab_pin.sym} 94560 -19670 0 0 {name=p94028 lab=_70472_/X }
C {devices/lab_pin.sym} 94560 -19630 0 0 {name=p94029 lab=_71785_/X }
C {devices/lab_pin.sym} 94680 -19670 0 1 {name=p94030 lab=_71790_/Y }
C {sky130_stdcells/nand3_4.sym} 94620 -19670 0 0 {name=X_71790_ }
C {devices/lab_pin.sym} 94530 -19530 0 0 {name=p94031 lab=_86553_/CLK }
C {devices/lab_pin.sym} 94530 -19510 0 0 {name=p94032 lab=_83776_/D }
C {devices/lab_pin.sym} 94710 -19530 0 1 {name=p94033 lab=_83776_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -19520 0 0 {name=X_83776_ }
C {devices/lab_pin.sym} 94530 -19390 0 0 {name=p94034 lab=_80849_/CLK }
C {devices/lab_pin.sym} 94530 -19370 0 0 {name=p94035 lab=_80988_/D }
C {devices/lab_pin.sym} 94710 -19390 0 1 {name=p94036 lab=_80944_/D }
C {sky130_stdcells/dfxtp_4.sym} 94620 -19380 0 0 {name=X_80988_ }
C {devices/lab_pin.sym} 94530 -19250 0 0 {name=p94037 lab=_88097_/CLK }
C {devices/lab_pin.sym} 94530 -19230 0 0 {name=p94038 lab=_88303_/D }
C {devices/lab_pin.sym} 94710 -19250 0 1 {name=p94039 lab=_88303_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -19240 0 0 {name=X_88303_ }
C {devices/lab_pin.sym} 94530 -19110 0 0 {name=p94040 lab=_86029_/CLK }
C {devices/lab_pin.sym} 94530 -19090 0 0 {name=p94041 lab=_54053_/Y }
C {devices/lab_pin.sym} 94710 -19110 0 1 {name=p94042 lab=_85515_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -19100 0 0 {name=X_85515_ }
C {devices/lab_pin.sym} 94560 -18980 0 0 {name=p94043 lab=_51902_/A }
C {devices/lab_pin.sym} 94560 -18940 0 0 {name=p94044 lab=_51043_/B }
C {devices/lab_pin.sym} 94680 -18960 0 1 {name=p94045 lab=_51907_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -18960 0 0 {name=X_51907_ }
C {devices/lab_pin.sym} 94540 -18850 0 0 {name=p94046 lab=_53101_/B }
C {devices/lab_pin.sym} 94540 -18810 0 0 {name=p94047 lab=_70738_/X }
C {devices/lab_pin.sym} 94540 -18770 0 0 {name=p94048 lab=_70740_/Y }
C {devices/lab_pin.sym} 94700 -18810 0 1 {name=p94049 lab=_70741_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -18810 0 0 {name=X_70741_ }
C {devices/lab_pin.sym} 94580 -18670 0 0 {name=p94050 lab=_83474_/Q }
C {devices/lab_pin.sym} 94660 -18670 0 1 {name=p94051 lab=_58463_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -18670 0 0 {name=X_58463_ }
C {devices/lab_pin.sym} 94530 -18550 0 0 {name=p94052 lab=_81190_/CLK }
C {devices/lab_pin.sym} 94530 -18530 0 0 {name=p94053 lab=_84111_/Q }
C {devices/lab_pin.sym} 94710 -18550 0 1 {name=p94054 lab=_82727_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -18540 0 0 {name=X_82727_ }
C {devices/lab_pin.sym} 94560 -18420 0 0 {name=p94055 lab=_55671_/Y }
C {devices/lab_pin.sym} 94560 -18380 0 0 {name=p94056 lab=_55675_/B }
C {devices/lab_pin.sym} 94680 -18400 0 1 {name=p94057 lab=_55675_/X }
C {sky130_stdcells/xor2_4.sym} 94620 -18400 0 0 {name=X_55675_ }
C {devices/lab_pin.sym} 94530 -18270 0 0 {name=p94058 lab=_85888_/CLK }
C {devices/lab_pin.sym} 94530 -18250 0 0 {name=p94059 lab=_86495_/D }
C {devices/lab_pin.sym} 94710 -18270 0 1 {name=p94060 lab=_65455_/B }
C {sky130_stdcells/dfxtp_4.sym} 94620 -18260 0 0 {name=X_86495_ }
C {devices/lab_pin.sym} 94560 -18160 0 0 {name=p94061 lab=_52867_/A }
C {devices/lab_pin.sym} 94560 -18120 0 0 {name=p94062 lab=_52879_/B }
C {devices/lab_pin.sym} 94560 -18080 0 0 {name=p94063 lab=_52872_/C }
C {devices/lab_pin.sym} 94560 -18040 0 0 {name=p94064 lab=_52887_/D }
C {devices/lab_pin.sym} 94680 -18100 0 1 {name=p94065 lab=_52887_/X }
C {sky130_stdcells/and4_4.sym} 94620 -18100 0 0 {name=X_52887_ }
C {devices/lab_pin.sym} 94580 -17950 0 0 {name=p94066 lab=clkbuf_9_287_0_CLK/X }
C {devices/lab_pin.sym} 94660 -17950 0 1 {name=p94067 lab=_82886_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 94620 -17950 0 0 {name=Xclkbuf_10_575_0_CLK }
C {devices/lab_pin.sym} 94560 -17840 0 0 {name=p94068 lab=_57414_/A }
C {devices/lab_pin.sym} 94560 -17800 0 0 {name=p94069 lab=_57413_/X }
C {devices/lab_pin.sym} 94680 -17820 0 1 {name=p94070 lab=_57414_/X }
C {sky130_stdcells/or2_4.sym} 94620 -17820 0 0 {name=X_57414_ }
C {devices/lab_pin.sym} 94530 -17690 0 0 {name=p94071 lab=_88164_/CLK }
C {devices/lab_pin.sym} 94530 -17670 0 0 {name=p94072 lab=_88234_/D }
C {devices/lab_pin.sym} 94710 -17690 0 1 {name=p94073 lab=_67553_/B }
C {sky130_stdcells/dfxtp_4.sym} 94620 -17680 0 0 {name=X_88234_ }
C {devices/lab_pin.sym} 94540 -17570 0 0 {name=p94074 lab=_54624_/Y }
C {devices/lab_pin.sym} 94540 -17530 0 0 {name=p94075 lab=_54611_/X }
C {devices/lab_pin.sym} 94540 -17490 0 0 {name=p94076 lab=_54625_/X }
C {devices/lab_pin.sym} 94700 -17530 0 1 {name=p94077 lab=_85408_/D }
C {sky130_stdcells/a21oi_4.sym} 94620 -17530 0 0 {name=X_54626_ }
C {devices/lab_pin.sym} 94540 -17420 0 0 {name=p94078 lab=_40955_/X }
C {devices/lab_pin.sym} 94540 -17380 0 0 {name=p94079 lab=_42631_/X }
C {devices/lab_pin.sym} 94540 -17340 0 0 {name=p94080 lab=_69176_/B }
C {devices/lab_pin.sym} 94540 -17300 0 0 {name=p94081 lab=_42634_/X }
C {devices/lab_pin.sym} 94700 -17360 0 1 {name=p94082 lab=_42640_/X }
C {sky130_stdcells/a2bb2o_4.sym} 94620 -17360 0 0 {name=X_42640_ }
C {devices/lab_pin.sym} 94560 -17220 0 0 {name=p94083 lab=_73339_/A }
C {devices/lab_pin.sym} 94560 -17180 0 0 {name=p94084 lab=_73460_/B }
C {devices/lab_pin.sym} 94680 -17200 0 1 {name=p94085 lab=_73460_/Y }
C {sky130_stdcells/nor2_4.sym} 94620 -17200 0 0 {name=X_73460_ }
C {devices/lab_pin.sym} 94530 -17070 0 0 {name=p94086 lab=_85447_/CLK }
C {devices/lab_pin.sym} 94530 -17050 0 0 {name=p94087 lab=_85446_/D }
C {devices/lab_pin.sym} 94710 -17070 0 1 {name=p94088 lab=_85446_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -17060 0 0 {name=X_85446_ }
C {devices/lab_pin.sym} 94560 -16960 0 0 {name=p94089 lab=_51851_/A }
C {devices/lab_pin.sym} 94560 -16920 0 0 {name=p94090 lab=_51815_/B }
C {devices/lab_pin.sym} 94560 -16880 0 0 {name=p94091 lab=_51851_/C }
C {devices/lab_pin.sym} 94560 -16840 0 0 {name=p94092 lab=_46775_/X }
C {devices/lab_pin.sym} 94680 -16900 0 1 {name=p94093 lab=_51838_/X }
C {sky130_stdcells/and4_4.sym} 94620 -16900 0 0 {name=X_51838_ }
C {devices/lab_pin.sym} 94580 -16750 0 0 {name=p94094 lab=_70543_/Y }
C {devices/lab_pin.sym} 94660 -16750 0 1 {name=p94095 lab=_70673_/A }
C {sky130_stdcells/buf_2.sym} 94620 -16750 0 0 {name=X_70672_ }
C {devices/lab_pin.sym} 94530 -16630 0 0 {name=p94096 lab=_82498_/CLK }
C {devices/lab_pin.sym} 94530 -16610 0 0 {name=p94097 lab=_82658_/D }
C {devices/lab_pin.sym} 94710 -16630 0 1 {name=p94098 lab=_78082_/A }
C {sky130_stdcells/dfxtp_4.sym} 94620 -16620 0 0 {name=X_82658_ }
C {devices/lab_pin.sym} 94560 -16500 0 0 {name=p94099 lab=_58393_/Y }
C {devices/lab_pin.sym} 94560 -16460 0 0 {name=p94100 lab=_58403_/B }
C {devices/lab_pin.sym} 94680 -16480 0 1 {name=p94101 lab=_58394_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -16480 0 0 {name=X_58394_ }
C {devices/lab_pin.sym} 94540 -16370 0 0 {name=p94102 lab=_72408_/Y }
C {devices/lab_pin.sym} 94540 -16330 0 0 {name=p94103 lab=_72410_/Y }
C {devices/lab_pin.sym} 94540 -16290 0 0 {name=p94104 lab=_72344_/X }
C {devices/lab_pin.sym} 94700 -16330 0 1 {name=p94105 lab=_72411_/X }
C {sky130_stdcells/a21o_4.sym} 94620 -16330 0 0 {name=X_72411_ }
C {devices/lab_pin.sym} 94530 -16190 0 0 {name=p94106 lab=_81801_/CLK }
C {devices/lab_pin.sym} 94530 -16170 0 0 {name=p94107 lab=_76258_/Y }
C {devices/lab_pin.sym} 94710 -16190 0 1 {name=p94108 lab=_81609_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -16180 0 0 {name=X_81609_ }
C {devices/lab_pin.sym} 94560 -16060 0 0 {name=p94109 lab=_56873_/X }
C {devices/lab_pin.sym} 94560 -16020 0 0 {name=p94110 lab=_57322_/B }
C {devices/lab_pin.sym} 94680 -16040 0 1 {name=p94111 lab=_57351_/A }
C {sky130_stdcells/nand2_4.sym} 94620 -16040 0 0 {name=X_57345_ }
C {devices/lab_pin.sym} 94530 -15910 0 0 {name=p94112 lab=_87915_/CLK }
C {devices/lab_pin.sym} 94530 -15890 0 0 {name=p94113 lab=_88165_/D }
C {devices/lab_pin.sym} 94710 -15910 0 1 {name=p94114 lab=_67683_/B }
C {sky130_stdcells/dfxtp_4.sym} 94620 -15900 0 0 {name=X_88165_ }
C {devices/lab_pin.sym} 94580 -15770 0 0 {name=p94115 lab=_42556_/A }
C {devices/lab_pin.sym} 94660 -15770 0 1 {name=p94116 lab=_42571_/X }
C {sky130_stdcells/buf_2.sym} 94620 -15770 0 0 {name=X_42571_ }
C {devices/lab_pin.sym} 94580 -15650 0 0 {name=p94117 lab=_54284_/A }
C {devices/lab_pin.sym} 94660 -15650 0 1 {name=p94118 lab=_54558_/A }
C {sky130_stdcells/buf_2.sym} 94620 -15650 0 0 {name=X_54557_ }
C {devices/lab_pin.sym} 94560 -15540 0 0 {name=p94119 lab=_73339_/A }
C {devices/lab_pin.sym} 94560 -15500 0 0 {name=p94120 lab=_73391_/B }
C {devices/lab_pin.sym} 94680 -15520 0 1 {name=p94121 lab=_73391_/Y }
C {sky130_stdcells/nor2_4.sym} 94620 -15520 0 0 {name=X_73391_ }
C {devices/lab_pin.sym} 94530 -15390 0 0 {name=p94122 lab=_83711_/CLK }
C {devices/lab_pin.sym} 94530 -15370 0 0 {name=p94123 lab=_85377_/D }
C {devices/lab_pin.sym} 94710 -15390 0 1 {name=p94124 lab=_85377_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -15380 0 0 {name=X_85377_ }
C {devices/lab_pin.sym} 94540 -15270 0 0 {name=p94125 lab=_51766_/Y }
C {devices/lab_pin.sym} 94540 -15230 0 0 {name=p94126 lab=_51767_/X }
C {devices/lab_pin.sym} 94540 -15190 0 0 {name=p94127 lab=_51768_/X }
C {devices/lab_pin.sym} 94700 -15230 0 1 {name=p94128 lab=_51769_/Y }
C {sky130_stdcells/a21oi_4.sym} 94620 -15230 0 0 {name=X_51769_ }
C {devices/lab_pin.sym} 94530 -15090 0 0 {name=p94129 lab=_82589_/CLK }
C {devices/lab_pin.sym} 94530 -15070 0 0 {name=p94130 lab=_82621_/Q }
C {devices/lab_pin.sym} 94710 -15090 0 1 {name=p94131 lab=_78273_/A }
C {sky130_stdcells/dfxtp_4.sym} 94620 -15080 0 0 {name=X_82589_ }
C {devices/lab_pin.sym} 94580 -14950 0 0 {name=p94132 lab=_57470_/B }
C {devices/lab_pin.sym} 94660 -14950 0 1 {name=p94133 lab=_44318_/A }
C {sky130_stdcells/buf_2.sym} 94620 -14950 0 0 {name=X_44310_ }
C {devices/lab_pin.sym} 94540 -14850 0 0 {name=p94134 lab=_75126_/X }
C {devices/lab_pin.sym} 94540 -14810 0 0 {name=p94135 lab=_75143_/A }
C {devices/lab_pin.sym} 94540 -14770 0 0 {name=p94136 lab=_75129_/Y }
C {devices/lab_pin.sym} 94700 -14810 0 1 {name=p94137 lab=_75130_/Y }
C {sky130_stdcells/a21oi_4.sym} 94620 -14810 0 0 {name=X_75130_ }
C {devices/lab_pin.sym} 94580 -14670 0 0 {name=p94138 lab=_41522_/A }
C {devices/lab_pin.sym} 94660 -14670 0 1 {name=p94139 lab=_41522_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -14670 0 0 {name=X_41522_ }
C {devices/lab_pin.sym} 94530 -14550 0 0 {name=p94140 lab=_87116_/CLK }
C {devices/lab_pin.sym} 94530 -14530 0 0 {name=p94141 lab=_87116_/D }
C {devices/lab_pin.sym} 94710 -14550 0 1 {name=p94142 lab=_87116_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -14540 0 0 {name=X_87116_ }
C {devices/lab_pin.sym} 94580 -14410 0 0 {name=p94143 lab=_53723_/A }
C {devices/lab_pin.sym} 94660 -14410 0 1 {name=p94144 lab=_53509_/A }
C {sky130_stdcells/buf_2.sym} 94620 -14410 0 0 {name=X_53508_ }
C {devices/lab_pin.sym} 94540 -14310 0 0 {name=p94145 lab=_72258_/X }
C {devices/lab_pin.sym} 94540 -14270 0 0 {name=p94146 lab=_85679_/Q }
C {devices/lab_pin.sym} 94540 -14230 0 0 {name=p94147 lab=_72308_/X }
C {devices/lab_pin.sym} 94700 -14270 0 1 {name=p94148 lab=_72342_/X }
C {sky130_stdcells/o21a_4.sym} 94620 -14270 0 0 {name=X_72342_ }
C {devices/lab_pin.sym} 94530 -14130 0 0 {name=p94149 lab=_84355_/CLK }
C {devices/lab_pin.sym} 94530 -14110 0 0 {name=p94150 lab=_84328_/D }
C {devices/lab_pin.sym} 94710 -14130 0 1 {name=p94151 lab=_80614_/B }
C {sky130_stdcells/dfxtp_4.sym} 94620 -14120 0 0 {name=X_84328_ }
C {devices/lab_pin.sym} 94540 -14010 0 0 {name=p94152 lab=_57271_/Y }
C {devices/lab_pin.sym} 94540 -13970 0 0 {name=p94153 lab=_57274_/Y }
C {devices/lab_pin.sym} 94540 -13930 0 0 {name=p94154 lab=_57275_/X }
C {devices/lab_pin.sym} 94700 -13970 0 1 {name=p94155 lab=_57276_/X }
C {sky130_stdcells/a21o_4.sym} 94620 -13970 0 0 {name=X_57276_ }
C {devices/lab_pin.sym} 94580 -13830 0 0 {name=p94156 lab=_45290_/A }
C {devices/lab_pin.sym} 94660 -13830 0 1 {name=p94157 lab=_45290_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -13830 0 0 {name=X_45290_ }
C {devices/lab_pin.sym} 94530 -13710 0 0 {name=p94158 lab=_88104_/CLK }
C {devices/lab_pin.sym} 94530 -13690 0 0 {name=p94159 lab=_41948_/Y }
C {devices/lab_pin.sym} 94710 -13710 0 1 {name=p94160 lab=_88096_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -13700 0 0 {name=X_88096_ }
C {devices/lab_pin.sym} 94540 -13590 0 0 {name=p94161 lab=_85433_/Q }
C {devices/lab_pin.sym} 94540 -13550 0 0 {name=p94162 lab=_54485_/X }
C {devices/lab_pin.sym} 94540 -13510 0 0 {name=p94163 lab=_54487_/Y }
C {devices/lab_pin.sym} 94700 -13550 0 1 {name=p94164 lab=_54488_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -13550 0 0 {name=X_54488_ }
C {devices/lab_pin.sym} 94540 -13430 0 0 {name=p94165 lab=_59001_/X }
C {devices/lab_pin.sym} 94540 -13390 0 0 {name=p94166 lab=_86080_/Q }
C {devices/lab_pin.sym} 94540 -13350 0 0 {name=p94167 lab=_59014_/X }
C {devices/lab_pin.sym} 94700 -13390 0 1 {name=p94168 lab=_59015_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -13390 0 0 {name=X_59015_ }
C {devices/lab_pin.sym} 94560 -13280 0 0 {name=p94169 lab=_44139_/X }
C {devices/lab_pin.sym} 94560 -13240 0 0 {name=p94170 lab=_44141_/X }
C {devices/lab_pin.sym} 94560 -13200 0 0 {name=p94171 lab=_44142_/X }
C {devices/lab_pin.sym} 94560 -13160 0 0 {name=p94172 lab=_44225_/Y }
C {devices/lab_pin.sym} 94680 -13220 0 1 {name=p94173 lab=_44241_/Y }
C {sky130_stdcells/nand4_4.sym} 94620 -13220 0 0 {name=X_44241_ }
C {devices/lab_pin.sym} 94560 -13090 0 0 {name=p94174 lab=_56233_/A }
C {devices/lab_pin.sym} 94560 -13050 0 0 {name=p94175 lab=_56229_/B }
C {devices/lab_pin.sym} 94560 -13010 0 0 {name=p94176 lab=_85268_/Q }
C {devices/lab_pin.sym} 94680 -13050 0 1 {name=p94177 lab=_56227_/Y }
C {sky130_stdcells/nand3_4.sym} 94620 -13050 0 0 {name=X_56227_ }
C {devices/lab_pin.sym} 94560 -12920 0 0 {name=p94178 lab=_80744_/Q }
C {devices/lab_pin.sym} 94560 -12880 0 0 {name=p94179 lab=_75061_/B }
C {devices/lab_pin.sym} 94680 -12900 0 1 {name=p94180 lab=_75067_/B }
C {sky130_stdcells/xor2_4.sym} 94620 -12900 0 0 {name=X_75061_ }
C {devices/lab_pin.sym} 94530 -12770 0 0 {name=p94181 lab=_88326_/CLK }
C {devices/lab_pin.sym} 94530 -12750 0 0 {name=p94182 lab=_87047_/D }
C {devices/lab_pin.sym} 94710 -12770 0 1 {name=p94183 lab=_73370_/A }
C {sky130_stdcells/dfxtp_4.sym} 94620 -12760 0 0 {name=X_87047_ }
C {devices/lab_pin.sym} 94540 -12650 0 0 {name=p94184 lab=_41449_/X }
C {devices/lab_pin.sym} 94540 -12610 0 0 {name=p94185 lab=_82882_/Q }
C {devices/lab_pin.sym} 94540 -12570 0 0 {name=p94186 lab=_41452_/X }
C {devices/lab_pin.sym} 94700 -12610 0 1 {name=p94187 lab=_41453_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -12610 0 0 {name=X_41453_ }
C {devices/lab_pin.sym} 94560 -12500 0 0 {name=p94188 lab=_53420_/A }
C {devices/lab_pin.sym} 94560 -12460 0 0 {name=p94189 lab=_53428_/X }
C {devices/lab_pin.sym} 94560 -12420 0 0 {name=p94190 lab=_54111_/C }
C {devices/lab_pin.sym} 94560 -12380 0 0 {name=p94191 lab=_47218_/D }
C {devices/lab_pin.sym} 94680 -12440 0 1 {name=p94192 lab=_53439_/X }
C {sky130_stdcells/and4_4.sym} 94620 -12440 0 0 {name=X_53439_ }
C {devices/lab_pin.sym} 94560 -12300 0 0 {name=p94193 lab=_86613_/Q }
C {devices/lab_pin.sym} 94560 -12260 0 0 {name=p94194 lab=_72332_/B }
C {devices/lab_pin.sym} 94680 -12280 0 1 {name=p94195 lab=_72273_/Y }
C {sky130_stdcells/nor2_4.sym} 94620 -12280 0 0 {name=X_72273_ }
C {devices/lab_pin.sym} 94530 -12150 0 0 {name=p94196 lab=_84314_/CLK }
C {devices/lab_pin.sym} 94530 -12130 0 0 {name=p94197 lab=_64291_/X }
C {devices/lab_pin.sym} 94710 -12150 0 1 {name=p94198 lab=_79817_/B }
C {sky130_stdcells/dfxtp_4.sym} 94620 -12140 0 0 {name=X_84259_ }
C {devices/lab_pin.sym} 94580 -12010 0 0 {name=p94199 lab=_74012_/A }
C {devices/lab_pin.sym} 94660 -12010 0 1 {name=p94200 lab=_74012_/X }
C {sky130_stdcells/buf_2.sym} 94620 -12010 0 0 {name=X_74012_ }
C {devices/lab_pin.sym} 94580 -11890 0 0 {name=p94201 lab=_40403_/Y }
C {devices/lab_pin.sym} 94660 -11890 0 1 {name=p94202 lab=_40404_/X }
C {sky130_stdcells/buf_2.sym} 94620 -11890 0 0 {name=X_40404_ }
C {devices/lab_pin.sym} 94540 -11790 0 0 {name=p94203 lab=_48847_/B }
C {devices/lab_pin.sym} 94540 -11750 0 0 {name=p94204 lab=_71216_/X }
C {devices/lab_pin.sym} 94540 -11710 0 0 {name=p94205 lab=_71223_/Y }
C {devices/lab_pin.sym} 94700 -11750 0 1 {name=p94206 lab=_71224_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -11750 0 0 {name=X_71224_ }
C {devices/lab_pin.sym} 94580 -11610 0 0 {name=p94207 lab=_44247_/A }
C {devices/lab_pin.sym} 94660 -11610 0 1 {name=p94208 lab=_44315_/A }
C {sky130_stdcells/buf_2.sym} 94620 -11610 0 0 {name=X_44172_ }
C {devices/lab_pin.sym} 94560 -11500 0 0 {name=p94209 lab=_56158_/A }
C {devices/lab_pin.sym} 94560 -11460 0 0 {name=p94210 lab=_56157_/Y }
C {devices/lab_pin.sym} 94680 -11480 0 1 {name=p94211 lab=_56159_/A }
C {sky130_stdcells/xor2_4.sym} 94620 -11480 0 0 {name=X_56158_ }
C {devices/lab_pin.sym} 94580 -11350 0 0 {name=p94212 lab=_41383_/Y }
C {devices/lab_pin.sym} 94660 -11350 0 1 {name=p94213 lab=_88225_/D }
C {sky130_stdcells/inv_2.sym} 94620 -11350 0 0 {name=X_41384_ }
C {devices/lab_pin.sym} 94580 -11230 0 0 {name=p94214 lab=clkbuf_9_256_0_CLK/X }
C {devices/lab_pin.sym} 94660 -11230 0 1 {name=p94215 lab=_81461_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 94620 -11230 0 0 {name=Xclkbuf_10_513_0_CLK }
C {devices/lab_pin.sym} 94580 -11110 0 0 {name=p94216 lab=_43123_/A }
C {devices/lab_pin.sym} 94660 -11110 0 1 {name=p94217 lab=_43123_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -11110 0 0 {name=X_43123_ }
C {devices/lab_pin.sym} 94540 -11010 0 0 {name=p94218 lab=_55107_/Y }
C {devices/lab_pin.sym} 94540 -10970 0 0 {name=p94219 lab=_55102_/X }
C {devices/lab_pin.sym} 94540 -10930 0 0 {name=p94220 lab=_55108_/X }
C {devices/lab_pin.sym} 94700 -10970 0 1 {name=p94221 lab=_55109_/Y }
C {sky130_stdcells/a21oi_4.sym} 94620 -10970 0 0 {name=X_55109_ }
C {devices/lab_pin.sym} 94560 -10840 0 0 {name=p94222 lab=_78810_/Y }
C {devices/lab_pin.sym} 94560 -10800 0 0 {name=p94223 lab=_78820_/B }
C {devices/lab_pin.sym} 94680 -10820 0 1 {name=p94224 lab=_78821_/B }
C {sky130_stdcells/xnor2_4.sym} 94620 -10820 0 0 {name=X_78820_ }
C {devices/lab_pin.sym} 94560 -10700 0 0 {name=p94225 lab=_40321_/A }
C {devices/lab_pin.sym} 94560 -10660 0 0 {name=p94226 lab=_40335_/B }
C {devices/lab_pin.sym} 94680 -10680 0 1 {name=p94227 lab=_43175_/A }
C {sky130_stdcells/nand2_4.sym} 94620 -10680 0 0 {name=X_40335_ }
C {devices/lab_pin.sym} 94560 -10580 0 0 {name=p94228 lab=_71181_/A }
C {devices/lab_pin.sym} 94560 -10540 0 0 {name=p94229 lab=_71155_/B }
C {devices/lab_pin.sym} 94560 -10500 0 0 {name=p94230 lab=_71160_/C }
C {devices/lab_pin.sym} 94560 -10460 0 0 {name=p94231 lab=_71160_/D }
C {devices/lab_pin.sym} 94680 -10520 0 1 {name=p94232 lab=_71155_/Y }
C {sky130_stdcells/nand4_4.sym} 94620 -10520 0 0 {name=X_71155_ }
C {devices/lab_pin.sym} 94540 -10390 0 0 {name=p94233 lab=_48975_/Y }
C {devices/lab_pin.sym} 94540 -10350 0 0 {name=p94234 lab=_48935_/X }
C {devices/lab_pin.sym} 94540 -10310 0 0 {name=p94235 lab=_48979_/X }
C {devices/lab_pin.sym} 94700 -10350 0 1 {name=p94236 lab=_48980_/Y }
C {sky130_stdcells/a21oi_4.sym} 94620 -10350 0 0 {name=X_48980_ }
C {devices/lab_pin.sym} 94560 -10220 0 0 {name=p94237 lab=_55845_/B }
C {devices/lab_pin.sym} 94560 -10180 0 0 {name=p94238 lab=_55844_/X }
C {devices/lab_pin.sym} 94680 -10200 0 1 {name=p94239 lab=_56089_/X }
C {sky130_stdcells/and2_4.sym} 94620 -10200 0 0 {name=X_56089_ }
C {devices/lab_pin.sym} 94580 -10070 0 0 {name=p94240 lab=_83136_/Q }
C {devices/lab_pin.sym} 94660 -10070 0 1 {name=p94241 lab=_70106_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -10070 0 0 {name=X_70106_ }
C {devices/lab_pin.sym} 94580 -9950 0 0 {name=p94242 lab=_53501_/B }
C {devices/lab_pin.sym} 94660 -9950 0 1 {name=p94243 lab=_47932_/B }
C {sky130_stdcells/buf_2.sym} 94620 -9950 0 0 {name=X_47931_ }
C {devices/lab_pin.sym} 94580 -9830 0 0 {name=p94244 lab=_43046_/A }
C {devices/lab_pin.sym} 94660 -9830 0 1 {name=p94245 lab=_43054_/X }
C {sky130_stdcells/buf_2.sym} 94620 -9830 0 0 {name=X_43054_ }
C {devices/lab_pin.sym} 94560 -9730 0 0 {name=p94246 lab=_59917_/A }
C {devices/lab_pin.sym} 94560 -9690 0 0 {name=p94247 lab=_59904_/B }
C {devices/lab_pin.sym} 94560 -9650 0 0 {name=p94248 lab=_60155_/C }
C {devices/lab_pin.sym} 94680 -9690 0 1 {name=p94249 lab=_59917_/X }
C {sky130_stdcells/and3_4.sym} 94620 -9690 0 0 {name=X_59917_ }
C {devices/lab_pin.sym} 94560 -9560 0 0 {name=p94250 lab=_78750_/A }
C {devices/lab_pin.sym} 94560 -9520 0 0 {name=p94251 lab=_82687_/D }
C {devices/lab_pin.sym} 94680 -9540 0 1 {name=p94252 lab=_78752_/A }
C {sky130_stdcells/nand2_4.sym} 94620 -9540 0 0 {name=X_78751_ }
C {devices/lab_pin.sym} 94560 -9430 0 0 {name=p94253 lab=_71088_/A }
C {devices/lab_pin.sym} 94560 -9390 0 0 {name=p94254 lab=_71230_/B }
C {devices/lab_pin.sym} 94560 -9350 0 0 {name=p94255 lab=_71088_/C }
C {devices/lab_pin.sym} 94680 -9390 0 1 {name=p94256 lab=_71086_/Y }
C {sky130_stdcells/nand3_4.sym} 94620 -9390 0 0 {name=X_71086_ }
C {devices/lab_pin.sym} 94560 -9270 0 0 {name=p94257 lab=_75956_/Y }
C {devices/lab_pin.sym} 94560 -9230 0 0 {name=p94258 lab=_75961_/Y }
C {devices/lab_pin.sym} 94560 -9190 0 0 {name=p94259 lab=_75963_/C }
C {devices/lab_pin.sym} 94680 -9230 0 1 {name=p94260 lab=_75963_/Y }
C {sky130_stdcells/nand3_4.sym} 94620 -9230 0 0 {name=X_75963_ }
C {devices/lab_pin.sym} 94530 -9090 0 0 {name=p94261 lab=_87952_/CLK }
C {devices/lab_pin.sym} 94530 -9070 0 0 {name=p94262 lab=_87949_/D }
C {devices/lab_pin.sym} 94710 -9090 0 1 {name=p94263 lab=_87949_/Q }
C {sky130_stdcells/dfxtp_4.sym} 94620 -9080 0 0 {name=X_87949_ }
C {devices/lab_pin.sym} 94540 -8990 0 0 {name=p94264 lab=_41998_/X }
C {devices/lab_pin.sym} 94540 -8950 0 0 {name=p94265 lab=_41993_/X }
C {devices/lab_pin.sym} 94540 -8910 0 0 {name=p94266 lab=_40810_/X }
C {devices/lab_pin.sym} 94540 -8870 0 0 {name=p94267 lab=_42004_/Y }
C {devices/lab_pin.sym} 94540 -8830 0 0 {name=p94268 lab=_42000_/X }
C {devices/lab_pin.sym} 94700 -8910 0 1 {name=p94269 lab=_88074_/D }
C {sky130_stdcells/o32ai_4.sym} 94620 -8910 0 0 {name=X_42005_ }
C {devices/lab_pin.sym} 94580 -8750 0 0 {name=p94270 lab=_77702_/A }
C {devices/lab_pin.sym} 94660 -8750 0 1 {name=p94271 lab=_77703_/C }
C {sky130_stdcells/inv_2.sym} 94620 -8750 0 0 {name=X_77702_ }
C {devices/lab_pin.sym} 94560 -8640 0 0 {name=p94272 lab=_74904_/Y }
C {devices/lab_pin.sym} 94560 -8600 0 0 {name=p94273 lab=_74914_/B }
C {devices/lab_pin.sym} 94680 -8620 0 1 {name=p94274 lab=_74914_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -8620 0 0 {name=X_74914_ }
C {devices/lab_pin.sym} 94540 -8510 0 0 {name=p94275 lab=_68749_/X }
C {devices/lab_pin.sym} 94540 -8470 0 0 {name=p94276 lab=_68751_/X }
C {devices/lab_pin.sym} 94540 -8430 0 0 {name=p94277 lab=_70005_/X }
C {devices/lab_pin.sym} 94700 -8470 0 1 {name=p94278 lab=_70037_/Y }
C {sky130_stdcells/a21oi_4.sym} 94620 -8470 0 0 {name=X_70037_ }
C {devices/lab_pin.sym} 94540 -8350 0 0 {name=p94279 lab=_47856_/Y }
C {devices/lab_pin.sym} 94540 -8310 0 0 {name=p94280 lab=_47846_/X }
C {devices/lab_pin.sym} 94540 -8270 0 0 {name=p94281 lab=_47861_/X }
C {devices/lab_pin.sym} 94700 -8310 0 1 {name=p94282 lab=_47862_/Y }
C {sky130_stdcells/a21oi_4.sym} 94620 -8310 0 0 {name=X_47862_ }
C {devices/lab_pin.sym} 94560 -8190 0 0 {name=p94283 lab=_59855_/A }
C {devices/lab_pin.sym} 94560 -8150 0 0 {name=p94284 lab=_59848_/B }
C {devices/lab_pin.sym} 94560 -8110 0 0 {name=p94285 lab=_80371_/A }
C {devices/lab_pin.sym} 94680 -8150 0 1 {name=p94286 lab=_59848_/Y }
C {sky130_stdcells/nor3_4.sym} 94620 -8150 0 0 {name=X_59848_ }
C {devices/lab_pin.sym} 94560 -8030 0 0 {name=p94287 lab=_78682_/A }
C {devices/lab_pin.sym} 94560 -7990 0 0 {name=p94288 lab=_78682_/B }
C {devices/lab_pin.sym} 94560 -7950 0 0 {name=p94289 lab=_78682_/C }
C {devices/lab_pin.sym} 94680 -7990 0 1 {name=p94290 lab=_78684_/A }
C {sky130_stdcells/or3_4.sym} 94620 -7990 0 0 {name=X_78682_ }
C {devices/lab_pin.sym} 94580 -7850 0 0 {name=p94291 lab=clkbuf_9_264_0_CLK/X }
C {devices/lab_pin.sym} 94660 -7850 0 1 {name=p94292 lab=_83940_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 94620 -7850 0 0 {name=Xclkbuf_10_528_0_CLK }
C {devices/lab_pin.sym} 94560 -7740 0 0 {name=p94293 lab=_84492_/Q }
C {devices/lab_pin.sym} 94560 -7700 0 0 {name=p94294 lab=_84364_/Q }
C {devices/lab_pin.sym} 94680 -7720 0 1 {name=p94295 lab=_80708_/D }
C {sky130_stdcells/xor2_4.sym} 94620 -7720 0 0 {name=X_75894_ }
C {devices/lab_pin.sym} 94580 -7590 0 0 {name=p94296 lab=clkbuf_5_9_0_CLK/X }
C {devices/lab_pin.sym} 94660 -7590 0 1 {name=p94297 lab=clkbuf_7_39_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 94620 -7590 0 0 {name=Xclkbuf_6_19_0_CLK }
C {devices/lab_pin.sym} 94540 -7490 0 0 {name=p94298 lab=_86357_/Q }
C {devices/lab_pin.sym} 94540 -7450 0 0 {name=p94299 lab=_49579_/X }
C {devices/lab_pin.sym} 94540 -7410 0 0 {name=p94300 lab=_49600_/Y }
C {devices/lab_pin.sym} 94700 -7450 0 1 {name=p94301 lab=_49601_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -7450 0 0 {name=X_49601_ }
C {devices/lab_pin.sym} 94580 -7310 0 0 {name=p94302 lab=_46767_/A }
C {devices/lab_pin.sym} 94660 -7310 0 1 {name=p94303 lab=_46813_/X }
C {sky130_stdcells/buf_2.sym} 94620 -7310 0 0 {name=X_46813_ }
C {devices/lab_pin.sym} 94560 -7210 0 0 {name=p94304 lab=_77629_/Y }
C {devices/lab_pin.sym} 94560 -7170 0 0 {name=p94305 lab=_77633_/B }
C {devices/lab_pin.sym} 94560 -7130 0 0 {name=p94306 lab=_77632_/Y }
C {devices/lab_pin.sym} 94680 -7170 0 1 {name=p94307 lab=_77633_/X }
C {sky130_stdcells/or3_4.sym} 94620 -7170 0 0 {name=X_77633_ }
C {devices/lab_pin.sym} 94580 -7030 0 0 {name=p94308 lab=_74844_/Y }
C {devices/lab_pin.sym} 94660 -7030 0 1 {name=p94309 lab=_80652_/D }
C {sky130_stdcells/inv_2.sym} 94620 -7030 0 0 {name=X_74845_ }
C {devices/lab_pin.sym} 94580 -6910 0 0 {name=p94310 lab=_81221_/Q }
C {devices/lab_pin.sym} 94660 -6910 0 1 {name=p94311 lab=_47794_/A }
C {sky130_stdcells/inv_2.sym} 94620 -6910 0 0 {name=X_47793_ }
C {devices/lab_pin.sym} 94540 -6830 0 0 {name=p94312 lab=_59758_/X }
C {devices/lab_pin.sym} 94540 -6790 0 0 {name=p94313 lab=_59775_/X }
C {devices/lab_pin.sym} 94540 -6750 0 0 {name=p94314 lab=_59724_/Y }
C {devices/lab_pin.sym} 94540 -6710 0 0 {name=p94315 lab=_59744_/Y }
C {devices/lab_pin.sym} 94540 -6680 0 0 {name=p94316 lab=_59778_/Y }
C {devices/lab_pin.sym} 94700 -6750 0 1 {name=p94317 lab=_59780_/A }
C {sky130_stdcells/a41o_4.sym} 94620 -6750 0 0 {name=X_59779_ }
C {devices/lab_pin.sym} 94580 -6590 0 0 {name=p94318 lab=_49614_/A }
C {devices/lab_pin.sym} 94660 -6590 0 1 {name=p94319 lab=_49537_/B }
C {sky130_stdcells/buf_2.sym} 94620 -6590 0 0 {name=X_49532_ }
C {devices/lab_pin.sym} 94560 -6500 0 0 {name=p94320 lab=_61386_/B }
C {devices/lab_pin.sym} 94560 -6460 0 0 {name=p94321 lab=_61795_/B }
C {devices/lab_pin.sym} 94560 -6420 0 0 {name=p94322 lab=_61795_/C }
C {devices/lab_pin.sym} 94560 -6380 0 0 {name=p94323 lab=_61778_/X }
C {devices/lab_pin.sym} 94680 -6440 0 1 {name=p94324 lab=_61810_/Y }
C {sky130_stdcells/nand4_4.sym} 94620 -6440 0 0 {name=X_61810_ }
C {devices/lab_pin.sym} 94580 -6290 0 0 {name=p94325 lab=_46743_/Y }
C {devices/lab_pin.sym} 94660 -6290 0 1 {name=p94326 lab=_46744_/X }
C {sky130_stdcells/buf_2.sym} 94620 -6290 0 0 {name=X_46744_ }
C {devices/lab_pin.sym} 94560 -6180 0 0 {name=p94327 lab=_77560_/Y }
C {devices/lab_pin.sym} 94560 -6140 0 0 {name=p94328 lab=_77564_/B }
C {devices/lab_pin.sym} 94680 -6160 0 1 {name=p94329 lab=_82200_/D }
C {sky130_stdcells/xor2_4.sym} 94620 -6160 0 0 {name=X_77564_ }
C {devices/lab_pin.sym} 94580 -6030 0 0 {name=p94330 lab=_80667_/Q }
C {devices/lab_pin.sym} 94660 -6030 0 1 {name=p94331 lab=_43957_/A }
C {sky130_stdcells/inv_2.sym} 94620 -6030 0 0 {name=X_43956_ }
C {devices/lab_pin.sym} 94540 -5950 0 0 {name=p94332 lab=_62784_/Y }
C {devices/lab_pin.sym} 94540 -5910 0 0 {name=p94333 lab=_62772_/X }
C {devices/lab_pin.sym} 94540 -5870 0 0 {name=p94334 lab=_62785_/Y }
C {devices/lab_pin.sym} 94540 -5830 0 0 {name=p94335 lab=_62787_/Y }
C {devices/lab_pin.sym} 94540 -5800 0 0 {name=p94336 lab=_62789_/X }
C {devices/lab_pin.sym} 94700 -5870 0 1 {name=p94337 lab=_62790_/X }
C {sky130_stdcells/a41o_4.sym} 94620 -5870 0 0 {name=X_62790_ }
C {devices/lab_pin.sym} 94540 -5750 0 0 {name=p94338 lab=_83845_/Q }
C {devices/lab_pin.sym} 94540 -5710 0 0 {name=p94339 lab=_74735_/X }
C {devices/lab_pin.sym} 94540 -5670 0 0 {name=p94340 lab=_74773_/X }
C {devices/lab_pin.sym} 94540 -5630 0 0 {name=p94341 lab=_74774_/X }
C {devices/lab_pin.sym} 94540 -5590 0 0 {name=p94342 lab=_74775_/X }
C {devices/lab_pin.sym} 94700 -5670 0 1 {name=p94343 lab=_74776_/Y }
C {sky130_stdcells/a2111oi_4.sym} 94620 -5670 0 0 {name=X_74776_ }
C {devices/lab_pin.sym} 94540 -5530 0 0 {name=p94344 lab=_83307_/Q }
C {devices/lab_pin.sym} 94540 -5490 0 0 {name=p94345 lab=_71985_/X }
C {devices/lab_pin.sym} 94540 -5450 0 0 {name=p94346 lab=_71987_/Y }
C {devices/lab_pin.sym} 94700 -5490 0 1 {name=p94347 lab=_71988_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -5490 0 0 {name=X_71988_ }
C {devices/lab_pin.sym} 94560 -5360 0 0 {name=p94348 lab=_79303_/A }
C {devices/lab_pin.sym} 94560 -5320 0 0 {name=p94349 lab=_79302_/Y }
C {devices/lab_pin.sym} 94680 -5340 0 1 {name=p94350 lab=_79303_/X }
C {sky130_stdcells/xor2_4.sym} 94620 -5340 0 0 {name=X_79303_ }
C {devices/lab_pin.sym} 94540 -5230 0 0 {name=p94351 lab=_76513_/C }
C {devices/lab_pin.sym} 94540 -5190 0 0 {name=p94352 lab=_76513_/D }
C {devices/lab_pin.sym} 94540 -5150 0 0 {name=p94353 lab=_76513_/B }
C {devices/lab_pin.sym} 94700 -5190 0 1 {name=p94354 lab=_76515_/X }
C {sky130_stdcells/a21bo_4.sym} 94620 -5190 0 0 {name=X_76515_ }
C {devices/lab_pin.sym} 94580 -5050 0 0 {name=p94355 lab=_42907_/A }
C {devices/lab_pin.sym} 94660 -5050 0 1 {name=p94356 lab=_87659_/D }
C {sky130_stdcells/inv_2.sym} 94620 -5050 0 0 {name=X_42907_ }
C {devices/lab_pin.sym} 94540 -4950 0 0 {name=p94357 lab=_49459_/Y }
C {devices/lab_pin.sym} 94540 -4910 0 0 {name=p94358 lab=_49460_/X }
C {devices/lab_pin.sym} 94540 -4870 0 0 {name=p94359 lab=_49462_/X }
C {devices/lab_pin.sym} 94700 -4910 0 1 {name=p94360 lab=_86383_/D }
C {sky130_stdcells/a21oi_4.sym} 94620 -4910 0 0 {name=X_49463_ }
C {devices/lab_pin.sym} 94580 -4770 0 0 {name=p94361 lab=_61777_/A }
C {devices/lab_pin.sym} 94660 -4770 0 1 {name=p94362 lab=_61761_/C }
C {sky130_stdcells/buf_2.sym} 94620 -4770 0 0 {name=X_61741_ }
C {devices/lab_pin.sym} 94540 -4670 0 0 {name=p94363 lab=_73724_/X }
C {devices/lab_pin.sym} 94540 -4630 0 0 {name=p94364 lab=_73726_/X }
C {devices/lab_pin.sym} 94540 -4590 0 0 {name=p94365 lab=_73679_/X }
C {devices/lab_pin.sym} 94700 -4630 0 1 {name=p94366 lab=_73727_/X }
C {sky130_stdcells/a21o_4.sym} 94620 -4630 0 0 {name=X_73727_ }
C {devices/lab_pin.sym} 94580 -4490 0 0 {name=p94367 lab=_70939_/A }
C {devices/lab_pin.sym} 94660 -4490 0 1 {name=p94368 lab=_70947_/C }
C {sky130_stdcells/buf_2.sym} 94620 -4490 0 0 {name=X_70939_ }
C {devices/lab_pin.sym} 94580 -4370 0 0 {name=p94369 lab=_83683_/Q }
C {devices/lab_pin.sym} 94660 -4370 0 1 {name=p94370 lab=_46676_/A }
C {sky130_stdcells/inv_2.sym} 94620 -4370 0 0 {name=X_46675_ }
C {devices/lab_pin.sym} 94560 -4270 0 0 {name=p94371 lab=_77495_/A }
C {devices/lab_pin.sym} 94560 -4230 0 0 {name=p94372 lab=_77493_/Y }
C {devices/lab_pin.sym} 94560 -4190 0 0 {name=p94373 lab=_77491_/Y }
C {devices/lab_pin.sym} 94680 -4230 0 1 {name=p94374 lab=_77495_/Y }
C {sky130_stdcells/nand3_4.sym} 94620 -4230 0 0 {name=X_77495_ }
C {devices/lab_pin.sym} 94580 -4090 0 0 {name=p94375 lab=_43869_/X }
C {devices/lab_pin.sym} 94660 -4090 0 1 {name=p94376 lab=_43887_/X }
C {sky130_stdcells/buf_2.sym} 94620 -4090 0 0 {name=X_43887_ }
C {devices/lab_pin.sym} 94560 -3980 0 0 {name=p94377 lab=_81788_/Q }
C {devices/lab_pin.sym} 94560 -3940 0 0 {name=p94378 lab=_48136_/B }
C {devices/lab_pin.sym} 94680 -3960 0 1 {name=p94379 lab=_48414_/X }
C {sky130_stdcells/or2_4.sym} 94620 -3960 0 0 {name=X_48414_ }
C {devices/lab_pin.sym} 94560 -3840 0 0 {name=p94380 lab=_79232_/B }
C {devices/lab_pin.sym} 94560 -3800 0 0 {name=p94381 lab=_79230_/Y }
C {devices/lab_pin.sym} 94680 -3820 0 1 {name=p94382 lab=_79235_/B }
C {sky130_stdcells/nand2_4.sym} 94620 -3820 0 0 {name=X_79234_ }
C {devices/lab_pin.sym} 94580 -3690 0 0 {name=p94383 lab=_85106_/Q }
C {devices/lab_pin.sym} 94660 -3690 0 1 {name=p94384 lab=_45626_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -3690 0 0 {name=X_45626_ }
C {devices/lab_pin.sym} 94540 -3590 0 0 {name=p94385 lab=_76425_/X }
C {devices/lab_pin.sym} 94540 -3550 0 0 {name=p94386 lab=_76444_/Y }
C {devices/lab_pin.sym} 94540 -3510 0 0 {name=p94387 lab=_76445_/Y }
C {devices/lab_pin.sym} 94700 -3550 0 1 {name=p94388 lab=_76446_/X }
C {sky130_stdcells/a21bo_4.sym} 94620 -3550 0 0 {name=X_76446_ }
C {devices/lab_pin.sym} 94540 -3440 0 0 {name=p94389 lab=_61135_/X }
C {devices/lab_pin.sym} 94540 -3400 0 0 {name=p94390 lab=_84836_/Q }
C {devices/lab_pin.sym} 94540 -3360 0 0 {name=p94391 lab=_64458_/X }
C {devices/lab_pin.sym} 94540 -3320 0 0 {name=p94392 lab=_64459_/Y }
C {devices/lab_pin.sym} 94700 -3380 0 1 {name=p94393 lab=_64460_/X }
C {sky130_stdcells/a211o_4.sym} 94620 -3380 0 0 {name=X_64460_ }
C {devices/lab_pin.sym} 94580 -3230 0 0 {name=p94394 lab=_42837_/Y }
C {devices/lab_pin.sym} 94660 -3230 0 1 {name=p94395 lab=_87693_/D }
C {sky130_stdcells/inv_2.sym} 94620 -3230 0 0 {name=X_42838_ }
C {devices/lab_pin.sym} 94560 -3120 0 0 {name=p94396 lab=_49410_/A }
C {devices/lab_pin.sym} 94560 -3080 0 0 {name=p94397 lab=_51779_/B }
C {devices/lab_pin.sym} 94680 -3100 0 1 {name=p94398 lab=_49394_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -3100 0 0 {name=X_49394_ }
C {devices/lab_pin.sym} 94540 -2990 0 0 {name=p94399 lab=_61670_/X }
C {devices/lab_pin.sym} 94540 -2950 0 0 {name=p94400 lab=_61645_/X }
C {devices/lab_pin.sym} 94540 -2910 0 0 {name=p94401 lab=_61671_/Y }
C {devices/lab_pin.sym} 94700 -2950 0 1 {name=p94402 lab=_61672_/Y }
C {sky130_stdcells/a21oi_4.sym} 94620 -2950 0 0 {name=X_61672_ }
C {devices/lab_pin.sym} 94540 -2830 0 0 {name=p94403 lab=_87003_/Q }
C {devices/lab_pin.sym} 94540 -2790 0 0 {name=p94404 lab=_56550_/X }
C {devices/lab_pin.sym} 94540 -2750 0 0 {name=p94405 lab=_73657_/X }
C {devices/lab_pin.sym} 94700 -2790 0 1 {name=p94406 lab=_73658_/Y }
C {sky130_stdcells/o21ai_4.sym} 94620 -2790 0 0 {name=X_73658_ }
C {devices/lab_pin.sym} 94540 -2680 0 0 {name=p94407 lab=_58418_/A }
C {devices/lab_pin.sym} 94540 -2640 0 0 {name=p94408 lab=_63370_/X }
C {devices/lab_pin.sym} 94540 -2600 0 0 {name=p94409 lab=_61378_/A }
C {devices/lab_pin.sym} 94540 -2560 0 0 {name=p94410 lab=_63372_/X }
C {devices/lab_pin.sym} 94700 -2620 0 1 {name=p94411 lab=_63411_/X }
C {sky130_stdcells/a2bb2o_4.sym} 94620 -2620 0 0 {name=X_63411_ }
C {devices/lab_pin.sym} 94560 -2480 0 0 {name=p94412 lab=_48401_/A }
C {devices/lab_pin.sym} 94560 -2440 0 0 {name=p94413 lab=_50383_/B }
C {devices/lab_pin.sym} 94680 -2460 0 1 {name=p94414 lab=_48345_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -2460 0 0 {name=X_48345_ }
C {devices/lab_pin.sym} 94580 -2330 0 0 {name=p94415 lab=_60655_/A }
C {devices/lab_pin.sym} 94660 -2330 0 1 {name=p94416 lab=_60624_/A }
C {sky130_stdcells/inv_2.sym} 94620 -2330 0 0 {name=X_60623_ }
C {devices/lab_pin.sym} 94540 -2240 0 0 {name=p94417 lab=_79267_/B }
C {devices/lab_pin.sym} 94540 -2200 0 0 {name=p94418 lab=_72590_/X }
C {devices/lab_pin.sym} 94540 -2160 0 0 {name=p94419 lab=_72606_/X }
C {devices/lab_pin.sym} 94540 -2120 0 0 {name=p94420 lab=_72608_/Y }
C {devices/lab_pin.sym} 94700 -2180 0 1 {name=p94421 lab=_83218_/D }
C {sky130_stdcells/o22a_4.sym} 94620 -2180 0 0 {name=X_72609_ }
C {devices/lab_pin.sym} 94560 -2040 0 0 {name=p94422 lab=_58946_/Y }
C {devices/lab_pin.sym} 94560 -2000 0 0 {name=p94423 lab=_79165_/B }
C {devices/lab_pin.sym} 94680 -2020 0 1 {name=p94424 lab=_79165_/Y }
C {sky130_stdcells/nand2_4.sym} 94620 -2020 0 0 {name=X_79165_ }
C {devices/lab_pin.sym} 94540 -1910 0 0 {name=p94425 lab=_56627_/B }
C {devices/lab_pin.sym} 94540 -1870 0 0 {name=p94426 lab=_45556_/X }
C {devices/lab_pin.sym} 94540 -1830 0 0 {name=p94427 lab=_45378_/X }
C {devices/lab_pin.sym} 94700 -1870 0 1 {name=p94428 lab=_45557_/X }
C {sky130_stdcells/o21a_4.sym} 94620 -1870 0 0 {name=X_45557_ }
C {devices/lab_pin.sym} 94580 -1730 0 0 {name=p94429 lab=_64274_/A }
C {devices/lab_pin.sym} 94660 -1730 0 1 {name=p94430 lab=_64391_/X }
C {sky130_stdcells/buf_2.sym} 94620 -1730 0 0 {name=X_64391_ }
C {devices/lab_pin.sym} 94580 -1610 0 0 {name=p94431 lab=_81650_/Q }
C {devices/lab_pin.sym} 94660 -1610 0 1 {name=p94432 lab=_76377_/Y }
C {sky130_stdcells/inv_2.sym} 94620 -1610 0 0 {name=X_76377_ }
C {devices/lab_pin.sym} 94540 -1520 0 0 {name=p94433 lab=_41302_/X }
C {devices/lab_pin.sym} 94540 -1480 0 0 {name=p94434 lab=_42767_/X }
C {devices/lab_pin.sym} 94540 -1440 0 0 {name=p94435 lab=_67406_/B }
C {devices/lab_pin.sym} 94540 -1400 0 0 {name=p94436 lab=_42768_/X }
C {devices/lab_pin.sym} 94700 -1460 0 1 {name=p94437 lab=_87728_/D }
C {sky130_stdcells/a2bb2o_4.sym} 94620 -1460 0 0 {name=X_42769_ }
C {devices/lab_pin.sym} 94540 -1340 0 0 {name=p94438 lab=_73566_/X }
C {devices/lab_pin.sym} 94540 -1300 0 0 {name=p94439 lab=_84992_/Q }
C {devices/lab_pin.sym} 94540 -1260 0 0 {name=p94440 lab=_73385_/X }
C {devices/lab_pin.sym} 94540 -1220 0 0 {name=p94441 lab=_73588_/X }
C {devices/lab_pin.sym} 94700 -1280 0 1 {name=p94442 lab=_73589_/X }
C {sky130_stdcells/a211o_4.sym} 94620 -1280 0 0 {name=X_73589_ }
C {devices/lab_pin.sym} 94580 -1130 0 0 {name=p94443 lab=_83248_/CLK }
C {devices/lab_pin.sym} 94660 -1130 0 1 {name=p94444 lab=_84837_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 94620 -1130 0 0 {name=Xclkbuf_opt_7_CLK }
C {devices/lab_pin.sym} 94540 -1040 0 0 {name=p94445 lab=_66053_/X }
C {devices/lab_pin.sym} 94540 -1000 0 0 {name=p94446 lab=_85618_/Q }
C {devices/lab_pin.sym} 94540 -960 0 0 {name=p94447 lab=_66096_/X }
C {devices/lab_pin.sym} 94540 -920 0 0 {name=p94448 lab=_66129_/X }
C {devices/lab_pin.sym} 94700 -980 0 1 {name=p94449 lab=_66130_/X }
C {sky130_stdcells/a211o_4.sym} 94620 -980 0 0 {name=X_66130_ }
C {devices/lab_pin.sym} 94540 -850 0 0 {name=p94450 lab=_78109_/Y }
C {devices/lab_pin.sym} 94540 -810 0 0 {name=p94451 lab=_78114_/Y }
C {devices/lab_pin.sym} 94540 -770 0 0 {name=p94452 lab=_78115_/Y }
C {devices/lab_pin.sym} 94700 -810 0 1 {name=p94453 lab=_78120_/C }
C {sky130_stdcells/a21o_4.sym} 94620 -810 0 0 {name=X_78116_ }
C {devices/lab_pin.sym} 94540 -710 0 0 {name=p94454 lab=_44496_/X }
C {devices/lab_pin.sym} 94540 -670 0 0 {name=p94455 lab=_44497_/X }
C {devices/lab_pin.sym} 94540 -630 0 0 {name=p94456 lab=_41276_/X }
C {devices/lab_pin.sym} 94540 -590 0 0 {name=p94457 lab=_87073_/Q }
C {devices/lab_pin.sym} 94540 -550 0 0 {name=p94458 lab=_44498_/X }
C {devices/lab_pin.sym} 94700 -630 0 1 {name=p94459 lab=_44509_/A }
C {sky130_stdcells/o32ai_4.sym} 94620 -630 0 0 {name=X_44508_ }
C {devices/lab_pin.sym} 95480 -42180 0 0 {name=p94460 lab=_60433_/A }
C {devices/lab_pin.sym} 95480 -42140 0 0 {name=p94461 lab=_63342_/B }
C {devices/lab_pin.sym} 95480 -42100 0 0 {name=p94462 lab=_63342_/C }
C {devices/lab_pin.sym} 95480 -42060 0 0 {name=p94463 lab=_60484_/A }
C {devices/lab_pin.sym} 95600 -42120 0 1 {name=p94464 lab=_63342_/X }
C {sky130_stdcells/and4_4.sym} 95540 -42120 0 0 {name=X_63342_ }
C {devices/lab_pin.sym} 95480 -41980 0 0 {name=p94465 lab=_75325_/Y }
C {devices/lab_pin.sym} 95480 -41940 0 0 {name=p94466 lab=_75328_/B }
C {devices/lab_pin.sym} 95600 -41960 0 1 {name=p94467 lab=_75328_/X }
C {sky130_stdcells/xor2_4.sym} 95540 -41960 0 0 {name=X_75328_ }
C {devices/lab_pin.sym} 95480 -41850 0 0 {name=p94468 lab=_60443_/A }
C {devices/lab_pin.sym} 95480 -41810 0 0 {name=p94469 lab=_60588_/A }
C {devices/lab_pin.sym} 95480 -41770 0 0 {name=p94470 lab=_60607_/A }
C {devices/lab_pin.sym} 95600 -41810 0 1 {name=p94471 lab=_60555_/A }
C {sky130_stdcells/nor3_4.sym} 95540 -41810 0 0 {name=X_60554_ }
C {devices/lab_pin.sym} 95500 -41670 0 0 {name=p94472 lab=_48020_/B }
C {devices/lab_pin.sym} 95580 -41670 0 1 {name=p94473 lab=_50322_/B }
C {sky130_stdcells/buf_2.sym} 95540 -41670 0 0 {name=X_48276_ }
C {devices/lab_pin.sym} 95480 -41560 0 0 {name=p94474 lab=_79095_/B }
C {devices/lab_pin.sym} 95480 -41520 0 0 {name=p94475 lab=_79095_/A }
C {devices/lab_pin.sym} 95600 -41540 0 1 {name=p94476 lab=_79109_/A }
C {sky130_stdcells/nand2_4.sym} 95540 -41540 0 0 {name=X_79096_ }
C {devices/lab_pin.sym} 95500 -41410 0 0 {name=p94477 lab=_57392_/B }
C {devices/lab_pin.sym} 95580 -41410 0 1 {name=p94478 lab=_45488_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -41410 0 0 {name=X_45488_ }
C {devices/lab_pin.sym} 95500 -41290 0 0 {name=p94479 lab=_47227_/A }
C {devices/lab_pin.sym} 95580 -41290 0 1 {name=p94480 lab=_52927_/D }
C {sky130_stdcells/buf_2.sym} 95540 -41290 0 0 {name=X_47227_ }
C {devices/lab_pin.sym} 95480 -41180 0 0 {name=p94481 lab=_66061_/A }
C {devices/lab_pin.sym} 95480 -41140 0 0 {name=p94482 lab=_66061_/B }
C {devices/lab_pin.sym} 95600 -41160 0 1 {name=p94483 lab=_66061_/Y }
C {sky130_stdcells/nand2_4.sym} 95540 -41160 0 0 {name=X_66061_ }
C {devices/lab_pin.sym} 95500 -41030 0 0 {name=p94484 lab=_78046_/Y }
C {devices/lab_pin.sym} 95580 -41030 0 1 {name=p94485 lab=_78047_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -41030 0 0 {name=X_78047_ }
C {devices/lab_pin.sym} 95460 -40950 0 0 {name=p94486 lab=_44425_/X }
C {devices/lab_pin.sym} 95460 -40910 0 0 {name=p94487 lab=_44427_/X }
C {devices/lab_pin.sym} 95460 -40870 0 0 {name=p94488 lab=_41606_/X }
C {devices/lab_pin.sym} 95460 -40830 0 0 {name=p94489 lab=_87107_/Q }
C {devices/lab_pin.sym} 95460 -40790 0 0 {name=p94490 lab=_44428_/X }
C {devices/lab_pin.sym} 95620 -40870 0 1 {name=p94491 lab=_44439_/Y }
C {sky130_stdcells/o32ai_4.sym} 95540 -40870 0 0 {name=X_44439_ }
C {devices/lab_pin.sym} 95480 -40740 0 0 {name=p94492 lab=_84842_/Q }
C {devices/lab_pin.sym} 95480 -40700 0 0 {name=p94493 lab=_63281_/B }
C {devices/lab_pin.sym} 95480 -40660 0 0 {name=p94494 lab=_63301_/C }
C {devices/lab_pin.sym} 95480 -40620 0 0 {name=p94495 lab=_63281_/D }
C {devices/lab_pin.sym} 95600 -40680 0 1 {name=p94496 lab=_63273_/X }
C {sky130_stdcells/or4_4.sym} 95540 -40680 0 0 {name=X_63273_ }
C {devices/lab_pin.sym} 95460 -40550 0 0 {name=p94497 lab=_75258_/B }
C {devices/lab_pin.sym} 95460 -40510 0 0 {name=p94498 lab=_75258_/C }
C {devices/lab_pin.sym} 95460 -40470 0 0 {name=p94499 lab=_75254_/Y }
C {devices/lab_pin.sym} 95620 -40510 0 1 {name=p94500 lab=_75259_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -40510 0 0 {name=X_75259_ }
C {devices/lab_pin.sym} 95500 -40370 0 0 {name=p94501 lab=_63280_/C }
C {devices/lab_pin.sym} 95580 -40370 0 1 {name=p94502 lab=_60488_/C }
C {sky130_stdcells/buf_2.sym} 95540 -40370 0 0 {name=X_60485_ }
C {devices/lab_pin.sym} 95480 -40260 0 0 {name=p94503 lab=_65012_/A }
C {devices/lab_pin.sym} 95480 -40220 0 0 {name=p94504 lab=_65012_/B }
C {devices/lab_pin.sym} 95600 -40240 0 1 {name=p94505 lab=_65012_/X }
C {sky130_stdcells/and2_4.sym} 95540 -40240 0 0 {name=X_65012_ }
C {devices/lab_pin.sym} 95500 -40110 0 0 {name=p94506 lab=_62501_/A }
C {devices/lab_pin.sym} 95580 -40110 0 1 {name=p94507 lab=_62631_/C }
C {sky130_stdcells/buf_2.sym} 95540 -40110 0 0 {name=X_62224_ }
C {devices/lab_pin.sym} 95500 -39990 0 0 {name=p94508 lab=_54578_/B }
C {devices/lab_pin.sym} 95580 -39990 0 1 {name=p94509 lab=_52885_/B }
C {sky130_stdcells/buf_2.sym} 95540 -39990 0 0 {name=X_47158_ }
C {devices/lab_pin.sym} 95480 -39880 0 0 {name=p94510 lab=_46109_/A }
C {devices/lab_pin.sym} 95480 -39840 0 0 {name=p94511 lab=_46108_/X }
C {devices/lab_pin.sym} 95600 -39860 0 1 {name=p94512 lab=_46109_/Y }
C {sky130_stdcells/nand2_4.sym} 95540 -39860 0 0 {name=X_46109_ }
C {devices/lab_pin.sym} 95500 -39730 0 0 {name=p94513 lab=_87808_/Q }
C {devices/lab_pin.sym} 95580 -39730 0 1 {name=p94514 lab=_69820_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -39730 0 0 {name=X_69820_ }
C {devices/lab_pin.sym} 95480 -39630 0 0 {name=p94515 lab=_62144_/A }
C {devices/lab_pin.sym} 95480 -39590 0 0 {name=p94516 lab=_62121_/X }
C {devices/lab_pin.sym} 95480 -39550 0 0 {name=p94517 lab=_78052_/B }
C {devices/lab_pin.sym} 95600 -39590 0 1 {name=p94518 lab=_62155_/Y }
C {sky130_stdcells/nor3_4.sym} 95540 -39590 0 0 {name=X_62155_ }
C {devices/lab_pin.sym} 95480 -39460 0 0 {name=p94519 lab=_47063_/A }
C {devices/lab_pin.sym} 95480 -39420 0 0 {name=p94520 lab=_52850_/B }
C {devices/lab_pin.sym} 95600 -39440 0 1 {name=p94521 lab=_47089_/Y }
C {sky130_stdcells/nand2_4.sym} 95540 -39440 0 0 {name=X_47089_ }
C {devices/lab_pin.sym} 95480 -39320 0 0 {name=p94522 lab=_79998_/A }
C {devices/lab_pin.sym} 95480 -39280 0 0 {name=p94523 lab=_79998_/B }
C {devices/lab_pin.sym} 95600 -39300 0 1 {name=p94524 lab=_80003_/B }
C {sky130_stdcells/xor2_4.sym} 95540 -39300 0 0 {name=X_79998_ }
C {devices/lab_pin.sym} 95460 -39200 0 0 {name=p94525 lab=_84520_/Q }
C {devices/lab_pin.sym} 95460 -39160 0 0 {name=p94526 lab=_60979_/X }
C {devices/lab_pin.sym} 95460 -39120 0 0 {name=p94527 lab=_61104_/Y }
C {devices/lab_pin.sym} 95460 -39080 0 0 {name=p94528 lab=_61105_/X }
C {devices/lab_pin.sym} 95620 -39140 0 1 {name=p94529 lab=_61106_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 95540 -39140 0 0 {name=X_61106_ }
C {devices/lab_pin.sym} 95500 -38990 0 0 {name=p94530 lab=_69751_/A }
C {devices/lab_pin.sym} 95580 -38990 0 1 {name=p94531 lab=_69751_/X }
C {sky130_stdcells/buf_2.sym} 95540 -38990 0 0 {name=X_69751_ }
C {devices/lab_pin.sym} 95460 -38900 0 0 {name=p94532 lab=_87427_/Q }
C {devices/lab_pin.sym} 95460 -38860 0 0 {name=p94533 lab=_66915_/X }
C {devices/lab_pin.sym} 95460 -38820 0 0 {name=p94534 lab=_66863_/X }
C {devices/lab_pin.sym} 95460 -38780 0 0 {name=p94535 lab=_66962_/X }
C {devices/lab_pin.sym} 95620 -38840 0 1 {name=p94536 lab=_66963_/X }
C {sky130_stdcells/a211o_4.sym} 95540 -38840 0 0 {name=X_66963_ }
C {devices/lab_pin.sym} 95480 -38720 0 0 {name=p94537 lab=_84890_/Q }
C {devices/lab_pin.sym} 95480 -38680 0 0 {name=p94538 lab=_62128_/B }
C {devices/lab_pin.sym} 95480 -38640 0 0 {name=p94539 lab=_62128_/C }
C {devices/lab_pin.sym} 95480 -38600 0 0 {name=p94540 lab=_62060_/X }
C {devices/lab_pin.sym} 95600 -38660 0 1 {name=p94541 lab=_62086_/Y }
C {sky130_stdcells/nand4_4.sym} 95540 -38660 0 0 {name=X_62086_ }
C {devices/lab_pin.sym} 95480 -38520 0 0 {name=p94542 lab=_82818_/Q }
C {devices/lab_pin.sym} 95480 -38480 0 0 {name=p94543 lab=_78949_/B }
C {devices/lab_pin.sym} 95600 -38500 0 1 {name=p94544 lab=_79115_/A }
C {sky130_stdcells/xnor2_4.sym} 95540 -38500 0 0 {name=X_78949_ }
C {devices/lab_pin.sym} 95480 -38380 0 0 {name=p94545 lab=_68599_/A }
C {devices/lab_pin.sym} 95480 -38340 0 0 {name=p94546 lab=_87750_/Q }
C {devices/lab_pin.sym} 95600 -38360 0 1 {name=p94547 lab=_68702_/X }
C {sky130_stdcells/and2_4.sym} 95540 -38360 0 0 {name=X_68702_ }
C {devices/lab_pin.sym} 95460 -38250 0 0 {name=p94548 lab=_65903_/X }
C {devices/lab_pin.sym} 95460 -38210 0 0 {name=p94549 lab=_65431_/Y }
C {devices/lab_pin.sym} 95460 -38170 0 0 {name=p94550 lab=_65913_/Y }
C {devices/lab_pin.sym} 95620 -38210 0 1 {name=p94551 lab=_65914_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -38210 0 0 {name=X_65914_ }
C {devices/lab_pin.sym} 95500 -38070 0 0 {name=p94552 lab=_61037_/A }
C {devices/lab_pin.sym} 95580 -38070 0 1 {name=p94553 lab=_61037_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -38070 0 0 {name=X_61037_ }
C {devices/lab_pin.sym} 95450 -37950 0 0 {name=p94554 lab=_82339_/CLK }
C {devices/lab_pin.sym} 95450 -37930 0 0 {name=p94555 lab=_83888_/Q }
C {devices/lab_pin.sym} 95630 -37950 0 1 {name=p94556 lab=_81960_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -37940 0 0 {name=X_81960_ }
C {devices/lab_pin.sym} 95460 -37830 0 0 {name=p94557 lab=_69679_/X }
C {devices/lab_pin.sym} 95460 -37790 0 0 {name=p94558 lab=_69681_/X }
C {devices/lab_pin.sym} 95460 -37750 0 0 {name=p94559 lab=_69655_/X }
C {devices/lab_pin.sym} 95620 -37790 0 1 {name=p94560 lab=_69682_/Y }
C {sky130_stdcells/a21oi_4.sym} 95540 -37790 0 0 {name=X_69682_ }
C {devices/lab_pin.sym} 95460 -37670 0 0 {name=p94561 lab=_66891_/X }
C {devices/lab_pin.sym} 95460 -37630 0 0 {name=p94562 lab=_66893_/X }
C {devices/lab_pin.sym} 95460 -37590 0 0 {name=p94563 lab=_66871_/X }
C {devices/lab_pin.sym} 95620 -37630 0 1 {name=p94564 lab=_66894_/Y }
C {sky130_stdcells/a21oi_4.sym} 95540 -37630 0 0 {name=X_66894_ }
C {devices/lab_pin.sym} 95450 -37490 0 0 {name=p94565 lab=_83918_/CLK }
C {devices/lab_pin.sym} 95450 -37470 0 0 {name=p94566 lab=_80911_/D }
C {devices/lab_pin.sym} 95630 -37490 0 1 {name=p94567 lab=_75687_/A }
C {sky130_stdcells/dfxtp_4.sym} 95540 -37480 0 0 {name=X_80911_ }
C {devices/lab_pin.sym} 95460 -37370 0 0 {name=p94568 lab=_68629_/X }
C {devices/lab_pin.sym} 95460 -37330 0 0 {name=p94569 lab=_68632_/X }
C {devices/lab_pin.sym} 95460 -37290 0 0 {name=p94570 lab=_68512_/X }
C {devices/lab_pin.sym} 95620 -37330 0 1 {name=p94571 lab=_68633_/Y }
C {sky130_stdcells/a21oi_4.sym} 95540 -37330 0 0 {name=X_68633_ }
C {devices/lab_pin.sym} 95500 -37190 0 0 {name=p94572 lab=_64752_/A }
C {devices/lab_pin.sym} 95580 -37190 0 1 {name=p94573 lab=_65845_/X }
C {sky130_stdcells/buf_2.sym} 95540 -37190 0 0 {name=X_65845_ }
C {devices/lab_pin.sym} 95450 -37070 0 0 {name=p94574 lab=_82145_/CLK }
C {devices/lab_pin.sym} 95450 -37050 0 0 {name=p94575 lab=_81891_/D }
C {devices/lab_pin.sym} 95630 -37070 0 1 {name=p94576 lab=_82299_/D }
C {sky130_stdcells/dfxtp_4.sym} 95540 -37060 0 0 {name=X_81891_ }
C {devices/lab_pin.sym} 95500 -36930 0 0 {name=p94577 lab=_52757_/A }
C {devices/lab_pin.sym} 95580 -36930 0 1 {name=p94578 lab=_52818_/A }
C {sky130_stdcells/buf_2.sym} 95540 -36930 0 0 {name=X_52810_ }
C {devices/lab_pin.sym} 95450 -36810 0 0 {name=p94579 lab=_83630_/CLK }
C {devices/lab_pin.sym} 95450 -36790 0 0 {name=p94580 lab=_71031_/Y }
C {devices/lab_pin.sym} 95630 -36810 0 1 {name=p94581 lab=_47631_/A }
C {sky130_stdcells/dfxtp_4.sym} 95540 -36800 0 0 {name=X_83630_ }
C {devices/lab_pin.sym} 95450 -36670 0 0 {name=p94582 lab=_80754_/CLK }
C {devices/lab_pin.sym} 95450 -36650 0 0 {name=p94583 lab=_80874_/Q }
C {devices/lab_pin.sym} 95630 -36670 0 1 {name=p94584 lab=_80842_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -36660 0 0 {name=X_80842_ }
C {devices/lab_pin.sym} 95460 -36550 0 0 {name=p94585 lab=_80826_/D }
C {devices/lab_pin.sym} 95460 -36510 0 0 {name=p94586 lab=_68462_/X }
C {devices/lab_pin.sym} 95460 -36470 0 0 {name=p94587 lab=_68563_/X }
C {devices/lab_pin.sym} 95620 -36510 0 1 {name=p94588 lab=_83970_/D }
C {sky130_stdcells/a21bo_4.sym} 95540 -36510 0 0 {name=X_68564_ }
C {devices/lab_pin.sym} 95460 -36390 0 0 {name=p94589 lab=_53787_/Y }
C {devices/lab_pin.sym} 95460 -36350 0 0 {name=p94590 lab=_53773_/X }
C {devices/lab_pin.sym} 95460 -36310 0 0 {name=p94591 lab=_53789_/X }
C {devices/lab_pin.sym} 95620 -36350 0 1 {name=p94592 lab=_53790_/Y }
C {sky130_stdcells/a21oi_4.sym} 95540 -36350 0 0 {name=X_53790_ }
C {devices/lab_pin.sym} 95460 -36230 0 0 {name=p94593 lab=_65772_/Y }
C {devices/lab_pin.sym} 95460 -36190 0 0 {name=p94594 lab=_65757_/X }
C {devices/lab_pin.sym} 95460 -36150 0 0 {name=p94595 lab=_65775_/X }
C {devices/lab_pin.sym} 95620 -36190 0 1 {name=p94596 lab=_84179_/D }
C {sky130_stdcells/a21o_4.sym} 95540 -36190 0 0 {name=X_65776_ }
C {devices/lab_pin.sym} 95480 -36070 0 0 {name=p94597 lab=_62988_/A }
C {devices/lab_pin.sym} 95480 -36030 0 0 {name=p94598 lab=_62988_/B }
C {devices/lab_pin.sym} 95480 -35990 0 0 {name=p94599 lab=_62988_/C }
C {devices/lab_pin.sym} 95600 -36030 0 1 {name=p94600 lab=_62988_/Y }
C {sky130_stdcells/nor3_4.sym} 95540 -36030 0 0 {name=X_62988_ }
C {devices/lab_pin.sym} 95460 -35910 0 0 {name=p94601 lab=_67510_/X }
C {devices/lab_pin.sym} 95460 -35870 0 0 {name=p94602 lab=_67514_/X }
C {devices/lab_pin.sym} 95460 -35830 0 0 {name=p94603 lab=_67442_/X }
C {devices/lab_pin.sym} 95620 -35870 0 1 {name=p94604 lab=_67515_/X }
C {sky130_stdcells/a21o_4.sym} 95540 -35870 0 0 {name=X_67515_ }
C {devices/lab_pin.sym} 95500 -35730 0 0 {name=p94605 lab=_52770_/A }
C {devices/lab_pin.sym} 95580 -35730 0 1 {name=p94606 lab=_52746_/B }
C {sky130_stdcells/buf_2.sym} 95540 -35730 0 0 {name=X_52741_ }
C {devices/lab_pin.sym} 95460 -35640 0 0 {name=p94607 lab=_64722_/X }
C {devices/lab_pin.sym} 95460 -35600 0 0 {name=p94608 lab=_85565_/Q }
C {devices/lab_pin.sym} 95460 -35560 0 0 {name=p94609 lab=_64724_/X }
C {devices/lab_pin.sym} 95460 -35520 0 0 {name=p94610 lab=_64726_/X }
C {devices/lab_pin.sym} 95620 -35580 0 1 {name=p94611 lab=_64727_/X }
C {sky130_stdcells/a211o_4.sym} 95540 -35580 0 0 {name=X_64727_ }
C {devices/lab_pin.sym} 95450 -35430 0 0 {name=p94612 lab=_83561_/CLK }
C {devices/lab_pin.sym} 95450 -35410 0 0 {name=p94613 lab=_71244_/Y }
C {devices/lab_pin.sym} 95630 -35430 0 1 {name=p94614 lab=_83561_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -35420 0 0 {name=X_83561_ }
C {devices/lab_pin.sym} 95500 -35290 0 0 {name=p94615 lab=_58329_/A }
C {devices/lab_pin.sym} 95580 -35290 0 1 {name=p94616 lab=_61939_/X }
C {sky130_stdcells/buf_2.sym} 95540 -35290 0 0 {name=X_61939_ }
C {devices/lab_pin.sym} 95450 -35170 0 0 {name=p94617 lab=_81990_/CLK }
C {devices/lab_pin.sym} 95450 -35150 0 0 {name=p94618 lab=_80773_/D }
C {devices/lab_pin.sym} 95630 -35170 0 1 {name=p94619 lab=_80773_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -35160 0 0 {name=X_80773_ }
C {devices/lab_pin.sym} 95480 -35040 0 0 {name=p94620 lab=_69001_/A }
C {devices/lab_pin.sym} 95480 -35000 0 0 {name=p94621 lab=_68495_/B }
C {devices/lab_pin.sym} 95600 -35020 0 1 {name=p94622 lab=_68495_/Y }
C {sky130_stdcells/nor2_4.sym} 95540 -35020 0 0 {name=X_68495_ }
C {devices/lab_pin.sym} 95450 -34890 0 0 {name=p94623 lab=_85270_/CLK }
C {devices/lab_pin.sym} 95450 -34870 0 0 {name=p94624 lab=_85300_/D }
C {devices/lab_pin.sym} 95630 -34890 0 1 {name=p94625 lab=_55870_/B }
C {sky130_stdcells/dfxtp_4.sym} 95540 -34880 0 0 {name=X_85300_ }
C {devices/lab_pin.sym} 95450 -34750 0 0 {name=p94626 lab=_82580_/CLK }
C {devices/lab_pin.sym} 95450 -34730 0 0 {name=p94627 lab=_82512_/D }
C {devices/lab_pin.sym} 95630 -34750 0 1 {name=p94628 lab=_82512_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -34740 0 0 {name=X_82512_ }
C {devices/lab_pin.sym} 95460 -34640 0 0 {name=p94629 lab=_45600_/A }
C {devices/lab_pin.sym} 95460 -34600 0 0 {name=p94630 lab=_55453_/X }
C {devices/lab_pin.sym} 95460 -34560 0 0 {name=p94631 lab=_55458_/X }
C {devices/lab_pin.sym} 95460 -34520 0 0 {name=p94632 lab=_55459_/Y }
C {devices/lab_pin.sym} 95620 -34580 0 1 {name=p94633 lab=_55460_/X }
C {sky130_stdcells/a211o_4.sym} 95540 -34580 0 0 {name=X_55460_ }
C {devices/lab_pin.sym} 95460 -34450 0 0 {name=p94634 lab=_67443_/X }
C {devices/lab_pin.sym} 95460 -34410 0 0 {name=p94635 lab=_67445_/X }
C {devices/lab_pin.sym} 95460 -34370 0 0 {name=p94636 lab=_67401_/X }
C {devices/lab_pin.sym} 95620 -34410 0 1 {name=p94637 lab=_67446_/Y }
C {sky130_stdcells/a21oi_4.sym} 95540 -34410 0 0 {name=X_67446_ }
C {devices/lab_pin.sym} 95450 -34270 0 0 {name=p94638 lab=_86600_/CLK }
C {devices/lab_pin.sym} 95450 -34250 0 0 {name=p94639 lab=_86280_/D }
C {devices/lab_pin.sym} 95630 -34270 0 1 {name=p94640 lab=_72415_/B }
C {sky130_stdcells/dfxtp_4.sym} 95540 -34260 0 0 {name=X_86280_ }
C {devices/lab_pin.sym} 95460 -34150 0 0 {name=p94641 lab=_85775_/Q }
C {devices/lab_pin.sym} 95460 -34110 0 0 {name=p94642 lab=_52656_/X }
C {devices/lab_pin.sym} 95460 -34070 0 0 {name=p94643 lab=_52671_/Y }
C {devices/lab_pin.sym} 95620 -34110 0 1 {name=p94644 lab=_52672_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -34110 0 0 {name=X_52672_ }
C {devices/lab_pin.sym} 95480 -33980 0 0 {name=p94645 lab=_64684_/A }
C {devices/lab_pin.sym} 95480 -33940 0 0 {name=p94646 lab=_64658_/B }
C {devices/lab_pin.sym} 95600 -33960 0 1 {name=p94647 lab=_64658_/X }
C {sky130_stdcells/and2_4.sym} 95540 -33960 0 0 {name=X_64658_ }
C {devices/lab_pin.sym} 95450 -33830 0 0 {name=p94648 lab=_83495_/CLK }
C {devices/lab_pin.sym} 95450 -33810 0 0 {name=p94649 lab=_71457_/X }
C {devices/lab_pin.sym} 95630 -33830 0 1 {name=p94650 lab=_83492_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -33820 0 0 {name=X_83492_ }
C {devices/lab_pin.sym} 95460 -33710 0 0 {name=p94651 lab=_85447_/Q }
C {devices/lab_pin.sym} 95460 -33670 0 0 {name=p94652 lab=_54404_/X }
C {devices/lab_pin.sym} 95460 -33630 0 0 {name=p94653 lab=_54410_/Y }
C {devices/lab_pin.sym} 95620 -33670 0 1 {name=p94654 lab=_54411_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -33670 0 0 {name=X_54411_ }
C {devices/lab_pin.sym} 95450 -33530 0 0 {name=p94655 lab=_85167_/CLK }
C {devices/lab_pin.sym} 95450 -33510 0 0 {name=p94656 lab=_56336_/Y }
C {devices/lab_pin.sym} 95630 -33530 0 1 {name=p94657 lab=_55821_/B }
C {sky130_stdcells/dfxtp_4.sym} 95540 -33520 0 0 {name=X_85231_ }
C {devices/lab_pin.sym} 95480 -33400 0 0 {name=p94658 lab=_51627_/A }
C {devices/lab_pin.sym} 95480 -33360 0 0 {name=p94659 lab=_53148_/B }
C {devices/lab_pin.sym} 95600 -33380 0 1 {name=p94660 lab=_51623_/Y }
C {sky130_stdcells/nand2_4.sym} 95540 -33380 0 0 {name=X_51623_ }
C {devices/lab_pin.sym} 95500 -33250 0 0 {name=p94661 lab=_63487_/A }
C {devices/lab_pin.sym} 95580 -33250 0 1 {name=p94662 lab=_63609_/X }
C {sky130_stdcells/buf_2.sym} 95540 -33250 0 0 {name=X_63609_ }
C {devices/lab_pin.sym} 95450 -33130 0 0 {name=p94663 lab=_82443_/CLK }
C {devices/lab_pin.sym} 95450 -33110 0 0 {name=p94664 lab=_79135_/X }
C {devices/lab_pin.sym} 95630 -33130 0 1 {name=p94665 lab=_82411_/D }
C {sky130_stdcells/dfxtp_4.sym} 95540 -33120 0 0 {name=X_82443_ }
C {devices/lab_pin.sym} 95460 -33010 0 0 {name=p94666 lab=_55380_/Y }
C {devices/lab_pin.sym} 95460 -32970 0 0 {name=p94667 lab=_55389_/Y }
C {devices/lab_pin.sym} 95460 -32930 0 0 {name=p94668 lab=_55441_/C }
C {devices/lab_pin.sym} 95620 -32970 0 1 {name=p94669 lab=_55393_/B }
C {sky130_stdcells/o21a_4.sym} 95540 -32970 0 0 {name=X_55391_ }
C {devices/lab_pin.sym} 95460 -32850 0 0 {name=p94670 lab=_81504_/D }
C {devices/lab_pin.sym} 95460 -32810 0 0 {name=p94671 lab=_67331_/X }
C {devices/lab_pin.sym} 95460 -32770 0 0 {name=p94672 lab=_67376_/X }
C {devices/lab_pin.sym} 95620 -32810 0 1 {name=p94673 lab=_84072_/D }
C {sky130_stdcells/a21bo_4.sym} 95540 -32810 0 0 {name=X_67377_ }
C {devices/lab_pin.sym} 95500 -32670 0 0 {name=p94674 lab=_64678_/A }
C {devices/lab_pin.sym} 95580 -32670 0 1 {name=p94675 lab=_64589_/X }
C {sky130_stdcells/buf_2.sym} 95540 -32670 0 0 {name=X_64589_ }
C {devices/lab_pin.sym} 95480 -32580 0 0 {name=p94676 lab=_56700_/Y }
C {devices/lab_pin.sym} 95480 -32540 0 0 {name=p94677 lab=_56808_/A }
C {devices/lab_pin.sym} 95480 -32500 0 0 {name=p94678 lab=_56816_/A }
C {devices/lab_pin.sym} 95480 -32460 0 0 {name=p94679 lab=_57129_/Y }
C {devices/lab_pin.sym} 95600 -32520 0 1 {name=p94680 lab=_57133_/A }
C {sky130_stdcells/and4_4.sym} 95540 -32520 0 0 {name=X_57130_ }
C {devices/lab_pin.sym} 95500 -32370 0 0 {name=p94681 lab=_64806_/A }
C {devices/lab_pin.sym} 95580 -32370 0 1 {name=p94682 lab=_69116_/X }
C {sky130_stdcells/buf_2.sym} 95540 -32370 0 0 {name=X_69116_ }
C {devices/lab_pin.sym} 95460 -32270 0 0 {name=p94683 lab=_85459_/Q }
C {devices/lab_pin.sym} 95460 -32230 0 0 {name=p94684 lab=_54320_/X }
C {devices/lab_pin.sym} 95460 -32190 0 0 {name=p94685 lab=_54341_/Y }
C {devices/lab_pin.sym} 95620 -32230 0 1 {name=p94686 lab=_54342_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -32230 0 0 {name=X_54342_ }
C {devices/lab_pin.sym} 95480 -32100 0 0 {name=p94687 lab=_66325_/X }
C {devices/lab_pin.sym} 95480 -32060 0 0 {name=p94688 lab=_66328_/B }
C {devices/lab_pin.sym} 95600 -32080 0 1 {name=p94689 lab=_66328_/Y }
C {sky130_stdcells/nand2_4.sym} 95540 -32080 0 0 {name=X_66328_ }
C {devices/lab_pin.sym} 95450 -31950 0 0 {name=p94690 lab=_80671_/CLK }
C {devices/lab_pin.sym} 95450 -31930 0 0 {name=p94691 lab=_85162_/D }
C {devices/lab_pin.sym} 95630 -31950 0 1 {name=p94692 lab=_85162_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -31940 0 0 {name=X_85162_ }
C {devices/lab_pin.sym} 95460 -31830 0 0 {name=p94693 lab=_51551_/Y }
C {devices/lab_pin.sym} 95460 -31790 0 0 {name=p94694 lab=_51531_/X }
C {devices/lab_pin.sym} 95460 -31750 0 0 {name=p94695 lab=_51553_/X }
C {devices/lab_pin.sym} 95620 -31790 0 1 {name=p94696 lab=_85989_/D }
C {sky130_stdcells/a21oi_4.sym} 95540 -31790 0 0 {name=X_51554_ }
C {devices/lab_pin.sym} 95450 -31650 0 0 {name=p94697 lab=_86655_/CLK }
C {devices/lab_pin.sym} 95450 -31630 0 0 {name=p94698 lab=_82374_/D }
C {devices/lab_pin.sym} 95630 -31650 0 1 {name=p94699 lab=_82374_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -31640 0 0 {name=X_82374_ }
C {devices/lab_pin.sym} 95450 -31510 0 0 {name=p94700 lab=_84111_/CLK }
C {devices/lab_pin.sym} 95450 -31490 0 0 {name=p94701 lab=_84113_/D }
C {devices/lab_pin.sym} 95630 -31510 0 1 {name=p94702 lab=_66490_/C }
C {sky130_stdcells/dfxtp_4.sym} 95540 -31500 0 0 {name=X_84113_ }
C {devices/lab_pin.sym} 95500 -31370 0 0 {name=p94703 lab=_50505_/A }
C {devices/lab_pin.sym} 95580 -31370 0 1 {name=p94704 lab=_50506_/A }
C {sky130_stdcells/buf_2.sym} 95540 -31370 0 0 {name=X_50505_ }
C {devices/lab_pin.sym} 95460 -31270 0 0 {name=p94705 lab=_56850_/X }
C {devices/lab_pin.sym} 95460 -31230 0 0 {name=p94706 lab=_56976_/X }
C {devices/lab_pin.sym} 95460 -31190 0 0 {name=p94707 lab=_57055_/A }
C {devices/lab_pin.sym} 95620 -31230 0 1 {name=p94708 lab=_57061_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -31230 0 0 {name=X_57061_ }
C {devices/lab_pin.sym} 95450 -31090 0 0 {name=p94709 lab=_81431_/CLK }
C {devices/lab_pin.sym} 95450 -31070 0 0 {name=p94710 lab=_76312_/X }
C {devices/lab_pin.sym} 95630 -31090 0 1 {name=p94711 lab=_81701_/D }
C {sky130_stdcells/dfxtp_4.sym} 95540 -31080 0 0 {name=X_81325_ }
C {devices/lab_pin.sym} 95460 -30970 0 0 {name=p94712 lab=_69043_/X }
C {devices/lab_pin.sym} 95460 -30930 0 0 {name=p94713 lab=_69046_/X }
C {devices/lab_pin.sym} 95460 -30890 0 0 {name=p94714 lab=_69025_/X }
C {devices/lab_pin.sym} 95620 -30930 0 1 {name=p94715 lab=_69047_/X }
C {sky130_stdcells/a21o_4.sym} 95540 -30930 0 0 {name=X_69047_ }
C {devices/lab_pin.sym} 95460 -30810 0 0 {name=p94716 lab=_85472_/Q }
C {devices/lab_pin.sym} 95460 -30770 0 0 {name=p94717 lab=_54266_/X }
C {devices/lab_pin.sym} 95460 -30730 0 0 {name=p94718 lab=_54272_/Y }
C {devices/lab_pin.sym} 95620 -30770 0 1 {name=p94719 lab=_54273_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -30770 0 0 {name=X_54273_ }
C {devices/lab_pin.sym} 95500 -30630 0 0 {name=p94720 lab=_66104_/A }
C {devices/lab_pin.sym} 95580 -30630 0 1 {name=p94721 lab=_66276_/B }
C {sky130_stdcells/buf_2.sym} 95540 -30630 0 0 {name=X_66259_ }
C {devices/lab_pin.sym} 95450 -30510 0 0 {name=p94722 lab=_85128_/CLK }
C {devices/lab_pin.sym} 95450 -30490 0 0 {name=p94723 lab=_85093_/D }
C {devices/lab_pin.sym} 95630 -30510 0 1 {name=p94724 lab=_57071_/B }
C {sky130_stdcells/dfxtp_4.sym} 95540 -30500 0 0 {name=X_85093_ }
C {devices/lab_pin.sym} 95500 -30370 0 0 {name=p94725 lab=_51539_/A }
C {devices/lab_pin.sym} 95580 -30370 0 1 {name=p94726 lab=_51485_/X }
C {sky130_stdcells/buf_2.sym} 95540 -30370 0 0 {name=X_51485_ }
C {devices/lab_pin.sym} 95480 -30280 0 0 {name=p94727 lab=_56054_/B }
C {devices/lab_pin.sym} 95480 -30240 0 0 {name=p94728 lab=_55928_/C }
C {devices/lab_pin.sym} 95480 -30200 0 0 {name=p94729 lab=_55927_/X }
C {devices/lab_pin.sym} 95480 -30160 0 0 {name=p94730 lab=_55956_/B }
C {devices/lab_pin.sym} 95600 -30220 0 1 {name=p94731 lab=_56030_/B }
C {sky130_stdcells/nand4_4.sym} 95540 -30220 0 0 {name=X_56012_ }
C {devices/lab_pin.sym} 95460 -30090 0 0 {name=p94732 lab=_53220_/Y }
C {devices/lab_pin.sym} 95460 -30050 0 0 {name=p94733 lab=_53215_/X }
C {devices/lab_pin.sym} 95460 -30010 0 0 {name=p94734 lab=_53223_/X }
C {devices/lab_pin.sym} 95620 -30050 0 1 {name=p94735 lab=_53224_/Y }
C {sky130_stdcells/a21oi_4.sym} 95540 -30050 0 0 {name=X_53224_ }
C {devices/lab_pin.sym} 95450 -29910 0 0 {name=p94736 lab=_88116_/CLK }
C {devices/lab_pin.sym} 95450 -29890 0 0 {name=p94737 lab=_84044_/D }
C {devices/lab_pin.sym} 95630 -29910 0 1 {name=p94738 lab=_84044_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -29900 0 0 {name=X_84044_ }
C {devices/lab_pin.sym} 95460 -29790 0 0 {name=p94739 lab=_50433_/Y }
C {devices/lab_pin.sym} 95460 -29750 0 0 {name=p94740 lab=_50429_/X }
C {devices/lab_pin.sym} 95460 -29710 0 0 {name=p94741 lab=_50435_/X }
C {devices/lab_pin.sym} 95620 -29750 0 1 {name=p94742 lab=_86201_/D }
C {sky130_stdcells/a21oi_4.sym} 95540 -29750 0 0 {name=X_50436_ }
C {devices/lab_pin.sym} 95450 -29610 0 0 {name=p94743 lab=_81288_/CLK }
C {devices/lab_pin.sym} 95450 -29590 0 0 {name=p94744 lab=_81256_/D }
C {devices/lab_pin.sym} 95630 -29610 0 1 {name=p94745 lab=_81256_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -29600 0 0 {name=X_81256_ }
C {devices/lab_pin.sym} 95480 -29480 0 0 {name=p94746 lab=_80205_/X }
C {devices/lab_pin.sym} 95480 -29440 0 0 {name=p94747 lab=_80207_/B }
C {devices/lab_pin.sym} 95600 -29460 0 1 {name=p94748 lab=_80207_/Y }
C {sky130_stdcells/xnor2_4.sym} 95540 -29460 0 0 {name=X_80207_ }
C {devices/lab_pin.sym} 95480 -29360 0 0 {name=p94749 lab=_53139_/A }
C {devices/lab_pin.sym} 95480 -29320 0 0 {name=p94750 lab=_53159_/B }
C {devices/lab_pin.sym} 95480 -29280 0 0 {name=p94751 lab=_53143_/X }
C {devices/lab_pin.sym} 95480 -29240 0 0 {name=p94752 lab=_53155_/D }
C {devices/lab_pin.sym} 95600 -29300 0 1 {name=p94753 lab=_53155_/X }
C {sky130_stdcells/and4_4.sym} 95540 -29300 0 0 {name=X_53155_ }
C {devices/lab_pin.sym} 95500 -29150 0 0 {name=p94754 lab=_50572_/A }
C {devices/lab_pin.sym} 95580 -29150 0 1 {name=p94755 lab=_50381_/A }
C {sky130_stdcells/buf_2.sym} 95540 -29150 0 0 {name=X_50367_ }
C {devices/lab_pin.sym} 95450 -29030 0 0 {name=p94756 lab=_80821_/CLK }
C {devices/lab_pin.sym} 95450 -29010 0 0 {name=p94757 lab=_74906_/X }
C {devices/lab_pin.sym} 95630 -29030 0 1 {name=p94758 lab=_49190_/A }
C {sky130_stdcells/dfxtp_4.sym} 95540 -29020 0 0 {name=X_81187_ }
C {devices/lab_pin.sym} 95460 -28910 0 0 {name=p94759 lab=_65451_/B }
C {devices/lab_pin.sym} 95460 -28870 0 0 {name=p94760 lab=_52089_/X }
C {devices/lab_pin.sym} 95460 -28830 0 0 {name=p94761 lab=_52105_/Y }
C {devices/lab_pin.sym} 95620 -28870 0 1 {name=p94762 lab=_52106_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -28870 0 0 {name=X_52106_ }
C {devices/lab_pin.sym} 95450 -28730 0 0 {name=p94763 lab=_87813_/CLK }
C {devices/lab_pin.sym} 95450 -28710 0 0 {name=p94764 lab=_42607_/Y }
C {devices/lab_pin.sym} 95630 -28730 0 1 {name=p94765 lab=_69882_/A }
C {sky130_stdcells/dfxtp_4.sym} 95540 -28720 0 0 {name=X_87803_ }
C {devices/lab_pin.sym} 95460 -28610 0 0 {name=p94766 lab=_80122_/X }
C {devices/lab_pin.sym} 95460 -28570 0 0 {name=p94767 lab=_80125_/Y }
C {devices/lab_pin.sym} 95460 -28530 0 0 {name=p94768 lab=_80137_/X }
C {devices/lab_pin.sym} 95620 -28570 0 1 {name=p94769 lab=_80138_/X }
C {sky130_stdcells/a21o_4.sym} 95540 -28570 0 0 {name=X_80138_ }
C {devices/lab_pin.sym} 95480 -28440 0 0 {name=p94770 lab=_53080_/A }
C {devices/lab_pin.sym} 95480 -28400 0 0 {name=p94771 lab=_53086_/B }
C {devices/lab_pin.sym} 95600 -28420 0 1 {name=p94772 lab=_53086_/Y }
C {sky130_stdcells/nand2_4.sym} 95540 -28420 0 0 {name=X_53086_ }
C {devices/lab_pin.sym} 95460 -28310 0 0 {name=p94773 lab=_57903_/X }
C {devices/lab_pin.sym} 95460 -28270 0 0 {name=p94774 lab=_85488_/Q }
C {devices/lab_pin.sym} 95460 -28230 0 0 {name=p94775 lab=_57962_/X }
C {devices/lab_pin.sym} 95620 -28270 0 1 {name=p94776 lab=_57963_/X }
C {sky130_stdcells/o21a_4.sym} 95540 -28270 0 0 {name=X_57963_ }
C {devices/lab_pin.sym} 95480 -28140 0 0 {name=p94777 lab=_69900_/A }
C {devices/lab_pin.sym} 95480 -28100 0 0 {name=p94778 lab=_88310_/Q }
C {devices/lab_pin.sym} 95600 -28120 0 1 {name=p94779 lab=_69949_/X }
C {sky130_stdcells/and2_4.sym} 95540 -28120 0 0 {name=X_69949_ }
C {devices/lab_pin.sym} 95460 -28010 0 0 {name=p94780 lab=_86228_/Q }
C {devices/lab_pin.sym} 95460 -27970 0 0 {name=p94781 lab=_50282_/X }
C {devices/lab_pin.sym} 95460 -27930 0 0 {name=p94782 lab=_50297_/Y }
C {devices/lab_pin.sym} 95620 -27970 0 1 {name=p94783 lab=_50298_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -27970 0 0 {name=X_50298_ }
C {devices/lab_pin.sym} 95450 -27830 0 0 {name=p94784 lab=_85709_/CLK }
C {devices/lab_pin.sym} 95450 -27810 0 0 {name=p94785 lab=_51523_/Y }
C {devices/lab_pin.sym} 95630 -27830 0 1 {name=p94786 lab=_85995_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -27820 0 0 {name=X_85995_ }
C {devices/lab_pin.sym} 95480 -27710 0 0 {name=p94787 lab=_59696_/A }
C {devices/lab_pin.sym} 95480 -27670 0 0 {name=p94788 lab=_59711_/B }
C {devices/lab_pin.sym} 95480 -27630 0 0 {name=p94789 lab=_80588_/A }
C {devices/lab_pin.sym} 95600 -27670 0 1 {name=p94790 lab=_59702_/Y }
C {sky130_stdcells/nor3_4.sym} 95540 -27670 0 0 {name=X_59702_ }
C {devices/lab_pin.sym} 95460 -27550 0 0 {name=p94791 lab=_85901_/Q }
C {devices/lab_pin.sym} 95460 -27510 0 0 {name=p94792 lab=_52013_/X }
C {devices/lab_pin.sym} 95460 -27470 0 0 {name=p94793 lab=_52036_/Y }
C {devices/lab_pin.sym} 95620 -27510 0 1 {name=p94794 lab=_52037_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -27510 0 0 {name=X_52037_ }
C {devices/lab_pin.sym} 95480 -27380 0 0 {name=p94795 lab=_56985_/D }
C {devices/lab_pin.sym} 95480 -27340 0 0 {name=p94796 lab=_57319_/D }
C {devices/lab_pin.sym} 95600 -27360 0 1 {name=p94797 lab=_56914_/Y }
C {sky130_stdcells/nor2_4.sym} 95540 -27360 0 0 {name=X_56914_ }
C {devices/lab_pin.sym} 95450 -27230 0 0 {name=p94798 lab=_87990_/CLK }
C {devices/lab_pin.sym} 95450 -27210 0 0 {name=p94799 lab=_87734_/D }
C {devices/lab_pin.sym} 95630 -27230 0 1 {name=p94800 lab=_69076_/B }
C {sky130_stdcells/dfxtp_4.sym} 95540 -27220 0 0 {name=X_87734_ }
C {devices/lab_pin.sym} 95480 -27100 0 0 {name=p94801 lab=_73093_/A }
C {devices/lab_pin.sym} 95480 -27060 0 0 {name=p94802 lab=_72960_/B }
C {devices/lab_pin.sym} 95600 -27080 0 1 {name=p94803 lab=_72960_/X }
C {sky130_stdcells/and2_4.sym} 95540 -27080 0 0 {name=X_72960_ }
C {devices/lab_pin.sym} 95450 -26950 0 0 {name=p94804 lab=_84945_/CLK }
C {devices/lab_pin.sym} 95450 -26930 0 0 {name=p94805 lab=_84946_/D }
C {devices/lab_pin.sym} 95630 -26950 0 1 {name=p94806 lab=_84946_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -26940 0 0 {name=X_84946_ }
C {devices/lab_pin.sym} 95480 -26820 0 0 {name=p94807 lab=_60089_/C }
C {devices/lab_pin.sym} 95480 -26780 0 0 {name=p94808 lab=_64022_/C }
C {devices/lab_pin.sym} 95600 -26800 0 1 {name=p94809 lab=_80069_/X }
C {sky130_stdcells/xor2_4.sym} 95540 -26800 0 0 {name=X_80069_ }
C {devices/lab_pin.sym} 95460 -26710 0 0 {name=p94810 lab=_57781_/X }
C {devices/lab_pin.sym} 95460 -26670 0 0 {name=p94811 lab=_57891_/Y }
C {devices/lab_pin.sym} 95460 -26630 0 0 {name=p94812 lab=_57892_/Y }
C {devices/lab_pin.sym} 95460 -26590 0 0 {name=p94813 lab=_57893_/X }
C {devices/lab_pin.sym} 95460 -26550 0 0 {name=p94814 lab=_57795_/X }
C {devices/lab_pin.sym} 95620 -26630 0 1 {name=p94815 lab=_57894_/X }
C {sky130_stdcells/o32a_4.sym} 95540 -26630 0 0 {name=X_57894_ }
C {devices/lab_pin.sym} 95460 -26490 0 0 {name=p94816 lab=_56878_/Y }
C {devices/lab_pin.sym} 95460 -26450 0 0 {name=p94817 lab=_71891_/Y }
C {devices/lab_pin.sym} 95460 -26410 0 0 {name=p94818 lab=_71910_/Y }
C {devices/lab_pin.sym} 95620 -26450 0 1 {name=p94819 lab=_83331_/D }
C {sky130_stdcells/o21ai_4.sym} 95540 -26450 0 0 {name=X_71911_ }
C {devices/lab_pin.sym} 95500 -26310 0 0 {name=p94820 lab=_59633_/A }
C {devices/lab_pin.sym} 95580 -26310 0 1 {name=p94821 lab=_59634_/A }
C {sky130_stdcells/inv_2.sym} 95540 -26310 0 0 {name=X_59633_ }
C {devices/lab_pin.sym} 95480 -26200 0 0 {name=p94822 lab=_46233_/Y }
C {devices/lab_pin.sym} 95480 -26160 0 0 {name=p94823 lab=_55680_/B }
C {devices/lab_pin.sym} 95600 -26180 0 1 {name=p94824 lab=_56845_/Y }
C {sky130_stdcells/nor2_4.sym} 95540 -26180 0 0 {name=X_56845_ }
C {devices/lab_pin.sym} 95450 -26050 0 0 {name=p94825 lab=_81783_/CLK }
C {devices/lab_pin.sym} 95450 -26030 0 0 {name=p94826 lab=_87665_/D }
C {devices/lab_pin.sym} 95630 -26050 0 1 {name=p94827 lab=_67378_/B }
C {sky130_stdcells/dfxtp_4.sym} 95540 -26040 0 0 {name=X_87665_ }
C {devices/lab_pin.sym} 95500 -25910 0 0 {name=p94828 lab=_44270_/X }
C {devices/lab_pin.sym} 95580 -25910 0 1 {name=p94829 lab=_72892_/B }
C {sky130_stdcells/buf_2.sym} 95540 -25910 0 0 {name=X_72891_ }
C {devices/lab_pin.sym} 95450 -25790 0 0 {name=p94830 lab=_84877_/CLK }
C {devices/lab_pin.sym} 95450 -25770 0 0 {name=p94831 lab=_84877_/D }
C {devices/lab_pin.sym} 95630 -25790 0 1 {name=p94832 lab=_84877_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -25780 0 0 {name=X_84877_ }
C {devices/lab_pin.sym} 95500 -25650 0 0 {name=p94833 lab=_43810_/A }
C {devices/lab_pin.sym} 95580 -25650 0 1 {name=p94834 lab=_43810_/X }
C {sky130_stdcells/buf_2.sym} 95540 -25650 0 0 {name=X_43810_ }
C {devices/lab_pin.sym} 95500 -25530 0 0 {name=p94835 lab=_74694_/A }
C {devices/lab_pin.sym} 95580 -25530 0 1 {name=p94836 lab=_74630_/X }
C {sky130_stdcells/buf_2.sym} 95540 -25530 0 0 {name=X_74630_ }
C {devices/lab_pin.sym} 95450 -25410 0 0 {name=p94837 lab=_85974_/CLK }
C {devices/lab_pin.sym} 95450 -25390 0 0 {name=p94838 lab=_86616_/D }
C {devices/lab_pin.sym} 95630 -25410 0 1 {name=p94839 lab=_86616_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -25400 0 0 {name=X_86616_ }
C {devices/lab_pin.sym} 95460 -25290 0 0 {name=p94840 lab=_71824_/Y }
C {devices/lab_pin.sym} 95460 -25250 0 0 {name=p94841 lab=_83355_/Q }
C {devices/lab_pin.sym} 95460 -25210 0 0 {name=p94842 lab=_71841_/X }
C {devices/lab_pin.sym} 95620 -25250 0 1 {name=p94843 lab=_83355_/D }
C {sky130_stdcells/a21o_4.sym} 95540 -25250 0 0 {name=X_71842_ }
C {devices/lab_pin.sym} 95480 -25130 0 0 {name=p94844 lab=_59564_/A }
C {devices/lab_pin.sym} 95480 -25090 0 0 {name=p94845 lab=_59564_/B }
C {devices/lab_pin.sym} 95480 -25050 0 0 {name=p94846 lab=_59890_/C }
C {devices/lab_pin.sym} 95600 -25090 0 1 {name=p94847 lab=_59752_/A }
C {sky130_stdcells/nand3_4.sym} 95540 -25090 0 0 {name=X_59564_ }
C {devices/lab_pin.sym} 95450 -24950 0 0 {name=p94848 lab=_83188_/CLK }
C {devices/lab_pin.sym} 95450 -24930 0 0 {name=p94849 lab=_70235_/X }
C {devices/lab_pin.sym} 95630 -24950 0 1 {name=p94850 lab=_83828_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -24940 0 0 {name=X_83828_ }
C {devices/lab_pin.sym} 95460 -24840 0 0 {name=p94851 lab=_41397_/A }
C {devices/lab_pin.sym} 95460 -24800 0 0 {name=p94852 lab=_44788_/X }
C {devices/lab_pin.sym} 95460 -24760 0 0 {name=p94853 lab=_86954_/Q }
C {devices/lab_pin.sym} 95460 -24720 0 0 {name=p94854 lab=_44789_/X }
C {devices/lab_pin.sym} 95620 -24780 0 1 {name=p94855 lab=_86954_/D }
C {sky130_stdcells/a2bb2o_4.sym} 95540 -24780 0 0 {name=X_44790_ }
C {devices/lab_pin.sym} 95480 -24640 0 0 {name=p94856 lab=_83325_/Q }
C {devices/lab_pin.sym} 95480 -24600 0 0 {name=p94857 lab=_56776_/B }
C {devices/lab_pin.sym} 95600 -24620 0 1 {name=p94858 lab=_56776_/X }
C {sky130_stdcells/xor2_4.sym} 95540 -24620 0 0 {name=X_56776_ }
C {devices/lab_pin.sym} 95450 -24490 0 0 {name=p94859 lab=_87045_/CLK }
C {devices/lab_pin.sym} 95450 -24470 0 0 {name=p94860 lab=_87596_/D }
C {devices/lab_pin.sym} 95630 -24490 0 1 {name=p94861 lab=_43043_/A }
C {sky130_stdcells/dfxtp_4.sym} 95540 -24480 0 0 {name=X_87596_ }
C {devices/lab_pin.sym} 95460 -24370 0 0 {name=p94862 lab=_53986_/Y }
C {devices/lab_pin.sym} 95460 -24330 0 0 {name=p94863 lab=_53982_/X }
C {devices/lab_pin.sym} 95460 -24290 0 0 {name=p94864 lab=_53987_/Y }
C {devices/lab_pin.sym} 95620 -24330 0 1 {name=p94865 lab=_85528_/D }
C {sky130_stdcells/a21boi_4.sym} 95540 -24330 0 0 {name=X_53988_ }
C {devices/lab_pin.sym} 95480 -24200 0 0 {name=p94866 lab=_63496_/B }
C {devices/lab_pin.sym} 95480 -24160 0 0 {name=p94867 lab=_58510_/X }
C {devices/lab_pin.sym} 95600 -24180 0 1 {name=p94868 lab=_58515_/Y }
C {sky130_stdcells/nor2_4.sym} 95540 -24180 0 0 {name=X_58515_ }
C {devices/lab_pin.sym} 95500 -24050 0 0 {name=p94869 lab=_87288_/Q }
C {devices/lab_pin.sym} 95580 -24050 0 1 {name=p94870 lab=_43741_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -24050 0 0 {name=X_43741_ }
C {devices/lab_pin.sym} 95460 -23950 0 0 {name=p94871 lab=_45007_/A }
C {devices/lab_pin.sym} 95460 -23910 0 0 {name=p94872 lab=_74551_/X }
C {devices/lab_pin.sym} 95460 -23870 0 0 {name=p94873 lab=_74560_/X }
C {devices/lab_pin.sym} 95620 -23910 0 1 {name=p94874 lab=_83035_/D }
C {sky130_stdcells/o21ai_4.sym} 95540 -23910 0 0 {name=X_74561_ }
C {devices/lab_pin.sym} 95460 -23790 0 0 {name=p94875 lab=_55719_/Y }
C {devices/lab_pin.sym} 95460 -23750 0 0 {name=p94876 lab=_55721_/Y }
C {devices/lab_pin.sym} 95460 -23710 0 0 {name=p94877 lab=_55726_/Y }
C {devices/lab_pin.sym} 95620 -23750 0 1 {name=p94878 lab=_56163_/A }
C {sky130_stdcells/a21oi_4.sym} 95540 -23750 0 0 {name=X_55727_ }
C {devices/lab_pin.sym} 95450 -23610 0 0 {name=p94879 lab=_86549_/CLK }
C {devices/lab_pin.sym} 95450 -23590 0 0 {name=p94880 lab=_48258_/Y }
C {devices/lab_pin.sym} 95630 -23610 0 1 {name=p94881 lab=_66119_/B }
C {sky130_stdcells/dfxtp_4.sym} 95540 -23600 0 0 {name=X_86547_ }
C {devices/lab_pin.sym} 95480 -23480 0 0 {name=p94882 lab=_82302_/Q }
C {devices/lab_pin.sym} 95480 -23440 0 0 {name=p94883 lab=_40932_/X }
C {devices/lab_pin.sym} 95600 -23460 0 1 {name=p94884 lab=_40953_/X }
C {sky130_stdcells/or2_4.sym} 95540 -23460 0 0 {name=X_40953_ }
C {devices/lab_pin.sym} 95460 -23350 0 0 {name=p94885 lab=_52937_/Y }
C {devices/lab_pin.sym} 95460 -23310 0 0 {name=p94886 lab=_52920_/X }
C {devices/lab_pin.sym} 95460 -23270 0 0 {name=p94887 lab=_52938_/X }
C {devices/lab_pin.sym} 95620 -23310 0 1 {name=p94888 lab=_52939_/Y }
C {sky130_stdcells/a21oi_4.sym} 95540 -23310 0 0 {name=X_52939_ }
C {devices/lab_pin.sym} 95450 -23170 0 0 {name=p94889 lab=_84945_/CLK }
C {devices/lab_pin.sym} 95450 -23150 0 0 {name=p94890 lab=_83759_/D }
C {devices/lab_pin.sym} 95630 -23170 0 1 {name=p94891 lab=_83759_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -23160 0 0 {name=X_83759_ }
C {devices/lab_pin.sym} 95460 -23050 0 0 {name=p94892 lab=_71762_/X }
C {devices/lab_pin.sym} 95460 -23010 0 0 {name=p94893 lab=_83381_/Q }
C {devices/lab_pin.sym} 95460 -22970 0 0 {name=p94894 lab=_71772_/X }
C {devices/lab_pin.sym} 95620 -23010 0 1 {name=p94895 lab=_71773_/X }
C {sky130_stdcells/a21o_4.sym} 95540 -23010 0 0 {name=X_71773_ }
C {devices/lab_pin.sym} 95460 -22890 0 0 {name=p94896 lab=_46179_/X }
C {devices/lab_pin.sym} 95460 -22850 0 0 {name=p94897 lab=_63410_/B }
C {devices/lab_pin.sym} 95460 -22810 0 0 {name=p94898 lab=_59494_/Y }
C {devices/lab_pin.sym} 95620 -22850 0 1 {name=p94899 lab=_84717_/D }
C {sky130_stdcells/o21a_4.sym} 95540 -22850 0 0 {name=X_59495_ }
C {devices/lab_pin.sym} 95500 -22710 0 0 {name=p94900 lab=clkbuf_4_9_0_CLK/X }
C {devices/lab_pin.sym} 95580 -22710 0 1 {name=p94901 lab=clkbuf_4_9_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 95540 -22710 0 0 {name=Xclkbuf_4_9_1_CLK }
C {devices/lab_pin.sym} 95500 -22590 0 0 {name=p94902 lab=_76300_/A }
C {devices/lab_pin.sym} 95580 -22590 0 1 {name=p94903 lab=_76300_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -22590 0 0 {name=X_76300_ }
C {devices/lab_pin.sym} 95460 -22490 0 0 {name=p94904 lab=_69961_/B }
C {devices/lab_pin.sym} 95460 -22450 0 0 {name=p94905 lab=_73026_/X }
C {devices/lab_pin.sym} 95460 -22410 0 0 {name=p94906 lab=_73421_/X }
C {devices/lab_pin.sym} 95620 -22450 0 1 {name=p94907 lab=_73512_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -22450 0 0 {name=X_73512_ }
C {devices/lab_pin.sym} 95460 -22330 0 0 {name=p94908 lab=_46403_/X }
C {devices/lab_pin.sym} 95460 -22290 0 0 {name=p94909 lab=_81199_/Q }
C {devices/lab_pin.sym} 95460 -22250 0 0 {name=p94910 lab=_46459_/X }
C {devices/lab_pin.sym} 95620 -22290 0 1 {name=p94911 lab=_51326_/B }
C {sky130_stdcells/o21ai_4.sym} 95540 -22290 0 0 {name=X_46460_ }
C {devices/lab_pin.sym} 95480 -22180 0 0 {name=p94912 lab=_70724_/A }
C {devices/lab_pin.sym} 95480 -22140 0 0 {name=p94913 lab=_70713_/X }
C {devices/lab_pin.sym} 95480 -22100 0 0 {name=p94914 lab=_70727_/C }
C {devices/lab_pin.sym} 95480 -22060 0 0 {name=p94915 lab=_70769_/D }
C {devices/lab_pin.sym} 95600 -22120 0 1 {name=p94916 lab=_70724_/Y }
C {sky130_stdcells/nand4_4.sym} 95540 -22120 0 0 {name=X_70724_ }
C {devices/lab_pin.sym} 95480 -21980 0 0 {name=p94917 lab=_58446_/A }
C {devices/lab_pin.sym} 95480 -21940 0 0 {name=p94918 lab=_58426_/X }
C {devices/lab_pin.sym} 95600 -21960 0 1 {name=p94919 lab=_58446_/Y }
C {sky130_stdcells/nand2_4.sym} 95540 -21960 0 0 {name=X_58446_ }
C {devices/lab_pin.sym} 95460 -21850 0 0 {name=p94920 lab=_77278_/X }
C {devices/lab_pin.sym} 95460 -21810 0 0 {name=p94921 lab=_77279_/Y }
C {devices/lab_pin.sym} 95460 -21770 0 0 {name=p94922 lab=_82214_/Q }
C {devices/lab_pin.sym} 95620 -21810 0 1 {name=p94923 lab=_77280_/X }
C {sky130_stdcells/a21o_4.sym} 95540 -21810 0 0 {name=X_77280_ }
C {devices/lab_pin.sym} 95500 -21670 0 0 {name=p94924 lab=_43606_/A }
C {devices/lab_pin.sym} 95580 -21670 0 1 {name=p94925 lab=_43673_/A }
C {sky130_stdcells/buf_2.sym} 95540 -21670 0 0 {name=X_43672_ }
C {devices/lab_pin.sym} 95480 -21560 0 0 {name=p94926 lab=_83315_/Q }
C {devices/lab_pin.sym} 95480 -21520 0 0 {name=p94927 lab=_83314_/Q }
C {devices/lab_pin.sym} 95600 -21540 0 1 {name=p94928 lab=_55658_/Y }
C {sky130_stdcells/nor2_4.sym} 95540 -21540 0 0 {name=X_55658_ }
C {devices/lab_pin.sym} 95500 -21410 0 0 {name=p94929 lab=_74492_/A }
C {devices/lab_pin.sym} 95580 -21410 0 1 {name=p94930 lab=_74492_/X }
C {sky130_stdcells/buf_2.sym} 95540 -21410 0 0 {name=X_74492_ }
C {devices/lab_pin.sym} 95450 -21290 0 0 {name=p94931 lab=_86506_/CLK }
C {devices/lab_pin.sym} 95450 -21270 0 0 {name=p94932 lab=_48815_/Y }
C {devices/lab_pin.sym} 95630 -21290 0 1 {name=p94933 lab=_86478_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -21280 0 0 {name=X_86478_ }
C {devices/lab_pin.sym} 95460 -21170 0 0 {name=p94934 lab=_40857_/X }
C {devices/lab_pin.sym} 95460 -21130 0 0 {name=p94935 lab=_41057_/A }
C {devices/lab_pin.sym} 95460 -21090 0 0 {name=p94936 lab=_40883_/X }
C {devices/lab_pin.sym} 95620 -21130 0 1 {name=p94937 lab=_40885_/A }
C {sky130_stdcells/o21a_4.sym} 95540 -21130 0 0 {name=X_40884_ }
C {devices/lab_pin.sym} 95500 -20990 0 0 {name=p94938 lab=_85024_/Q }
C {devices/lab_pin.sym} 95580 -20990 0 1 {name=p94939 lab=_55628_/B }
C {sky130_stdcells/inv_2.sym} 95540 -20990 0 0 {name=X_45411_ }
C {devices/lab_pin.sym} 95460 -20890 0 0 {name=p94940 lab=_76232_/A }
C {devices/lab_pin.sym} 95460 -20850 0 0 {name=p94941 lab=_76229_/Y }
C {devices/lab_pin.sym} 95460 -20810 0 0 {name=p94942 lab=_76230_/Y }
C {devices/lab_pin.sym} 95620 -20850 0 1 {name=p94943 lab=_76231_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -20850 0 0 {name=X_76231_ }
C {devices/lab_pin.sym} 95450 -20710 0 0 {name=p94944 lab=_88215_/CLK }
C {devices/lab_pin.sym} 95450 -20690 0 0 {name=p94945 lab=_41430_/X }
C {devices/lab_pin.sym} 95630 -20710 0 1 {name=p94946 lab=_88217_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -20700 0 0 {name=X_88217_ }
C {devices/lab_pin.sym} 95460 -20610 0 0 {name=p94947 lab=_49210_/B }
C {devices/lab_pin.sym} 95460 -20570 0 0 {name=p94948 lab=_42569_/X }
C {devices/lab_pin.sym} 95460 -20530 0 0 {name=p94949 lab=_40925_/X }
C {devices/lab_pin.sym} 95460 -20490 0 0 {name=p94950 lab=_69958_/B }
C {devices/lab_pin.sym} 95460 -20450 0 0 {name=p94951 lab=_42612_/X }
C {devices/lab_pin.sym} 95620 -20530 0 1 {name=p94952 lab=_87797_/D }
C {sky130_stdcells/o32ai_4.sym} 95540 -20530 0 0 {name=X_42623_ }
C {devices/lab_pin.sym} 95480 -20380 0 0 {name=p94953 lab=_54600_/A }
C {devices/lab_pin.sym} 95480 -20340 0 0 {name=p94954 lab=_47212_/Y }
C {devices/lab_pin.sym} 95600 -20360 0 1 {name=p94955 lab=_54609_/Y }
C {sky130_stdcells/nand2_4.sym} 95540 -20360 0 0 {name=X_54609_ }
C {devices/lab_pin.sym} 95460 -20250 0 0 {name=p94956 lab=_69923_/B }
C {devices/lab_pin.sym} 95460 -20210 0 0 {name=p94957 lab=_72865_/X }
C {devices/lab_pin.sym} 95460 -20170 0 0 {name=p94958 lab=_72866_/X }
C {devices/lab_pin.sym} 95620 -20210 0 1 {name=p94959 lab=_73443_/X }
C {sky130_stdcells/o21a_4.sym} 95540 -20210 0 0 {name=X_73443_ }
C {devices/lab_pin.sym} 95450 -20070 0 0 {name=p94960 lab=_83046_/CLK }
C {devices/lab_pin.sym} 95450 -20050 0 0 {name=p94961 lab=_54510_/Y }
C {devices/lab_pin.sym} 95630 -20070 0 1 {name=p94962 lab=_85429_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -20060 0 0 {name=X_85429_ }
C {devices/lab_pin.sym} 95500 -19930 0 0 {name=p94963 lab=_46391_/A }
C {devices/lab_pin.sym} 95580 -19930 0 1 {name=p94964 lab=_52482_/B }
C {sky130_stdcells/buf_2.sym} 95540 -19930 0 0 {name=X_46391_ }
C {devices/lab_pin.sym} 95500 -19810 0 0 {name=p94965 lab=_70925_/A }
C {devices/lab_pin.sym} 95580 -19810 0 1 {name=p94966 lab=_70890_/C }
C {sky130_stdcells/buf_2.sym} 95540 -19810 0 0 {name=X_70655_ }
C {devices/lab_pin.sym} 95480 -19700 0 0 {name=p94967 lab=_58377_/A }
C {devices/lab_pin.sym} 95480 -19660 0 0 {name=p94968 lab=_58369_/X }
C {devices/lab_pin.sym} 95600 -19680 0 1 {name=p94969 lab=_58377_/Y }
C {sky130_stdcells/nand2_4.sym} 95540 -19680 0 0 {name=X_58377_ }
C {devices/lab_pin.sym} 95500 -19550 0 0 {name=p94970 lab=_55843_/A }
C {devices/lab_pin.sym} 95580 -19550 0 1 {name=p94971 lab=_55908_/A }
C {sky130_stdcells/buf_2.sym} 95540 -19550 0 0 {name=X_55589_ }
C {sky130_stdcells/decap_3.sym} 95540 -19400 0 0 {name=XPHY_60 }
C {devices/lab_pin.sym} 95500 -19250 0 0 {name=p94972 lab=_48130_/A }
C {devices/lab_pin.sym} 95580 -19250 0 1 {name=p94973 lab=_57637_/B }
C {sky130_stdcells/inv_2.sym} 95540 -19250 0 0 {name=X_48130_ }
C {devices/lab_pin.sym} 95460 -19150 0 0 {name=p94974 lab=_45338_/Y }
C {devices/lab_pin.sym} 95460 -19110 0 0 {name=p94975 lab=_45341_/Y }
C {devices/lab_pin.sym} 95460 -19070 0 0 {name=p94976 lab=_45287_/X }
C {devices/lab_pin.sym} 95620 -19110 0 1 {name=p94977 lab=_45342_/X }
C {sky130_stdcells/a21o_4.sym} 95540 -19110 0 0 {name=X_45342_ }
C {sky130_stdcells/decap_3.sym} 95540 -18940 0 0 {name=XPHY_71 }
C {devices/lab_pin.sym} 95500 -18790 0 0 {name=p94978 lab=_57328_/A }
C {devices/lab_pin.sym} 95580 -18790 0 1 {name=p94979 lab=_57328_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -18790 0 0 {name=X_57328_ }
C {devices/lab_pin.sym} 95450 -18670 0 0 {name=p94980 lab=_88208_/CLK }
C {devices/lab_pin.sym} 95450 -18650 0 0 {name=p94981 lab=_41794_/Y }
C {devices/lab_pin.sym} 95630 -18670 0 1 {name=p94982 lab=_88148_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -18660 0 0 {name=X_88148_ }
C {devices/lab_pin.sym} 95480 -18540 0 0 {name=p94983 lab=_76155_/A }
C {devices/lab_pin.sym} 95480 -18500 0 0 {name=p94984 lab=_76155_/B }
C {devices/lab_pin.sym} 95600 -18520 0 1 {name=p94985 lab=_76162_/Y }
C {sky130_stdcells/nor2_4.sym} 95540 -18520 0 0 {name=X_76162_ }
C {devices/lab_pin.sym} 95500 -18390 0 0 {name=p94986 lab=_42554_/A }
C {devices/lab_pin.sym} 95580 -18390 0 1 {name=p94987 lab=_42554_/X }
C {sky130_stdcells/buf_2.sym} 95540 -18390 0 0 {name=X_42554_ }
C {devices/lab_pin.sym} 95480 -18280 0 0 {name=p94988 lab=_73374_/A }
C {devices/lab_pin.sym} 95480 -18240 0 0 {name=p94989 lab=_73372_/B }
C {devices/lab_pin.sym} 95600 -18260 0 1 {name=p94990 lab=_73374_/Y }
C {sky130_stdcells/nor2_4.sym} 95540 -18260 0 0 {name=X_73374_ }
C {sky130_stdcells/decap_3.sym} 95540 -18100 0 0 {name=XPHY_82 }
C {devices/lab_pin.sym} 95500 -17950 0 0 {name=p94991 lab=_70576_/X }
C {devices/lab_pin.sym} 95580 -17950 0 1 {name=p94992 lab=_70586_/X }
C {sky130_stdcells/buf_2.sym} 95540 -17950 0 0 {name=X_70586_ }
C {sky130_stdcells/decap_3.sym} 95540 -17800 0 0 {name=XPHY_93 }
C {devices/lab_pin.sym} 95480 -17670 0 0 {name=p94993 lab=_75113_/A }
C {devices/lab_pin.sym} 95480 -17630 0 0 {name=p94994 lab=_81061_/Q }
C {devices/lab_pin.sym} 95480 -17590 0 0 {name=p94995 lab=_75113_/C }
C {devices/lab_pin.sym} 95600 -17630 0 1 {name=p94996 lab=_75117_/C }
C {sky130_stdcells/nand3_4.sym} 95540 -17630 0 0 {name=X_75113_ }
C {devices/lab_pin.sym} 95480 -17500 0 0 {name=p94997 lab=_81176_/Q }
C {devices/lab_pin.sym} 95480 -17460 0 0 {name=p94998 lab=_41523_/B }
C {devices/lab_pin.sym} 95600 -17480 0 1 {name=p94999 lab=_41505_/X }
C {sky130_stdcells/or2_4.sym} 95540 -17480 0 0 {name=X_41505_ }
C {devices/lab_pin.sym} 95500 -17350 0 0 {name=p95000 lab=_53567_/B }
C {devices/lab_pin.sym} 95580 -17350 0 1 {name=p95001 lab=_52047_/B }
C {sky130_stdcells/buf_2.sym} 95540 -17350 0 0 {name=X_48061_ }
C {devices/lab_pin.sym} 95460 -17250 0 0 {name=p95002 lab=_72287_/X }
C {devices/lab_pin.sym} 95460 -17210 0 0 {name=p95003 lab=_85328_/Q }
C {devices/lab_pin.sym} 95460 -17170 0 0 {name=p95004 lab=_72324_/X }
C {devices/lab_pin.sym} 95620 -17210 0 1 {name=p95005 lab=_72325_/X }
C {sky130_stdcells/o21a_4.sym} 95540 -17210 0 0 {name=X_72325_ }
C {devices/lab_pin.sym} 95480 -17080 0 0 {name=p95006 lab=_45273_/A }
C {devices/lab_pin.sym} 95480 -17040 0 0 {name=p95007 lab=_45272_/X }
C {devices/lab_pin.sym} 95600 -17060 0 1 {name=p95008 lab=_45273_/Y }
C {sky130_stdcells/nand2_4.sym} 95540 -17060 0 0 {name=X_45273_ }
C {devices/lab_pin.sym} 95460 -16960 0 0 {name=p95009 lab=_57243_/X }
C {devices/lab_pin.sym} 95460 -16920 0 0 {name=p95010 lab=_56630_/X }
C {devices/lab_pin.sym} 95460 -16880 0 0 {name=p95011 lab=_45567_/A }
C {devices/lab_pin.sym} 95460 -16840 0 0 {name=p95012 lab=_57245_/X }
C {devices/lab_pin.sym} 95620 -16900 0 1 {name=p95013 lab=_57259_/X }
C {sky130_stdcells/a2bb2o_4.sym} 95540 -16900 0 0 {name=X_57259_ }
C {devices/lab_pin.sym} 95500 -16750 0 0 {name=p95014 lab=_76093_/A }
C {devices/lab_pin.sym} 95580 -16750 0 1 {name=p95015 lab=_76093_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -16750 0 0 {name=X_76093_ }
C {devices/lab_pin.sym} 95450 -16630 0 0 {name=p95016 lab=_87288_/CLK }
C {devices/lab_pin.sym} 95450 -16610 0 0 {name=p95017 lab=_41991_/Y }
C {devices/lab_pin.sym} 95630 -16630 0 1 {name=p95018 lab=_72855_/A }
C {sky130_stdcells/dfxtp_4.sym} 95540 -16620 0 0 {name=X_88079_ }
C {devices/lab_pin.sym} 95500 -16490 0 0 {name=p95019 lab=_42465_/A }
C {devices/lab_pin.sym} 95580 -16490 0 1 {name=p95020 lab=_42554_/A }
C {sky130_stdcells/buf_2.sym} 95540 -16490 0 0 {name=X_42485_ }
C {devices/lab_pin.sym} 95500 -16370 0 0 {name=p95021 lab=clkbuf_9_226_0_CLK/X }
C {devices/lab_pin.sym} 95580 -16370 0 1 {name=p95022 lab=_84922_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 95540 -16370 0 0 {name=Xclkbuf_10_452_0_CLK }
C {devices/lab_pin.sym} 95500 -16250 0 0 {name=p95023 lab=_54494_/D }
C {devices/lab_pin.sym} 95580 -16250 0 1 {name=p95024 lab=_52801_/D }
C {sky130_stdcells/buf_2.sym} 95540 -16250 0 0 {name=X_47012_ }
C {devices/lab_pin.sym} 95500 -16130 0 0 {name=p95025 lab=_66608_/A }
C {devices/lab_pin.sym} 95580 -16130 0 1 {name=p95026 lab=_44225_/B }
C {sky130_stdcells/buf_2.sym} 95540 -16130 0 0 {name=X_44224_ }
C {devices/lab_pin.sym} 95480 -16020 0 0 {name=p95027 lab=_75041_/Y }
C {devices/lab_pin.sym} 95480 -15980 0 0 {name=p95028 lab=_75043_/Y }
C {devices/lab_pin.sym} 95600 -16000 0 1 {name=p95029 lab=_75045_/B }
C {sky130_stdcells/xor2_4.sym} 95540 -16000 0 0 {name=X_75044_ }
C {devices/lab_pin.sym} 95500 -15870 0 0 {name=p95030 lab=_79921_/A }
C {devices/lab_pin.sym} 95580 -15870 0 1 {name=p95031 lab=_79922_/A }
C {sky130_stdcells/inv_2.sym} 95540 -15870 0 0 {name=X_79921_ }
C {devices/lab_pin.sym} 95460 -15770 0 0 {name=p95032 lab=_41412_/X }
C {devices/lab_pin.sym} 95460 -15730 0 0 {name=p95033 lab=_82885_/Q }
C {devices/lab_pin.sym} 95460 -15690 0 0 {name=p95034 lab=_41435_/X }
C {devices/lab_pin.sym} 95620 -15730 0 1 {name=p95035 lab=_41436_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -15730 0 0 {name=X_41436_ }
C {devices/lab_pin.sym} 95460 -15610 0 0 {name=p95036 lab=_72196_/X }
C {devices/lab_pin.sym} 95460 -15570 0 0 {name=p95037 lab=_85334_/Q }
C {devices/lab_pin.sym} 95460 -15530 0 0 {name=p95038 lab=_72255_/X }
C {devices/lab_pin.sym} 95620 -15570 0 1 {name=p95039 lab=_72256_/X }
C {sky130_stdcells/o21a_4.sym} 95540 -15570 0 0 {name=X_72256_ }
C {devices/lab_pin.sym} 95480 -15440 0 0 {name=p95040 lab=_60156_/Y }
C {devices/lab_pin.sym} 95480 -15400 0 0 {name=p95041 lab=_60204_/A }
C {devices/lab_pin.sym} 95600 -15420 0 1 {name=p95042 lab=_60271_/A }
C {sky130_stdcells/and2_4.sym} 95540 -15420 0 0 {name=X_60270_ }
C {devices/lab_pin.sym} 95480 -15310 0 0 {name=p95043 lab=_71211_/A }
C {devices/lab_pin.sym} 95480 -15270 0 0 {name=p95044 lab=_71230_/B }
C {devices/lab_pin.sym} 95480 -15230 0 0 {name=p95045 lab=_71197_/C }
C {devices/lab_pin.sym} 95600 -15270 0 1 {name=p95046 lab=_71207_/Y }
C {sky130_stdcells/nand3_4.sym} 95540 -15270 0 0 {name=X_71207_ }
C {devices/lab_pin.sym} 95500 -15130 0 0 {name=p95047 lab=_66563_/A }
C {devices/lab_pin.sym} 95580 -15130 0 1 {name=p95048 lab=_66180_/A }
C {sky130_stdcells/buf_2.sym} 95540 -15130 0 0 {name=X_44155_ }
C {devices/lab_pin.sym} 95480 -15020 0 0 {name=p95049 lab=_79851_/Y }
C {devices/lab_pin.sym} 95480 -14980 0 0 {name=p95050 lab=_79852_/B }
C {devices/lab_pin.sym} 95600 -15000 0 1 {name=p95051 lab=_79852_/X }
C {sky130_stdcells/and2_4.sym} 95540 -15000 0 0 {name=X_79852_ }
C {devices/lab_pin.sym} 95500 -14870 0 0 {name=p95052 lab=_41366_/Y }
C {devices/lab_pin.sym} 95580 -14870 0 1 {name=p95053 lab=_41367_/X }
C {sky130_stdcells/buf_2.sym} 95540 -14870 0 0 {name=X_41367_ }
C {devices/lab_pin.sym} 95480 -14760 0 0 {name=p95054 lab=_72220_/A }
C {devices/lab_pin.sym} 95480 -14720 0 0 {name=p95055 lab=_72187_/B }
C {devices/lab_pin.sym} 95600 -14740 0 1 {name=p95056 lab=_72187_/Y }
C {sky130_stdcells/nor2_4.sym} 95540 -14740 0 0 {name=X_72187_ }
C {devices/lab_pin.sym} 95500 -14610 0 0 {name=p95057 lab=_43189_/A }
C {devices/lab_pin.sym} 95580 -14610 0 1 {name=p95058 lab=_43106_/X }
C {sky130_stdcells/buf_2.sym} 95540 -14610 0 0 {name=X_43106_ }
C {devices/lab_pin.sym} 95480 -14500 0 0 {name=p95059 lab=_82834_/Q }
C {devices/lab_pin.sym} 95480 -14460 0 0 {name=p95060 lab=_82546_/Q }
C {devices/lab_pin.sym} 95600 -14480 0 1 {name=p95061 lab=_78804_/B }
C {sky130_stdcells/xnor2_4.sym} 95540 -14480 0 0 {name=X_78803_ }
C {devices/lab_pin.sym} 95500 -14350 0 0 {name=p95062 lab=_71138_/A }
C {devices/lab_pin.sym} 95580 -14350 0 1 {name=p95063 lab=_71138_/X }
C {sky130_stdcells/buf_2.sym} 95540 -14350 0 0 {name=X_71138_ }
C {devices/lab_pin.sym} 95500 -14230 0 0 {name=p95064 lab=_71996_/B }
C {devices/lab_pin.sym} 95580 -14230 0 1 {name=p95065 lab=_48963_/X }
C {sky130_stdcells/buf_2.sym} 95540 -14230 0 0 {name=X_48963_ }
C {devices/lab_pin.sym} 95500 -14110 0 0 {name=p95066 lab=_44086_/A }
C {devices/lab_pin.sym} 95580 -14110 0 1 {name=p95067 lab=_44087_/B }
C {sky130_stdcells/buf_2.sym} 95540 -14110 0 0 {name=X_44086_ }
C {devices/lab_pin.sym} 95480 -14000 0 0 {name=p95068 lab=_84224_/Q }
C {devices/lab_pin.sym} 95480 -13960 0 0 {name=p95069 lab=_72224_/A }
C {devices/lab_pin.sym} 95600 -13980 0 1 {name=p95070 lab=_79794_/A }
C {sky130_stdcells/xor2_4.sym} 95540 -13980 0 0 {name=X_79783_ }
C {devices/lab_pin.sym} 95500 -13850 0 0 {name=p95071 lab=_41298_/A }
C {devices/lab_pin.sym} 95580 -13850 0 1 {name=p95072 lab=_41298_/X }
C {sky130_stdcells/buf_2.sym} 95540 -13850 0 0 {name=X_41298_ }
C {devices/lab_pin.sym} 95480 -13740 0 0 {name=p95073 lab=_60970_/C }
C {devices/lab_pin.sym} 95480 -13700 0 0 {name=p95074 lab=_76995_/B }
C {devices/lab_pin.sym} 95600 -13720 0 1 {name=p95075 lab=_76995_/X }
C {sky130_stdcells/xor2_4.sym} 95540 -13720 0 0 {name=X_76995_ }
C {devices/lab_pin.sym} 95500 -13590 0 0 {name=p95076 lab=clkbuf_9_233_0_CLK/X }
C {devices/lab_pin.sym} 95580 -13590 0 1 {name=p95077 lab=_83663_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 95540 -13590 0 0 {name=Xclkbuf_10_467_0_CLK }
C {devices/lab_pin.sym} 95500 -13470 0 0 {name=p95078 lab=_82362_/Q }
C {devices/lab_pin.sym} 95580 -13470 0 1 {name=p95079 lab=_48438_/B }
C {sky130_stdcells/inv_2.sym} 95540 -13470 0 0 {name=X_47914_ }
C {devices/lab_pin.sym} 95500 -13350 0 0 {name=p95080 lab=_43036_/Y }
C {devices/lab_pin.sym} 95580 -13350 0 1 {name=p95081 lab=_87599_/D }
C {sky130_stdcells/inv_2.sym} 95540 -13350 0 0 {name=X_43037_ }
C {devices/lab_pin.sym} 95460 -13250 0 0 {name=p95082 lab=_78709_/Y }
C {devices/lab_pin.sym} 95460 -13210 0 0 {name=p95083 lab=_78713_/B }
C {devices/lab_pin.sym} 95460 -13170 0 0 {name=p95084 lab=_78712_/A }
C {devices/lab_pin.sym} 95620 -13210 0 1 {name=p95085 lab=_78735_/A }
C {sky130_stdcells/o21a_4.sym} 95540 -13210 0 0 {name=X_78734_ }
C {devices/lab_pin.sym} 95480 -13080 0 0 {name=p95086 lab=_81701_/D }
C {devices/lab_pin.sym} 95480 -13040 0 0 {name=p95087 lab=_75940_/B }
C {devices/lab_pin.sym} 95600 -13060 0 1 {name=p95088 lab=_75946_/Y }
C {sky130_stdcells/nor2_4.sym} 95540 -13060 0 0 {name=X_75946_ }
C {devices/lab_pin.sym} 95480 -12950 0 0 {name=p95089 lab=_63960_/A }
C {devices/lab_pin.sym} 95480 -12910 0 0 {name=p95090 lab=_63960_/B }
C {devices/lab_pin.sym} 95480 -12870 0 0 {name=p95091 lab=_80111_/B }
C {devices/lab_pin.sym} 95600 -12910 0 1 {name=p95092 lab=_63960_/Y }
C {sky130_stdcells/nor3_4.sym} 95540 -12910 0 0 {name=X_63960_ }
C {devices/lab_pin.sym} 95500 -12770 0 0 {name=p95093 lab=_71069_/A }
C {devices/lab_pin.sym} 95580 -12770 0 1 {name=p95094 lab=_71070_/A }
C {sky130_stdcells/buf_2.sym} 95540 -12770 0 0 {name=X_71069_ }
C {devices/lab_pin.sym} 95480 -12670 0 0 {name=p95095 lab=_48894_/A }
C {devices/lab_pin.sym} 95480 -12630 0 0 {name=p95096 lab=_48894_/B }
C {devices/lab_pin.sym} 95480 -12590 0 0 {name=p95097 lab=_48894_/C }
C {devices/lab_pin.sym} 95600 -12630 0 1 {name=p95098 lab=_48894_/X }
C {sky130_stdcells/and3_4.sym} 95540 -12630 0 0 {name=X_48894_ }
C {devices/lab_pin.sym} 95480 -12520 0 0 {name=p95099 lab=_62967_/A }
C {devices/lab_pin.sym} 95480 -12480 0 0 {name=p95100 lab=_58459_/Y }
C {devices/lab_pin.sym} 95480 -12440 0 0 {name=p95101 lab=_62911_/C }
C {devices/lab_pin.sym} 95480 -12400 0 0 {name=p95102 lab=_62967_/D }
C {devices/lab_pin.sym} 95600 -12460 0 1 {name=p95103 lab=_62911_/X }
C {sky130_stdcells/and4_4.sym} 95540 -12460 0 0 {name=X_62911_ }
C {devices/lab_pin.sym} 95460 -12330 0 0 {name=p95104 lab=_65921_/B }
C {devices/lab_pin.sym} 95460 -12290 0 0 {name=p95105 lab=_47840_/X }
C {devices/lab_pin.sym} 95460 -12250 0 0 {name=p95106 lab=_47844_/Y }
C {devices/lab_pin.sym} 95620 -12290 0 1 {name=p95107 lab=_47845_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -12290 0 0 {name=X_47845_ }
C {devices/lab_pin.sym} 95460 -12170 0 0 {name=p95108 lab=_78645_/Y }
C {devices/lab_pin.sym} 95460 -12130 0 0 {name=p95109 lab=_78649_/B }
C {devices/lab_pin.sym} 95460 -12090 0 0 {name=p95110 lab=_78648_/A }
C {devices/lab_pin.sym} 95620 -12130 0 1 {name=p95111 lab=_78665_/X }
C {sky130_stdcells/o21a_4.sym} 95540 -12130 0 0 {name=X_78665_ }
C {devices/lab_pin.sym} 95500 -11990 0 0 {name=p95112 lab=_60984_/A }
C {devices/lab_pin.sym} 95580 -11990 0 1 {name=p95113 lab=_63892_/D }
C {sky130_stdcells/buf_2.sym} 95540 -11990 0 0 {name=X_63891_ }
C {devices/lab_pin.sym} 95500 -11870 0 0 {name=p95114 lab=_81025_/Q }
C {devices/lab_pin.sym} 95580 -11870 0 1 {name=p95115 lab=_75878_/B }
C {sky130_stdcells/inv_2.sym} 95540 -11870 0 0 {name=X_75877_ }
C {devices/lab_pin.sym} 95460 -11780 0 0 {name=p95116 lab=_65524_/X }
C {devices/lab_pin.sym} 95460 -11740 0 0 {name=p95117 lab=_83068_/Q }
C {devices/lab_pin.sym} 95460 -11700 0 0 {name=p95118 lab=_65568_/X }
C {devices/lab_pin.sym} 95460 -11660 0 0 {name=p95119 lab=_65629_/X }
C {devices/lab_pin.sym} 95620 -11720 0 1 {name=p95120 lab=_65630_/X }
C {sky130_stdcells/a211o_4.sym} 95540 -11720 0 0 {name=X_65630_ }
C {devices/lab_pin.sym} 95460 -11590 0 0 {name=p95121 lab=_77603_/A }
C {devices/lab_pin.sym} 95460 -11550 0 0 {name=p95122 lab=_77600_/Y }
C {devices/lab_pin.sym} 95460 -11510 0 0 {name=p95123 lab=_77601_/Y }
C {devices/lab_pin.sym} 95620 -11550 0 1 {name=p95124 lab=_77616_/X }
C {sky130_stdcells/o21a_4.sym} 95540 -11550 0 0 {name=X_77616_ }
C {devices/lab_pin.sym} 95480 -11440 0 0 {name=p95125 lab=_63557_/B }
C {devices/lab_pin.sym} 95480 -11400 0 0 {name=p95126 lab=_62841_/X }
C {devices/lab_pin.sym} 95480 -11360 0 0 {name=p95127 lab=_60309_/C }
C {devices/lab_pin.sym} 95480 -11320 0 0 {name=p95128 lab=_60254_/B }
C {devices/lab_pin.sym} 95600 -11380 0 1 {name=p95129 lab=_62842_/Y }
C {sky130_stdcells/nand4_4.sym} 95540 -11380 0 0 {name=X_62842_ }
C {devices/lab_pin.sym} 95500 -11230 0 0 {name=p95130 lab=_74828_/A }
C {devices/lab_pin.sym} 95580 -11230 0 1 {name=p95131 lab=_74828_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -11230 0 0 {name=X_74828_ }
C {devices/lab_pin.sym} 95500 -11110 0 0 {name=p95132 lab=_47776_/A }
C {devices/lab_pin.sym} 95580 -11110 0 1 {name=p95133 lab=_53238_/D }
C {sky130_stdcells/buf_2.sym} 95540 -11110 0 0 {name=X_47776_ }
C {devices/lab_pin.sym} 95500 -10990 0 0 {name=p95134 lab=_82806_/Q }
C {devices/lab_pin.sym} 95580 -10990 0 1 {name=p95135 lab=_78596_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -10990 0 0 {name=X_78596_ }
C {devices/lab_pin.sym} 95460 -10890 0 0 {name=p95136 lab=_55943_/B }
C {devices/lab_pin.sym} 95460 -10850 0 0 {name=p95137 lab=_44963_/X }
C {devices/lab_pin.sym} 95460 -10810 0 0 {name=p95138 lab=_44964_/X }
C {devices/lab_pin.sym} 95620 -10850 0 1 {name=p95139 lab=_44988_/X }
C {sky130_stdcells/o21a_4.sym} 95540 -10850 0 0 {name=X_44988_ }
C {devices/lab_pin.sym} 95500 -10710 0 0 {name=p95140 lab=_49407_/A }
C {devices/lab_pin.sym} 95580 -10710 0 1 {name=p95141 lab=_49537_/A }
C {sky130_stdcells/buf_2.sym} 95540 -10710 0 0 {name=X_49515_ }
C {devices/lab_pin.sym} 95500 -10590 0 0 {name=p95142 lab=_46727_/A }
C {devices/lab_pin.sym} 95580 -10590 0 1 {name=p95143 lab=_46727_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -10590 0 0 {name=X_46727_ }
C {devices/lab_pin.sym} 95480 -10480 0 0 {name=p95144 lab=_65777_/A }
C {devices/lab_pin.sym} 95480 -10440 0 0 {name=p95145 lab=_85880_/Q }
C {devices/lab_pin.sym} 95600 -10460 0 1 {name=p95146 lab=_65561_/X }
C {sky130_stdcells/and2_4.sym} 95540 -10460 0 0 {name=X_65561_ }
C {devices/lab_pin.sym} 95480 -10340 0 0 {name=p95147 lab=_77547_/A }
C {devices/lab_pin.sym} 95480 -10300 0 0 {name=p95148 lab=_77547_/B }
C {devices/lab_pin.sym} 95600 -10320 0 1 {name=p95149 lab=_82199_/D }
C {sky130_stdcells/xor2_4.sym} 95540 -10320 0 0 {name=X_77547_ }
C {devices/lab_pin.sym} 95500 -10190 0 0 {name=p95150 lab=_43927_/X }
C {devices/lab_pin.sym} 95580 -10190 0 1 {name=p95151 lab=_43939_/X }
C {sky130_stdcells/buf_2.sym} 95540 -10190 0 0 {name=X_43939_ }
C {devices/lab_pin.sym} 95500 -10070 0 0 {name=p95152 lab=_60362_/A }
C {devices/lab_pin.sym} 95580 -10070 0 1 {name=p95153 lab=_62773_/X }
C {sky130_stdcells/buf_2.sym} 95540 -10070 0 0 {name=X_62773_ }
C {devices/lab_pin.sym} 95500 -9950 0 0 {name=p95154 lab=_70735_/X }
C {devices/lab_pin.sym} 95580 -9950 0 1 {name=p95155 lab=_74780_/D }
C {sky130_stdcells/buf_2.sym} 95540 -9950 0 0 {name=X_74759_ }
C {devices/lab_pin.sym} 95500 -9830 0 0 {name=p95156 lab=clkbuf_9_510_0_CLK/A }
C {devices/lab_pin.sym} 95580 -9830 0 1 {name=p95157 lab=clkbuf_9_511_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 95540 -9830 0 0 {name=Xclkbuf_9_511_0_CLK }
C {devices/lab_pin.sym} 95480 -9720 0 0 {name=p95158 lab=_67324_/A }
C {devices/lab_pin.sym} 95480 -9680 0 0 {name=p95159 lab=_88181_/Q }
C {devices/lab_pin.sym} 95600 -9700 0 1 {name=p95160 lab=_67300_/X }
C {sky130_stdcells/and2_4.sym} 95540 -9700 0 0 {name=X_67300_ }
C {devices/lab_pin.sym} 95480 -9600 0 0 {name=p95161 lab=_64363_/A }
C {devices/lab_pin.sym} 95480 -9560 0 0 {name=p95162 lab=_64363_/B }
C {devices/lab_pin.sym} 95480 -9520 0 0 {name=p95163 lab=_84910_/Q }
C {devices/lab_pin.sym} 95480 -9480 0 0 {name=p95164 lab=_61145_/X }
C {devices/lab_pin.sym} 95600 -9540 0 1 {name=p95165 lab=_64512_/X }
C {sky130_stdcells/and4_4.sym} 95540 -9540 0 0 {name=X_64512_ }
C {devices/lab_pin.sym} 95460 -9410 0 0 {name=p95166 lab=_58763_/B }
C {devices/lab_pin.sym} 95460 -9370 0 0 {name=p95167 lab=_49443_/X }
C {devices/lab_pin.sym} 95460 -9330 0 0 {name=p95168 lab=_49445_/Y }
C {devices/lab_pin.sym} 95620 -9370 0 1 {name=p95169 lab=_49446_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -9370 0 0 {name=X_49446_ }
C {devices/lab_pin.sym} 95480 -9250 0 0 {name=p95170 lab=_61752_/A }
C {devices/lab_pin.sym} 95480 -9210 0 0 {name=p95171 lab=_61723_/X }
C {devices/lab_pin.sym} 95480 -9170 0 0 {name=p95172 lab=_78080_/B }
C {devices/lab_pin.sym} 95600 -9210 0 1 {name=p95173 lab=_61724_/Y }
C {sky130_stdcells/nor3_4.sym} 95540 -9210 0 0 {name=X_61724_ }
C {devices/lab_pin.sym} 95460 -9090 0 0 {name=p95174 lab=_67731_/X }
C {devices/lab_pin.sym} 95460 -9050 0 0 {name=p95175 lab=_67733_/X }
C {devices/lab_pin.sym} 95460 -9010 0 0 {name=p95176 lab=_68239_/X }
C {devices/lab_pin.sym} 95620 -9050 0 1 {name=p95177 lab=_68280_/Y }
C {sky130_stdcells/a21oi_4.sym} 95540 -9050 0 0 {name=X_68280_ }
C {devices/lab_pin.sym} 95500 -8910 0 0 {name=p95178 lab=_46658_/A }
C {devices/lab_pin.sym} 95580 -8910 0 1 {name=p95179 lab=_51772_/D }
C {sky130_stdcells/buf_2.sym} 95540 -8910 0 0 {name=X_46658_ }
C {devices/lab_pin.sym} 95480 -8800 0 0 {name=p95180 lab=_65474_/X }
C {devices/lab_pin.sym} 95480 -8760 0 0 {name=p95181 lab=_86525_/Q }
C {devices/lab_pin.sym} 95600 -8780 0 1 {name=p95182 lab=_65492_/X }
C {sky130_stdcells/and2_4.sym} 95540 -8780 0 0 {name=X_65492_ }
C {devices/lab_pin.sym} 95480 -8670 0 0 {name=p95183 lab=_77478_/A }
C {devices/lab_pin.sym} 95480 -8630 0 0 {name=p95184 lab=_77478_/B }
C {devices/lab_pin.sym} 95480 -8590 0 0 {name=p95185 lab=_77477_/Y }
C {devices/lab_pin.sym} 95600 -8630 0 1 {name=p95186 lab=_77478_/X }
C {sky130_stdcells/or3_4.sym} 95540 -8630 0 0 {name=X_77478_ }
C {devices/lab_pin.sym} 95500 -8490 0 0 {name=p95187 lab=clkbuf_9_202_0_CLK/X }
C {devices/lab_pin.sym} 95580 -8490 0 1 {name=p95188 lab=_85375_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 95540 -8490 0 0 {name=Xclkbuf_10_405_0_CLK }
C {devices/lab_pin.sym} 95480 -8380 0 0 {name=p95189 lab=_67183_/A }
C {devices/lab_pin.sym} 95480 -8340 0 0 {name=p95190 lab=_67231_/B }
C {devices/lab_pin.sym} 95600 -8360 0 1 {name=p95191 lab=_67231_/X }
C {sky130_stdcells/and2_4.sym} 95540 -8360 0 0 {name=X_67231_ }
C {devices/lab_pin.sym} 95480 -8250 0 0 {name=p95192 lab=_79213_/Y }
C {devices/lab_pin.sym} 95480 -8210 0 0 {name=p95193 lab=_79215_/X }
C {devices/lab_pin.sym} 95480 -8170 0 0 {name=p95194 lab=_79236_/A }
C {devices/lab_pin.sym} 95600 -8210 0 1 {name=p95195 lab=_79217_/Y }
C {sky130_stdcells/nand3_4.sym} 95540 -8210 0 0 {name=X_79217_ }
C {devices/lab_pin.sym} 95460 -8090 0 0 {name=p95196 lab=_45591_/X }
C {devices/lab_pin.sym} 95460 -8050 0 0 {name=p95197 lab=_61492_/A }
C {devices/lab_pin.sym} 95460 -8010 0 0 {name=p95198 lab=_45608_/X }
C {devices/lab_pin.sym} 95620 -8050 0 1 {name=p95199 lab=_45609_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -8050 0 0 {name=X_45609_ }
C {devices/lab_pin.sym} 95460 -7930 0 0 {name=p95200 lab=_64431_/Y }
C {devices/lab_pin.sym} 95460 -7890 0 0 {name=p95201 lab=_64441_/X }
C {devices/lab_pin.sym} 95460 -7850 0 0 {name=p95202 lab=_64442_/X }
C {devices/lab_pin.sym} 95620 -7890 0 1 {name=p95203 lab=_64443_/X }
C {sky130_stdcells/o21a_4.sym} 95540 -7890 0 0 {name=X_64443_ }
C {devices/lab_pin.sym} 95500 -7750 0 0 {name=p95204 lab=_76429_/A }
C {devices/lab_pin.sym} 95580 -7750 0 1 {name=p95205 lab=_76430_/C }
C {sky130_stdcells/inv_2.sym} 95540 -7750 0 0 {name=X_76429_ }
C {devices/lab_pin.sym} 95460 -7650 0 0 {name=p95206 lab=_86398_/Q }
C {devices/lab_pin.sym} 95460 -7610 0 0 {name=p95207 lab=_49360_/X }
C {devices/lab_pin.sym} 95460 -7570 0 0 {name=p95208 lab=_49376_/Y }
C {devices/lab_pin.sym} 95620 -7610 0 1 {name=p95209 lab=_49377_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -7610 0 0 {name=X_49377_ }
C {devices/lab_pin.sym} 95480 -7500 0 0 {name=p95210 lab=_61655_/A }
C {devices/lab_pin.sym} 95480 -7460 0 0 {name=p95211 lab=_61653_/X }
C {devices/lab_pin.sym} 95480 -7420 0 0 {name=p95212 lab=_61654_/X }
C {devices/lab_pin.sym} 95480 -7380 0 0 {name=p95213 lab=_61639_/X }
C {devices/lab_pin.sym} 95600 -7440 0 1 {name=p95214 lab=_61655_/Y }
C {sky130_stdcells/nand4_4.sym} 95540 -7440 0 0 {name=X_61655_ }
C {devices/lab_pin.sym} 95480 -7300 0 0 {name=p95215 lab=_82915_/Q }
C {devices/lab_pin.sym} 95480 -7260 0 0 {name=p95216 lab=_46579_/X }
C {devices/lab_pin.sym} 95600 -7280 0 1 {name=p95217 lab=_46589_/X }
C {sky130_stdcells/or2_4.sym} 95540 -7280 0 0 {name=X_46589_ }
C {devices/lab_pin.sym} 95460 -7170 0 0 {name=p95218 lab=_66301_/B }
C {devices/lab_pin.sym} 95460 -7130 0 0 {name=p95219 lab=_48293_/X }
C {devices/lab_pin.sym} 95460 -7090 0 0 {name=p95220 lab=_48327_/Y }
C {devices/lab_pin.sym} 95620 -7130 0 1 {name=p95221 lab=_48328_/Y }
C {sky130_stdcells/o21ai_4.sym} 95540 -7130 0 0 {name=X_48328_ }
C {devices/lab_pin.sym} 95500 -6990 0 0 {name=p95222 lab=_60606_/A }
C {devices/lab_pin.sym} 95580 -6990 0 1 {name=p95223 lab=_60606_/X }
C {sky130_stdcells/buf_2.sym} 95540 -6990 0 0 {name=X_60606_ }
C {devices/lab_pin.sym} 95460 -6900 0 0 {name=p95224 lab=_87111_/Q }
C {devices/lab_pin.sym} 95460 -6860 0 0 {name=p95225 lab=_67110_/X }
C {devices/lab_pin.sym} 95460 -6820 0 0 {name=p95226 lab=_67160_/X }
C {devices/lab_pin.sym} 95460 -6780 0 0 {name=p95227 lab=_67161_/X }
C {devices/lab_pin.sym} 95620 -6840 0 1 {name=p95228 lab=_67162_/X }
C {sky130_stdcells/a211o_4.sym} 95540 -6840 0 0 {name=X_67162_ }
C {devices/lab_pin.sym} 95480 -6700 0 0 {name=p95229 lab=_79148_/A }
C {devices/lab_pin.sym} 95480 -6660 0 0 {name=p95230 lab=_79148_/B }
C {devices/lab_pin.sym} 95600 -6680 0 1 {name=p95231 lab=_82456_/D }
C {sky130_stdcells/xor2_4.sym} 95540 -6680 0 0 {name=X_79148_ }
C {devices/lab_pin.sym} 95500 -6550 0 0 {name=p95232 lab=_64315_/A }
C {devices/lab_pin.sym} 95580 -6550 0 1 {name=p95233 lab=_64418_/B }
C {sky130_stdcells/buf_2.sym} 95540 -6550 0 0 {name=X_64374_ }
C {devices/lab_pin.sym} 95460 -6470 0 0 {name=p95234 lab=_61579_/Y }
C {devices/lab_pin.sym} 95460 -6430 0 0 {name=p95235 lab=_61581_/Y }
C {devices/lab_pin.sym} 95460 -6390 0 0 {name=p95236 lab=_61582_/Y }
C {devices/lab_pin.sym} 95460 -6350 0 0 {name=p95237 lab=_61583_/Y }
C {devices/lab_pin.sym} 95460 -6320 0 0 {name=p95238 lab=_61585_/Y }
C {devices/lab_pin.sym} 95620 -6390 0 1 {name=p95239 lab=_61586_/Y }
C {sky130_stdcells/a41oi_4.sym} 95540 -6390 0 0 {name=X_61586_ }
C {devices/lab_pin.sym} 95460 -6260 0 0 {name=p95240 lab=_72155_/A }
C {devices/lab_pin.sym} 95460 -6220 0 0 {name=p95241 lab=_86227_/Q }
C {devices/lab_pin.sym} 95460 -6180 0 0 {name=p95242 lab=_64692_/X }
C {devices/lab_pin.sym} 95460 -6140 0 0 {name=p95243 lab=_66112_/X }
C {devices/lab_pin.sym} 95620 -6200 0 1 {name=p95244 lab=_66113_/X }
C {sky130_stdcells/a211o_4.sym} 95540 -6200 0 0 {name=X_66113_ }
C {devices/lab_pin.sym} 95460 -6090 0 0 {name=p95245 lab=_63321_/Y }
C {devices/lab_pin.sym} 95460 -6050 0 0 {name=p95246 lab=_63322_/X }
C {devices/lab_pin.sym} 95460 -6010 0 0 {name=p95247 lab=_63323_/X }
C {devices/lab_pin.sym} 95460 -5970 0 0 {name=p95248 lab=_63324_/X }
C {devices/lab_pin.sym} 95460 -5930 0 0 {name=p95249 lab=_63242_/X }
C {devices/lab_pin.sym} 95620 -6010 0 1 {name=p95250 lab=_63325_/Y }
C {sky130_stdcells/o41ai_4.sym} 95540 -6010 0 0 {name=X_63325_ }
C {devices/lab_pin.sym} 95480 -5860 0 0 {name=p95251 lab=_48190_/A }
C {devices/lab_pin.sym} 95480 -5820 0 0 {name=p95252 lab=_50306_/B }
C {devices/lab_pin.sym} 95600 -5840 0 1 {name=p95253 lab=_48259_/Y }
C {sky130_stdcells/nand2_4.sym} 95540 -5840 0 0 {name=X_48259_ }
C {devices/lab_pin.sym} 95500 -5710 0 0 {name=p95254 lab=_60536_/X }
C {devices/lab_pin.sym} 95580 -5710 0 1 {name=p95255 lab=_60537_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -5710 0 0 {name=X_60537_ }
C {devices/lab_pin.sym} 95500 -5590 0 0 {name=p95256 lab=_66565_/A }
C {devices/lab_pin.sym} 95580 -5590 0 1 {name=p95257 lab=_67093_/X }
C {sky130_stdcells/buf_2.sym} 95540 -5590 0 0 {name=X_67093_ }
C {devices/lab_pin.sym} 95480 -5480 0 0 {name=p95258 lab=_79075_/Y }
C {devices/lab_pin.sym} 95480 -5440 0 0 {name=p95259 lab=_79078_/Y }
C {devices/lab_pin.sym} 95600 -5460 0 1 {name=p95260 lab=_79080_/A }
C {sky130_stdcells/xor2_4.sym} 95540 -5460 0 0 {name=X_79079_ }
C {devices/lab_pin.sym} 95450 -5330 0 0 {name=p95261 lab=_80708_/CLK }
C {devices/lab_pin.sym} 95450 -5310 0 0 {name=p95262 lab=_79771_/X }
C {devices/lab_pin.sym} 95630 -5330 0 1 {name=p95263 lab=_81110_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -5320 0 0 {name=X_81110_ }
C {devices/lab_pin.sym} 95480 -5210 0 0 {name=p95264 lab=_66044_/A }
C {devices/lab_pin.sym} 95480 -5170 0 0 {name=p95265 lab=_66062_/B }
C {devices/lab_pin.sym} 95480 -5130 0 0 {name=p95266 lab=_65570_/X }
C {devices/lab_pin.sym} 95600 -5170 0 1 {name=p95267 lab=_66044_/Y }
C {sky130_stdcells/nand3_4.sym} 95540 -5170 0 0 {name=X_66044_ }
C {devices/lab_pin.sym} 95480 -5040 0 0 {name=p95268 lab=_51278_/A }
C {devices/lab_pin.sym} 95480 -5000 0 0 {name=p95269 lab=_46330_/A }
C {devices/lab_pin.sym} 95600 -5020 0 1 {name=p95270 lab=_51270_/X }
C {sky130_stdcells/and2_4.sym} 95540 -5020 0 0 {name=X_51270_ }
C {devices/lab_pin.sym} 95480 -4910 0 0 {name=p95271 lab=_63285_/A }
C {devices/lab_pin.sym} 95480 -4870 0 0 {name=p95272 lab=_63285_/B }
C {devices/lab_pin.sym} 95480 -4830 0 0 {name=p95273 lab=_79288_/A }
C {devices/lab_pin.sym} 95600 -4870 0 1 {name=p95274 lab=_63256_/Y }
C {sky130_stdcells/nor3_4.sym} 95540 -4870 0 0 {name=X_63256_ }
C {devices/lab_pin.sym} 95450 -4730 0 0 {name=p95275 lab=_82009_/CLK }
C {devices/lab_pin.sym} 95450 -4710 0 0 {name=p95276 lab=_77338_/B }
C {devices/lab_pin.sym} 95630 -4730 0 1 {name=p95277 lab=_77060_/A }
C {sky130_stdcells/dfxtp_4.sym} 95540 -4720 0 0 {name=X_82090_ }
C {devices/lab_pin.sym} 95500 -4590 0 0 {name=p95278 lab=_60399_/B }
C {devices/lab_pin.sym} 95580 -4590 0 1 {name=p95279 lab=_60570_/B }
C {sky130_stdcells/buf_2.sym} 95540 -4590 0 0 {name=X_60468_ }
C {devices/lab_pin.sym} 95500 -4470 0 0 {name=p95280 lab=_50221_/A }
C {devices/lab_pin.sym} 95580 -4470 0 1 {name=p95281 lab=_51074_/A }
C {sky130_stdcells/buf_2.sym} 95540 -4470 0 0 {name=X_50221_ }
C {devices/lab_pin.sym} 95500 -4350 0 0 {name=p95282 lab=_59896_/X }
C {devices/lab_pin.sym} 95580 -4350 0 1 {name=p95283 lab=_62560_/B }
C {sky130_stdcells/buf_2.sym} 95540 -4350 0 0 {name=X_62207_ }
C {devices/lab_pin.sym} 95450 -4230 0 0 {name=p95284 lab=_81041_/CLK }
C {devices/lab_pin.sym} 95450 -4210 0 0 {name=p95285 lab=_81041_/D }
C {devices/lab_pin.sym} 95630 -4230 0 1 {name=p95286 lab=_81041_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -4220 0 0 {name=X_81041_ }
C {devices/lab_pin.sym} 95460 -4110 0 0 {name=p95287 lab=_84346_/Q }
C {devices/lab_pin.sym} 95460 -4070 0 0 {name=p95288 lab=_63130_/X }
C {devices/lab_pin.sym} 95460 -4030 0 0 {name=p95289 lab=_63186_/Y }
C {devices/lab_pin.sym} 95620 -4070 0 1 {name=p95290 lab=_84346_/D }
C {sky130_stdcells/a21o_4.sym} 95540 -4070 0 0 {name=X_63187_ }
C {devices/lab_pin.sym} 95480 -3950 0 0 {name=p95291 lab=_60515_/C }
C {devices/lab_pin.sym} 95480 -3910 0 0 {name=p95292 lab=_60399_/B }
C {devices/lab_pin.sym} 95480 -3870 0 0 {name=p95293 lab=_60570_/A }
C {devices/lab_pin.sym} 95600 -3910 0 1 {name=p95294 lab=_60399_/Y }
C {sky130_stdcells/nor3_4.sym} 95540 -3910 0 0 {name=X_60399_ }
C {devices/lab_pin.sym} 95460 -3790 0 0 {name=p95295 lab=_81968_/D }
C {devices/lab_pin.sym} 95460 -3750 0 0 {name=p95296 lab=_69763_/X }
C {devices/lab_pin.sym} 95460 -3710 0 0 {name=p95297 lab=_69802_/X }
C {devices/lab_pin.sym} 95620 -3750 0 1 {name=p95298 lab=_83896_/D }
C {sky130_stdcells/a21bo_4.sym} 95540 -3750 0 0 {name=X_69803_ }
C {devices/lab_pin.sym} 95460 -3630 0 0 {name=p95299 lab=_50150_/Y }
C {devices/lab_pin.sym} 95460 -3590 0 0 {name=p95300 lab=_50141_/X }
C {devices/lab_pin.sym} 95460 -3550 0 0 {name=p95301 lab=_50151_/X }
C {devices/lab_pin.sym} 95620 -3590 0 1 {name=p95302 lab=_50152_/Y }
C {sky130_stdcells/a21oi_4.sym} 95540 -3590 0 0 {name=X_50152_ }
C {devices/lab_pin.sym} 95480 -3480 0 0 {name=p95303 lab=_61652_/B }
C {devices/lab_pin.sym} 95480 -3440 0 0 {name=p95304 lab=_62149_/B }
C {devices/lab_pin.sym} 95480 -3400 0 0 {name=p95305 lab=_62149_/C }
C {devices/lab_pin.sym} 95480 -3360 0 0 {name=p95306 lab=_61749_/B }
C {devices/lab_pin.sym} 95600 -3420 0 1 {name=p95307 lab=_62138_/Y }
C {sky130_stdcells/nand4_4.sym} 95540 -3420 0 0 {name=X_62138_ }
C {devices/lab_pin.sym} 95460 -3300 0 0 {name=p95308 lab=_67948_/X }
C {devices/lab_pin.sym} 95460 -3260 0 0 {name=p95309 lab=_67981_/Y }
C {devices/lab_pin.sym} 95460 -3220 0 0 {name=p95310 lab=_67983_/X }
C {devices/lab_pin.sym} 95460 -3180 0 0 {name=p95311 lab=_67994_/Y }
C {devices/lab_pin.sym} 95620 -3240 0 1 {name=p95312 lab=_67995_/X }
C {sky130_stdcells/a211o_4.sym} 95540 -3240 0 0 {name=X_67995_ }
C {devices/lab_pin.sym} 95500 -3090 0 0 {name=p95313 lab=clkbuf_8_95_0_CLK/A }
C {devices/lab_pin.sym} 95580 -3090 0 1 {name=p95314 lab=clkbuf_8_94_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 95540 -3090 0 0 {name=Xclkbuf_8_94_0_CLK }
C {devices/lab_pin.sym} 95450 -2970 0 0 {name=p95315 lab=_86713_/CLK }
C {devices/lab_pin.sym} 95450 -2950 0 0 {name=p95316 lab=_84800_/D }
C {devices/lab_pin.sym} 95630 -2970 0 1 {name=p95317 lab=_84800_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -2960 0 0 {name=X_84800_ }
C {devices/lab_pin.sym} 95500 -2830 0 0 {name=p95318 lab=_69734_/A }
C {devices/lab_pin.sym} 95580 -2830 0 1 {name=p95319 lab=_69734_/Y }
C {sky130_stdcells/inv_2.sym} 95540 -2830 0 0 {name=X_69734_ }
C {devices/lab_pin.sym} 95460 -2730 0 0 {name=p95320 lab=_50081_/Y }
C {devices/lab_pin.sym} 95460 -2690 0 0 {name=p95321 lab=_50068_/X }
C {devices/lab_pin.sym} 95460 -2650 0 0 {name=p95322 lab=_50082_/X }
C {devices/lab_pin.sym} 95620 -2690 0 1 {name=p95323 lab=_50083_/Y }
C {sky130_stdcells/a21oi_4.sym} 95540 -2690 0 0 {name=X_50083_ }
C {devices/lab_pin.sym} 95460 -2570 0 0 {name=p95324 lab=_54958_/Y }
C {devices/lab_pin.sym} 95460 -2530 0 0 {name=p95325 lab=_54253_/X }
C {devices/lab_pin.sym} 95460 -2490 0 0 {name=p95326 lab=_54959_/X }
C {devices/lab_pin.sym} 95620 -2530 0 1 {name=p95327 lab=_85345_/D }
C {sky130_stdcells/a21oi_4.sym} 95540 -2530 0 0 {name=X_54960_ }
C {devices/lab_pin.sym} 95460 -2410 0 0 {name=p95328 lab=_80914_/D }
C {devices/lab_pin.sym} 95460 -2370 0 0 {name=p95329 lab=_66850_/X }
C {devices/lab_pin.sym} 95460 -2330 0 0 {name=p95330 lab=_66945_/X }
C {devices/lab_pin.sym} 95620 -2370 0 1 {name=p95331 lab=_66946_/X }
C {sky130_stdcells/a21bo_4.sym} 95540 -2370 0 0 {name=X_66946_ }
C {devices/lab_pin.sym} 95460 -2250 0 0 {name=p95332 lab=_62067_/Y }
C {devices/lab_pin.sym} 95460 -2210 0 0 {name=p95333 lab=_62033_/X }
C {devices/lab_pin.sym} 95460 -2170 0 0 {name=p95334 lab=_62068_/Y }
C {devices/lab_pin.sym} 95620 -2210 0 1 {name=p95335 lab=_62069_/Y }
C {sky130_stdcells/a21oi_4.sym} 95540 -2210 0 0 {name=X_62069_ }
C {devices/lab_pin.sym} 95450 -2070 0 0 {name=p95336 lab=_82956_/CLK }
C {devices/lab_pin.sym} 95450 -2050 0 0 {name=p95337 lab=_52650_/Y }
C {devices/lab_pin.sym} 95630 -2070 0 1 {name=p95338 lab=_85780_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -2060 0 0 {name=X_85780_ }
C {devices/lab_pin.sym} 95450 -1930 0 0 {name=p95339 lab=_85039_/CLK }
C {devices/lab_pin.sym} 95450 -1910 0 0 {name=p95340 lab=_74664_/Y }
C {devices/lab_pin.sym} 95630 -1930 0 1 {name=p95341 lab=_82992_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -1920 0 0 {name=X_82992_ }
C {devices/lab_pin.sym} 95460 -1810 0 0 {name=p95342 lab=_53909_/Y }
C {devices/lab_pin.sym} 95460 -1770 0 0 {name=p95343 lab=_53862_/X }
C {devices/lab_pin.sym} 95460 -1730 0 0 {name=p95344 lab=_53910_/Y }
C {devices/lab_pin.sym} 95620 -1770 0 1 {name=p95345 lab=_85544_/D }
C {sky130_stdcells/a21boi_4.sym} 95540 -1770 0 0 {name=X_53911_ }
C {devices/lab_pin.sym} 95450 -1630 0 0 {name=p95346 lab=_84732_/CLK }
C {devices/lab_pin.sym} 95450 -1610 0 0 {name=p95347 lab=_84731_/D }
C {devices/lab_pin.sym} 95630 -1630 0 1 {name=p95348 lab=_59443_/A }
C {sky130_stdcells/dfxtp_4.sym} 95540 -1620 0 0 {name=X_84731_ }
C {devices/lab_pin.sym} 95450 -1490 0 0 {name=p95349 lab=_82133_/CLK }
C {devices/lab_pin.sym} 95450 -1470 0 0 {name=p95350 lab=_81943_/D }
C {devices/lab_pin.sym} 95630 -1490 0 1 {name=p95351 lab=_81943_/Q }
C {sky130_stdcells/dfxtp_4.sym} 95540 -1480 0 0 {name=X_81943_ }
C {devices/lab_pin.sym} 95500 -1350 0 0 {name=p95352 lab=_69797_/A }
C {devices/lab_pin.sym} 95580 -1350 0 1 {name=p95353 lab=_69665_/X }
C {sky130_stdcells/buf_2.sym} 95540 -1350 0 0 {name=X_69665_ }
C {devices/lab_pin.sym} 95460 -1250 0 0 {name=p95354 lab=_54886_/Y }
C {devices/lab_pin.sym} 95460 -1210 0 0 {name=p95355 lab=_54882_/X }
C {devices/lab_pin.sym} 95460 -1170 0 0 {name=p95356 lab=_54890_/X }
C {devices/lab_pin.sym} 95620 -1210 0 1 {name=p95357 lab=_54891_/Y }
C {sky130_stdcells/a21oi_4.sym} 95540 -1210 0 0 {name=X_54891_ }
C {devices/lab_pin.sym} 95460 -1100 0 0 {name=p95358 lab=_87942_/Q }
C {devices/lab_pin.sym} 95460 -1060 0 0 {name=p95359 lab=_66875_/X }
C {devices/lab_pin.sym} 95460 -1020 0 0 {name=p95360 lab=_66807_/X }
C {devices/lab_pin.sym} 95460 -980 0 0 {name=p95361 lab=_66876_/X }
C {devices/lab_pin.sym} 95620 -1040 0 1 {name=p95362 lab=_66877_/X }
C {sky130_stdcells/a211o_4.sym} 95540 -1040 0 0 {name=X_66877_ }
C {devices/lab_pin.sym} 95500 -890 0 0 {name=p95363 lab=_56630_/A }
C {devices/lab_pin.sym} 95580 -890 0 1 {name=p95364 lab=_56630_/X }
C {sky130_stdcells/buf_2.sym} 95540 -890 0 0 {name=X_56630_ }
C {devices/lab_pin.sym} 95460 -800 0 0 {name=p95365 lab=_87593_/Q }
C {devices/lab_pin.sym} 95460 -760 0 0 {name=p95366 lab=_68463_/X }
C {devices/lab_pin.sym} 95460 -720 0 0 {name=p95367 lab=_68613_/X }
C {devices/lab_pin.sym} 95460 -680 0 0 {name=p95368 lab=_68615_/X }
C {devices/lab_pin.sym} 95620 -740 0 1 {name=p95369 lab=_68616_/X }
C {sky130_stdcells/a211o_4.sym} 95540 -740 0 0 {name=X_68616_ }
C {devices/lab_pin.sym} 96370 -42150 0 0 {name=p95370 lab=_87446_/CLK }
C {devices/lab_pin.sym} 96370 -42130 0 0 {name=p95371 lab=_87450_/D }
C {devices/lab_pin.sym} 96550 -42150 0 1 {name=p95372 lab=_87450_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -42140 0 0 {name=X_87450_ }
C {devices/lab_pin.sym} 96380 -42030 0 0 {name=p95373 lab=_85557_/Q }
C {devices/lab_pin.sym} 96380 -41990 0 0 {name=p95374 lab=_53816_/X }
C {devices/lab_pin.sym} 96380 -41950 0 0 {name=p95375 lab=_53841_/Y }
C {devices/lab_pin.sym} 96540 -41990 0 1 {name=p95376 lab=_53842_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -41990 0 0 {name=X_53842_ }
C {devices/lab_pin.sym} 96400 -41870 0 0 {name=p95377 lab=_65288_/X }
C {devices/lab_pin.sym} 96400 -41830 0 0 {name=p95378 lab=_65828_/B }
C {devices/lab_pin.sym} 96400 -41790 0 0 {name=p95379 lab=_65290_/X }
C {devices/lab_pin.sym} 96520 -41830 0 1 {name=p95380 lab=_65828_/Y }
C {sky130_stdcells/nand3_4.sym} 96460 -41830 0 0 {name=X_65828_ }
C {devices/lab_pin.sym} 96370 -41690 0 0 {name=p95381 lab=_84660_/CLK }
C {devices/lab_pin.sym} 96370 -41670 0 0 {name=p95382 lab=_84662_/D }
C {devices/lab_pin.sym} 96550 -41690 0 1 {name=p95383 lab=_60097_/C }
C {sky130_stdcells/dfxtp_4.sym} 96460 -41680 0 0 {name=X_84662_ }
C {devices/lab_pin.sym} 96370 -41550 0 0 {name=p95384 lab=_81857_/CLK }
C {devices/lab_pin.sym} 96370 -41530 0 0 {name=p95385 lab=_78065_/X }
C {devices/lab_pin.sym} 96550 -41550 0 1 {name=p95386 lab=_81842_/D }
C {sky130_stdcells/dfxtp_4.sym} 96460 -41540 0 0 {name=X_81874_ }
C {devices/lab_pin.sym} 96380 -41430 0 0 {name=p95387 lab=_69593_/X }
C {devices/lab_pin.sym} 96380 -41390 0 0 {name=p95388 lab=_69595_/X }
C {devices/lab_pin.sym} 96380 -41350 0 0 {name=p95389 lab=_69570_/X }
C {devices/lab_pin.sym} 96540 -41390 0 1 {name=p95390 lab=_69596_/X }
C {sky130_stdcells/a21o_4.sym} 96460 -41390 0 0 {name=X_69596_ }
C {devices/lab_pin.sym} 96370 -41250 0 0 {name=p95391 lab=_84815_/CLK }
C {devices/lab_pin.sym} 96370 -41230 0 0 {name=p95392 lab=_49365_/Y }
C {devices/lab_pin.sym} 96550 -41250 0 1 {name=p95393 lab=_86401_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -41240 0 0 {name=X_86401_ }
C {devices/lab_pin.sym} 96370 -41110 0 0 {name=p95394 lab=_83613_/CLK }
C {devices/lab_pin.sym} 96370 -41090 0 0 {name=p95395 lab=_71083_/Y }
C {devices/lab_pin.sym} 96550 -41110 0 1 {name=p95396 lab=_49005_/A }
C {sky130_stdcells/dfxtp_4.sym} 96460 -41100 0 0 {name=X_83613_ }
C {devices/lab_pin.sym} 96420 -40970 0 0 {name=p95397 lab=_56560_/X }
C {devices/lab_pin.sym} 96500 -40970 0 1 {name=p95398 lab=_56561_/X }
C {sky130_stdcells/buf_2.sym} 96460 -40970 0 0 {name=X_56561_ }
C {devices/lab_pin.sym} 96380 -40880 0 0 {name=p95399 lab=_87500_/Q }
C {devices/lab_pin.sym} 96380 -40840 0 0 {name=p95400 lab=_68472_/A }
C {devices/lab_pin.sym} 96380 -40800 0 0 {name=p95401 lab=_68545_/X }
C {devices/lab_pin.sym} 96380 -40760 0 0 {name=p95402 lab=_68546_/X }
C {devices/lab_pin.sym} 96540 -40820 0 1 {name=p95403 lab=_68547_/X }
C {sky130_stdcells/a211o_4.sym} 96460 -40820 0 0 {name=X_68547_ }
C {devices/lab_pin.sym} 96370 -40670 0 0 {name=p95404 lab=_80931_/CLK }
C {devices/lab_pin.sym} 96370 -40650 0 0 {name=p95405 lab=_80825_/D }
C {devices/lab_pin.sym} 96550 -40670 0 1 {name=p95406 lab=_80825_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -40660 0 0 {name=X_80825_ }
C {devices/lab_pin.sym} 96370 -40530 0 0 {name=p95407 lab=_86914_/CLK }
C {devices/lab_pin.sym} 96370 -40510 0 0 {name=p95408 lab=_87381_/D }
C {devices/lab_pin.sym} 96550 -40530 0 1 {name=p95409 lab=_87381_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -40520 0 0 {name=X_87381_ }
C {devices/lab_pin.sym} 96420 -40390 0 0 {name=p95410 lab=_53773_/A }
C {devices/lab_pin.sym} 96500 -40390 0 1 {name=p95411 lab=_53773_/X }
C {sky130_stdcells/buf_2.sym} 96460 -40390 0 0 {name=X_53773_ }
C {devices/lab_pin.sym} 96380 -40290 0 0 {name=p95412 lab=_65756_/Y }
C {devices/lab_pin.sym} 96380 -40250 0 0 {name=p95413 lab=_65757_/X }
C {devices/lab_pin.sym} 96380 -40210 0 0 {name=p95414 lab=_65758_/X }
C {devices/lab_pin.sym} 96540 -40250 0 1 {name=p95415 lab=_84180_/D }
C {sky130_stdcells/a21o_4.sym} 96460 -40250 0 0 {name=X_65759_ }
C {devices/lab_pin.sym} 96370 -40110 0 0 {name=p95416 lab=_82452_/CLK }
C {devices/lab_pin.sym} 96370 -40090 0 0 {name=p95417 lab=_60587_/Y }
C {devices/lab_pin.sym} 96550 -40110 0 1 {name=p95418 lab=_79133_/A }
C {sky130_stdcells/dfxtp_4.sym} 96460 -40100 0 0 {name=X_84593_ }
C {devices/lab_pin.sym} 96400 -40000 0 0 {name=p95419 lab=_50973_/X }
C {devices/lab_pin.sym} 96400 -39960 0 0 {name=p95420 lab=_50985_/B }
C {devices/lab_pin.sym} 96400 -39920 0 0 {name=p95421 lab=_50985_/C }
C {devices/lab_pin.sym} 96400 -39880 0 0 {name=p95422 lab=_46791_/X }
C {devices/lab_pin.sym} 96520 -39940 0 1 {name=p95423 lab=_50985_/X }
C {sky130_stdcells/and4_4.sym} 96460 -39940 0 0 {name=X_50985_ }
C {devices/lab_pin.sym} 96420 -39790 0 0 {name=p95424 lab=_58510_/A }
C {devices/lab_pin.sym} 96500 -39790 0 1 {name=p95425 lab=_58344_/B }
C {sky130_stdcells/buf_2.sym} 96460 -39790 0 0 {name=X_58300_ }
C {devices/lab_pin.sym} 96420 -39670 0 0 {name=p95426 lab=_55458_/X }
C {devices/lab_pin.sym} 96500 -39670 0 1 {name=p95427 lab=_55512_/X }
C {sky130_stdcells/buf_2.sym} 96460 -39670 0 0 {name=X_55512_ }
C {devices/lab_pin.sym} 96370 -39550 0 0 {name=p95428 lab=_86651_/CLK }
C {devices/lab_pin.sym} 96370 -39530 0 0 {name=p95429 lab=_86332_/D }
C {devices/lab_pin.sym} 96550 -39550 0 1 {name=p95430 lab=_86332_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -39540 0 0 {name=X_86332_ }
C {devices/lab_pin.sym} 96400 -39440 0 0 {name=p95431 lab=_52704_/A }
C {devices/lab_pin.sym} 96400 -39400 0 0 {name=p95432 lab=_52724_/B }
C {devices/lab_pin.sym} 96400 -39360 0 0 {name=p95433 lab=_52708_/X }
C {devices/lab_pin.sym} 96400 -39320 0 0 {name=p95434 lab=_52724_/D }
C {devices/lab_pin.sym} 96520 -39380 0 1 {name=p95435 lab=_52724_/X }
C {sky130_stdcells/and4_4.sym} 96460 -39380 0 0 {name=X_52724_ }
C {devices/lab_pin.sym} 96380 -39260 0 0 {name=p95436 lab=_84755_/Q }
C {devices/lab_pin.sym} 96380 -39220 0 0 {name=p95437 lab=_59268_/X }
C {devices/lab_pin.sym} 96380 -39180 0 0 {name=p95438 lab=_59272_/X }
C {devices/lab_pin.sym} 96380 -39140 0 0 {name=p95439 lab=_59279_/X }
C {devices/lab_pin.sym} 96540 -39200 0 1 {name=p95440 lab=_84755_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 96460 -39200 0 0 {name=X_59280_ }
C {devices/lab_pin.sym} 96370 -39050 0 0 {name=p95441 lab=_83544_/CLK }
C {devices/lab_pin.sym} 96370 -39030 0 0 {name=p95442 lab=_83544_/D }
C {devices/lab_pin.sym} 96550 -39050 0 1 {name=p95443 lab=_83544_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -39040 0 0 {name=X_83544_ }
C {devices/lab_pin.sym} 96400 -38930 0 0 {name=p95444 lab=_56487_/X }
C {devices/lab_pin.sym} 96400 -38890 0 0 {name=p95445 lab=_56484_/X }
C {devices/lab_pin.sym} 96400 -38850 0 0 {name=p95446 lab=_55896_/B }
C {devices/lab_pin.sym} 96520 -38890 0 1 {name=p95447 lab=_56492_/Y }
C {sky130_stdcells/nand3_4.sym} 96460 -38890 0 0 {name=X_56492_ }
C {devices/lab_pin.sym} 96370 -38750 0 0 {name=p95448 lab=_80804_/CLK }
C {devices/lab_pin.sym} 96370 -38730 0 0 {name=p95449 lab=_80756_/D }
C {devices/lab_pin.sym} 96550 -38750 0 1 {name=p95450 lab=_81132_/D }
C {sky130_stdcells/dfxtp_4.sym} 96460 -38740 0 0 {name=X_80756_ }
C {devices/lab_pin.sym} 96380 -38630 0 0 {name=p95451 lab=_68471_/X }
C {devices/lab_pin.sym} 96380 -38590 0 0 {name=p95452 lab=_68476_/X }
C {devices/lab_pin.sym} 96380 -38550 0 0 {name=p95453 lab=_68477_/X }
C {devices/lab_pin.sym} 96540 -38590 0 1 {name=p95454 lab=_68478_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -38590 0 0 {name=X_68478_ }
C {devices/lab_pin.sym} 96420 -38450 0 0 {name=p95455 lab=clkbuf_7_16_0_CLK/X }
C {devices/lab_pin.sym} 96500 -38450 0 1 {name=p95456 lab=clkbuf_9_65_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 96460 -38450 0 0 {name=Xclkbuf_8_32_0_CLK }
C {devices/lab_pin.sym} 96380 -38350 0 0 {name=p95457 lab=_46179_/X }
C {devices/lab_pin.sym} 96380 -38310 0 0 {name=p95458 lab=_58228_/X }
C {devices/lab_pin.sym} 96380 -38270 0 0 {name=p95459 lab=_58230_/Y }
C {devices/lab_pin.sym} 96540 -38310 0 1 {name=p95460 lab=_84902_/D }
C {sky130_stdcells/o21a_4.sym} 96460 -38310 0 0 {name=X_58231_ }
C {devices/lab_pin.sym} 96400 -38200 0 0 {name=p95461 lab=_55443_/A }
C {devices/lab_pin.sym} 96400 -38160 0 0 {name=p95462 lab=_55442_/Y }
C {devices/lab_pin.sym} 96400 -38120 0 0 {name=p95463 lab=_55443_/C }
C {devices/lab_pin.sym} 96400 -38080 0 0 {name=p95464 lab=_55443_/D }
C {devices/lab_pin.sym} 96520 -38140 0 1 {name=p95465 lab=_55443_/Y }
C {sky130_stdcells/nand4_4.sym} 96460 -38140 0 0 {name=X_55443_ }
C {devices/lab_pin.sym} 96400 -38000 0 0 {name=p95466 lab=_67381_/A }
C {devices/lab_pin.sym} 96400 -37960 0 0 {name=p95467 lab=_67429_/B }
C {devices/lab_pin.sym} 96520 -37980 0 1 {name=p95468 lab=_67429_/X }
C {sky130_stdcells/and2_4.sym} 96460 -37980 0 0 {name=X_67429_ }
C {devices/lab_pin.sym} 96370 -37850 0 0 {name=p95469 lab=_83305_/CLK }
C {devices/lab_pin.sym} 96370 -37830 0 0 {name=p95470 lab=_86263_/D }
C {devices/lab_pin.sym} 96550 -37850 0 1 {name=p95471 lab=_86263_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -37840 0 0 {name=X_86263_ }
C {devices/lab_pin.sym} 96380 -37730 0 0 {name=p95472 lab=_52652_/Y }
C {devices/lab_pin.sym} 96380 -37690 0 0 {name=p95473 lab=_52647_/X }
C {devices/lab_pin.sym} 96380 -37650 0 0 {name=p95474 lab=_52654_/X }
C {devices/lab_pin.sym} 96540 -37690 0 1 {name=p95475 lab=_85779_/D }
C {sky130_stdcells/a21oi_4.sym} 96460 -37690 0 0 {name=X_52655_ }
C {devices/lab_pin.sym} 96370 -37550 0 0 {name=p95476 lab=_83763_/CLK }
C {devices/lab_pin.sym} 96370 -37530 0 0 {name=p95477 lab=_71503_/X }
C {devices/lab_pin.sym} 96550 -37550 0 1 {name=p95478 lab=_83475_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -37540 0 0 {name=X_83475_ }
C {devices/lab_pin.sym} 96370 -37410 0 0 {name=p95479 lab=_80719_/CLK }
C {devices/lab_pin.sym} 96370 -37390 0 0 {name=p95480 lab=_80687_/D }
C {devices/lab_pin.sym} 96550 -37410 0 1 {name=p95481 lab=_75255_/A }
C {sky130_stdcells/dfxtp_4.sym} 96460 -37400 0 0 {name=X_80687_ }
C {sky130_stdcells/decap_3.sym} 96460 -37240 0 0 {name=XPHY_603 }
C {devices/lab_pin.sym} 96370 -37090 0 0 {name=p95482 lab=_88002_/CLK }
C {devices/lab_pin.sym} 96370 -37070 0 0 {name=p95483 lab=_88002_/D }
C {devices/lab_pin.sym} 96550 -37090 0 1 {name=p95484 lab=_88002_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -37080 0 0 {name=X_88002_ }
C {sky130_stdcells/decap_3.sym} 96460 -36920 0 0 {name=XPHY_614 }
C {devices/lab_pin.sym} 96370 -36770 0 0 {name=p95485 lab=_83001_/CLK }
C {devices/lab_pin.sym} 96370 -36750 0 0 {name=p95486 lab=_56387_/Y }
C {devices/lab_pin.sym} 96550 -36770 0 1 {name=p95487 lab=_56386_/C }
C {sky130_stdcells/dfxtp_4.sym} 96460 -36760 0 0 {name=X_85214_ }
C {devices/lab_pin.sym} 96380 -36650 0 0 {name=p95488 lab=_85979_/Q }
C {devices/lab_pin.sym} 96380 -36610 0 0 {name=p95489 lab=_51594_/X }
C {devices/lab_pin.sym} 96380 -36570 0 0 {name=p95490 lab=_51605_/Y }
C {devices/lab_pin.sym} 96540 -36610 0 1 {name=p95491 lab=_51606_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -36610 0 0 {name=X_51606_ }
C {devices/lab_pin.sym} 96420 -36470 0 0 {name=p95492 lab=_70997_/A }
C {devices/lab_pin.sym} 96500 -36470 0 1 {name=p95493 lab=_70949_/B }
C {sky130_stdcells/buf_2.sym} 96460 -36470 0 0 {name=X_70440_ }
C {devices/lab_pin.sym} 96420 -36350 0 0 {name=p95494 lab=_58162_/A }
C {devices/lab_pin.sym} 96500 -36350 0 1 {name=p95495 lab=_63054_/A }
C {sky130_stdcells/inv_2.sym} 96460 -36350 0 0 {name=X_58162_ }
C {sky130_stdcells/decap_3.sym} 96460 -36200 0 0 {name=XPHY_625 }
C {devices/lab_pin.sym} 96370 -36050 0 0 {name=p95496 lab=_82833_/CLK }
C {devices/lab_pin.sym} 96370 -36030 0 0 {name=p95497 lab=_82458_/Q }
C {devices/lab_pin.sym} 96550 -36050 0 1 {name=p95498 lab=_78661_/A }
C {sky130_stdcells/dfxtp_4.sym} 96460 -36040 0 0 {name=X_82426_ }
C {devices/lab_pin.sym} 96380 -35930 0 0 {name=p95499 lab=_55373_/Y }
C {devices/lab_pin.sym} 96380 -35890 0 0 {name=p95500 lab=_55298_/X }
C {devices/lab_pin.sym} 96380 -35850 0 0 {name=p95501 lab=_55201_/Y }
C {devices/lab_pin.sym} 96540 -35890 0 1 {name=p95502 lab=_55374_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -35890 0 0 {name=X_55374_ }
C {devices/lab_pin.sym} 96370 -35750 0 0 {name=p95503 lab=_83313_/CLK }
C {devices/lab_pin.sym} 96370 -35730 0 0 {name=p95504 lab=_50476_/Y }
C {devices/lab_pin.sym} 96550 -35750 0 1 {name=p95505 lab=_86194_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -35740 0 0 {name=X_86194_ }
C {sky130_stdcells/decap_3.sym} 96460 -35580 0 0 {name=XPHY_636 }
C {devices/lab_pin.sym} 96400 -35440 0 0 {name=p95506 lab=_52590_/A }
C {devices/lab_pin.sym} 96400 -35400 0 0 {name=p95507 lab=_54277_/B }
C {devices/lab_pin.sym} 96520 -35420 0 1 {name=p95508 lab=_52586_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -35420 0 0 {name=X_52586_ }
C {sky130_stdcells/decap_3.sym} 96460 -35260 0 0 {name=XPHY_647 }
C {sky130_stdcells/decap_3.sym} 96460 -35080 0 0 {name=XPHY_658 }
C {devices/lab_pin.sym} 96400 -34950 0 0 {name=p95509 lab=_56960_/X }
C {devices/lab_pin.sym} 96400 -34910 0 0 {name=p95510 lab=_57113_/B }
C {devices/lab_pin.sym} 96400 -34870 0 0 {name=p95511 lab=_57112_/X }
C {devices/lab_pin.sym} 96520 -34910 0 1 {name=p95512 lab=_57113_/Y }
C {sky130_stdcells/nor3_4.sym} 96460 -34910 0 0 {name=X_57113_ }
C {devices/lab_pin.sym} 96400 -34800 0 0 {name=p95513 lab=_54325_/A }
C {devices/lab_pin.sym} 96400 -34760 0 0 {name=p95514 lab=_54325_/B }
C {devices/lab_pin.sym} 96400 -34720 0 0 {name=p95515 lab=_54317_/X }
C {devices/lab_pin.sym} 96400 -34680 0 0 {name=p95516 lab=_54325_/D }
C {devices/lab_pin.sym} 96520 -34740 0 1 {name=p95517 lab=_54325_/X }
C {sky130_stdcells/and4_4.sym} 96460 -34740 0 0 {name=X_54325_ }
C {sky130_stdcells/decap_3.sym} 96460 -34560 0 0 {name=XPHY_669 }
C {devices/lab_pin.sym} 96370 -34410 0 0 {name=p95518 lab=_85057_/CLK }
C {devices/lab_pin.sym} 96370 -34390 0 0 {name=p95519 lab=_85145_/D }
C {devices/lab_pin.sym} 96550 -34410 0 1 {name=p95520 lab=_56614_/B }
C {sky130_stdcells/dfxtp_4.sym} 96460 -34400 0 0 {name=X_85145_ }
C {devices/lab_pin.sym} 96400 -34300 0 0 {name=p95521 lab=_51521_/X }
C {devices/lab_pin.sym} 96400 -34260 0 0 {name=p95522 lab=_51553_/B }
C {devices/lab_pin.sym} 96400 -34220 0 0 {name=p95523 lab=_51533_/C }
C {devices/lab_pin.sym} 96400 -34180 0 0 {name=p95524 lab=_53063_/D }
C {devices/lab_pin.sym} 96520 -34240 0 1 {name=p95525 lab=_51537_/X }
C {sky130_stdcells/and4_4.sym} 96460 -34240 0 0 {name=X_51537_ }
C {devices/lab_pin.sym} 96400 -34110 0 0 {name=p95526 lab=_70366_/X }
C {devices/lab_pin.sym} 96400 -34070 0 0 {name=p95527 lab=_70368_/X }
C {devices/lab_pin.sym} 96400 -34030 0 0 {name=p95528 lab=_70375_/C }
C {devices/lab_pin.sym} 96520 -34070 0 1 {name=p95529 lab=_70371_/Y }
C {sky130_stdcells/nand3_4.sym} 96460 -34070 0 0 {name=X_70371_ }
C {devices/lab_pin.sym} 96380 -33960 0 0 {name=p95530 lab=_84926_/Q }
C {devices/lab_pin.sym} 96380 -33920 0 0 {name=p95531 lab=_58025_/X }
C {devices/lab_pin.sym} 96380 -33880 0 0 {name=p95532 lab=_58084_/X }
C {devices/lab_pin.sym} 96380 -33840 0 0 {name=p95533 lab=_58092_/X }
C {devices/lab_pin.sym} 96540 -33900 0 1 {name=p95534 lab=_84926_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 96460 -33900 0 0 {name=X_58093_ }
C {devices/lab_pin.sym} 96370 -33750 0 0 {name=p95535 lab=_84981_/CLK }
C {devices/lab_pin.sym} 96370 -33730 0 0 {name=p95536 lab=_77191_/X }
C {devices/lab_pin.sym} 96550 -33750 0 1 {name=p95537 lab=_47963_/A }
C {sky130_stdcells/dfxtp_4.sym} 96460 -33740 0 0 {name=X_82357_ }
C {devices/lab_pin.sym} 96420 -33610 0 0 {name=p95538 lab=clkbuf_8_47_0_CLK/A }
C {devices/lab_pin.sym} 96500 -33610 0 1 {name=p95539 lab=clkbuf_9_94_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 96460 -33610 0 0 {name=Xclkbuf_8_47_0_CLK }
C {devices/lab_pin.sym} 96400 -33500 0 0 {name=p95540 lab=_72068_/A }
C {devices/lab_pin.sym} 96400 -33460 0 0 {name=p95541 lab=_53936_/B }
C {devices/lab_pin.sym} 96520 -33480 0 1 {name=p95542 lab=_72110_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -33480 0 0 {name=X_72110_ }
C {devices/lab_pin.sym} 96370 -33350 0 0 {name=p95543 lab=_81632_/CLK }
C {devices/lab_pin.sym} 96370 -33330 0 0 {name=p95544 lab=_76996_/X }
C {devices/lab_pin.sym} 96550 -33350 0 1 {name=p95545 lab=_81276_/D }
C {sky130_stdcells/dfxtp_4.sym} 96460 -33340 0 0 {name=X_81308_ }
C {devices/lab_pin.sym} 96380 -33230 0 0 {name=p95546 lab=_56930_/X }
C {devices/lab_pin.sym} 96380 -33190 0 0 {name=p95547 lab=_57040_/Y }
C {devices/lab_pin.sym} 96380 -33150 0 0 {name=p95548 lab=_57043_/Y }
C {devices/lab_pin.sym} 96540 -33190 0 1 {name=p95549 lab=_57044_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -33190 0 0 {name=X_57044_ }
C {devices/lab_pin.sym} 96380 -33080 0 0 {name=p95550 lab=_41503_/X }
C {devices/lab_pin.sym} 96380 -33040 0 0 {name=p95551 lab=_42258_/X }
C {devices/lab_pin.sym} 96380 -33000 0 0 {name=p95552 lab=_87947_/Q }
C {devices/lab_pin.sym} 96380 -32960 0 0 {name=p95553 lab=_42259_/X }
C {devices/lab_pin.sym} 96540 -33020 0 1 {name=p95554 lab=_87947_/D }
C {sky130_stdcells/a2bb2o_4.sym} 96460 -33020 0 0 {name=X_42270_ }
C {devices/lab_pin.sym} 96380 -32890 0 0 {name=p95555 lab=_54252_/Y }
C {devices/lab_pin.sym} 96380 -32850 0 0 {name=p95556 lab=_54253_/X }
C {devices/lab_pin.sym} 96380 -32810 0 0 {name=p95557 lab=_54255_/X }
C {devices/lab_pin.sym} 96540 -32850 0 1 {name=p95558 lab=_54256_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -32850 0 0 {name=X_54256_ }
C {devices/lab_pin.sym} 96400 -32720 0 0 {name=p95559 lab=_73132_/A }
C {devices/lab_pin.sym} 96400 -32680 0 0 {name=p95560 lab=_85877_/Q }
C {devices/lab_pin.sym} 96520 -32700 0 1 {name=p95561 lab=_73090_/X }
C {sky130_stdcells/and2_4.sym} 96460 -32700 0 0 {name=X_73090_ }
C {devices/lab_pin.sym} 96370 -32570 0 0 {name=p95562 lab=_85042_/CLK }
C {devices/lab_pin.sym} 96370 -32550 0 0 {name=p95563 lab=_85076_/D }
C {devices/lab_pin.sym} 96550 -32570 0 1 {name=p95564 lab=_45595_/A }
C {sky130_stdcells/dfxtp_4.sym} 96460 -32560 0 0 {name=X_85076_ }
C {devices/lab_pin.sym} 96380 -32450 0 0 {name=p95565 lab=_51465_/Y }
C {devices/lab_pin.sym} 96380 -32410 0 0 {name=p95566 lab=_51448_/X }
C {devices/lab_pin.sym} 96380 -32370 0 0 {name=p95567 lab=_51467_/X }
C {devices/lab_pin.sym} 96540 -32410 0 1 {name=p95568 lab=_86005_/D }
C {sky130_stdcells/a21oi_4.sym} 96460 -32410 0 0 {name=X_51468_ }
C {devices/lab_pin.sym} 96370 -32270 0 0 {name=p95569 lab=_82288_/CLK }
C {devices/lab_pin.sym} 96370 -32250 0 0 {name=p95570 lab=_82288_/D }
C {devices/lab_pin.sym} 96550 -32270 0 1 {name=p95571 lab=_40852_/B }
C {sky130_stdcells/dfxtp_4.sym} 96460 -32260 0 0 {name=X_82288_ }
C {devices/lab_pin.sym} 96380 -32170 0 0 {name=p95572 lab=_41205_/X }
C {devices/lab_pin.sym} 96380 -32130 0 0 {name=p95573 lab=_41206_/X }
C {devices/lab_pin.sym} 96380 -32090 0 0 {name=p95574 lab=_41220_/X }
C {devices/lab_pin.sym} 96380 -32050 0 0 {name=p95575 lab=_88255_/Q }
C {devices/lab_pin.sym} 96380 -32010 0 0 {name=p95576 lab=_41194_/X }
C {devices/lab_pin.sym} 96540 -32090 0 1 {name=p95577 lab=_41221_/Y }
C {sky130_stdcells/o32ai_4.sym} 96460 -32090 0 0 {name=X_41221_ }
C {devices/lab_pin.sym} 96400 -31960 0 0 {name=p95578 lab=_53211_/A }
C {devices/lab_pin.sym} 96400 -31920 0 0 {name=p95579 lab=_53211_/B }
C {devices/lab_pin.sym} 96400 -31880 0 0 {name=p95580 lab=_53195_/X }
C {devices/lab_pin.sym} 96400 -31840 0 0 {name=p95581 lab=_53207_/D }
C {devices/lab_pin.sym} 96520 -31900 0 1 {name=p95582 lab=_53207_/X }
C {sky130_stdcells/and4_4.sym} 96460 -31900 0 0 {name=X_53207_ }
C {devices/lab_pin.sym} 96380 -31770 0 0 {name=p95583 lab=_83296_/Q }
C {devices/lab_pin.sym} 96380 -31730 0 0 {name=p95584 lab=_72001_/X }
C {devices/lab_pin.sym} 96380 -31690 0 0 {name=p95585 lab=_72040_/Y }
C {devices/lab_pin.sym} 96540 -31730 0 1 {name=p95586 lab=_72041_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -31730 0 0 {name=X_72041_ }
C {devices/lab_pin.sym} 96370 -31590 0 0 {name=p95587 lab=_82067_/CLK }
C {devices/lab_pin.sym} 96370 -31570 0 0 {name=p95588 lab=_68147_/X }
C {devices/lab_pin.sym} 96550 -31590 0 1 {name=p95589 lab=_82067_/D }
C {sky130_stdcells/dfxtp_4.sym} 96460 -31580 0 0 {name=X_84027_ }
C {devices/lab_pin.sym} 96400 -31460 0 0 {name=p95590 lab=_50481_/A }
C {devices/lab_pin.sym} 96400 -31420 0 0 {name=p95591 lab=_52121_/B }
C {devices/lab_pin.sym} 96520 -31440 0 1 {name=p95592 lab=_50419_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -31440 0 0 {name=X_50419_ }
C {devices/lab_pin.sym} 96370 -31310 0 0 {name=p95593 lab=_85335_/CLK }
C {devices/lab_pin.sym} 96370 -31290 0 0 {name=p95594 lab=_81047_/Q }
C {devices/lab_pin.sym} 96550 -31310 0 1 {name=p95595 lab=_81239_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -31300 0 0 {name=X_81239_ }
C {devices/lab_pin.sym} 96380 -31190 0 0 {name=p95596 lab=_54185_/Y }
C {devices/lab_pin.sym} 96380 -31150 0 0 {name=p95597 lab=_54171_/X }
C {devices/lab_pin.sym} 96380 -31110 0 0 {name=p95598 lab=_54186_/X }
C {devices/lab_pin.sym} 96540 -31150 0 1 {name=p95599 lab=_54187_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -31150 0 0 {name=X_54187_ }
C {devices/lab_pin.sym} 96380 -31030 0 0 {name=p95600 lab=_86017_/Q }
C {devices/lab_pin.sym} 96380 -30990 0 0 {name=p95601 lab=_51209_/X }
C {devices/lab_pin.sym} 96380 -30950 0 0 {name=p95602 lab=_51398_/Y }
C {devices/lab_pin.sym} 96540 -30990 0 1 {name=p95603 lab=_51399_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -30990 0 0 {name=X_51399_ }
C {devices/lab_pin.sym} 96420 -30850 0 0 {name=p95604 lab=_53112_/A }
C {devices/lab_pin.sym} 96500 -30850 0 1 {name=p95605 lab=_53139_/A }
C {sky130_stdcells/buf_2.sym} 96460 -30850 0 0 {name=X_53138_ }
C {devices/lab_pin.sym} 96420 -30730 0 0 {name=p95606 lab=_40941_/A }
C {devices/lab_pin.sym} 96500 -30730 0 1 {name=p95607 lab=_41152_/X }
C {sky130_stdcells/buf_2.sym} 96460 -30730 0 0 {name=X_41152_ }
C {devices/lab_pin.sym} 96380 -30630 0 0 {name=p95608 lab=_58334_/X }
C {devices/lab_pin.sym} 96380 -30590 0 0 {name=p95609 lab=_58993_/Y }
C {devices/lab_pin.sym} 96380 -30550 0 0 {name=p95610 lab=_58994_/Y }
C {devices/lab_pin.sym} 96540 -30590 0 1 {name=p95611 lab=_58995_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -30590 0 0 {name=X_58995_ }
C {devices/lab_pin.sym} 96400 -30460 0 0 {name=p95612 lab=_75800_/A }
C {devices/lab_pin.sym} 96400 -30420 0 0 {name=p95613 lab=_75800_/B }
C {devices/lab_pin.sym} 96520 -30440 0 1 {name=p95614 lab=_80891_/D }
C {sky130_stdcells/xnor2_4.sym} 96460 -30440 0 0 {name=X_75800_ }
C {devices/lab_pin.sym} 96380 -30350 0 0 {name=p95615 lab=_45954_/X }
C {devices/lab_pin.sym} 96380 -30310 0 0 {name=p95616 lab=_74831_/A }
C {devices/lab_pin.sym} 96380 -30270 0 0 {name=p95617 lab=_45933_/Y }
C {devices/lab_pin.sym} 96380 -30230 0 0 {name=p95618 lab=_45958_/X }
C {devices/lab_pin.sym} 96380 -30190 0 0 {name=p95619 lab=_45959_/X }
C {devices/lab_pin.sym} 96540 -30270 0 1 {name=p95620 lab=_45961_/A }
C {sky130_stdcells/a32o_4.sym} 96460 -30270 0 0 {name=X_45960_ }
C {devices/lab_pin.sym} 96380 -30150 0 0 {name=p95621 lab=_41040_/X }
C {devices/lab_pin.sym} 96380 -30110 0 0 {name=p95622 lab=_41041_/X }
C {devices/lab_pin.sym} 96380 -30070 0 0 {name=p95623 lab=_41082_/X }
C {devices/lab_pin.sym} 96380 -30030 0 0 {name=p95624 lab=_88281_/Q }
C {devices/lab_pin.sym} 96380 -29990 0 0 {name=p95625 lab=_41037_/X }
C {devices/lab_pin.sym} 96540 -30070 0 1 {name=p95626 lab=_41084_/A }
C {sky130_stdcells/o32ai_4.sym} 96460 -30070 0 0 {name=X_41083_ }
C {devices/lab_pin.sym} 96420 -29910 0 0 {name=p95627 lab=_53069_/A }
C {devices/lab_pin.sym} 96500 -29910 0 1 {name=p95628 lab=_53069_/X }
C {sky130_stdcells/buf_2.sym} 96460 -29910 0 0 {name=X_53069_ }
C {devices/lab_pin.sym} 96380 -29810 0 0 {name=p95629 lab=_57760_/X }
C {devices/lab_pin.sym} 96380 -29770 0 0 {name=p95630 lab=_85393_/Q }
C {devices/lab_pin.sym} 96380 -29730 0 0 {name=p95631 lab=_57945_/X }
C {devices/lab_pin.sym} 96540 -29770 0 1 {name=p95632 lab=_57946_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -29770 0 0 {name=X_57946_ }
C {devices/lab_pin.sym} 96380 -29650 0 0 {name=p95633 lab=_81487_/Q }
C {devices/lab_pin.sym} 96380 -29610 0 0 {name=p95634 lab=_81359_/D }
C {devices/lab_pin.sym} 96380 -29570 0 0 {name=p95635 lab=_76779_/X }
C {devices/lab_pin.sym} 96540 -29610 0 1 {name=p95636 lab=_76780_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -29610 0 0 {name=X_76780_ }
C {devices/lab_pin.sym} 96380 -29490 0 0 {name=p95637 lab=_73985_/Y }
C {devices/lab_pin.sym} 96380 -29450 0 0 {name=p95638 lab=_73986_/Y }
C {devices/lab_pin.sym} 96380 -29410 0 0 {name=p95639 lab=_73991_/X }
C {devices/lab_pin.sym} 96540 -29450 0 1 {name=p95640 lab=_73992_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -29450 0 0 {name=X_73992_ }
C {devices/lab_pin.sym} 96370 -29310 0 0 {name=p95641 lab=_85974_/CLK }
C {devices/lab_pin.sym} 96370 -29290 0 0 {name=p95642 lab=_85978_/D }
C {devices/lab_pin.sym} 96550 -29310 0 1 {name=p95643 lab=_85978_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -29300 0 0 {name=X_85978_ }
C {devices/lab_pin.sym} 96420 -29170 0 0 {name=p95644 lab=_45824_/B }
C {devices/lab_pin.sym} 96500 -29170 0 1 {name=p95645 lab=_44911_/X }
C {sky130_stdcells/buf_2.sym} 96460 -29170 0 0 {name=X_44911_ }
C {devices/lab_pin.sym} 96400 -29060 0 0 {name=p95646 lab=_81011_/Q }
C {devices/lab_pin.sym} 96400 -29020 0 0 {name=p95647 lab=_75731_/B }
C {devices/lab_pin.sym} 96520 -29040 0 1 {name=p95648 lab=_75731_/X }
C {sky130_stdcells/xor2_4.sym} 96460 -29040 0 0 {name=X_75731_ }
C {devices/lab_pin.sym} 96370 -28910 0 0 {name=p95649 lab=_87394_/CLK }
C {devices/lab_pin.sym} 96370 -28890 0 0 {name=p95650 lab=_42790_/X }
C {devices/lab_pin.sym} 96550 -28910 0 1 {name=p95651 lab=_87717_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -28900 0 0 {name=X_87717_ }
C {devices/lab_pin.sym} 96420 -28770 0 0 {name=p95652 lab=_72943_/A }
C {devices/lab_pin.sym} 96500 -28770 0 1 {name=p95653 lab=_72943_/X }
C {sky130_stdcells/buf_2.sym} 96460 -28770 0 0 {name=X_72943_ }
C {devices/lab_pin.sym} 96370 -28650 0 0 {name=p95654 lab=_85379_/CLK }
C {devices/lab_pin.sym} 96370 -28630 0 0 {name=p95655 lab=_84929_/D }
C {devices/lab_pin.sym} 96550 -28650 0 1 {name=p95656 lab=_84929_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -28640 0 0 {name=X_84929_ }
C {devices/lab_pin.sym} 96380 -28530 0 0 {name=p95657 lab=_57875_/X }
C {devices/lab_pin.sym} 96380 -28490 0 0 {name=p95658 lab=_85399_/Q }
C {devices/lab_pin.sym} 96380 -28450 0 0 {name=p95659 lab=_57876_/X }
C {devices/lab_pin.sym} 96540 -28490 0 1 {name=p95660 lab=_57877_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -28490 0 0 {name=X_57877_ }
C {devices/lab_pin.sym} 96420 -28350 0 0 {name=p95661 lab=_45890_/X }
C {devices/lab_pin.sym} 96500 -28350 0 1 {name=p95662 lab=_45891_/X }
C {sky130_stdcells/buf_2.sym} 96460 -28350 0 0 {name=X_45891_ }
C {devices/lab_pin.sym} 96380 -28250 0 0 {name=p95663 lab=_47625_/Y }
C {devices/lab_pin.sym} 96380 -28210 0 0 {name=p95664 lab=_47602_/X }
C {devices/lab_pin.sym} 96380 -28170 0 0 {name=p95665 lab=_47629_/X }
C {devices/lab_pin.sym} 96540 -28210 0 1 {name=p95666 lab=_47630_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -28210 0 0 {name=X_47630_ }
C {devices/lab_pin.sym} 96400 -28080 0 0 {name=p95667 lab=_44008_/A }
C {devices/lab_pin.sym} 96400 -28040 0 0 {name=p95668 lab=_61078_/B }
C {devices/lab_pin.sym} 96520 -28060 0 1 {name=p95669 lab=_59893_/C }
C {sky130_stdcells/nor2_4.sym} 96460 -28060 0 0 {name=X_59616_ }
C {devices/lab_pin.sym} 96400 -27950 0 0 {name=p95670 lab=_78450_/A }
C {devices/lab_pin.sym} 96400 -27910 0 0 {name=p95671 lab=_78450_/B }
C {devices/lab_pin.sym} 96400 -27870 0 0 {name=p95672 lab=_78450_/C }
C {devices/lab_pin.sym} 96520 -27910 0 1 {name=p95673 lab=_78450_/Y }
C {sky130_stdcells/nor3_4.sym} 96460 -27910 0 0 {name=X_78450_ }
C {devices/lab_pin.sym} 96380 -27800 0 0 {name=p95674 lab=_41727_/A }
C {devices/lab_pin.sym} 96380 -27760 0 0 {name=p95675 lab=_44838_/X }
C {devices/lab_pin.sym} 96380 -27720 0 0 {name=p95676 lab=_67773_/B }
C {devices/lab_pin.sym} 96380 -27680 0 0 {name=p95677 lab=_44839_/X }
C {devices/lab_pin.sym} 96540 -27740 0 1 {name=p95678 lab=_44842_/X }
C {sky130_stdcells/a2bb2o_4.sym} 96460 -27740 0 0 {name=X_44842_ }
C {devices/lab_pin.sym} 96380 -27610 0 0 {name=p95679 lab=_56756_/X }
C {devices/lab_pin.sym} 96380 -27570 0 0 {name=p95680 lab=_56788_/X }
C {devices/lab_pin.sym} 96380 -27530 0 0 {name=p95681 lab=_56732_/X }
C {devices/lab_pin.sym} 96540 -27570 0 1 {name=p95682 lab=_56828_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -27570 0 0 {name=X_56828_ }
C {devices/lab_pin.sym} 96370 -27430 0 0 {name=p95683 lab=_87646_/CLK }
C {devices/lab_pin.sym} 96370 -27410 0 0 {name=p95684 lab=_87648_/D }
C {devices/lab_pin.sym} 96550 -27430 0 1 {name=p95685 lab=_87648_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -27420 0 0 {name=X_87648_ }
C {devices/lab_pin.sym} 96420 -27290 0 0 {name=p95686 lab=_75637_/Y }
C {devices/lab_pin.sym} 96500 -27290 0 1 {name=p95687 lab=_75662_/Y }
C {sky130_stdcells/inv_2.sym} 96460 -27290 0 0 {name=X_75662_ }
C {devices/lab_pin.sym} 96400 -27180 0 0 {name=p95688 lab=_72874_/A }
C {devices/lab_pin.sym} 96400 -27140 0 0 {name=p95689 lab=_65489_/B }
C {devices/lab_pin.sym} 96520 -27160 0 1 {name=p95690 lab=_72874_/X }
C {sky130_stdcells/and2_4.sym} 96460 -27160 0 0 {name=X_72874_ }
C {devices/lab_pin.sym} 96380 -27050 0 0 {name=p95691 lab=_77387_/X }
C {devices/lab_pin.sym} 96380 -27010 0 0 {name=p95692 lab=_77399_/Y }
C {devices/lab_pin.sym} 96380 -26970 0 0 {name=p95693 lab=_77400_/Y }
C {devices/lab_pin.sym} 96540 -27010 0 1 {name=p95694 lab=_77401_/X }
C {sky130_stdcells/a21o_4.sym} 96460 -27010 0 0 {name=X_77401_ }
C {devices/lab_pin.sym} 96420 -26870 0 0 {name=p95695 lab=_74552_/X }
C {devices/lab_pin.sym} 96500 -26870 0 1 {name=p95696 lab=_74613_/X }
C {sky130_stdcells/buf_2.sym} 96460 -26870 0 0 {name=X_74613_ }
C {devices/lab_pin.sym} 96420 -26750 0 0 {name=p95697 lab=_47561_/A }
C {devices/lab_pin.sym} 96500 -26750 0 1 {name=p95698 lab=_47561_/Y }
C {sky130_stdcells/inv_2.sym} 96460 -26750 0 0 {name=X_47561_ }
C {devices/lab_pin.sym} 96420 -26630 0 0 {name=p95699 lab=_71824_/Y }
C {devices/lab_pin.sym} 96500 -26630 0 1 {name=p95700 lab=_71825_/X }
C {sky130_stdcells/buf_2.sym} 96460 -26630 0 0 {name=X_71825_ }
C {devices/lab_pin.sym} 96400 -26530 0 0 {name=p95701 lab=_59564_/A }
C {devices/lab_pin.sym} 96400 -26490 0 0 {name=p95702 lab=_59562_/B }
C {devices/lab_pin.sym} 96400 -26450 0 0 {name=p95703 lab=_59741_/C }
C {devices/lab_pin.sym} 96520 -26490 0 1 {name=p95704 lab=_60183_/A }
C {sky130_stdcells/nand3_4.sym} 96460 -26490 0 0 {name=X_59547_ }
C {devices/lab_pin.sym} 96380 -26370 0 0 {name=p95705 lab=_78363_/Y }
C {devices/lab_pin.sym} 96380 -26330 0 0 {name=p95706 lab=_78369_/B }
C {devices/lab_pin.sym} 96380 -26290 0 0 {name=p95707 lab=_78365_/A }
C {devices/lab_pin.sym} 96540 -26330 0 1 {name=p95708 lab=_78382_/B }
C {sky130_stdcells/o21ai_4.sym} 96460 -26330 0 0 {name=X_78381_ }
C {devices/lab_pin.sym} 96380 -26220 0 0 {name=p95709 lab=_41351_/Y }
C {devices/lab_pin.sym} 96380 -26180 0 0 {name=p95710 lab=_44754_/X }
C {devices/lab_pin.sym} 96380 -26140 0 0 {name=p95711 lab=_86963_/Q }
C {devices/lab_pin.sym} 96380 -26100 0 0 {name=p95712 lab=_44755_/X }
C {devices/lab_pin.sym} 96540 -26160 0 1 {name=p95713 lab=_86963_/D }
C {sky130_stdcells/a2bb2o_4.sym} 96460 -26160 0 0 {name=X_44773_ }
C {devices/lab_pin.sym} 96420 -26010 0 0 {name=p95714 lab=_83336_/Q }
C {devices/lab_pin.sym} 96500 -26010 0 1 {name=p95715 lab=_56759_/X }
C {sky130_stdcells/buf_2.sym} 96460 -26010 0 0 {name=X_56759_ }
C {devices/lab_pin.sym} 96380 -25910 0 0 {name=p95716 lab=_75590_/X }
C {devices/lab_pin.sym} 96380 -25870 0 0 {name=p95717 lab=_75591_/Y }
C {devices/lab_pin.sym} 96380 -25830 0 0 {name=p95718 lab=_75594_/B }
C {devices/lab_pin.sym} 96540 -25870 0 1 {name=p95719 lab=_75595_/A }
C {sky130_stdcells/a21o_4.sym} 96460 -25870 0 0 {name=X_75593_ }
C {devices/lab_pin.sym} 96370 -25730 0 0 {name=p95720 lab=_88108_/CLK }
C {devices/lab_pin.sym} 96370 -25710 0 0 {name=p95721 lab=_87579_/D }
C {devices/lab_pin.sym} 96550 -25730 0 1 {name=p95722 lab=_74123_/A }
C {sky130_stdcells/dfxtp_4.sym} 96460 -25720 0 0 {name=X_87579_ }
C {devices/lab_pin.sym} 96380 -25630 0 0 {name=p95723 lab=_41982_/X }
C {devices/lab_pin.sym} 96380 -25590 0 0 {name=p95724 lab=_41975_/X }
C {devices/lab_pin.sym} 96380 -25550 0 0 {name=p95725 lab=_40771_/X }
C {devices/lab_pin.sym} 96380 -25510 0 0 {name=p95726 lab=_41983_/Y }
C {devices/lab_pin.sym} 96380 -25470 0 0 {name=p95727 lab=_41984_/X }
C {devices/lab_pin.sym} 96540 -25550 0 1 {name=p95728 lab=_41985_/Y }
C {sky130_stdcells/o32ai_4.sym} 96460 -25550 0 0 {name=X_41985_ }
C {devices/lab_pin.sym} 96420 -25390 0 0 {name=p95729 lab=_49415_/A }
C {devices/lab_pin.sym} 96500 -25390 0 1 {name=p95730 lab=_49300_/X }
C {sky130_stdcells/buf_2.sym} 96460 -25390 0 0 {name=X_49300_ }
C {devices/lab_pin.sym} 96400 -25280 0 0 {name=p95731 lab=_46434_/A }
C {devices/lab_pin.sym} 96400 -25240 0 0 {name=p95732 lab=_49320_/B }
C {devices/lab_pin.sym} 96520 -25260 0 1 {name=p95733 lab=_46512_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -25260 0 0 {name=X_46512_ }
C {devices/lab_pin.sym} 96400 -25150 0 0 {name=p95734 lab=_77327_/Y }
C {devices/lab_pin.sym} 96400 -25110 0 0 {name=p95735 lab=_77329_/Y }
C {devices/lab_pin.sym} 96400 -25070 0 0 {name=p95736 lab=_77332_/C }
C {devices/lab_pin.sym} 96520 -25110 0 1 {name=p95737 lab=_77333_/A }
C {sky130_stdcells/nand3_4.sym} 96460 -25110 0 0 {name=X_77332_ }
C {devices/lab_pin.sym} 96420 -24970 0 0 {name=p95738 lab=_43724_/A }
C {devices/lab_pin.sym} 96500 -24970 0 1 {name=p95739 lab=_69838_/B }
C {sky130_stdcells/inv_2.sym} 96460 -24970 0 0 {name=X_43724_ }
C {devices/lab_pin.sym} 96380 -24870 0 0 {name=p95740 lab=_56004_/X }
C {devices/lab_pin.sym} 96380 -24830 0 0 {name=p95741 lab=_74538_/Y }
C {devices/lab_pin.sym} 96380 -24790 0 0 {name=p95742 lab=_74543_/Y }
C {devices/lab_pin.sym} 96540 -24830 0 1 {name=p95743 lab=_83040_/D }
C {sky130_stdcells/o21ai_4.sym} 96460 -24830 0 0 {name=X_74544_ }
C {devices/lab_pin.sym} 96380 -24720 0 0 {name=p95744 lab=_40935_/X }
C {devices/lab_pin.sym} 96380 -24680 0 0 {name=p95745 lab=_40904_/X }
C {devices/lab_pin.sym} 96380 -24640 0 0 {name=p95746 lab=_88307_/Q }
C {devices/lab_pin.sym} 96380 -24600 0 0 {name=p95747 lab=_40905_/X }
C {devices/lab_pin.sym} 96540 -24660 0 1 {name=p95748 lab=_40936_/X }
C {sky130_stdcells/a2bb2o_4.sym} 96460 -24660 0 0 {name=X_40936_ }
C {devices/lab_pin.sym} 96380 -24530 0 0 {name=p95749 lab=_58097_/A }
C {devices/lab_pin.sym} 96380 -24490 0 0 {name=p95750 lab=_47478_/X }
C {devices/lab_pin.sym} 96380 -24450 0 0 {name=p95751 lab=_47491_/Y }
C {devices/lab_pin.sym} 96540 -24490 0 1 {name=p95752 lab=_47492_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -24490 0 0 {name=X_47492_ }
C {devices/lab_pin.sym} 96400 -24380 0 0 {name=p95753 lab=_71183_/A }
C {devices/lab_pin.sym} 96400 -24340 0 0 {name=p95754 lab=_71753_/B }
C {devices/lab_pin.sym} 96400 -24300 0 0 {name=p95755 lab=_71755_/X }
C {devices/lab_pin.sym} 96400 -24260 0 0 {name=p95756 lab=_71753_/D }
C {devices/lab_pin.sym} 96520 -24320 0 1 {name=p95757 lab=_71756_/Y }
C {sky130_stdcells/nand4_4.sym} 96460 -24320 0 0 {name=X_71756_ }
C {devices/lab_pin.sym} 96400 -24180 0 0 {name=p95758 lab=_59478_/A }
C {devices/lab_pin.sym} 96400 -24140 0 0 {name=p95759 lab=_59478_/B }
C {devices/lab_pin.sym} 96520 -24160 0 1 {name=p95760 lab=_59478_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -24160 0 0 {name=X_59478_ }
C {devices/lab_pin.sym} 96380 -24050 0 0 {name=p95761 lab=_49229_/Y }
C {devices/lab_pin.sym} 96380 -24010 0 0 {name=p95762 lab=_49189_/X }
C {devices/lab_pin.sym} 96380 -23970 0 0 {name=p95763 lab=_49230_/X }
C {devices/lab_pin.sym} 96540 -24010 0 1 {name=p95764 lab=_86429_/D }
C {sky130_stdcells/a21oi_4.sym} 96460 -24010 0 0 {name=X_49231_ }
C {devices/lab_pin.sym} 96420 -23870 0 0 {name=p95765 lab=_70721_/A }
C {devices/lab_pin.sym} 96500 -23870 0 1 {name=p95766 lab=_70710_/D }
C {sky130_stdcells/buf_2.sym} 96460 -23870 0 0 {name=X_70707_ }
C {devices/lab_pin.sym} 96400 -23760 0 0 {name=p95767 lab=_46421_/A }
C {devices/lab_pin.sym} 96400 -23720 0 0 {name=p95768 lab=_51320_/B }
C {devices/lab_pin.sym} 96520 -23740 0 1 {name=p95769 lab=_46443_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -23740 0 0 {name=X_46443_ }
C {devices/lab_pin.sym} 96420 -23610 0 0 {name=p95770 lab=_84850_/Q }
C {devices/lab_pin.sym} 96500 -23610 0 1 {name=p95771 lab=_58429_/Y }
C {sky130_stdcells/inv_2.sym} 96460 -23610 0 0 {name=X_58429_ }
C {devices/lab_pin.sym} 96400 -23500 0 0 {name=p95772 lab=_77265_/A }
C {devices/lab_pin.sym} 96400 -23460 0 0 {name=p95773 lab=_77265_/B }
C {devices/lab_pin.sym} 96520 -23480 0 1 {name=p95774 lab=_77264_/A }
C {sky130_stdcells/nor2_4.sym} 96460 -23480 0 0 {name=X_77263_ }
C {devices/lab_pin.sym} 96420 -23350 0 0 {name=p95775 lab=_43602_/X }
C {devices/lab_pin.sym} 96500 -23350 0 1 {name=p95776 lab=_43685_/A }
C {sky130_stdcells/buf_2.sym} 96460 -23350 0 0 {name=X_43655_ }
C {devices/lab_pin.sym} 96420 -23230 0 0 {name=p95777 lab=_46280_/A }
C {devices/lab_pin.sym} 96500 -23230 0 1 {name=p95778 lab=_74490_/A }
C {sky130_stdcells/buf_2.sym} 96460 -23230 0 0 {name=X_74475_ }
C {devices/lab_pin.sym} 96420 -23110 0 0 {name=p95779 lab=_40832_/A }
C {devices/lab_pin.sym} 96500 -23110 0 1 {name=p95780 lab=_40867_/X }
C {sky130_stdcells/buf_2.sym} 96460 -23110 0 0 {name=X_40867_ }
C {devices/lab_pin.sym} 96380 -23010 0 0 {name=p95781 lab=_58493_/Y }
C {devices/lab_pin.sym} 96380 -22970 0 0 {name=p95782 lab=_71669_/A }
C {devices/lab_pin.sym} 96380 -22930 0 0 {name=p95783 lab=_71686_/Y }
C {devices/lab_pin.sym} 96540 -22970 0 1 {name=p95784 lab=_83411_/D }
C {sky130_stdcells/o21ai_4.sym} 96460 -22970 0 0 {name=X_71687_ }
C {devices/lab_pin.sym} 96420 -22830 0 0 {name=p95785 lab=_82648_/Q }
C {devices/lab_pin.sym} 96500 -22830 0 1 {name=p95786 lab=_79002_/Y }
C {sky130_stdcells/inv_2.sym} 96460 -22830 0 0 {name=X_79002_ }
C {devices/lab_pin.sym} 96400 -22720 0 0 {name=p95787 lab=_81255_/Q }
C {devices/lab_pin.sym} 96400 -22680 0 0 {name=p95788 lab=_81511_/D }
C {devices/lab_pin.sym} 96520 -22700 0 1 {name=p95789 lab=_76215_/A }
C {sky130_stdcells/nor2_4.sym} 96460 -22700 0 0 {name=X_76214_ }
C {devices/lab_pin.sym} 96380 -22610 0 0 {name=p95790 lab=_42590_/X }
C {devices/lab_pin.sym} 96380 -22570 0 0 {name=p95791 lab=_42592_/X }
C {devices/lab_pin.sym} 96380 -22530 0 0 {name=p95792 lab=_40894_/X }
C {devices/lab_pin.sym} 96380 -22490 0 0 {name=p95793 lab=_69882_/A }
C {devices/lab_pin.sym} 96380 -22450 0 0 {name=p95794 lab=_42597_/X }
C {devices/lab_pin.sym} 96540 -22530 0 1 {name=p95795 lab=_42607_/A }
C {sky130_stdcells/o32ai_4.sym} 96460 -22530 0 0 {name=X_42606_ }
C {devices/lab_pin.sym} 96380 -22390 0 0 {name=p95796 lab=_49128_/X }
C {devices/lab_pin.sym} 96380 -22350 0 0 {name=p95797 lab=_48664_/A }
C {devices/lab_pin.sym} 96380 -22310 0 0 {name=p95798 lab=_49161_/Y }
C {devices/lab_pin.sym} 96540 -22350 0 1 {name=p95799 lab=_49163_/A }
C {sky130_stdcells/a21o_4.sym} 96460 -22350 0 0 {name=X_49162_ }
C {devices/lab_pin.sym} 96400 -22240 0 0 {name=p95800 lab=_61440_/A }
C {devices/lab_pin.sym} 96400 -22200 0 0 {name=p95801 lab=_61404_/X }
C {devices/lab_pin.sym} 96400 -22160 0 0 {name=p95802 lab=_61406_/C }
C {devices/lab_pin.sym} 96400 -22120 0 0 {name=p95803 lab=_61390_/D }
C {devices/lab_pin.sym} 96520 -22180 0 1 {name=p95804 lab=_61440_/Y }
C {sky130_stdcells/nand4_4.sym} 96460 -22180 0 0 {name=X_61440_ }
C {devices/lab_pin.sym} 96400 -22040 0 0 {name=p95805 lab=_73426_/A }
C {devices/lab_pin.sym} 96400 -22000 0 0 {name=p95806 lab=_86471_/Q }
C {devices/lab_pin.sym} 96520 -22020 0 1 {name=p95807 lab=_73426_/X }
C {sky130_stdcells/and2_4.sym} 96460 -22020 0 0 {name=X_73426_ }
C {devices/lab_pin.sym} 96400 -21900 0 0 {name=p95808 lab=_46362_/A }
C {devices/lab_pin.sym} 96400 -21860 0 0 {name=p95809 lab=_53993_/B }
C {devices/lab_pin.sym} 96520 -21880 0 1 {name=p95810 lab=_46374_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -21880 0 0 {name=X_46374_ }
C {devices/lab_pin.sym} 96420 -21750 0 0 {name=p95811 lab=_70638_/A }
C {devices/lab_pin.sym} 96500 -21750 0 1 {name=p95812 lab=_70638_/X }
C {sky130_stdcells/buf_2.sym} 96460 -21750 0 0 {name=X_70638_ }
C {devices/lab_pin.sym} 96400 -21640 0 0 {name=p95813 lab=_77194_/A }
C {devices/lab_pin.sym} 96400 -21600 0 0 {name=p95814 lab=_77194_/B }
C {devices/lab_pin.sym} 96520 -21620 0 1 {name=p95815 lab=_77202_/C }
C {sky130_stdcells/nand2_4.sym} 96460 -21620 0 0 {name=X_77194_ }
C {devices/lab_pin.sym} 96420 -21490 0 0 {name=p95816 lab=_43585_/X }
C {devices/lab_pin.sym} 96500 -21490 0 1 {name=p95817 lab=_43586_/X }
C {sky130_stdcells/buf_2.sym} 96460 -21490 0 0 {name=X_43586_ }
C {devices/lab_pin.sym} 96420 -21370 0 0 {name=p95818 lab=_40798_/A }
C {devices/lab_pin.sym} 96500 -21370 0 1 {name=p95819 lab=_40798_/X }
C {sky130_stdcells/buf_2.sym} 96460 -21370 0 0 {name=X_40798_ }
C {devices/lab_pin.sym} 96380 -21270 0 0 {name=p95820 lab=_48108_/Y }
C {devices/lab_pin.sym} 96380 -21230 0 0 {name=p95821 lab=_48109_/X }
C {devices/lab_pin.sym} 96380 -21190 0 0 {name=p95822 lab=_48112_/X }
C {devices/lab_pin.sym} 96540 -21230 0 1 {name=p95823 lab=_48113_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -21230 0 0 {name=X_48113_ }
C {devices/lab_pin.sym} 96420 -21090 0 0 {name=p95824 lab=clkbuf_9_195_0_CLK/X }
C {devices/lab_pin.sym} 96500 -21090 0 1 {name=p95825 lab=_83229_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 96460 -21090 0 0 {name=Xclkbuf_10_391_0_CLK }
C {devices/lab_pin.sym} 96380 -20990 0 0 {name=p95826 lab=_85253_/Q }
C {devices/lab_pin.sym} 96380 -20950 0 0 {name=p95827 lab=_45297_/X }
C {devices/lab_pin.sym} 96380 -20910 0 0 {name=p95828 lab=_45324_/X }
C {devices/lab_pin.sym} 96540 -20950 0 1 {name=p95829 lab=_45325_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -20950 0 0 {name=X_45325_ }
C {devices/lab_pin.sym} 96400 -20820 0 0 {name=p95830 lab=_76145_/A }
C {devices/lab_pin.sym} 96400 -20780 0 0 {name=p95831 lab=_76145_/B }
C {devices/lab_pin.sym} 96520 -20800 0 1 {name=p95832 lab=_76145_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -20800 0 0 {name=X_76145_ }
C {devices/lab_pin.sym} 96420 -20670 0 0 {name=p95833 lab=_87829_/Q }
C {devices/lab_pin.sym} 96500 -20670 0 1 {name=p95834 lab=_69089_/B }
C {sky130_stdcells/inv_2.sym} 96460 -20670 0 0 {name=X_42537_ }
C {devices/lab_pin.sym} 96380 -20580 0 0 {name=p95835 lab=_73355_/X }
C {devices/lab_pin.sym} 96380 -20540 0 0 {name=p95836 lab=_85578_/Q }
C {devices/lab_pin.sym} 96380 -20500 0 0 {name=p95837 lab=_73284_/X }
C {devices/lab_pin.sym} 96380 -20460 0 0 {name=p95838 lab=_73356_/X }
C {devices/lab_pin.sym} 96540 -20520 0 1 {name=p95839 lab=_73357_/X }
C {sky130_stdcells/a211o_4.sym} 96460 -20520 0 0 {name=X_73357_ }
C {devices/lab_pin.sym} 96420 -20370 0 0 {name=p95840 lab=_49093_/A }
C {devices/lab_pin.sym} 96500 -20370 0 1 {name=p95841 lab=_53886_/B }
C {sky130_stdcells/inv_2.sym} 96460 -20370 0 0 {name=X_49093_ }
C {devices/lab_pin.sym} 96400 -20270 0 0 {name=p95842 lab=_61384_/A }
C {devices/lab_pin.sym} 96400 -20230 0 0 {name=p95843 lab=_61384_/B }
C {devices/lab_pin.sym} 96400 -20190 0 0 {name=p95844 lab=_79154_/B }
C {devices/lab_pin.sym} 96520 -20230 0 1 {name=p95845 lab=_61371_/Y }
C {sky130_stdcells/nor3_4.sym} 96460 -20230 0 0 {name=X_61371_ }
C {devices/lab_pin.sym} 96380 -20110 0 0 {name=p95846 lab=_70532_/Y }
C {devices/lab_pin.sym} 96380 -20070 0 0 {name=p95847 lab=_83747_/Q }
C {devices/lab_pin.sym} 96380 -20030 0 0 {name=p95848 lab=_70568_/Y }
C {devices/lab_pin.sym} 96540 -20070 0 1 {name=p95849 lab=_83747_/D }
C {sky130_stdcells/a21o_4.sym} 96460 -20070 0 0 {name=X_70569_ }
C {devices/lab_pin.sym} 96400 -19960 0 0 {name=p95850 lab=_63100_/A }
C {devices/lab_pin.sym} 96400 -19920 0 0 {name=p95851 lab=_63110_/B }
C {devices/lab_pin.sym} 96400 -19880 0 0 {name=p95852 lab=_63079_/C }
C {devices/lab_pin.sym} 96400 -19840 0 0 {name=p95853 lab=_63066_/D }
C {devices/lab_pin.sym} 96520 -19900 0 1 {name=p95854 lab=_63110_/X }
C {sky130_stdcells/and4_4.sym} 96460 -19900 0 0 {name=X_63110_ }
C {devices/lab_pin.sym} 96400 -19760 0 0 {name=p95855 lab=_48044_/A }
C {devices/lab_pin.sym} 96400 -19720 0 0 {name=p95856 lab=_48044_/B }
C {devices/lab_pin.sym} 96520 -19740 0 1 {name=p95857 lab=_48044_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -19740 0 0 {name=X_48044_ }
C {devices/lab_pin.sym} 96380 -19640 0 0 {name=p95858 lab=_60268_/Y }
C {devices/lab_pin.sym} 96380 -19600 0 0 {name=p95859 lab=_60350_/A }
C {devices/lab_pin.sym} 96380 -19560 0 0 {name=p95860 lab=_79713_/A }
C {devices/lab_pin.sym} 96380 -19520 0 0 {name=p95861 lab=_59868_/X }
C {devices/lab_pin.sym} 96540 -19580 0 1 {name=p95862 lab=_60322_/X }
C {sky130_stdcells/a2bb2o_4.sym} 96460 -19580 0 0 {name=X_60322_ }
C {devices/lab_pin.sym} 96420 -19430 0 0 {name=p95863 lab=_58126_/A }
C {devices/lab_pin.sym} 96500 -19430 0 1 {name=p95864 lab=_72308_/X }
C {sky130_stdcells/buf_2.sym} 96460 -19430 0 0 {name=X_72308_ }
C {devices/lab_pin.sym} 96380 -19330 0 0 {name=p95865 lab=_85290_/Q }
C {devices/lab_pin.sym} 96380 -19290 0 0 {name=p95866 lab=_45194_/X }
C {devices/lab_pin.sym} 96380 -19250 0 0 {name=p95867 lab=_45229_/X }
C {devices/lab_pin.sym} 96540 -19290 0 1 {name=p95868 lab=_45256_/X }
C {sky130_stdcells/o21a_4.sym} 96460 -19290 0 0 {name=X_45256_ }
C {devices/lab_pin.sym} 96400 -19180 0 0 {name=p95869 lab=_63265_/B }
C {devices/lab_pin.sym} 96400 -19140 0 0 {name=p95870 lab=_64118_/B }
C {devices/lab_pin.sym} 96400 -19100 0 0 {name=p95871 lab=_64155_/C }
C {devices/lab_pin.sym} 96400 -19060 0 0 {name=p95872 lab=_64142_/D }
C {devices/lab_pin.sym} 96520 -19120 0 1 {name=p95873 lab=_64090_/Y }
C {sky130_stdcells/nand4_4.sym} 96460 -19120 0 0 {name=X_64090_ }
C {devices/lab_pin.sym} 96400 -18980 0 0 {name=p95874 lab=_76068_/A }
C {devices/lab_pin.sym} 96400 -18940 0 0 {name=p95875 lab=_76073_/A }
C {devices/lab_pin.sym} 96520 -18960 0 1 {name=p95876 lab=_76076_/X }
C {sky130_stdcells/and2_4.sym} 96460 -18960 0 0 {name=X_76076_ }
C {devices/lab_pin.sym} 96380 -18870 0 0 {name=p95877 lab=_42466_/X }
C {devices/lab_pin.sym} 96380 -18830 0 0 {name=p95878 lab=_42467_/X }
C {devices/lab_pin.sym} 96380 -18790 0 0 {name=p95879 lab=_40605_/X }
C {devices/lab_pin.sym} 96380 -18750 0 0 {name=p95880 lab=_87855_/Q }
C {devices/lab_pin.sym} 96380 -18710 0 0 {name=p95881 lab=_42453_/X }
C {devices/lab_pin.sym} 96540 -18790 0 1 {name=p95882 lab=_42468_/Y }
C {sky130_stdcells/o32ai_4.sym} 96460 -18790 0 0 {name=X_42468_ }
C {devices/lab_pin.sym} 96400 -18640 0 0 {name=p95883 lab=_73407_/A }
C {devices/lab_pin.sym} 96400 -18600 0 0 {name=p95884 lab=_86509_/Q }
C {devices/lab_pin.sym} 96520 -18620 0 1 {name=p95885 lab=_73288_/X }
C {sky130_stdcells/and2_4.sym} 96460 -18620 0 0 {name=X_73288_ }
C {devices/lab_pin.sym} 96420 -18490 0 0 {name=p95886 lab=_44207_/A }
C {devices/lab_pin.sym} 96500 -18490 0 1 {name=p95887 lab=_58547_/A }
C {sky130_stdcells/buf_2.sym} 96460 -18490 0 0 {name=X_44207_ }
C {devices/lab_pin.sym} 96400 -18400 0 0 {name=p95888 lab=_63041_/A }
C {devices/lab_pin.sym} 96400 -18360 0 0 {name=p95889 lab=_63041_/B }
C {devices/lab_pin.sym} 96400 -18320 0 0 {name=p95890 lab=_63030_/C }
C {devices/lab_pin.sym} 96400 -18280 0 0 {name=p95891 lab=_60541_/C }
C {devices/lab_pin.sym} 96520 -18340 0 1 {name=p95892 lab=_63041_/X }
C {sky130_stdcells/and4_4.sym} 96460 -18340 0 0 {name=X_63041_ }
C {devices/lab_pin.sym} 96400 -18200 0 0 {name=p95893 lab=_75030_/A }
C {devices/lab_pin.sym} 96400 -18160 0 0 {name=p95894 lab=_75026_/Y }
C {devices/lab_pin.sym} 96520 -18180 0 1 {name=p95895 lab=_75028_/B }
C {sky130_stdcells/xor2_4.sym} 96460 -18180 0 0 {name=X_75027_ }
C {devices/lab_pin.sym} 96400 -18060 0 0 {name=p95896 lab=_84923_/Q }
C {devices/lab_pin.sym} 96400 -18020 0 0 {name=p95897 lab=_84171_/Q }
C {devices/lab_pin.sym} 96520 -18040 0 1 {name=p95898 lab=_79911_/A }
C {sky130_stdcells/nand2_4.sym} 96460 -18040 0 0 {name=X_79904_ }
C {devices/lab_pin.sym} 96420 -17910 0 0 {name=p95899 lab=_41253_/A }
C {devices/lab_pin.sym} 96500 -17910 0 1 {name=p95900 lab=_41419_/X }
C {sky130_stdcells/buf_2.sym} 96460 -17910 0 0 {name=X_41419_ }
C {devices/lab_pin.sym} 96420 -17790 0 0 {name=p95901 lab=_60253_/A }
C {devices/lab_pin.sym} 96500 -17790 0 1 {name=p95902 lab=_60268_/C }
C {sky130_stdcells/buf_2.sym} 96460 -17790 0 0 {name=X_60253_ }
C {devices/lab_pin.sym} 96380 -17690 0 0 {name=p95903 lab=_72166_/X }
C {devices/lab_pin.sym} 96380 -17650 0 0 {name=p95904 lab=_85367_/Q }
C {devices/lab_pin.sym} 96380 -17610 0 0 {name=p95905 lab=_72238_/X }
C {devices/lab_pin.sym} 96540 -17650 0 1 {name=p95906 lab=_72239_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -17650 0 0 {name=X_72239_ }
C {devices/lab_pin.sym} 96380 -17530 0 0 {name=p95907 lab=_56339_/C }
C {devices/lab_pin.sym} 96380 -17490 0 0 {name=p95908 lab=_45131_/X }
C {devices/lab_pin.sym} 96380 -17450 0 0 {name=p95909 lab=_45161_/X }
C {devices/lab_pin.sym} 96540 -17490 0 1 {name=p95910 lab=_45187_/X }
C {sky130_stdcells/o21a_4.sym} 96460 -17490 0 0 {name=X_45187_ }
C {devices/lab_pin.sym} 96380 -17390 0 0 {name=p95911 lab=_42378_/X }
C {devices/lab_pin.sym} 96380 -17350 0 0 {name=p95912 lab=_42397_/X }
C {devices/lab_pin.sym} 96380 -17310 0 0 {name=p95913 lab=_40426_/X }
C {devices/lab_pin.sym} 96380 -17270 0 0 {name=p95914 lab=_87881_/Q }
C {devices/lab_pin.sym} 96380 -17230 0 0 {name=p95915 lab=_42398_/X }
C {devices/lab_pin.sym} 96540 -17310 0 1 {name=p95916 lab=_42400_/A }
C {sky130_stdcells/o32ai_4.sym} 96460 -17310 0 0 {name=X_42399_ }
C {devices/lab_pin.sym} 96380 -17170 0 0 {name=p95917 lab=_44026_/Y }
C {devices/lab_pin.sym} 96380 -17130 0 0 {name=p95918 lab=_44041_/Y }
C {devices/lab_pin.sym} 96380 -17090 0 0 {name=p95919 lab=_44163_/B }
C {devices/lab_pin.sym} 96540 -17130 0 1 {name=p95920 lab=_44138_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -17130 0 0 {name=X_44138_ }
C {devices/lab_pin.sym} 96380 -17010 0 0 {name=p95921 lab=_64764_/C }
C {devices/lab_pin.sym} 96380 -16970 0 0 {name=p95922 lab=_72179_/Y }
C {devices/lab_pin.sym} 96380 -16930 0 0 {name=p95923 lab=_79834_/Y }
C {devices/lab_pin.sym} 96540 -16970 0 1 {name=p95924 lab=_79835_/X }
C {sky130_stdcells/o21a_4.sym} 96460 -16970 0 0 {name=X_79835_ }
C {devices/lab_pin.sym} 96420 -16830 0 0 {name=p95925 lab=_60184_/A }
C {devices/lab_pin.sym} 96500 -16830 0 1 {name=p95926 lab=_61278_/B }
C {sky130_stdcells/buf_2.sym} 96460 -16830 0 0 {name=X_60184_ }
C {devices/lab_pin.sym} 96400 -16740 0 0 {name=p95927 lab=_49995_/A }
C {devices/lab_pin.sym} 96400 -16700 0 0 {name=p95928 lab=_49994_/X }
C {devices/lab_pin.sym} 96400 -16660 0 0 {name=p95929 lab=_50005_/C }
C {devices/lab_pin.sym} 96400 -16620 0 0 {name=p95930 lab=_53207_/D }
C {devices/lab_pin.sym} 96520 -16680 0 1 {name=p95931 lab=_49995_/X }
C {sky130_stdcells/and4_4.sym} 96460 -16680 0 0 {name=X_49995_ }
C {devices/lab_pin.sym} 96380 -16550 0 0 {name=p95932 lab=_66796_/X }
C {devices/lab_pin.sym} 96380 -16510 0 0 {name=p95933 lab=_66799_/X }
C {devices/lab_pin.sym} 96380 -16470 0 0 {name=p95934 lab=_66726_/X }
C {devices/lab_pin.sym} 96540 -16510 0 1 {name=p95935 lab=_66800_/X }
C {sky130_stdcells/a21o_4.sym} 96460 -16510 0 0 {name=X_66800_ }
C {devices/lab_pin.sym} 96420 -16370 0 0 {name=p95936 lab=_48946_/A }
C {devices/lab_pin.sym} 96500 -16370 0 1 {name=p95937 lab=_48946_/X }
C {sky130_stdcells/buf_2.sym} 96460 -16370 0 0 {name=X_48946_ }
C {devices/lab_pin.sym} 96420 -16250 0 0 {name=p95938 lab=_44086_/A }
C {devices/lab_pin.sym} 96500 -16250 0 1 {name=p95939 lab=_44070_/B }
C {sky130_stdcells/buf_2.sym} 96460 -16250 0 0 {name=X_44069_ }
C {devices/lab_pin.sym} 96380 -16160 0 0 {name=p95940 lab=_67664_/X }
C {devices/lab_pin.sym} 96380 -16120 0 0 {name=p95941 lab=_67769_/Y }
C {devices/lab_pin.sym} 96380 -16080 0 0 {name=p95942 lab=_67747_/X }
C {devices/lab_pin.sym} 96380 -16040 0 0 {name=p95943 lab=_67779_/Y }
C {devices/lab_pin.sym} 96540 -16100 0 1 {name=p95944 lab=_67780_/X }
C {sky130_stdcells/a211o_4.sym} 96460 -16100 0 0 {name=X_67780_ }
C {devices/lab_pin.sym} 96400 -15960 0 0 {name=p95945 lab=_79762_/X }
C {devices/lab_pin.sym} 96400 -15920 0 0 {name=p95946 lab=_79766_/B }
C {devices/lab_pin.sym} 96520 -15940 0 1 {name=p95947 lab=_79766_/X }
C {sky130_stdcells/xor2_4.sym} 96460 -15940 0 0 {name=X_79766_ }
C {devices/lab_pin.sym} 96400 -15820 0 0 {name=p95948 lab=_64877_/X }
C {devices/lab_pin.sym} 96400 -15780 0 0 {name=p95949 lab=_64992_/B }
C {devices/lab_pin.sym} 96520 -15800 0 1 {name=p95950 lab=_64992_/X }
C {sky130_stdcells/and2_4.sym} 96460 -15800 0 0 {name=X_64992_ }
C {devices/lab_pin.sym} 96400 -15680 0 0 {name=p95951 lab=_84530_/Q }
C {devices/lab_pin.sym} 96400 -15640 0 0 {name=p95952 lab=_84402_/Q }
C {devices/lab_pin.sym} 96520 -15660 0 1 {name=p95953 lab=_76978_/X }
C {sky130_stdcells/xor2_4.sym} 96460 -15660 0 0 {name=X_76978_ }
C {devices/lab_pin.sym} 96380 -15560 0 0 {name=p95954 lab=_66526_/X }
C {devices/lab_pin.sym} 96380 -15520 0 0 {name=p95955 lab=_66720_/Y }
C {devices/lab_pin.sym} 96380 -15480 0 0 {name=p95956 lab=_66672_/X }
C {devices/lab_pin.sym} 96380 -15440 0 0 {name=p95957 lab=_66730_/Y }
C {devices/lab_pin.sym} 96540 -15500 0 1 {name=p95958 lab=_66731_/X }
C {sky130_stdcells/a211o_4.sym} 96460 -15500 0 0 {name=X_66731_ }
C {devices/lab_pin.sym} 96380 -15370 0 0 {name=p95959 lab=_78713_/X }
C {devices/lab_pin.sym} 96380 -15330 0 0 {name=p95960 lab=_78718_/C }
C {devices/lab_pin.sym} 96380 -15290 0 0 {name=p95961 lab=_78716_/Y }
C {devices/lab_pin.sym} 96540 -15330 0 1 {name=p95962 lab=_78717_/X }
C {sky130_stdcells/a21o_4.sym} 96460 -15330 0 0 {name=X_78717_ }
C {devices/lab_pin.sym} 96380 -15230 0 0 {name=p95963 lab=_63939_/X }
C {devices/lab_pin.sym} 96380 -15190 0 0 {name=p95964 lab=_63890_/X }
C {devices/lab_pin.sym} 96380 -15150 0 0 {name=p95965 lab=_63940_/Y }
C {devices/lab_pin.sym} 96380 -15110 0 0 {name=p95966 lab=_63941_/Y }
C {devices/lab_pin.sym} 96380 -15080 0 0 {name=p95967 lab=_63942_/X }
C {devices/lab_pin.sym} 96540 -15150 0 1 {name=p95968 lab=_63943_/X }
C {sky130_stdcells/a41o_4.sym} 96460 -15150 0 0 {name=X_63943_ }
C {devices/lab_pin.sym} 96400 -15000 0 0 {name=p95969 lab=_75929_/A }
C {devices/lab_pin.sym} 96400 -14960 0 0 {name=p95970 lab=_75929_/B }
C {devices/lab_pin.sym} 96520 -14980 0 1 {name=p95971 lab=_81788_/D }
C {sky130_stdcells/xor2_4.sym} 96460 -14980 0 0 {name=X_75929_ }
C {devices/lab_pin.sym} 96420 -14850 0 0 {name=p95972 lab=_48876_/Y }
C {devices/lab_pin.sym} 96500 -14850 0 1 {name=p95973 lab=_48878_/B }
C {sky130_stdcells/buf_2.sym} 96460 -14850 0 0 {name=X_48877_ }
C {devices/lab_pin.sym} 96400 -14740 0 0 {name=p95974 lab=_84215_/Q }
C {devices/lab_pin.sym} 96400 -14700 0 0 {name=p95975 lab=_83263_/Q }
C {devices/lab_pin.sym} 96520 -14720 0 1 {name=p95976 lab=_79697_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -14720 0 0 {name=X_79697_ }
C {devices/lab_pin.sym} 96380 -14620 0 0 {name=p95977 lab=_69423_/X }
C {devices/lab_pin.sym} 96380 -14580 0 0 {name=p95978 lab=_69448_/Y }
C {devices/lab_pin.sym} 96380 -14540 0 0 {name=p95979 lab=_69405_/X }
C {devices/lab_pin.sym} 96380 -14500 0 0 {name=p95980 lab=_69449_/Y }
C {devices/lab_pin.sym} 96540 -14560 0 1 {name=p95981 lab=_69450_/X }
C {sky130_stdcells/a211o_4.sym} 96460 -14560 0 0 {name=X_69450_ }
C {devices/lab_pin.sym} 96380 -14430 0 0 {name=p95982 lab=_48914_/A }
C {devices/lab_pin.sym} 96380 -14390 0 0 {name=p95983 lab=_82945_/Q }
C {devices/lab_pin.sym} 96380 -14350 0 0 {name=p95984 lab=_47827_/Y }
C {devices/lab_pin.sym} 96540 -14390 0 1 {name=p95985 lab=_47829_/A }
C {sky130_stdcells/o21a_4.sym} 96460 -14390 0 0 {name=X_47828_ }
C {devices/lab_pin.sym} 96400 -14260 0 0 {name=p95986 lab=_66689_/A }
C {devices/lab_pin.sym} 96400 -14220 0 0 {name=p95987 lab=_87695_/Q }
C {devices/lab_pin.sym} 96520 -14240 0 1 {name=p95988 lab=_66662_/X }
C {sky130_stdcells/and2_4.sym} 96460 -14240 0 0 {name=X_66662_ }
C {devices/lab_pin.sym} 96420 -14110 0 0 {name=p95989 lab=_78648_/A }
C {devices/lab_pin.sym} 96500 -14110 0 1 {name=p95990 lab=_78648_/Y }
C {sky130_stdcells/inv_2.sym} 96460 -14110 0 0 {name=X_78648_ }
C {devices/lab_pin.sym} 96400 -14020 0 0 {name=p95991 lab=_63867_/Y }
C {devices/lab_pin.sym} 96400 -13980 0 0 {name=p95992 lab=_63869_/Y }
C {devices/lab_pin.sym} 96400 -13940 0 0 {name=p95993 lab=_63871_/Y }
C {devices/lab_pin.sym} 96400 -13900 0 0 {name=p95994 lab=_63873_/Y }
C {devices/lab_pin.sym} 96520 -13960 0 1 {name=p95995 lab=_63874_/X }
C {sky130_stdcells/and4_4.sym} 96460 -13960 0 0 {name=X_63874_ }
C {devices/lab_pin.sym} 96380 -13830 0 0 {name=p95996 lab=_68391_/X }
C {devices/lab_pin.sym} 96380 -13790 0 0 {name=p95997 lab=_68398_/X }
C {devices/lab_pin.sym} 96380 -13750 0 0 {name=p95998 lab=_68400_/X }
C {devices/lab_pin.sym} 96540 -13790 0 1 {name=p95999 lab=_68401_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -13790 0 0 {name=X_68401_ }
C {devices/lab_pin.sym} 96420 -13650 0 0 {name=p96000 lab=clkbuf_9_451_0_CLK/A }
C {devices/lab_pin.sym} 96500 -13650 0 1 {name=p96001 lab=clkbuf_9_450_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 96460 -13650 0 0 {name=Xclkbuf_9_450_0_CLK }
C {devices/lab_pin.sym} 96380 -13560 0 0 {name=p96002 lab=_65503_/X }
C {devices/lab_pin.sym} 96380 -13520 0 0 {name=p96003 lab=_85589_/Q }
C {devices/lab_pin.sym} 96380 -13480 0 0 {name=p96004 lab=_65504_/X }
C {devices/lab_pin.sym} 96380 -13440 0 0 {name=p96005 lab=_65612_/X }
C {devices/lab_pin.sym} 96540 -13500 0 1 {name=p96006 lab=_65613_/X }
C {sky130_stdcells/a211o_4.sym} 96460 -13500 0 0 {name=X_65613_ }
C {devices/lab_pin.sym} 96400 -13370 0 0 {name=p96007 lab=_62792_/X }
C {devices/lab_pin.sym} 96400 -13330 0 0 {name=p96008 lab=_62839_/B }
C {devices/lab_pin.sym} 96400 -13290 0 0 {name=p96009 lab=_62825_/C }
C {devices/lab_pin.sym} 96520 -13330 0 1 {name=p96010 lab=_62825_/Y }
C {sky130_stdcells/nor3_4.sym} 96460 -13330 0 0 {name=X_62825_ }
C {devices/lab_pin.sym} 96400 -13200 0 0 {name=p96011 lab=_69234_/A }
C {devices/lab_pin.sym} 96400 -13160 0 0 {name=p96012 lab=_69381_/B }
C {devices/lab_pin.sym} 96520 -13180 0 1 {name=p96013 lab=_69381_/X }
C {sky130_stdcells/and2_4.sym} 96460 -13180 0 0 {name=X_69381_ }
C {devices/lab_pin.sym} 96380 -13070 0 0 {name=p96014 lab=_47754_/Y }
C {devices/lab_pin.sym} 96380 -13030 0 0 {name=p96015 lab=_47745_/X }
C {devices/lab_pin.sym} 96380 -12990 0 0 {name=p96016 lab=_47758_/X }
C {devices/lab_pin.sym} 96540 -13030 0 1 {name=p96017 lab=_86601_/D }
C {sky130_stdcells/a21oi_4.sym} 96460 -13030 0 0 {name=X_47759_ }
C {devices/lab_pin.sym} 96420 -12890 0 0 {name=p96018 lab=_69457_/A }
C {devices/lab_pin.sym} 96500 -12890 0 1 {name=p96019 lab=_66593_/X }
C {sky130_stdcells/buf_2.sym} 96460 -12890 0 0 {name=X_66593_ }
C {devices/lab_pin.sym} 96380 -12790 0 0 {name=p96020 lab=_78578_/X }
C {devices/lab_pin.sym} 96380 -12750 0 0 {name=p96021 lab=_78560_/A }
C {devices/lab_pin.sym} 96380 -12710 0 0 {name=p96022 lab=_78558_/X }
C {devices/lab_pin.sym} 96540 -12750 0 1 {name=p96023 lab=_78579_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -12750 0 0 {name=X_78579_ }
C {devices/lab_pin.sym} 96420 -12610 0 0 {name=p96024 lab=clkbuf_9_172_0_CLK/X }
C {devices/lab_pin.sym} 96500 -12610 0 1 {name=p96025 lab=_86351_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 96460 -12610 0 0 {name=Xclkbuf_10_344_0_CLK }
C {devices/lab_pin.sym} 96400 -12500 0 0 {name=p96026 lab=_80607_/X }
C {devices/lab_pin.sym} 96400 -12460 0 0 {name=p96027 lab=_80610_/B }
C {devices/lab_pin.sym} 96520 -12480 0 1 {name=p96028 lab=_82271_/D }
C {sky130_stdcells/xor2_4.sym} 96460 -12480 0 0 {name=X_80610_ }
C {devices/lab_pin.sym} 96380 -12370 0 0 {name=p96029 lab=_68034_/X }
C {devices/lab_pin.sym} 96380 -12330 0 0 {name=p96030 lab=_68036_/X }
C {devices/lab_pin.sym} 96380 -12290 0 0 {name=p96031 lab=_68331_/X }
C {devices/lab_pin.sym} 96540 -12330 0 1 {name=p96032 lab=_68332_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -12330 0 0 {name=X_68332_ }
C {devices/lab_pin.sym} 96400 -12210 0 0 {name=p96033 lab=_64808_/X }
C {devices/lab_pin.sym} 96400 -12170 0 0 {name=p96034 lab=_65647_/B }
C {devices/lab_pin.sym} 96400 -12130 0 0 {name=p96035 lab=_64811_/X }
C {devices/lab_pin.sym} 96520 -12170 0 1 {name=p96036 lab=_65544_/Y }
C {sky130_stdcells/nand3_4.sym} 96460 -12170 0 0 {name=X_65544_ }
C {devices/lab_pin.sym} 96380 -12050 0 0 {name=p96037 lab=_50767_/Y }
C {devices/lab_pin.sym} 96380 -12010 0 0 {name=p96038 lab=_50768_/X }
C {devices/lab_pin.sym} 96380 -11970 0 0 {name=p96039 lab=_50769_/Y }
C {devices/lab_pin.sym} 96540 -12010 0 1 {name=p96040 lab=_50770_/Y }
C {sky130_stdcells/a21boi_4.sym} 96460 -12010 0 0 {name=X_50770_ }
C {devices/lab_pin.sym} 96380 -11910 0 0 {name=p96041 lab=_62751_/Y }
C {devices/lab_pin.sym} 96380 -11870 0 0 {name=p96042 lab=_62713_/X }
C {devices/lab_pin.sym} 96380 -11830 0 0 {name=p96043 lab=_62753_/Y }
C {devices/lab_pin.sym} 96380 -11790 0 0 {name=p96044 lab=_62754_/Y }
C {devices/lab_pin.sym} 96380 -11760 0 0 {name=p96045 lab=_62755_/X }
C {devices/lab_pin.sym} 96540 -11830 0 1 {name=p96046 lab=_62756_/X }
C {sky130_stdcells/a41o_4.sym} 96460 -11830 0 0 {name=X_62756_ }
C {devices/lab_pin.sym} 96370 -11670 0 0 {name=p96047 lab=_81330_/CLK }
C {devices/lab_pin.sym} 96370 -11650 0 0 {name=p96048 lab=_84190_/Q }
C {devices/lab_pin.sym} 96550 -11670 0 1 {name=p96049 lab=_81590_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -11660 0 0 {name=X_81590_ }
C {devices/lab_pin.sym} 96420 -11530 0 0 {name=p96050 lab=clkbuf_9_487_0_CLK/X }
C {devices/lab_pin.sym} 96500 -11530 0 1 {name=p96051 lab=_86525_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 96460 -11530 0 0 {name=Xclkbuf_10_974_0_CLK }
C {devices/lab_pin.sym} 96400 -11440 0 0 {name=p96052 lab=_49420_/A }
C {devices/lab_pin.sym} 96400 -11400 0 0 {name=p96053 lab=_49447_/B }
C {devices/lab_pin.sym} 96400 -11360 0 0 {name=p96054 lab=_49420_/C }
C {devices/lab_pin.sym} 96400 -11320 0 0 {name=p96055 lab=_46736_/X }
C {devices/lab_pin.sym} 96520 -11380 0 1 {name=p96056 lab=_49429_/X }
C {sky130_stdcells/and4_4.sym} 96460 -11380 0 0 {name=X_49429_ }
C {devices/lab_pin.sym} 96380 -11250 0 0 {name=p96057 lab=_63355_/A }
C {devices/lab_pin.sym} 96380 -11210 0 0 {name=p96058 lab=_61706_/X }
C {devices/lab_pin.sym} 96380 -11170 0 0 {name=p96059 lab=_59763_/A }
C {devices/lab_pin.sym} 96540 -11210 0 1 {name=p96060 lab=_61715_/B }
C {sky130_stdcells/a21o_4.sym} 96460 -11210 0 0 {name=X_61707_ }
C {devices/lab_pin.sym} 96400 -11080 0 0 {name=p96061 lab=_80537_/X }
C {devices/lab_pin.sym} 96400 -11040 0 0 {name=p96062 lab=_80541_/B }
C {devices/lab_pin.sym} 96520 -11060 0 1 {name=p96063 lab=_80551_/B }
C {sky130_stdcells/xor2_4.sym} 96460 -11060 0 0 {name=X_80541_ }
C {devices/lab_pin.sym} 96380 -10950 0 0 {name=p96064 lab=_83998_/Q }
C {devices/lab_pin.sym} 96380 -10910 0 0 {name=p96065 lab=_68259_/X }
C {devices/lab_pin.sym} 96380 -10870 0 0 {name=p96066 lab=_68262_/X }
C {devices/lab_pin.sym} 96540 -10910 0 1 {name=p96067 lab=_68263_/X }
C {sky130_stdcells/a21bo_4.sym} 96460 -10910 0 0 {name=X_68263_ }
C {devices/lab_pin.sym} 96400 -10780 0 0 {name=p96068 lab=_65474_/X }
C {devices/lab_pin.sym} 96400 -10740 0 0 {name=p96069 lab=_72843_/B }
C {devices/lab_pin.sym} 96520 -10760 0 1 {name=p96070 lab=_65475_/X }
C {sky130_stdcells/and2_4.sym} 96460 -10760 0 0 {name=X_65475_ }
C {devices/lab_pin.sym} 96400 -10650 0 0 {name=p96071 lab=_62673_/A }
C {devices/lab_pin.sym} 96400 -10610 0 0 {name=p96072 lab=_62673_/B }
C {devices/lab_pin.sym} 96400 -10570 0 0 {name=p96073 lab=_84391_/Q }
C {devices/lab_pin.sym} 96520 -10610 0 1 {name=p96074 lab=_62687_/Y }
C {sky130_stdcells/nor3_4.sym} 96460 -10610 0 0 {name=X_62687_ }
C {devices/lab_pin.sym} 96420 -10470 0 0 {name=p96075 lab=clkbuf_8_232_0_CLK/X }
C {devices/lab_pin.sym} 96500 -10470 0 1 {name=p96076 lab=clkbuf_9_465_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 96460 -10470 0 0 {name=Xclkbuf_9_465_0_CLK }
C {devices/lab_pin.sym} 96380 -10380 0 0 {name=p96077 lab=_87864_/Q }
C {devices/lab_pin.sym} 96380 -10340 0 0 {name=p96078 lab=_67117_/X }
C {devices/lab_pin.sym} 96380 -10300 0 0 {name=p96079 lab=_67167_/X }
C {devices/lab_pin.sym} 96380 -10260 0 0 {name=p96080 lab=_67213_/X }
C {devices/lab_pin.sym} 96540 -10320 0 1 {name=p96081 lab=_67214_/X }
C {sky130_stdcells/a211o_4.sym} 96460 -10320 0 0 {name=X_67214_ }
C {devices/lab_pin.sym} 96400 -10180 0 0 {name=p96082 lab=_52466_/A }
C {devices/lab_pin.sym} 96400 -10140 0 0 {name=p96083 lab=_52440_/B }
C {devices/lab_pin.sym} 96520 -10160 0 1 {name=p96084 lab=_52440_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -10160 0 0 {name=X_52440_ }
C {devices/lab_pin.sym} 96380 -10070 0 0 {name=p96085 lab=_64419_/Y }
C {devices/lab_pin.sym} 96380 -10030 0 0 {name=p96086 lab=_64420_/X }
C {devices/lab_pin.sym} 96380 -9990 0 0 {name=p96087 lab=_64422_/X }
C {devices/lab_pin.sym} 96380 -9950 0 0 {name=p96088 lab=_64425_/Y }
C {devices/lab_pin.sym} 96380 -9910 0 0 {name=p96089 lab=_64384_/X }
C {devices/lab_pin.sym} 96540 -9990 0 1 {name=p96090 lab=_64426_/X }
C {sky130_stdcells/o41a_4.sym} 96460 -9990 0 0 {name=X_64426_ }
C {devices/lab_pin.sym} 96370 -9830 0 0 {name=p96091 lab=_81227_/CLK }
C {devices/lab_pin.sym} 96370 -9810 0 0 {name=p96092 lab=_83260_/D }
C {devices/lab_pin.sym} 96550 -9830 0 1 {name=p96093 lab=_83260_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -9820 0 0 {name=X_83260_ }
C {devices/lab_pin.sym} 96400 -9710 0 0 {name=p96094 lab=_61608_/X }
C {devices/lab_pin.sym} 96400 -9670 0 0 {name=p96095 lab=_61637_/X }
C {devices/lab_pin.sym} 96400 -9630 0 0 {name=p96096 lab=_61619_/C }
C {devices/lab_pin.sym} 96520 -9670 0 1 {name=p96097 lab=_61638_/Y }
C {sky130_stdcells/nand3_4.sym} 96460 -9670 0 0 {name=X_61638_ }
C {devices/lab_pin.sym} 96400 -9540 0 0 {name=p96098 lab=_80472_/A }
C {devices/lab_pin.sym} 96400 -9500 0 0 {name=p96099 lab=_80472_/B }
C {devices/lab_pin.sym} 96520 -9520 0 1 {name=p96100 lab=_80472_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -9520 0 0 {name=X_80472_ }
C {devices/lab_pin.sym} 96380 -9420 0 0 {name=p96101 lab=_68188_/X }
C {devices/lab_pin.sym} 96380 -9380 0 0 {name=p96102 lab=_67197_/Y }
C {devices/lab_pin.sym} 96380 -9340 0 0 {name=p96103 lab=_68189_/X }
C {devices/lab_pin.sym} 96380 -9300 0 0 {name=p96104 lab=_68193_/Y }
C {devices/lab_pin.sym} 96540 -9360 0 1 {name=p96105 lab=_68194_/X }
C {sky130_stdcells/a211o_4.sym} 96460 -9360 0 0 {name=X_68194_ }
C {devices/lab_pin.sym} 96420 -9210 0 0 {name=p96106 lab=clkbuf_9_179_0_CLK/X }
C {devices/lab_pin.sym} 96500 -9210 0 1 {name=p96107 lab=_82390_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 96460 -9210 0 0 {name=Xclkbuf_10_359_0_CLK }
C {devices/lab_pin.sym} 96370 -9090 0 0 {name=p96108 lab=_82211_/CLK }
C {devices/lab_pin.sym} 96370 -9070 0 0 {name=p96109 lab=_82243_/Q }
C {devices/lab_pin.sym} 96550 -9090 0 1 {name=p96110 lab=_77239_/B }
C {sky130_stdcells/dfxtp_4.sym} 96460 -9080 0 0 {name=X_82211_ }
C {devices/lab_pin.sym} 96400 -8960 0 0 {name=p96111 lab=_67241_/A }
C {devices/lab_pin.sym} 96400 -8920 0 0 {name=p96112 lab=_86814_/Q }
C {devices/lab_pin.sym} 96520 -8940 0 1 {name=p96113 lab=_67145_/X }
C {sky130_stdcells/and2_4.sym} 96460 -8940 0 0 {name=X_67145_ }
C {devices/lab_pin.sym} 96380 -8830 0 0 {name=p96114 lab=_52368_/Y }
C {devices/lab_pin.sym} 96380 -8790 0 0 {name=p96115 lab=_52364_/X }
C {devices/lab_pin.sym} 96380 -8750 0 0 {name=p96116 lab=_52370_/X }
C {devices/lab_pin.sym} 96540 -8790 0 1 {name=p96117 lab=_52371_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -8790 0 0 {name=X_52371_ }
C {devices/lab_pin.sym} 96380 -8690 0 0 {name=p96118 lab=_64352_/X }
C {devices/lab_pin.sym} 96380 -8650 0 0 {name=p96119 lab=_64353_/X }
C {devices/lab_pin.sym} 96380 -8610 0 0 {name=p96120 lab=_64354_/X }
C {devices/lab_pin.sym} 96380 -8570 0 0 {name=p96121 lab=_64356_/Y }
C {devices/lab_pin.sym} 96380 -8530 0 0 {name=p96122 lab=_64326_/X }
C {devices/lab_pin.sym} 96540 -8610 0 1 {name=p96123 lab=_64357_/X }
C {sky130_stdcells/o41a_4.sym} 96460 -8610 0 0 {name=X_64357_ }
C {devices/lab_pin.sym} 96370 -8450 0 0 {name=p96124 lab=_83191_/CLK }
C {devices/lab_pin.sym} 96370 -8430 0 0 {name=p96125 lab=_72682_/X }
C {devices/lab_pin.sym} 96550 -8450 0 1 {name=p96126 lab=_70225_/C }
C {sky130_stdcells/dfxtp_4.sym} 96460 -8440 0 0 {name=X_83191_ }
C {devices/lab_pin.sym} 96420 -8310 0 0 {name=p96127 lab=clkbuf_9_494_0_CLK/X }
C {devices/lab_pin.sym} 96500 -8310 0 1 {name=p96128 lab=_85558_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 96460 -8310 0 0 {name=Xclkbuf_10_989_0_CLK }
C {devices/lab_pin.sym} 96420 -8190 0 0 {name=p96129 lab=_84861_/Q }
C {devices/lab_pin.sym} 96500 -8190 0 1 {name=p96130 lab=_61570_/B }
C {sky130_stdcells/buf_2.sym} 96460 -8190 0 0 {name=X_61569_ }
C {devices/lab_pin.sym} 96420 -8070 0 0 {name=p96131 lab=_54217_/A }
C {devices/lab_pin.sym} 96500 -8070 0 1 {name=p96132 lab=_54123_/B }
C {sky130_stdcells/buf_2.sym} 96460 -8070 0 0 {name=X_54110_ }
C {devices/lab_pin.sym} 96400 -7970 0 0 {name=p96133 lab=_50812_/A }
C {devices/lab_pin.sym} 96400 -7930 0 0 {name=p96134 lab=_51266_/B }
C {devices/lab_pin.sym} 96400 -7890 0 0 {name=p96135 lab=_51330_/C }
C {devices/lab_pin.sym} 96520 -7930 0 1 {name=p96136 lab=_51322_/X }
C {sky130_stdcells/and3_4.sym} 96460 -7930 0 0 {name=X_51322_ }
C {devices/lab_pin.sym} 96380 -7810 0 0 {name=p96137 lab=_63303_/X }
C {devices/lab_pin.sym} 96380 -7770 0 0 {name=p96138 lab=_63284_/X }
C {devices/lab_pin.sym} 96380 -7730 0 0 {name=p96139 lab=_63307_/Y }
C {devices/lab_pin.sym} 96540 -7770 0 1 {name=p96140 lab=_63308_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -7770 0 0 {name=X_63308_ }
C {devices/lab_pin.sym} 96370 -7630 0 0 {name=p96141 lab=_82575_/CLK }
C {devices/lab_pin.sym} 96370 -7610 0 0 {name=p96142 lab=_82142_/D }
C {devices/lab_pin.sym} 96550 -7630 0 1 {name=p96143 lab=_77468_/B }
C {sky130_stdcells/dfxtp_4.sym} 96460 -7620 0 0 {name=X_82142_ }
C {devices/lab_pin.sym} 96380 -7510 0 0 {name=p96144 lab=_85320_/Q }
C {devices/lab_pin.sym} 96380 -7470 0 0 {name=p96145 lab=_55072_/X }
C {devices/lab_pin.sym} 96380 -7430 0 0 {name=p96146 lab=_55089_/Y }
C {devices/lab_pin.sym} 96540 -7470 0 1 {name=p96147 lab=_55090_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -7470 0 0 {name=X_55090_ }
C {devices/lab_pin.sym} 96400 -7340 0 0 {name=p96148 lab=_67028_/A }
C {devices/lab_pin.sym} 96400 -7300 0 0 {name=p96149 lab=_88126_/Q }
C {devices/lab_pin.sym} 96520 -7320 0 1 {name=p96150 lab=_67076_/X }
C {sky130_stdcells/and2_4.sym} 96460 -7320 0 0 {name=X_67076_ }
C {devices/lab_pin.sym} 96380 -7210 0 0 {name=p96151 lab=_59471_/A }
C {devices/lab_pin.sym} 96380 -7170 0 0 {name=p96152 lab=_64249_/X }
C {devices/lab_pin.sym} 96380 -7130 0 0 {name=p96153 lab=_64287_/Y }
C {devices/lab_pin.sym} 96540 -7170 0 1 {name=p96154 lab=_64288_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -7170 0 0 {name=X_64288_ }
C {devices/lab_pin.sym} 96400 -7040 0 0 {name=p96155 lab=_54037_/A }
C {devices/lab_pin.sym} 96400 -7000 0 0 {name=p96156 lab=_52522_/B }
C {devices/lab_pin.sym} 96520 -7020 0 1 {name=p96157 lab=_54041_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -7020 0 0 {name=X_54041_ }
C {devices/lab_pin.sym} 96420 -6890 0 0 {name=p96158 lab=_65407_/A }
C {devices/lab_pin.sym} 96500 -6890 0 1 {name=p96159 lab=_66027_/X }
C {sky130_stdcells/buf_2.sym} 96460 -6890 0 0 {name=X_66027_ }
C {devices/lab_pin.sym} 96400 -6780 0 0 {name=p96160 lab=_51240_/A }
C {devices/lab_pin.sym} 96400 -6740 0 0 {name=p96161 lab=_46295_/X }
C {devices/lab_pin.sym} 96520 -6760 0 1 {name=p96162 lab=_51253_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -6760 0 0 {name=X_51253_ }
C {devices/lab_pin.sym} 96400 -6660 0 0 {name=p96163 lab=_63203_/X }
C {devices/lab_pin.sym} 96400 -6620 0 0 {name=p96164 lab=_84837_/Q }
C {devices/lab_pin.sym} 96400 -6580 0 0 {name=p96165 lab=_63204_/X }
C {devices/lab_pin.sym} 96400 -6540 0 0 {name=p96166 lab=_63239_/D }
C {devices/lab_pin.sym} 96520 -6600 0 1 {name=p96167 lab=_63239_/X }
C {sky130_stdcells/and4_4.sym} 96460 -6600 0 0 {name=X_63239_ }
C {devices/lab_pin.sym} 96370 -6450 0 0 {name=p96168 lab=_88208_/CLK }
C {devices/lab_pin.sym} 96370 -6430 0 0 {name=p96169 lab=_44797_/Y }
C {devices/lab_pin.sym} 96550 -6450 0 1 {name=p96170 lab=_86950_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -6440 0 0 {name=X_86950_ }
C {devices/lab_pin.sym} 96370 -6310 0 0 {name=p96171 lab=_81154_/CLK }
C {devices/lab_pin.sym} 96370 -6290 0 0 {name=p96172 lab=_82073_/D }
C {devices/lab_pin.sym} 96550 -6310 0 1 {name=p96173 lab=_82073_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -6300 0 0 {name=X_82073_ }
C {devices/lab_pin.sym} 96420 -6170 0 0 {name=p96174 lab=clkbuf_9_456_0_CLK/X }
C {devices/lab_pin.sym} 96500 -6170 0 1 {name=p96175 lab=_82553_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 96460 -6170 0 0 {name=Xclkbuf_10_912_0_CLK }
C {devices/lab_pin.sym} 96380 -6070 0 0 {name=p96176 lab=_86243_/Q }
C {devices/lab_pin.sym} 96380 -6030 0 0 {name=p96177 lab=_50185_/X }
C {devices/lab_pin.sym} 96380 -5990 0 0 {name=p96178 lab=_50203_/Y }
C {devices/lab_pin.sym} 96540 -6030 0 1 {name=p96179 lab=_50204_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -6030 0 0 {name=X_50204_ }
C {devices/lab_pin.sym} 96370 -5890 0 0 {name=p96180 lab=_86530_/CLK }
C {devices/lab_pin.sym} 96370 -5870 0 0 {name=p96181 lab=_85901_/D }
C {devices/lab_pin.sym} 96550 -5890 0 1 {name=p96182 lab=_85901_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -5880 0 0 {name=X_85901_ }
C {devices/lab_pin.sym} 96370 -5750 0 0 {name=p96183 lab=_84175_/CLK }
C {devices/lab_pin.sym} 96370 -5730 0 0 {name=p96184 lab=_81024_/D }
C {devices/lab_pin.sym} 96550 -5750 0 1 {name=p96185 lab=_81024_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -5740 0 0 {name=X_81024_ }
C {devices/lab_pin.sym} 96420 -5610 0 0 {name=p96186 lab=_51129_/A }
C {devices/lab_pin.sym} 96500 -5610 0 1 {name=p96187 lab=_51184_/X }
C {sky130_stdcells/buf_2.sym} 96460 -5610 0 0 {name=X_51184_ }
C {devices/lab_pin.sym} 96420 -5490 0 0 {name=p96188 lab=clkbuf_9_0_0_CLK/X }
C {devices/lab_pin.sym} 96500 -5490 0 1 {name=p96189 lab=_86900_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 96460 -5490 0 0 {name=Xclkbuf_10_1_0_CLK }
C {devices/lab_pin.sym} 96370 -5370 0 0 {name=p96190 lab=_86882_/CLK }
C {devices/lab_pin.sym} 96370 -5350 0 0 {name=p96191 lab=_45372_/Y }
C {devices/lab_pin.sym} 96550 -5370 0 1 {name=p96192 lab=_64545_/B }
C {sky130_stdcells/dfxtp_4.sym} 96460 -5360 0 0 {name=X_86881_ }
C {devices/lab_pin.sym} 96420 -5230 0 0 {name=p96193 lab=clkbuf_9_402_0_CLK/A }
C {devices/lab_pin.sym} 96500 -5230 0 1 {name=p96194 lab=clkbuf_9_403_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 96460 -5230 0 0 {name=Xclkbuf_9_403_0_CLK }
C {devices/lab_pin.sym} 96420 -5110 0 0 {name=p96195 lab=_57800_/A }
C {devices/lab_pin.sym} 96500 -5110 0 1 {name=p96196 lab=_57800_/X }
C {sky130_stdcells/buf_2.sym} 96460 -5110 0 0 {name=X_57800_ }
C {devices/lab_pin.sym} 96380 -5010 0 0 {name=p96197 lab=_50645_/A }
C {devices/lab_pin.sym} 96380 -4970 0 0 {name=p96198 lab=_50645_/B }
C {devices/lab_pin.sym} 96380 -4930 0 0 {name=p96199 lab=_47848_/X }
C {devices/lab_pin.sym} 96540 -4970 0 1 {name=p96200 lab=_50135_/X }
C {sky130_stdcells/o21a_4.sym} 96460 -4970 0 0 {name=X_50135_ }
C {devices/lab_pin.sym} 96370 -4830 0 0 {name=p96201 lab=_86154_/CLK }
C {devices/lab_pin.sym} 96370 -4810 0 0 {name=p96202 lab=_52392_/Y }
C {devices/lab_pin.sym} 96550 -4830 0 1 {name=p96203 lab=_65247_/B }
C {sky130_stdcells/dfxtp_4.sym} 96460 -4820 0 0 {name=X_85832_ }
C {devices/lab_pin.sym} 96400 -4700 0 0 {name=p96204 lab=_86704_/Q }
C {devices/lab_pin.sym} 96400 -4660 0 0 {name=p96205 lab=_58688_/B }
C {devices/lab_pin.sym} 96520 -4680 0 1 {name=p96206 lab=_58780_/Y }
C {sky130_stdcells/nor2_4.sym} 96460 -4680 0 0 {name=X_58780_ }
C {devices/lab_pin.sym} 96400 -4570 0 0 {name=p96207 lab=_55802_/X }
C {devices/lab_pin.sym} 96400 -4530 0 0 {name=p96208 lab=_55811_/X }
C {devices/lab_pin.sym} 96400 -4490 0 0 {name=p96209 lab=_56108_/A }
C {devices/lab_pin.sym} 96520 -4530 0 1 {name=p96210 lab=_56102_/B }
C {sky130_stdcells/nand3_4.sym} 96460 -4530 0 0 {name=X_55992_ }
C {devices/lab_pin.sym} 96380 -4410 0 0 {name=p96211 lab=_67973_/X }
C {devices/lab_pin.sym} 96380 -4370 0 0 {name=p96212 lab=_67976_/X }
C {devices/lab_pin.sym} 96380 -4330 0 0 {name=p96213 lab=_67977_/X }
C {devices/lab_pin.sym} 96540 -4370 0 1 {name=p96214 lab=_67978_/X }
C {sky130_stdcells/a21o_4.sym} 96460 -4370 0 0 {name=X_67978_ }
C {devices/lab_pin.sym} 96400 -4240 0 0 {name=p96215 lab=_44151_/X }
C {devices/lab_pin.sym} 96400 -4200 0 0 {name=p96216 lab=_57731_/B }
C {devices/lab_pin.sym} 96520 -4220 0 1 {name=p96217 lab=_57731_/Y }
C {sky130_stdcells/nor2_4.sym} 96460 -4220 0 0 {name=X_57731_ }
C {devices/lab_pin.sym} 96380 -4110 0 0 {name=p96218 lab=_83902_/Q }
C {devices/lab_pin.sym} 96380 -4070 0 0 {name=p96219 lab=_69696_/X }
C {devices/lab_pin.sym} 96380 -4030 0 0 {name=p96220 lab=_69716_/X }
C {devices/lab_pin.sym} 96540 -4070 0 1 {name=p96221 lab=_83902_/D }
C {sky130_stdcells/a21bo_4.sym} 96460 -4070 0 0 {name=X_69717_ }
C {devices/lab_pin.sym} 96380 -3950 0 0 {name=p96222 lab=_86271_/Q }
C {devices/lab_pin.sym} 96380 -3910 0 0 {name=p96223 lab=_50061_/X }
C {devices/lab_pin.sym} 96380 -3870 0 0 {name=p96224 lab=_50065_/Y }
C {devices/lab_pin.sym} 96540 -3910 0 1 {name=p96225 lab=_50066_/Y }
C {sky130_stdcells/o21ai_4.sym} 96460 -3910 0 0 {name=X_50066_ }
C {devices/lab_pin.sym} 96380 -3790 0 0 {name=p96226 lab=_54940_/Y }
C {devices/lab_pin.sym} 96380 -3750 0 0 {name=p96227 lab=_54936_/X }
C {devices/lab_pin.sym} 96380 -3710 0 0 {name=p96228 lab=_54942_/X }
C {devices/lab_pin.sym} 96540 -3750 0 1 {name=p96229 lab=_54943_/Y }
C {sky130_stdcells/a21oi_4.sym} 96460 -3750 0 0 {name=X_54943_ }
C {devices/lab_pin.sym} 96400 -3620 0 0 {name=p96230 lab=_66902_/X }
C {devices/lab_pin.sym} 96400 -3580 0 0 {name=p96231 lab=_86791_/Q }
C {devices/lab_pin.sym} 96520 -3600 0 1 {name=p96232 lab=_66929_/X }
C {sky130_stdcells/and2_4.sym} 96460 -3600 0 0 {name=X_66929_ }
C {devices/lab_pin.sym} 96370 -3470 0 0 {name=p96233 lab=_85764_/CLK }
C {devices/lab_pin.sym} 96370 -3450 0 0 {name=p96234 lab=_85763_/D }
C {devices/lab_pin.sym} 96550 -3470 0 1 {name=p96235 lab=_85763_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -3460 0 0 {name=X_85763_ }
C {devices/lab_pin.sym} 96370 -3330 0 0 {name=p96236 lab=_82975_/CLK }
C {devices/lab_pin.sym} 96370 -3310 0 0 {name=p96237 lab=_82783_/Q }
C {devices/lab_pin.sym} 96550 -3330 0 1 {name=p96238 lab=_46637_/A }
C {sky130_stdcells/dfxtp_4.sym} 96460 -3320 0 0 {name=X_82975_ }
C {devices/lab_pin.sym} 96420 -3190 0 0 {name=p96239 lab=clkbuf_9_463_0_CLK/X }
C {devices/lab_pin.sym} 96500 -3190 0 1 {name=p96240 lab=_86570_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 96460 -3190 0 0 {name=Xclkbuf_10_927_0_CLK }
C {devices/lab_pin.sym} 96370 -3070 0 0 {name=p96241 lab=_87520_/CLK }
C {devices/lab_pin.sym} 96370 -3050 0 0 {name=p96242 lab=_87502_/D }
C {devices/lab_pin.sym} 96550 -3070 0 1 {name=p96243 lab=_87502_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -3060 0 0 {name=X_87502_ }
C {devices/lab_pin.sym} 96370 -2930 0 0 {name=p96244 lab=_84714_/CLK }
C {devices/lab_pin.sym} 96370 -2910 0 0 {name=p96245 lab=_59507_/Y }
C {devices/lab_pin.sym} 96550 -2930 0 1 {name=p96246 lab=_64295_/C }
C {sky130_stdcells/dfxtp_4.sym} 96460 -2920 0 0 {name=X_84714_ }
C {devices/lab_pin.sym} 96380 -2810 0 0 {name=p96247 lab=_57650_/X }
C {devices/lab_pin.sym} 96380 -2770 0 0 {name=p96248 lab=_57659_/Y }
C {devices/lab_pin.sym} 96380 -2730 0 0 {name=p96249 lab=_57661_/Y }
C {devices/lab_pin.sym} 96540 -2770 0 1 {name=p96250 lab=_84959_/D }
C {sky130_stdcells/a21oi_4.sym} 96460 -2770 0 0 {name=X_57662_ }
C {devices/lab_pin.sym} 96370 -2630 0 0 {name=p96251 lab=_82124_/CLK }
C {devices/lab_pin.sym} 96370 -2610 0 0 {name=p96252 lab=_81926_/D }
C {devices/lab_pin.sym} 96550 -2630 0 1 {name=p96253 lab=_81926_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -2620 0 0 {name=X_81926_ }
C {devices/lab_pin.sym} 96400 -2500 0 0 {name=p96254 lab=_69648_/A }
C {devices/lab_pin.sym} 96400 -2460 0 0 {name=p96255 lab=_42558_/Y }
C {devices/lab_pin.sym} 96520 -2480 0 1 {name=p96256 lab=_69648_/Y }
C {sky130_stdcells/nor2_4.sym} 96460 -2480 0 0 {name=X_69648_ }
C {devices/lab_pin.sym} 96400 -2380 0 0 {name=p96257 lab=_54883_/A }
C {devices/lab_pin.sym} 96400 -2340 0 0 {name=p96258 lab=_54883_/B }
C {devices/lab_pin.sym} 96400 -2300 0 0 {name=p96259 lab=_54883_/C }
C {devices/lab_pin.sym} 96400 -2260 0 0 {name=p96260 lab=_53181_/D }
C {devices/lab_pin.sym} 96520 -2320 0 1 {name=p96261 lab=_54874_/X }
C {sky130_stdcells/and4_4.sym} 96460 -2320 0 0 {name=X_54874_ }
C {devices/lab_pin.sym} 96370 -2170 0 0 {name=p96262 lab=_85692_/CLK }
C {devices/lab_pin.sym} 96370 -2150 0 0 {name=p96263 lab=_85694_/D }
C {devices/lab_pin.sym} 96550 -2170 0 1 {name=p96264 lab=_85694_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -2160 0 0 {name=X_85694_ }
C {devices/lab_pin.sym} 96420 -2030 0 0 {name=p96265 lab=clkbuf_9_419_0_CLK/A }
C {devices/lab_pin.sym} 96500 -2030 0 1 {name=p96266 lab=clkbuf_9_418_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 96460 -2030 0 0 {name=Xclkbuf_9_418_0_CLK }
C {devices/lab_pin.sym} 96420 -1910 0 0 {name=p96267 lab=_84742_/Q }
C {devices/lab_pin.sym} 96500 -1910 0 1 {name=p96268 lab=_63139_/A }
C {sky130_stdcells/inv_2.sym} 96460 -1910 0 0 {name=X_59401_ }
C {devices/lab_pin.sym} 96420 -1790 0 0 {name=p96269 lab=_56613_/A }
C {devices/lab_pin.sym} 96500 -1790 0 1 {name=p96270 lab=_56613_/X }
C {sky130_stdcells/buf_2.sym} 96460 -1790 0 0 {name=X_56613_ }
C {devices/lab_pin.sym} 96370 -1670 0 0 {name=p96271 lab=_86796_/CLK }
C {devices/lab_pin.sym} 96370 -1650 0 0 {name=p96272 lab=_87433_/D }
C {devices/lab_pin.sym} 96550 -1670 0 1 {name=p96273 lab=_87433_/Q }
C {sky130_stdcells/dfxtp_4.sym} 96460 -1660 0 0 {name=X_87433_ }
C {devices/lab_pin.sym} 96400 -1540 0 0 {name=p96274 lab=_53825_/A }
C {devices/lab_pin.sym} 96400 -1500 0 0 {name=p96275 lab=_71998_/B }
C {devices/lab_pin.sym} 96520 -1520 0 1 {name=p96276 lab=_53825_/Y }
C {sky130_stdcells/nand2_4.sym} 96460 -1520 0 0 {name=X_53825_ }
C {devices/lab_pin.sym} 96370 -1390 0 0 {name=p96277 lab=_84645_/CLK }
C {devices/lab_pin.sym} 96370 -1370 0 0 {name=p96278 lab=_60261_/Y }
C {devices/lab_pin.sym} 96550 -1390 0 1 {name=p96279 lab=_79837_/A }
C {sky130_stdcells/dfxtp_4.sym} 96460 -1380 0 0 {name=X_84645_ }
C {devices/lab_pin.sym} 96400 -1270 0 0 {name=p96280 lab=_48046_/A }
C {devices/lab_pin.sym} 96400 -1230 0 0 {name=p96281 lab=_57619_/B }
C {devices/lab_pin.sym} 96400 -1190 0 0 {name=p96282 lab=_71960_/C }
C {devices/lab_pin.sym} 96520 -1230 0 1 {name=p96283 lab=_57593_/X }
C {sky130_stdcells/and3_4.sym} 96460 -1230 0 0 {name=X_57593_ }
C {devices/lab_pin.sym} 96420 -1090 0 0 {name=p96284 lab=_69746_/A }
C {devices/lab_pin.sym} 96500 -1090 0 1 {name=p96285 lab=_69579_/X }
C {sky130_stdcells/buf_2.sym} 96460 -1090 0 0 {name=X_69579_ }
C {devices/lab_pin.sym} 96370 -970 0 0 {name=p96286 lab=_81857_/CLK }
C {devices/lab_pin.sym} 96370 -950 0 0 {name=p96287 lab=_81857_/D }
C {devices/lab_pin.sym} 96550 -970 0 1 {name=p96288 lab=_77715_/A }
C {sky130_stdcells/dfxtp_4.sym} 96460 -960 0 0 {name=X_81857_ }
C {devices/lab_pin.sym} 96380 -850 0 0 {name=p96289 lab=_71604_/X }
C {devices/lab_pin.sym} 96380 -810 0 0 {name=p96290 lab=_83440_/Q }
C {devices/lab_pin.sym} 96380 -770 0 0 {name=p96291 lab=_71609_/Y }
C {devices/lab_pin.sym} 96540 -810 0 1 {name=p96292 lab=_83440_/D }
C {sky130_stdcells/a21o_4.sym} 96460 -810 0 0 {name=X_71610_ }
C {devices/lab_pin.sym} 96380 -690 0 0 {name=p96293 lab=_59273_/X }
C {devices/lab_pin.sym} 96380 -650 0 0 {name=p96294 lab=_85638_/Q }
C {devices/lab_pin.sym} 96380 -610 0 0 {name=p96295 lab=_59308_/X }
C {devices/lab_pin.sym} 96540 -650 0 1 {name=p96296 lab=_59332_/X }
C {sky130_stdcells/o21a_4.sym} 96460 -650 0 0 {name=X_59332_ }
C {devices/lab_pin.sym} 97320 -42170 0 0 {name=p96297 lab=_56175_/A }
C {devices/lab_pin.sym} 97320 -42130 0 0 {name=p96298 lab=_57364_/D }
C {devices/lab_pin.sym} 97320 -42090 0 0 {name=p96299 lab=_56174_/X }
C {devices/lab_pin.sym} 97440 -42130 0 1 {name=p96300 lab=_56546_/A }
C {sky130_stdcells/nand3_4.sym} 97380 -42130 0 0 {name=X_56544_ }
C {devices/lab_pin.sym} 97290 -41990 0 0 {name=p96301 lab=_80776_/CLK }
C {devices/lab_pin.sym} 97290 -41970 0 0 {name=p96302 lab=_80808_/D }
C {devices/lab_pin.sym} 97470 -41990 0 1 {name=p96303 lab=_80808_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -41980 0 0 {name=X_80808_ }
C {devices/lab_pin.sym} 97290 -41850 0 0 {name=p96304 lab=_86824_/CLK }
C {devices/lab_pin.sym} 97290 -41830 0 0 {name=p96305 lab=_87364_/D }
C {devices/lab_pin.sym} 97470 -41850 0 1 {name=p96306 lab=_87364_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -41840 0 0 {name=X_87364_ }
C {devices/lab_pin.sym} 97340 -41710 0 0 {name=p96307 lab=_48135_/A }
C {devices/lab_pin.sym} 97420 -41710 0 1 {name=p96308 lab=_48946_/A }
C {sky130_stdcells/buf_2.sym} 97380 -41710 0 0 {name=X_41770_ }
C {devices/lab_pin.sym} 97320 -41600 0 0 {name=p96309 lab=_53766_/A }
C {devices/lab_pin.sym} 97320 -41560 0 0 {name=p96310 lab=_48660_/A }
C {devices/lab_pin.sym} 97440 -41580 0 1 {name=p96311 lab=_53756_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -41580 0 0 {name=X_53756_ }
C {devices/lab_pin.sym} 97340 -41450 0 0 {name=p96312 lab=clkbuf_6_3_0_CLK/A }
C {devices/lab_pin.sym} 97420 -41450 0 1 {name=p96313 lab=clkbuf_7_6_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 97380 -41450 0 0 {name=Xclkbuf_6_3_0_CLK }
C {devices/lab_pin.sym} 97340 -41330 0 0 {name=p96314 lab=_72590_/A }
C {devices/lab_pin.sym} 97420 -41330 0 1 {name=p96315 lab=_72590_/X }
C {sky130_stdcells/buf_2.sym} 97380 -41330 0 0 {name=X_72590_ }
C {devices/lab_pin.sym} 97290 -41210 0 0 {name=p96316 lab=_84562_/CLK }
C {devices/lab_pin.sym} 97290 -41190 0 0 {name=p96317 lab=_60747_/Y }
C {devices/lab_pin.sym} 97470 -41210 0 1 {name=p96318 lab=_60746_/C }
C {sky130_stdcells/dfxtp_4.sym} 97380 -41200 0 0 {name=X_84576_ }
C {devices/lab_pin.sym} 97300 -41090 0 0 {name=p96319 lab=_86098_/Q }
C {devices/lab_pin.sym} 97300 -41050 0 0 {name=p96320 lab=_50965_/X }
C {devices/lab_pin.sym} 97300 -41010 0 0 {name=p96321 lab=_50967_/Y }
C {devices/lab_pin.sym} 97460 -41050 0 1 {name=p96322 lab=_50968_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -41050 0 0 {name=X_50968_ }
C {devices/lab_pin.sym} 97290 -40910 0 0 {name=p96323 lab=_86753_/CLK }
C {devices/lab_pin.sym} 97290 -40890 0 0 {name=p96324 lab=_81788_/D }
C {devices/lab_pin.sym} 97470 -40910 0 1 {name=p96325 lab=_81788_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -40900 0 0 {name=X_81788_ }
C {devices/lab_pin.sym} 97290 -40770 0 0 {name=p96326 lab=_86312_/CLK }
C {devices/lab_pin.sym} 97290 -40750 0 0 {name=p96327 lab=_49836_/Y }
C {devices/lab_pin.sym} 97470 -40770 0 1 {name=p96328 lab=_58026_/B }
C {sky130_stdcells/dfxtp_4.sym} 97380 -40760 0 0 {name=X_86315_ }
C {devices/lab_pin.sym} 97300 -40660 0 0 {name=p96329 lab=_40716_/X }
C {devices/lab_pin.sym} 97300 -40620 0 0 {name=p96330 lab=_40719_/X }
C {devices/lab_pin.sym} 97300 -40580 0 0 {name=p96331 lab=_88348_/Q }
C {devices/lab_pin.sym} 97300 -40540 0 0 {name=p96332 lab=_40720_/X }
C {devices/lab_pin.sym} 97460 -40600 0 1 {name=p96333 lab=_40721_/X }
C {sky130_stdcells/a2bb2o_4.sym} 97380 -40600 0 0 {name=X_40721_ }
C {devices/lab_pin.sym} 97300 -40470 0 0 {name=p96334 lab=_85769_/Q }
C {devices/lab_pin.sym} 97300 -40430 0 0 {name=p96335 lab=_52684_/X }
C {devices/lab_pin.sym} 97300 -40390 0 0 {name=p96336 lab=_52706_/Y }
C {devices/lab_pin.sym} 97460 -40430 0 1 {name=p96337 lab=_52707_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -40430 0 0 {name=X_52707_ }
C {devices/lab_pin.sym} 97340 -40290 0 0 {name=p96338 lab=_59037_/A }
C {devices/lab_pin.sym} 97420 -40290 0 1 {name=p96339 lab=_59263_/X }
C {sky130_stdcells/buf_2.sym} 97380 -40290 0 0 {name=X_59263_ }
C {devices/lab_pin.sym} 97340 -40170 0 0 {name=p96340 lab=_71585_/A }
C {devices/lab_pin.sym} 97420 -40170 0 1 {name=p96341 lab=_71546_/B }
C {sky130_stdcells/buf_2.sym} 97380 -40170 0 0 {name=X_71541_ }
C {devices/lab_pin.sym} 97290 -40050 0 0 {name=p96342 lab=_83498_/CLK }
C {devices/lab_pin.sym} 97290 -40030 0 0 {name=p96343 lab=_71358_/X }
C {devices/lab_pin.sym} 97470 -40050 0 1 {name=p96344 lab=_83527_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -40040 0 0 {name=X_83527_ }
C {devices/lab_pin.sym} 97320 -39930 0 0 {name=p96345 lab=_56474_/X }
C {devices/lab_pin.sym} 97320 -39890 0 0 {name=p96346 lab=_56472_/B }
C {devices/lab_pin.sym} 97320 -39850 0 0 {name=p96347 lab=_55960_/B }
C {devices/lab_pin.sym} 97440 -39890 0 1 {name=p96348 lab=_56475_/Y }
C {sky130_stdcells/nand3_4.sym} 97380 -39890 0 0 {name=X_56475_ }
C {devices/lab_pin.sym} 97290 -39750 0 0 {name=p96349 lab=_80740_/CLK }
C {devices/lab_pin.sym} 97290 -39730 0 0 {name=p96350 lab=_75094_/X }
C {devices/lab_pin.sym} 97470 -39750 0 1 {name=p96351 lab=_81147_/D }
C {sky130_stdcells/dfxtp_4.sym} 97380 -39740 0 0 {name=X_80739_ }
C {devices/lab_pin.sym} 97290 -39610 0 0 {name=p96352 lab=_87814_/CLK }
C {devices/lab_pin.sym} 97290 -39590 0 0 {name=p96353 lab=_43726_/Y }
C {devices/lab_pin.sym} 97470 -39610 0 1 {name=p96354 lab=_43724_/A }
C {sky130_stdcells/dfxtp_4.sym} 97380 -39600 0 0 {name=X_87295_ }
C {devices/lab_pin.sym} 97340 -39470 0 0 {name=p96355 lab=_53687_/A }
C {devices/lab_pin.sym} 97420 -39470 0 1 {name=p96356 lab=_53687_/X }
C {sky130_stdcells/buf_2.sym} 97380 -39470 0 0 {name=X_53687_ }
C {devices/lab_pin.sym} 97300 -39370 0 0 {name=p96357 lab=_50894_/Y }
C {devices/lab_pin.sym} 97300 -39330 0 0 {name=p96358 lab=_50839_/X }
C {devices/lab_pin.sym} 97300 -39290 0 0 {name=p96359 lab=_50898_/X }
C {devices/lab_pin.sym} 97460 -39330 0 1 {name=p96360 lab=_50899_/Y }
C {sky130_stdcells/a21oi_4.sym} 97380 -39330 0 0 {name=X_50899_ }
C {devices/lab_pin.sym} 97320 -39200 0 0 {name=p96361 lab=_63713_/A }
C {devices/lab_pin.sym} 97320 -39160 0 0 {name=p96362 lab=_58217_/B }
C {devices/lab_pin.sym} 97440 -39180 0 1 {name=p96363 lab=_58214_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -39180 0 0 {name=X_58214_ }
C {sky130_stdcells/decap_3.sym} 97380 -39020 0 0 {name=XPHY_400 }
C {devices/lab_pin.sym} 97320 -38880 0 0 {name=p96364 lab=_55156_/X }
C {devices/lab_pin.sym} 97320 -38840 0 0 {name=p96365 lab=_55160_/X }
C {devices/lab_pin.sym} 97440 -38860 0 1 {name=p96366 lab=_55426_/X }
C {sky130_stdcells/and2_4.sym} 97380 -38860 0 0 {name=X_55426_ }
C {devices/lab_pin.sym} 97300 -38760 0 0 {name=p96367 lab=_41580_/X }
C {devices/lab_pin.sym} 97300 -38720 0 0 {name=p96368 lab=_43431_/X }
C {devices/lab_pin.sym} 97300 -38680 0 0 {name=p96369 lab=_87420_/Q }
C {devices/lab_pin.sym} 97300 -38640 0 0 {name=p96370 lab=_43432_/X }
C {devices/lab_pin.sym} 97460 -38700 0 1 {name=p96371 lab=_43440_/X }
C {sky130_stdcells/a2bb2o_4.sym} 97380 -38700 0 0 {name=X_43440_ }
C {devices/lab_pin.sym} 97300 -38570 0 0 {name=p96372 lab=_74248_/X }
C {devices/lab_pin.sym} 97300 -38530 0 0 {name=p96373 lab=_74250_/X }
C {devices/lab_pin.sym} 97300 -38490 0 0 {name=p96374 lab=_74259_/X }
C {devices/lab_pin.sym} 97460 -38530 0 1 {name=p96375 lab=_74260_/X }
C {sky130_stdcells/a21o_4.sym} 97380 -38530 0 0 {name=X_74260_ }
C {devices/lab_pin.sym} 97290 -38390 0 0 {name=p96376 lab=_86246_/CLK }
C {devices/lab_pin.sym} 97290 -38370 0 0 {name=p96377 lab=_86246_/D }
C {devices/lab_pin.sym} 97470 -38390 0 1 {name=p96378 lab=_65315_/B }
C {sky130_stdcells/dfxtp_4.sym} 97380 -38380 0 0 {name=X_86246_ }
C {sky130_stdcells/decap_3.sym} 97380 -38220 0 0 {name=XPHY_411 }
C {devices/lab_pin.sym} 97300 -38090 0 0 {name=p96379 lab=_85782_/Q }
C {devices/lab_pin.sym} 97300 -38050 0 0 {name=p96380 lab=_52629_/X }
C {devices/lab_pin.sym} 97300 -38010 0 0 {name=p96381 lab=_52637_/Y }
C {devices/lab_pin.sym} 97460 -38050 0 1 {name=p96382 lab=_52638_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -38050 0 0 {name=X_52638_ }
C {devices/lab_pin.sym} 97340 -37910 0 0 {name=p96383 lab=_40599_/A }
C {devices/lab_pin.sym} 97420 -37910 0 1 {name=p96384 lab=_40652_/X }
C {sky130_stdcells/buf_2.sym} 97380 -37910 0 0 {name=X_40652_ }
C {devices/lab_pin.sym} 97300 -37810 0 0 {name=p96385 lab=_71464_/X }
C {devices/lab_pin.sym} 97300 -37770 0 0 {name=p96386 lab=_83487_/Q }
C {devices/lab_pin.sym} 97300 -37730 0 0 {name=p96387 lab=_71471_/X }
C {devices/lab_pin.sym} 97460 -37770 0 1 {name=p96388 lab=_71472_/X }
C {sky130_stdcells/a21o_4.sym} 97380 -37770 0 0 {name=X_71472_ }
C {devices/lab_pin.sym} 97320 -37640 0 0 {name=p96389 lab=_86673_/Q }
C {devices/lab_pin.sym} 97320 -37600 0 0 {name=p96390 lab=_59282_/B }
C {devices/lab_pin.sym} 97440 -37620 0 1 {name=p96391 lab=_59194_/Y }
C {sky130_stdcells/nor2_4.sym} 97380 -37620 0 0 {name=X_59194_ }
C {devices/lab_pin.sym} 97290 -37490 0 0 {name=p96392 lab=_83495_/CLK }
C {devices/lab_pin.sym} 97290 -37470 0 0 {name=p96393 lab=_83458_/D }
C {devices/lab_pin.sym} 97470 -37490 0 1 {name=p96394 lab=_83458_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -37480 0 0 {name=X_83458_ }
C {sky130_stdcells/decap_3.sym} 97380 -37320 0 0 {name=XPHY_422 }
C {sky130_stdcells/decap_3.sym} 97380 -37140 0 0 {name=XPHY_433 }
C {devices/lab_pin.sym} 97320 -37000 0 0 {name=p96395 lab=_73260_/A }
C {devices/lab_pin.sym} 97320 -36960 0 0 {name=p96396 lab=_86480_/Q }
C {devices/lab_pin.sym} 97440 -36980 0 1 {name=p96397 lab=_73211_/X }
C {sky130_stdcells/and2_4.sym} 97380 -36980 0 0 {name=X_73211_ }
C {sky130_stdcells/decap_3.sym} 97380 -36820 0 0 {name=XPHY_444 }
C {devices/lab_pin.sym} 97340 -36670 0 0 {name=p96398 lab=HASH_ADDR[0] }
C {devices/lab_pin.sym} 97420 -36670 0 1 {name=p96399 lab=_70423_/X }
C {sky130_stdcells/buf_2.sym} 97380 -36670 0 0 {name=X_70423_ }
C {devices/lab_pin.sym} 97340 -36550 0 0 {name=p96400 lab=_83497_/Q }
C {devices/lab_pin.sym} 97420 -36550 0 1 {name=p96401 lab=_58145_/Y }
C {sky130_stdcells/inv_2.sym} 97380 -36550 0 0 {name=X_58145_ }
C {devices/lab_pin.sym} 97290 -36430 0 0 {name=p96402 lab=_82820_/CLK }
C {devices/lab_pin.sym} 97290 -36410 0 0 {name=p96403 lab=_82409_/D }
C {devices/lab_pin.sym} 97470 -36430 0 1 {name=p96404 lab=_78403_/A }
C {sky130_stdcells/dfxtp_4.sym} 97380 -36420 0 0 {name=X_82409_ }
C {sky130_stdcells/decap_3.sym} 97380 -36260 0 0 {name=XPHY_455 }
C {devices/lab_pin.sym} 97340 -36110 0 0 {name=p96405 lab=_43396_/A }
C {devices/lab_pin.sym} 97420 -36110 0 1 {name=p96406 lab=_43371_/X }
C {sky130_stdcells/buf_2.sym} 97380 -36110 0 0 {name=X_43371_ }
C {devices/lab_pin.sym} 97300 -36010 0 0 {name=p96407 lab=_56708_/A }
C {devices/lab_pin.sym} 97300 -35970 0 0 {name=p96408 lab=_55445_/D }
C {devices/lab_pin.sym} 97300 -35930 0 0 {name=p96409 lab=_55353_/X }
C {devices/lab_pin.sym} 97460 -35970 0 1 {name=p96410 lab=_55369_/B }
C {sky130_stdcells/a21bo_4.sym} 97380 -35970 0 0 {name=X_55357_ }
C {devices/lab_pin.sym} 97320 -35840 0 0 {name=p96411 lab=_74188_/X }
C {devices/lab_pin.sym} 97320 -35800 0 0 {name=p96412 lab=_74190_/X }
C {devices/lab_pin.sym} 97440 -35820 0 1 {name=p96413 lab=_74191_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -35820 0 0 {name=X_74191_ }
C {devices/lab_pin.sym} 97290 -35690 0 0 {name=p96414 lab=_83311_/CLK }
C {devices/lab_pin.sym} 97290 -35670 0 0 {name=p96415 lab=_86177_/D }
C {devices/lab_pin.sym} 97470 -35690 0 1 {name=p96416 lab=_86177_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -35680 0 0 {name=X_86177_ }
C {devices/lab_pin.sym} 97340 -35550 0 0 {name=p96417 lab=_40583_/A }
C {devices/lab_pin.sym} 97420 -35550 0 1 {name=p96418 lab=_40583_/Y }
C {sky130_stdcells/inv_2.sym} 97380 -35550 0 0 {name=X_40583_ }
C {devices/lab_pin.sym} 97320 -35440 0 0 {name=p96419 lab=_52280_/X }
C {devices/lab_pin.sym} 97320 -35400 0 0 {name=p96420 lab=_54087_/B }
C {devices/lab_pin.sym} 97440 -35420 0 1 {name=p96421 lab=_52569_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -35420 0 0 {name=X_52569_ }
C {sky130_stdcells/decap_3.sym} 97380 -35260 0 0 {name=XPHY_466 }
C {devices/lab_pin.sym} 97290 -35110 0 0 {name=p96422 lab=_85499_/CLK }
C {devices/lab_pin.sym} 97290 -35090 0 0 {name=p96423 lab=_71752_/Y }
C {devices/lab_pin.sym} 97470 -35110 0 1 {name=p96424 lab=_47259_/A }
C {sky130_stdcells/dfxtp_4.sym} 97380 -35100 0 0 {name=X_83389_ }
C {sky130_stdcells/decap_3.sym} 97380 -34940 0 0 {name=XPHY_477 }
C {sky130_stdcells/decap_3.sym} 97380 -34760 0 0 {name=XPHY_488 }
C {devices/lab_pin.sym} 97340 -34610 0 0 {name=p96425 lab=_64364_/B }
C {devices/lab_pin.sym} 97420 -34610 0 1 {name=p96426 lab=_61489_/B }
C {sky130_stdcells/buf_2.sym} 97380 -34610 0 0 {name=X_45110_ }
C {devices/lab_pin.sym} 97340 -34490 0 0 {name=p96427 lab=_42321_/Y }
C {devices/lab_pin.sym} 97420 -34490 0 1 {name=p96428 lab=_42322_/Y }
C {sky130_stdcells/inv_2.sym} 97380 -34490 0 0 {name=X_42322_ }
C {devices/lab_pin.sym} 97300 -34390 0 0 {name=p96429 lab=_54306_/Y }
C {devices/lab_pin.sym} 97300 -34350 0 0 {name=p96430 lab=_54285_/X }
C {devices/lab_pin.sym} 97300 -34310 0 0 {name=p96431 lab=_54307_/X }
C {devices/lab_pin.sym} 97460 -34350 0 1 {name=p96432 lab=_54308_/Y }
C {sky130_stdcells/a21oi_4.sym} 97380 -34350 0 0 {name=X_54308_ }
C {sky130_stdcells/decap_3.sym} 97380 -34180 0 0 {name=XPHY_499 }
C {devices/lab_pin.sym} 97300 -34050 0 0 {name=p96433 lab=_73128_/X }
C {devices/lab_pin.sym} 97300 -34010 0 0 {name=p96434 lab=_73131_/Y }
C {devices/lab_pin.sym} 97300 -33970 0 0 {name=p96435 lab=_73141_/X }
C {devices/lab_pin.sym} 97460 -34010 0 1 {name=p96436 lab=_73142_/X }
C {sky130_stdcells/a21o_4.sym} 97380 -34010 0 0 {name=X_73142_ }
C {devices/lab_pin.sym} 97290 -33870 0 0 {name=p96437 lab=_85128_/CLK }
C {devices/lab_pin.sym} 97290 -33850 0 0 {name=p96438 lab=_56855_/Y }
C {devices/lab_pin.sym} 97470 -33870 0 1 {name=p96439 lab=_85128_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -33860 0 0 {name=X_85128_ }
C {devices/lab_pin.sym} 97340 -33730 0 0 {name=p96440 lab=_46112_/A }
C {devices/lab_pin.sym} 97420 -33730 0 1 {name=p96441 lab=_46090_/Y }
C {sky130_stdcells/inv_2.sym} 97380 -33730 0 0 {name=X_46090_ }
C {devices/lab_pin.sym} 97300 -33630 0 0 {name=p96442 lab=_58043_/X }
C {devices/lab_pin.sym} 97300 -33590 0 0 {name=p96443 lab=_85991_/Q }
C {devices/lab_pin.sym} 97300 -33550 0 0 {name=p96444 lab=_58075_/X }
C {devices/lab_pin.sym} 97460 -33590 0 1 {name=p96445 lab=_58076_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -33590 0 0 {name=X_58076_ }
C {devices/lab_pin.sym} 97320 -33480 0 0 {name=p96446 lab=_70496_/A }
C {devices/lab_pin.sym} 97320 -33440 0 0 {name=p96447 lab=_70412_/A }
C {devices/lab_pin.sym} 97320 -33400 0 0 {name=p96448 lab=HASH_ADDR[4] }
C {devices/lab_pin.sym} 97320 -33360 0 0 {name=p96449 lab=MACRO_WR_SELECT }
C {devices/lab_pin.sym} 97440 -33420 0 1 {name=p96450 lab=_70355_/A }
C {sky130_stdcells/and4_4.sym} 97380 -33420 0 0 {name=X_70354_ }
C {devices/lab_pin.sym} 97320 -33300 0 0 {name=p96451 lab=_55288_/A }
C {devices/lab_pin.sym} 97320 -33260 0 0 {name=p96452 lab=_55288_/B }
C {devices/lab_pin.sym} 97320 -33220 0 0 {name=p96453 lab=_55288_/C }
C {devices/lab_pin.sym} 97320 -33180 0 0 {name=p96454 lab=_55287_/X }
C {devices/lab_pin.sym} 97440 -33240 0 1 {name=p96455 lab=_55288_/Y }
C {sky130_stdcells/nand4_4.sym} 97380 -33240 0 0 {name=X_55288_ }
C {devices/lab_pin.sym} 97300 -33110 0 0 {name=p96456 lab=_85176_/Q }
C {devices/lab_pin.sym} 97300 -33070 0 0 {name=p96457 lab=_44982_/X }
C {devices/lab_pin.sym} 97300 -33030 0 0 {name=p96458 lab=_45040_/X }
C {devices/lab_pin.sym} 97460 -33070 0 1 {name=p96459 lab=_45041_/X }
C {sky130_stdcells/o21a_4.sym} 97380 -33070 0 0 {name=X_45041_ }
C {devices/lab_pin.sym} 97320 -32940 0 0 {name=p96460 lab=_57027_/A }
C {devices/lab_pin.sym} 97320 -32900 0 0 {name=p96461 lab=_57026_/X }
C {devices/lab_pin.sym} 97440 -32920 0 1 {name=p96462 lab=_57027_/Y }
C {sky130_stdcells/nor2_4.sym} 97380 -32920 0 0 {name=X_57027_ }
C {devices/lab_pin.sym} 97300 -32830 0 0 {name=p96463 lab=_42252_/X }
C {devices/lab_pin.sym} 97300 -32790 0 0 {name=p96464 lab=_42243_/X }
C {devices/lab_pin.sym} 97300 -32750 0 0 {name=p96465 lab=_41442_/X }
C {devices/lab_pin.sym} 97300 -32710 0 0 {name=p96466 lab=_87958_/Q }
C {devices/lab_pin.sym} 97300 -32670 0 0 {name=p96467 lab=_42244_/X }
C {devices/lab_pin.sym} 97460 -32750 0 1 {name=p96468 lab=_42254_/A }
C {sky130_stdcells/o32ai_4.sym} 97380 -32750 0 0 {name=X_42253_ }
C {devices/lab_pin.sym} 97320 -32600 0 0 {name=p96469 lab=_73073_/A }
C {devices/lab_pin.sym} 97320 -32560 0 0 {name=p96470 lab=_73073_/B }
C {devices/lab_pin.sym} 97440 -32580 0 1 {name=p96471 lab=_73073_/X }
C {sky130_stdcells/xor2_4.sym} 97380 -32580 0 0 {name=X_73073_ }
C {devices/lab_pin.sym} 97320 -32460 0 0 {name=p96472 lab=_54230_/A }
C {devices/lab_pin.sym} 97320 -32420 0 0 {name=p96473 lab=_53072_/B }
C {devices/lab_pin.sym} 97440 -32440 0 1 {name=p96474 lab=_54239_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -32440 0 0 {name=X_54239_ }
C {devices/lab_pin.sym} 97320 -32320 0 0 {name=p96475 lab=_77950_/A }
C {devices/lab_pin.sym} 97320 -32280 0 0 {name=p96476 lab=_77950_/B }
C {devices/lab_pin.sym} 97440 -32300 0 1 {name=p96477 lab=_77951_/B }
C {sky130_stdcells/xor2_4.sym} 97380 -32300 0 0 {name=X_77950_ }
C {devices/lab_pin.sym} 97290 -32170 0 0 {name=p96478 lab=_85005_/CLK }
C {devices/lab_pin.sym} 97290 -32150 0 0 {name=p96479 lab=_85059_/D }
C {devices/lab_pin.sym} 97470 -32170 0 1 {name=p96480 lab=_85059_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -32160 0 0 {name=X_85059_ }
C {devices/lab_pin.sym} 97320 -32060 0 0 {name=p96481 lab=_70292_/A }
C {devices/lab_pin.sym} 97320 -32020 0 0 {name=p96482 lab=_70292_/B }
C {devices/lab_pin.sym} 97320 -31980 0 0 {name=p96483 lab=_70285_/C }
C {devices/lab_pin.sym} 97320 -31940 0 0 {name=p96484 lab=_70292_/D }
C {devices/lab_pin.sym} 97440 -32000 0 1 {name=p96485 lab=_70285_/X }
C {sky130_stdcells/and4_4.sym} 97380 -32000 0 0 {name=X_70285_ }
C {devices/lab_pin.sym} 97300 -31880 0 0 {name=p96486 lab=_41203_/X }
C {devices/lab_pin.sym} 97300 -31840 0 0 {name=p96487 lab=_41181_/X }
C {devices/lab_pin.sym} 97300 -31800 0 0 {name=p96488 lab=_68796_/B }
C {devices/lab_pin.sym} 97300 -31760 0 0 {name=p96489 lab=_41182_/X }
C {devices/lab_pin.sym} 97460 -31820 0 1 {name=p96490 lab=_41204_/X }
C {sky130_stdcells/a2bb2o_4.sym} 97380 -31820 0 0 {name=X_41204_ }
C {devices/lab_pin.sym} 97340 -31670 0 0 {name=p96491 lab=_71993_/A }
C {devices/lab_pin.sym} 97420 -31670 0 1 {name=p96492 lab=_72025_/A }
C {sky130_stdcells/buf_2.sym} 97380 -31670 0 0 {name=X_72024_ }
C {devices/lab_pin.sym} 97320 -31570 0 0 {name=p96493 lab=_76901_/A }
C {devices/lab_pin.sym} 97320 -31530 0 0 {name=p96494 lab=_76893_/Y }
C {devices/lab_pin.sym} 97320 -31490 0 0 {name=p96495 lab=_76899_/Y }
C {devices/lab_pin.sym} 97440 -31530 0 1 {name=p96496 lab=_76902_/B }
C {sky130_stdcells/nand3_4.sym} 97380 -31530 0 0 {name=X_76901_ }
C {devices/lab_pin.sym} 97340 -31390 0 0 {name=p96497 lab=_42162_/A }
C {devices/lab_pin.sym} 97420 -31390 0 1 {name=p96498 lab=_42184_/X }
C {sky130_stdcells/buf_2.sym} 97380 -31390 0 0 {name=X_42184_ }
C {devices/lab_pin.sym} 97320 -31280 0 0 {name=p96499 lab=_82162_/Q }
C {devices/lab_pin.sym} 97320 -31240 0 0 {name=p96500 lab=_77880_/X }
C {devices/lab_pin.sym} 97440 -31260 0 1 {name=p96501 lab=_82130_/D }
C {sky130_stdcells/xor2_4.sym} 97380 -31260 0 0 {name=X_77881_ }
C {devices/lab_pin.sym} 97300 -31150 0 0 {name=p96502 lab=_86480_/Q }
C {devices/lab_pin.sym} 97300 -31110 0 0 {name=p96503 lab=_48781_/X }
C {devices/lab_pin.sym} 97300 -31070 0 0 {name=p96504 lab=_48799_/Y }
C {devices/lab_pin.sym} 97460 -31110 0 1 {name=p96505 lab=_48800_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -31110 0 0 {name=X_48800_ }
C {devices/lab_pin.sym} 97340 -30970 0 0 {name=p96506 lab=_79620_/A }
C {devices/lab_pin.sym} 97420 -30970 0 1 {name=p96507 lab=_79624_/A }
C {sky130_stdcells/inv_2.sym} 97380 -30970 0 0 {name=X_79620_ }
C {devices/lab_pin.sym} 97300 -30880 0 0 {name=p96508 lab=_41134_/X }
C {devices/lab_pin.sym} 97300 -30840 0 0 {name=p96509 lab=_41109_/X }
C {devices/lab_pin.sym} 97300 -30800 0 0 {name=p96510 lab=_68485_/B }
C {devices/lab_pin.sym} 97300 -30760 0 0 {name=p96511 lab=_41110_/X }
C {devices/lab_pin.sym} 97460 -30820 0 1 {name=p96512 lab=_41135_/X }
C {sky130_stdcells/a2bb2o_4.sym} 97380 -30820 0 0 {name=X_41135_ }
C {devices/lab_pin.sym} 97340 -30670 0 0 {name=p96513 lab=_76821_/Y }
C {devices/lab_pin.sym} 97420 -30670 0 1 {name=p96514 lab=_76832_/Y }
C {sky130_stdcells/inv_2.sym} 97380 -30670 0 0 {name=X_76832_ }
C {devices/lab_pin.sym} 97300 -30570 0 0 {name=p96515 lab=_49775_/Y }
C {devices/lab_pin.sym} 97300 -30530 0 0 {name=p96516 lab=_49759_/X }
C {devices/lab_pin.sym} 97300 -30490 0 0 {name=p96517 lab=_49779_/X }
C {devices/lab_pin.sym} 97460 -30530 0 1 {name=p96518 lab=_86325_/D }
C {sky130_stdcells/a21oi_4.sym} 97380 -30530 0 0 {name=X_49780_ }
C {devices/lab_pin.sym} 97300 -30410 0 0 {name=p96519 lab=_46986_/Y }
C {devices/lab_pin.sym} 97300 -30370 0 0 {name=p96520 lab=_46987_/X }
C {devices/lab_pin.sym} 97300 -30330 0 0 {name=p96521 lab=_46991_/X }
C {devices/lab_pin.sym} 97460 -30370 0 1 {name=p96522 lab=_86682_/D }
C {sky130_stdcells/a21oi_4.sym} 97380 -30370 0 0 {name=X_46992_ }
C {devices/lab_pin.sym} 97340 -30230 0 0 {name=p96523 lab=_84782_/Q }
C {devices/lab_pin.sym} 97420 -30230 0 1 {name=p96524 lab=_58978_/Y }
C {sky130_stdcells/inv_2.sym} 97380 -30230 0 0 {name=X_58978_ }
C {devices/lab_pin.sym} 97340 -30110 0 0 {name=p96525 lab=_48731_/A }
C {devices/lab_pin.sym} 97420 -30110 0 1 {name=p96526 lab=_48737_/A }
C {sky130_stdcells/buf_2.sym} 97380 -30110 0 0 {name=X_48731_ }
C {devices/lab_pin.sym} 97320 -30000 0 0 {name=p96527 lab=_79549_/Y }
C {devices/lab_pin.sym} 97320 -29960 0 0 {name=p96528 lab=_79550_/Y }
C {devices/lab_pin.sym} 97440 -29980 0 1 {name=p96529 lab=_79555_/A }
C {sky130_stdcells/nand2_4.sym} 97380 -29980 0 0 {name=X_79551_ }
C {devices/lab_pin.sym} 97340 -29850 0 0 {name=p96530 lab=_45943_/A }
C {devices/lab_pin.sym} 97420 -29850 0 1 {name=p96531 lab=_64961_/A }
C {sky130_stdcells/buf_2.sym} 97380 -29850 0 0 {name=X_45943_ }
C {devices/lab_pin.sym} 97340 -29730 0 0 {name=p96532 lab=_40989_/A }
C {devices/lab_pin.sym} 97420 -29730 0 1 {name=p96533 lab=_41066_/X }
C {sky130_stdcells/buf_2.sym} 97380 -29730 0 0 {name=X_41066_ }
C {devices/lab_pin.sym} 97300 -29630 0 0 {name=p96534 lab=_57925_/Y }
C {devices/lab_pin.sym} 97300 -29590 0 0 {name=p96535 lab=_57928_/Y }
C {devices/lab_pin.sym} 97300 -29550 0 0 {name=p96536 lab=_57889_/X }
C {devices/lab_pin.sym} 97460 -29590 0 1 {name=p96537 lab=_57929_/X }
C {sky130_stdcells/a21o_4.sym} 97380 -29590 0 0 {name=X_57929_ }
C {devices/lab_pin.sym} 97320 -29460 0 0 {name=p96538 lab=_76763_/A }
C {devices/lab_pin.sym} 97320 -29420 0 0 {name=p96539 lab=_76762_/Y }
C {devices/lab_pin.sym} 97440 -29440 0 1 {name=p96540 lab=_76764_/B }
C {sky130_stdcells/xor2_4.sym} 97380 -29440 0 0 {name=X_76763_ }
C {devices/lab_pin.sym} 97300 -29330 0 0 {name=p96541 lab=_73971_/X }
C {devices/lab_pin.sym} 97300 -29290 0 0 {name=p96542 lab=_73974_/X }
C {devices/lab_pin.sym} 97300 -29250 0 0 {name=p96543 lab=_73857_/X }
C {devices/lab_pin.sym} 97460 -29290 0 1 {name=p96544 lab=_73978_/A }
C {sky130_stdcells/a21o_4.sym} 97380 -29290 0 0 {name=X_73975_ }
C {devices/lab_pin.sym} 97320 -29160 0 0 {name=p96545 lab=_78503_/A }
C {devices/lab_pin.sym} 97320 -29120 0 0 {name=p96546 lab=_82672_/D }
C {devices/lab_pin.sym} 97440 -29140 0 1 {name=p96547 lab=_78505_/B }
C {sky130_stdcells/nor2_4.sym} 97380 -29140 0 0 {name=X_78502_ }
C {devices/lab_pin.sym} 97320 -29020 0 0 {name=p96548 lab=_81090_/Q }
C {devices/lab_pin.sym} 97320 -28980 0 0 {name=p96549 lab=_75714_/B }
C {devices/lab_pin.sym} 97440 -29000 0 1 {name=p96550 lab=_75714_/Y }
C {sky130_stdcells/xnor2_4.sym} 97380 -29000 0 0 {name=X_75714_ }
C {devices/lab_pin.sym} 97300 -28890 0 0 {name=p96551 lab=_86502_/Q }
C {devices/lab_pin.sym} 97300 -28850 0 0 {name=p96552 lab=_48612_/X }
C {devices/lab_pin.sym} 97300 -28810 0 0 {name=p96553 lab=_48661_/Y }
C {devices/lab_pin.sym} 97460 -28850 0 1 {name=p96554 lab=_48662_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -28850 0 0 {name=X_48662_ }
C {devices/lab_pin.sym} 97320 -28730 0 0 {name=p96555 lab=_60901_/A }
C {devices/lab_pin.sym} 97320 -28690 0 0 {name=p96556 lab=_64172_/D }
C {devices/lab_pin.sym} 97320 -28650 0 0 {name=p96557 lab=_60957_/B }
C {devices/lab_pin.sym} 97440 -28690 0 1 {name=p96558 lab=_60940_/Y }
C {sky130_stdcells/nor3_4.sym} 97380 -28690 0 0 {name=X_60940_ }
C {devices/lab_pin.sym} 97300 -28570 0 0 {name=p96559 lab=_72923_/X }
C {devices/lab_pin.sym} 97300 -28530 0 0 {name=p96560 lab=_72925_/X }
C {devices/lab_pin.sym} 97300 -28490 0 0 {name=p96561 lab=_72737_/X }
C {devices/lab_pin.sym} 97460 -28530 0 1 {name=p96562 lab=_72926_/X }
C {sky130_stdcells/a21o_4.sym} 97380 -28530 0 0 {name=X_72926_ }
C {devices/lab_pin.sym} 97320 -28400 0 0 {name=p96563 lab=_79481_/Y }
C {devices/lab_pin.sym} 97320 -28360 0 0 {name=p96564 lab=_79482_/B }
C {devices/lab_pin.sym} 97440 -28380 0 1 {name=p96565 lab=_79482_/X }
C {sky130_stdcells/and2_4.sym} 97380 -28380 0 0 {name=X_79482_ }
C {devices/lab_pin.sym} 97300 -28270 0 0 {name=p96566 lab=_85122_/Q }
C {devices/lab_pin.sym} 97300 -28230 0 0 {name=p96567 lab=_45627_/X }
C {devices/lab_pin.sym} 97300 -28190 0 0 {name=p96568 lab=_44889_/A }
C {devices/lab_pin.sym} 97460 -28230 0 1 {name=p96569 lab=_45874_/X }
C {sky130_stdcells/o21a_4.sym} 97380 -28230 0 0 {name=X_45874_ }
C {devices/lab_pin.sym} 97320 -28100 0 0 {name=p96570 lab=_76694_/A }
C {devices/lab_pin.sym} 97320 -28060 0 0 {name=p96571 lab=_76694_/B }
C {devices/lab_pin.sym} 97440 -28080 0 1 {name=p96572 lab=_81447_/D }
C {sky130_stdcells/xnor2_4.sym} 97380 -28080 0 0 {name=X_76694_ }
C {devices/lab_pin.sym} 97340 -27950 0 0 {name=p96573 lab=_46902_/A }
C {devices/lab_pin.sym} 97420 -27950 0 1 {name=p96574 lab=_47661_/A }
C {sky130_stdcells/buf_2.sym} 97380 -27950 0 0 {name=X_47613_ }
C {devices/lab_pin.sym} 97320 -27840 0 0 {name=p96575 lab=_78434_/B }
C {devices/lab_pin.sym} 97320 -27800 0 0 {name=p96576 lab=_78434_/A }
C {devices/lab_pin.sym} 97440 -27820 0 1 {name=p96577 lab=_78439_/B }
C {sky130_stdcells/or2_4.sym} 97380 -27820 0 0 {name=X_78433_ }
C {devices/lab_pin.sym} 97340 -27690 0 0 {name=p96578 lab=_44825_/A }
C {devices/lab_pin.sym} 97420 -27690 0 1 {name=p96579 lab=_86935_/D }
C {sky130_stdcells/inv_2.sym} 97380 -27690 0 0 {name=X_44825_ }
C {devices/lab_pin.sym} 97300 -27590 0 0 {name=p96580 lab=_75625_/Y }
C {devices/lab_pin.sym} 97300 -27550 0 0 {name=p96581 lab=_75641_/A }
C {devices/lab_pin.sym} 97300 -27510 0 0 {name=p96582 lab=_75644_/X }
C {devices/lab_pin.sym} 97460 -27550 0 1 {name=p96583 lab=_75645_/Y }
C {sky130_stdcells/a21oi_4.sym} 97380 -27550 0 0 {name=X_75645_ }
C {devices/lab_pin.sym} 97340 -27410 0 0 {name=p96584 lab=_48593_/A }
C {devices/lab_pin.sym} 97420 -27410 0 1 {name=p96585 lab=_48820_/B }
C {sky130_stdcells/buf_2.sym} 97380 -27410 0 0 {name=X_48593_ }
C {devices/lab_pin.sym} 97340 -27290 0 0 {name=p96586 lab=_73092_/A }
C {devices/lab_pin.sym} 97420 -27290 0 1 {name=p96587 lab=_72857_/X }
C {sky130_stdcells/buf_2.sym} 97380 -27290 0 0 {name=X_72857_ }
C {devices/lab_pin.sym} 97300 -27190 0 0 {name=p96588 lab=_60857_/D }
C {devices/lab_pin.sym} 97300 -27150 0 0 {name=p96589 lab=_60844_/X }
C {devices/lab_pin.sym} 97300 -27110 0 0 {name=p96590 lab=_60863_/X }
C {devices/lab_pin.sym} 97460 -27150 0 1 {name=p96591 lab=_60871_/Y }
C {sky130_stdcells/a21boi_4.sym} 97380 -27150 0 0 {name=X_60871_ }
C {devices/lab_pin.sym} 97300 -27030 0 0 {name=p96592 lab=_62196_/X }
C {devices/lab_pin.sym} 97300 -26990 0 0 {name=p96593 lab=_62162_/X }
C {devices/lab_pin.sym} 97300 -26950 0 0 {name=p96594 lab=_62609_/X }
C {devices/lab_pin.sym} 97460 -26990 0 1 {name=p96595 lab=_62610_/X }
C {sky130_stdcells/a21o_4.sym} 97380 -26990 0 0 {name=X_62610_ }
C {devices/lab_pin.sym} 97340 -26850 0 0 {name=p96596 lab=_47543_/Y }
C {devices/lab_pin.sym} 97420 -26850 0 1 {name=p96597 lab=_53109_/B }
C {sky130_stdcells/buf_2.sym} 97380 -26850 0 0 {name=X_47544_ }
C {devices/lab_pin.sym} 97320 -26750 0 0 {name=p96598 lab=_71779_/A }
C {devices/lab_pin.sym} 97320 -26710 0 0 {name=p96599 lab=_71424_/C }
C {devices/lab_pin.sym} 97320 -26670 0 0 {name=p96600 lab=_70852_/C }
C {devices/lab_pin.sym} 97440 -26710 0 1 {name=p96601 lab=_71808_/X }
C {sky130_stdcells/and3_4.sym} 97380 -26710 0 0 {name=X_71808_ }
C {devices/lab_pin.sym} 97320 -26590 0 0 {name=p96602 lab=_78362_/Y }
C {devices/lab_pin.sym} 97320 -26550 0 0 {name=p96603 lab=_78359_/X }
C {devices/lab_pin.sym} 97320 -26510 0 0 {name=p96604 lab=_78364_/C }
C {devices/lab_pin.sym} 97440 -26550 0 1 {name=p96605 lab=_78365_/A }
C {sky130_stdcells/nand3_4.sym} 97380 -26550 0 0 {name=X_78364_ }
C {devices/lab_pin.sym} 97300 -26440 0 0 {name=p96606 lab=_41301_/Y }
C {devices/lab_pin.sym} 97300 -26400 0 0 {name=p96607 lab=_44754_/X }
C {devices/lab_pin.sym} 97300 -26360 0 0 {name=p96608 lab=_86972_/Q }
C {devices/lab_pin.sym} 97300 -26320 0 0 {name=p96609 lab=_44755_/X }
C {devices/lab_pin.sym} 97460 -26380 0 1 {name=p96610 lab=_44756_/X }
C {sky130_stdcells/a2bb2o_4.sym} 97380 -26380 0 0 {name=X_44756_ }
C {devices/lab_pin.sym} 97340 -26230 0 0 {name=p96611 lab=_63528_/A }
C {devices/lab_pin.sym} 97420 -26230 0 1 {name=p96612 lab=_63615_/A }
C {sky130_stdcells/buf_2.sym} 97380 -26230 0 0 {name=X_63590_ }
C {devices/lab_pin.sym} 97300 -26130 0 0 {name=p96613 lab=_75573_/Y }
C {devices/lab_pin.sym} 97300 -26090 0 0 {name=p96614 lab=_75575_/Y }
C {devices/lab_pin.sym} 97300 -26050 0 0 {name=p96615 lab=_75570_/A }
C {devices/lab_pin.sym} 97460 -26090 0 1 {name=p96616 lab=_75586_/A }
C {sky130_stdcells/a21oi_4.sym} 97380 -26090 0 0 {name=X_75576_ }
C {devices/lab_pin.sym} 97300 -25990 0 0 {name=p96617 lab=_41965_/X }
C {devices/lab_pin.sym} 97300 -25950 0 0 {name=p96618 lab=_41956_/X }
C {devices/lab_pin.sym} 97300 -25910 0 0 {name=p96619 lab=_40734_/X }
C {devices/lab_pin.sym} 97300 -25870 0 0 {name=p96620 lab=_41966_/Y }
C {devices/lab_pin.sym} 97300 -25830 0 0 {name=p96621 lab=_41967_/X }
C {devices/lab_pin.sym} 97460 -25910 0 1 {name=p96622 lab=_88089_/D }
C {sky130_stdcells/o32ai_4.sym} 97380 -25910 0 0 {name=X_41968_ }
C {devices/lab_pin.sym} 97320 -25760 0 0 {name=p96623 lab=_72783_/X }
C {devices/lab_pin.sym} 97320 -25720 0 0 {name=p96624 lab=_72788_/B }
C {devices/lab_pin.sym} 97440 -25740 0 1 {name=p96625 lab=_72789_/B }
C {sky130_stdcells/nand2_4.sym} 97380 -25740 0 0 {name=X_72788_ }
C {devices/lab_pin.sym} 97320 -25630 0 0 {name=p96626 lab=_77315_/A }
C {devices/lab_pin.sym} 97320 -25590 0 0 {name=p96627 lab=_77315_/B }
C {devices/lab_pin.sym} 97320 -25550 0 0 {name=p96628 lab=_77315_/C }
C {devices/lab_pin.sym} 97440 -25590 0 1 {name=p96629 lab=_77316_/B }
C {sky130_stdcells/nand3_4.sym} 97380 -25590 0 0 {name=X_77315_ }
C {devices/lab_pin.sym} 97300 -25480 0 0 {name=p96630 lab=_40839_/A }
C {devices/lab_pin.sym} 97300 -25440 0 0 {name=p96631 lab=_43698_/X }
C {devices/lab_pin.sym} 97300 -25400 0 0 {name=p96632 lab=_69752_/B }
C {devices/lab_pin.sym} 97300 -25360 0 0 {name=p96633 lab=_43700_/X }
C {devices/lab_pin.sym} 97460 -25420 0 1 {name=p96634 lab=_43707_/X }
C {sky130_stdcells/a2bb2o_4.sym} 97380 -25420 0 0 {name=X_43707_ }
C {devices/lab_pin.sym} 97320 -25290 0 0 {name=p96635 lab=_62483_/X }
C {devices/lab_pin.sym} 97320 -25250 0 0 {name=p96636 lab=_62541_/B }
C {devices/lab_pin.sym} 97320 -25210 0 0 {name=p96637 lab=_62541_/C }
C {devices/lab_pin.sym} 97440 -25250 0 1 {name=p96638 lab=_62541_/Y }
C {sky130_stdcells/nor3_4.sym} 97380 -25250 0 0 {name=X_62541_ }
C {devices/lab_pin.sym} 97320 -25140 0 0 {name=p96639 lab=_74527_/A }
C {devices/lab_pin.sym} 97320 -25100 0 0 {name=p96640 lab=_74531_/B }
C {devices/lab_pin.sym} 97320 -25060 0 0 {name=p96641 lab=_74531_/C }
C {devices/lab_pin.sym} 97320 -25020 0 0 {name=p96642 lab=_74531_/D }
C {devices/lab_pin.sym} 97440 -25080 0 1 {name=p96643 lab=_74527_/Y }
C {sky130_stdcells/nand4_4.sym} 97380 -25080 0 0 {name=X_74527_ }
C {devices/lab_pin.sym} 97320 -24940 0 0 {name=p96644 lab=_46469_/B }
C {devices/lab_pin.sym} 97320 -24900 0 0 {name=p96645 lab=_40919_/B }
C {devices/lab_pin.sym} 97440 -24920 0 1 {name=p96646 lab=_40919_/X }
C {sky130_stdcells/or2_4.sym} 97380 -24920 0 0 {name=X_40919_ }
C {devices/lab_pin.sym} 97320 -24820 0 0 {name=p96647 lab=_47437_/X }
C {devices/lab_pin.sym} 97320 -24780 0 0 {name=p96648 lab=_47463_/X }
C {devices/lab_pin.sym} 97320 -24740 0 0 {name=p96649 lab=_47513_/C }
C {devices/lab_pin.sym} 97320 -24700 0 0 {name=p96650 lab=_53070_/D }
C {devices/lab_pin.sym} 97440 -24760 0 1 {name=p96651 lab=_47475_/X }
C {sky130_stdcells/and4_4.sym} 97380 -24760 0 0 {name=X_47475_ }
C {devices/lab_pin.sym} 97340 -24610 0 0 {name=p96652 lab=_71738_/X }
C {devices/lab_pin.sym} 97420 -24610 0 1 {name=p96653 lab=_71753_/D }
C {sky130_stdcells/buf_2.sym} 97380 -24610 0 0 {name=X_71739_ }
C {devices/lab_pin.sym} 97320 -24500 0 0 {name=p96654 lab=_78296_/A }
C {devices/lab_pin.sym} 97320 -24460 0 0 {name=p96655 lab=_78296_/B }
C {devices/lab_pin.sym} 97440 -24480 0 1 {name=p96656 lab=_78295_/Y }
C {sky130_stdcells/nor2_4.sym} 97380 -24480 0 0 {name=X_78295_ }
C {devices/lab_pin.sym} 97340 -24350 0 0 {name=p96657 lab=_43047_/A }
C {devices/lab_pin.sym} 97420 -24350 0 1 {name=p96658 lab=_44687_/X }
C {sky130_stdcells/buf_2.sym} 97380 -24350 0 0 {name=X_44687_ }
C {devices/lab_pin.sym} 97340 -24230 0 0 {name=p96659 lab=_88109_/Q }
C {devices/lab_pin.sym} 97420 -24230 0 1 {name=p96660 lab=_41899_/Y }
C {sky130_stdcells/inv_2.sym} 97380 -24230 0 0 {name=X_41899_ }
C {devices/lab_pin.sym} 97340 -24110 0 0 {name=p96661 lab=_49247_/A }
C {devices/lab_pin.sym} 97420 -24110 0 1 {name=p96662 lab=_49214_/X }
C {sky130_stdcells/buf_2.sym} 97380 -24110 0 0 {name=X_49214_ }
C {devices/lab_pin.sym} 97300 -24010 0 0 {name=p96663 lab=_46423_/X }
C {devices/lab_pin.sym} 97300 -23970 0 0 {name=p96664 lab=_49039_/A }
C {devices/lab_pin.sym} 97300 -23930 0 0 {name=p96665 lab=_46425_/Y }
C {devices/lab_pin.sym} 97460 -23970 0 1 {name=p96666 lab=_46427_/A }
C {sky130_stdcells/o21ai_4.sym} 97380 -23970 0 0 {name=X_46426_ }
C {devices/lab_pin.sym} 97320 -23840 0 0 {name=p96667 lab=_65159_/A }
C {devices/lab_pin.sym} 97320 -23800 0 0 {name=p96668 lab=_65260_/B }
C {devices/lab_pin.sym} 97440 -23820 0 1 {name=p96669 lab=_65260_/X }
C {sky130_stdcells/and2_4.sym} 97380 -23820 0 0 {name=X_65260_ }
C {devices/lab_pin.sym} 97320 -23700 0 0 {name=p96670 lab=_77244_/X }
C {devices/lab_pin.sym} 97320 -23660 0 0 {name=p96671 lab=_77261_/A }
C {devices/lab_pin.sym} 97440 -23680 0 1 {name=p96672 lab=_77246_/X }
C {sky130_stdcells/and2_4.sym} 97380 -23680 0 0 {name=X_77246_ }
C {devices/lab_pin.sym} 97340 -23550 0 0 {name=p96673 lab=_43637_/X }
C {devices/lab_pin.sym} 97420 -23550 0 1 {name=p96674 lab=_87333_/D }
C {sky130_stdcells/inv_2.sym} 97380 -23550 0 0 {name=X_43638_ }
C {devices/lab_pin.sym} 97340 -23430 0 0 {name=p96675 lab=_74458_/A }
C {devices/lab_pin.sym} 97420 -23430 0 1 {name=p96676 lab=_74478_/C }
C {sky130_stdcells/buf_2.sym} 97380 -23430 0 0 {name=X_74458_ }
C {devices/lab_pin.sym} 97320 -23340 0 0 {name=p96677 lab=_61551_/A }
C {devices/lab_pin.sym} 97320 -23300 0 0 {name=p96678 lab=_62472_/B }
C {devices/lab_pin.sym} 97320 -23260 0 0 {name=p96679 lab=_62490_/C }
C {devices/lab_pin.sym} 97320 -23220 0 0 {name=p96680 lab=_62566_/D }
C {devices/lab_pin.sym} 97440 -23280 0 1 {name=p96681 lab=_62472_/Y }
C {sky130_stdcells/nand4_4.sym} 97380 -23280 0 0 {name=X_62472_ }
C {devices/lab_pin.sym} 97320 -23150 0 0 {name=p96682 lab=_61182_/X }
C {devices/lab_pin.sym} 97320 -23110 0 0 {name=p96683 lab=_61301_/X }
C {devices/lab_pin.sym} 97320 -23070 0 0 {name=p96684 lab=_64211_/C }
C {devices/lab_pin.sym} 97440 -23110 0 1 {name=p96685 lab=_64211_/Y }
C {sky130_stdcells/nand3_4.sym} 97380 -23110 0 0 {name=X_64211_ }
C {devices/lab_pin.sym} 97320 -22980 0 0 {name=p96686 lab=_49117_/A }
C {devices/lab_pin.sym} 97320 -22940 0 0 {name=p96687 lab=_49144_/X }
C {devices/lab_pin.sym} 97440 -22960 0 1 {name=p96688 lab=_49145_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -22960 0 0 {name=X_49145_ }
C {devices/lab_pin.sym} 97340 -22830 0 0 {name=p96689 lab=_61422_/Y }
C {devices/lab_pin.sym} 97420 -22830 0 1 {name=p96690 lab=_61423_/Y }
C {sky130_stdcells/inv_2.sym} 97380 -22830 0 0 {name=X_61423_ }
C {devices/lab_pin.sym} 97320 -22720 0 0 {name=p96691 lab=_73409_/A }
C {devices/lab_pin.sym} 97320 -22680 0 0 {name=p96692 lab=_73408_/X }
C {devices/lab_pin.sym} 97440 -22700 0 1 {name=p96693 lab=_73409_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -22700 0 0 {name=X_73409_ }
C {devices/lab_pin.sym} 97320 -22580 0 0 {name=p96694 lab=_46326_/A }
C {devices/lab_pin.sym} 97320 -22540 0 0 {name=p96695 lab=_46356_/X }
C {devices/lab_pin.sym} 97440 -22560 0 1 {name=p96696 lab=_46357_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -22560 0 0 {name=X_46357_ }
C {devices/lab_pin.sym} 97300 -22460 0 0 {name=p96697 lab=_64835_/X }
C {devices/lab_pin.sym} 97300 -22420 0 0 {name=p96698 lab=_83291_/Q }
C {devices/lab_pin.sym} 97300 -22380 0 0 {name=p96699 lab=_65015_/X }
C {devices/lab_pin.sym} 97300 -22340 0 0 {name=p96700 lab=_65190_/X }
C {devices/lab_pin.sym} 97460 -22400 0 1 {name=p96701 lab=_65191_/X }
C {sky130_stdcells/a211o_4.sym} 97380 -22400 0 0 {name=X_65191_ }
C {devices/lab_pin.sym} 97320 -22260 0 0 {name=p96702 lab=_77177_/A }
C {devices/lab_pin.sym} 97320 -22220 0 0 {name=p96703 lab=_77177_/B }
C {devices/lab_pin.sym} 97440 -22240 0 1 {name=p96704 lab=_77178_/B }
C {sky130_stdcells/xnor2_4.sym} 97380 -22240 0 0 {name=X_77177_ }
C {devices/lab_pin.sym} 97300 -22140 0 0 {name=p96705 lab=_40507_/X }
C {devices/lab_pin.sym} 97300 -22100 0 0 {name=p96706 lab=_43560_/X }
C {devices/lab_pin.sym} 97300 -22060 0 0 {name=p96707 lab=_87356_/Q }
C {devices/lab_pin.sym} 97300 -22020 0 0 {name=p96708 lab=_43561_/X }
C {devices/lab_pin.sym} 97460 -22080 0 1 {name=p96709 lab=_43569_/X }
C {sky130_stdcells/a2bb2o_4.sym} 97380 -22080 0 0 {name=X_43569_ }
C {devices/lab_pin.sym} 97320 -21940 0 0 {name=p96710 lab=_74466_/A }
C {devices/lab_pin.sym} 97320 -21900 0 0 {name=p96711 lab=_74389_/B }
C {devices/lab_pin.sym} 97440 -21920 0 1 {name=p96712 lab=_74389_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -21920 0 0 {name=X_74389_ }
C {devices/lab_pin.sym} 97340 -21790 0 0 {name=p96713 lab=_45308_/A }
C {devices/lab_pin.sym} 97420 -21790 0 1 {name=p96714 lab=_61636_/B }
C {sky130_stdcells/buf_2.sym} 97380 -21790 0 0 {name=X_45308_ }
C {devices/lab_pin.sym} 97320 -21700 0 0 {name=p96715 lab=_61655_/A }
C {devices/lab_pin.sym} 97320 -21660 0 0 {name=p96716 lab=_64177_/B }
C {devices/lab_pin.sym} 97320 -21620 0 0 {name=p96717 lab=_64155_/C }
C {devices/lab_pin.sym} 97320 -21580 0 0 {name=p96718 lab=_64142_/D }
C {devices/lab_pin.sym} 97440 -21640 0 1 {name=p96719 lab=_64142_/Y }
C {sky130_stdcells/nand4_4.sym} 97380 -21640 0 0 {name=X_64142_ }
C {devices/lab_pin.sym} 97300 -21510 0 0 {name=p96720 lab=_76123_/Y }
C {devices/lab_pin.sym} 97300 -21470 0 0 {name=p96721 lab=_76099_/B }
C {devices/lab_pin.sym} 97300 -21430 0 0 {name=p96722 lab=_76127_/X }
C {devices/lab_pin.sym} 97460 -21470 0 1 {name=p96723 lab=_76129_/B }
C {sky130_stdcells/o21ai_4.sym} 97380 -21470 0 0 {name=X_76128_ }
C {devices/lab_pin.sym} 97320 -21350 0 0 {name=p96724 lab=_61329_/A }
C {devices/lab_pin.sym} 97320 -21310 0 0 {name=p96725 lab=_61354_/B }
C {devices/lab_pin.sym} 97320 -21270 0 0 {name=p96726 lab=_61375_/C }
C {devices/lab_pin.sym} 97440 -21310 0 1 {name=p96727 lab=_61354_/Y }
C {sky130_stdcells/nand3_4.sym} 97380 -21310 0 0 {name=X_61354_ }
C {devices/lab_pin.sym} 97340 -21170 0 0 {name=p96728 lab=_48995_/A }
C {devices/lab_pin.sym} 97420 -21170 0 1 {name=p96729 lab=_49080_/A }
C {sky130_stdcells/buf_2.sym} 97380 -21170 0 0 {name=X_49076_ }
C {devices/lab_pin.sym} 97320 -21060 0 0 {name=p96730 lab=_46288_/A }
C {devices/lab_pin.sym} 97320 -21020 0 0 {name=p96731 lab=_53959_/B }
C {devices/lab_pin.sym} 97440 -21040 0 1 {name=p96732 lab=_46288_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -21040 0 0 {name=X_46288_ }
C {devices/lab_pin.sym} 97300 -20930 0 0 {name=p96733 lab=_60268_/C }
C {devices/lab_pin.sym} 97300 -20890 0 0 {name=p96734 lab=_60300_/B }
C {devices/lab_pin.sym} 97300 -20850 0 0 {name=p96735 lab=_60337_/C }
C {devices/lab_pin.sym} 97460 -20890 0 1 {name=p96736 lab=_60305_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -20890 0 0 {name=X_60305_ }
C {devices/lab_pin.sym} 97300 -20770 0 0 {name=p96737 lab=_47971_/X }
C {devices/lab_pin.sym} 97300 -20730 0 0 {name=p96738 lab=_46459_/A }
C {devices/lab_pin.sym} 97300 -20690 0 0 {name=p96739 lab=_48026_/X }
C {devices/lab_pin.sym} 97460 -20730 0 1 {name=p96740 lab=_48028_/B }
C {sky130_stdcells/o21ai_4.sym} 97380 -20730 0 0 {name=X_48027_ }
C {devices/lab_pin.sym} 97300 -20610 0 0 {name=p96741 lab=_56250_/C }
C {devices/lab_pin.sym} 97300 -20570 0 0 {name=p96742 lab=_45222_/X }
C {devices/lab_pin.sym} 97300 -20530 0 0 {name=p96743 lab=_45238_/X }
C {devices/lab_pin.sym} 97460 -20570 0 1 {name=p96744 lab=_45239_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -20570 0 0 {name=X_45239_ }
C {devices/lab_pin.sym} 97300 -20460 0 0 {name=p96745 lab=_87080_/Q }
C {devices/lab_pin.sym} 97300 -20420 0 0 {name=p96746 lab=_68948_/X }
C {devices/lab_pin.sym} 97300 -20380 0 0 {name=p96747 lab=_68875_/X }
C {devices/lab_pin.sym} 97300 -20340 0 0 {name=p96748 lab=_68949_/X }
C {devices/lab_pin.sym} 97460 -20400 0 1 {name=p96749 lab=_68950_/X }
C {sky130_stdcells/a211o_4.sym} 97380 -20400 0 0 {name=X_68950_ }
C {devices/lab_pin.sym} 97340 -20250 0 0 {name=p96750 lab=_63912_/X }
C {devices/lab_pin.sym} 97420 -20250 0 1 {name=p96751 lab=_64073_/X }
C {sky130_stdcells/buf_2.sym} 97380 -20250 0 0 {name=X_64073_ }
C {devices/lab_pin.sym} 97300 -20150 0 0 {name=p96752 lab=_76052_/Y }
C {devices/lab_pin.sym} 97300 -20110 0 0 {name=p96753 lab=_76063_/A }
C {devices/lab_pin.sym} 97300 -20070 0 0 {name=p96754 lab=_76058_/Y }
C {devices/lab_pin.sym} 97460 -20110 0 1 {name=p96755 lab=_76060_/B }
C {sky130_stdcells/a21boi_4.sym} 97380 -20110 0 0 {name=X_76059_ }
C {devices/lab_pin.sym} 97320 -20000 0 0 {name=p96756 lab=_59536_/A }
C {devices/lab_pin.sym} 97320 -19960 0 0 {name=p96757 lab=_60122_/A }
C {devices/lab_pin.sym} 97320 -19920 0 0 {name=p96758 lab=_61285_/C }
C {devices/lab_pin.sym} 97320 -19880 0 0 {name=p96759 lab=_60122_/C }
C {devices/lab_pin.sym} 97440 -19940 0 1 {name=p96760 lab=_72621_/B }
C {sky130_stdcells/and4_4.sym} 97380 -19940 0 0 {name=X_61285_ }
C {devices/lab_pin.sym} 97300 -19810 0 0 {name=p96761 lab=_79502_/A }
C {devices/lab_pin.sym} 97300 -19770 0 0 {name=p96762 lab=_63008_/X }
C {devices/lab_pin.sym} 97300 -19730 0 0 {name=p96763 lab=_63023_/Y }
C {devices/lab_pin.sym} 97460 -19770 0 1 {name=p96764 lab=_84360_/D }
C {sky130_stdcells/a21o_4.sym} 97380 -19770 0 0 {name=X_63024_ }
C {devices/lab_pin.sym} 97320 -19640 0 0 {name=p96765 lab=_67901_/A }
C {devices/lab_pin.sym} 97320 -19600 0 0 {name=p96766 lab=_67901_/B }
C {devices/lab_pin.sym} 97440 -19620 0 1 {name=p96767 lab=_67901_/X }
C {sky130_stdcells/and2_4.sym} 97380 -19620 0 0 {name=X_67901_ }
C {devices/lab_pin.sym} 97340 -19490 0 0 {name=p96768 lab=_60227_/A }
C {devices/lab_pin.sym} 97420 -19490 0 1 {name=p96769 lab=_60254_/B }
C {sky130_stdcells/buf_2.sym} 97380 -19490 0 0 {name=X_60236_ }
C {devices/lab_pin.sym} 97300 -19390 0 0 {name=p96770 lab=_83957_/Q }
C {devices/lab_pin.sym} 97300 -19350 0 0 {name=p96771 lab=_68838_/X }
C {devices/lab_pin.sym} 97300 -19310 0 0 {name=p96772 lab=_68880_/X }
C {devices/lab_pin.sym} 97460 -19350 0 1 {name=p96773 lab=_68881_/X }
C {sky130_stdcells/a21bo_4.sym} 97380 -19350 0 0 {name=X_68881_ }
C {devices/lab_pin.sym} 97320 -19220 0 0 {name=p96774 lab=_67901_/A }
C {devices/lab_pin.sym} 97320 -19180 0 0 {name=p96775 lab=_67832_/B }
C {devices/lab_pin.sym} 97440 -19200 0 1 {name=p96776 lab=_67832_/X }
C {sky130_stdcells/and2_4.sym} 97380 -19200 0 0 {name=X_67832_ }
C {devices/lab_pin.sym} 97320 -19080 0 0 {name=p96777 lab=_79816_/X }
C {devices/lab_pin.sym} 97320 -19040 0 0 {name=p96778 lab=_79817_/X }
C {devices/lab_pin.sym} 97440 -19060 0 1 {name=p96779 lab=_79818_/Y }
C {sky130_stdcells/xnor2_4.sym} 97380 -19060 0 0 {name=X_79818_ }
C {devices/lab_pin.sym} 97320 -18950 0 0 {name=p96780 lab=_60387_/A }
C {devices/lab_pin.sym} 97320 -18910 0 0 {name=p96781 lab=_60164_/Y }
C {devices/lab_pin.sym} 97320 -18870 0 0 {name=p96782 lab=_60166_/X }
C {devices/lab_pin.sym} 97440 -18910 0 1 {name=p96783 lab=_60168_/A }
C {sky130_stdcells/and3_4.sym} 97380 -18910 0 0 {name=X_60167_ }
C {devices/lab_pin.sym} 97340 -18770 0 0 {name=p96784 lab=_46308_/A }
C {devices/lab_pin.sym} 97420 -18770 0 1 {name=p96785 lab=_49995_/A }
C {sky130_stdcells/buf_2.sym} 97380 -18770 0 0 {name=X_49978_ }
C {devices/lab_pin.sym} 97300 -18670 0 0 {name=p96786 lab=_48923_/Y }
C {devices/lab_pin.sym} 97300 -18630 0 0 {name=p96787 lab=_48880_/X }
C {devices/lab_pin.sym} 97300 -18590 0 0 {name=p96788 lab=_48928_/X }
C {devices/lab_pin.sym} 97460 -18630 0 1 {name=p96789 lab=_86461_/D }
C {sky130_stdcells/a21oi_4.sym} 97380 -18630 0 0 {name=X_48929_ }
C {devices/lab_pin.sym} 97300 -18520 0 0 {name=p96790 lab=_87969_/Q }
C {devices/lab_pin.sym} 97300 -18480 0 0 {name=p96791 lab=_67713_/X }
C {devices/lab_pin.sym} 97300 -18440 0 0 {name=p96792 lab=_67761_/X }
C {devices/lab_pin.sym} 97300 -18400 0 0 {name=p96793 lab=_67762_/X }
C {devices/lab_pin.sym} 97460 -18460 0 1 {name=p96794 lab=_67763_/X }
C {sky130_stdcells/a211o_4.sym} 97380 -18460 0 0 {name=X_67763_ }
C {devices/lab_pin.sym} 97300 -18330 0 0 {name=p96795 lab=_79736_/X }
C {devices/lab_pin.sym} 97300 -18290 0 0 {name=p96796 lab=_79747_/X }
C {devices/lab_pin.sym} 97300 -18250 0 0 {name=p96797 lab=_79748_/X }
C {devices/lab_pin.sym} 97460 -18290 0 1 {name=p96798 lab=_79749_/Y }
C {sky130_stdcells/a21oi_4.sym} 97380 -18290 0 0 {name=X_79749_ }
C {devices/lab_pin.sym} 97300 -18180 0 0 {name=p96799 lab=_64971_/X }
C {devices/lab_pin.sym} 97300 -18140 0 0 {name=p96800 lab=_86131_/Q }
C {devices/lab_pin.sym} 97300 -18100 0 0 {name=p96801 lab=_64972_/X }
C {devices/lab_pin.sym} 97300 -18060 0 0 {name=p96802 lab=_64974_/X }
C {devices/lab_pin.sym} 97460 -18120 0 1 {name=p96803 lab=_64975_/X }
C {sky130_stdcells/a211o_4.sym} 97380 -18120 0 0 {name=X_64975_ }
C {devices/lab_pin.sym} 97300 -18010 0 0 {name=p96804 lab=_60078_/X }
C {devices/lab_pin.sym} 97300 -17970 0 0 {name=p96805 lab=_60092_/B }
C {devices/lab_pin.sym} 97300 -17930 0 0 {name=p96806 lab=_60045_/Y }
C {devices/lab_pin.sym} 97300 -17890 0 0 {name=p96807 lab=_60096_/Y }
C {devices/lab_pin.sym} 97300 -17860 0 0 {name=p96808 lab=_60097_/Y }
C {devices/lab_pin.sym} 97460 -17930 0 1 {name=p96809 lab=_84662_/D }
C {sky130_stdcells/a41oi_4.sym} 97380 -17930 0 0 {name=X_60098_ }
C {devices/lab_pin.sym} 97340 -17770 0 0 {name=p96810 lab=clkbuf_9_25_0_CLK/X }
C {devices/lab_pin.sym} 97420 -17770 0 1 {name=p96811 lab=_85042_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 97380 -17770 0 0 {name=Xclkbuf_10_50_0_CLK }
C {devices/lab_pin.sym} 97300 -17680 0 0 {name=p96812 lab=_69423_/X }
C {devices/lab_pin.sym} 97300 -17640 0 0 {name=p96813 lab=_69499_/Y }
C {devices/lab_pin.sym} 97300 -17600 0 0 {name=p96814 lab=_69405_/X }
C {devices/lab_pin.sym} 97300 -17560 0 0 {name=p96815 lab=_69501_/Y }
C {devices/lab_pin.sym} 97460 -17620 0 1 {name=p96816 lab=_69502_/X }
C {sky130_stdcells/a211o_4.sym} 97380 -17620 0 0 {name=X_69502_ }
C {devices/lab_pin.sym} 97300 -17490 0 0 {name=p96817 lab=_66711_/X }
C {devices/lab_pin.sym} 97300 -17450 0 0 {name=p96818 lab=_66713_/X }
C {devices/lab_pin.sym} 97300 -17410 0 0 {name=p96819 lab=_66667_/X }
C {devices/lab_pin.sym} 97460 -17450 0 1 {name=p96820 lab=_66720_/A }
C {sky130_stdcells/a21o_4.sym} 97380 -17450 0 0 {name=X_66714_ }
C {devices/lab_pin.sym} 97300 -17330 0 0 {name=p96821 lab=_65932_/B }
C {devices/lab_pin.sym} 97300 -17290 0 0 {name=p96822 lab=_51929_/X }
C {devices/lab_pin.sym} 97300 -17250 0 0 {name=p96823 lab=_51939_/Y }
C {devices/lab_pin.sym} 97460 -17290 0 1 {name=p96824 lab=_51940_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -17290 0 0 {name=X_51940_ }
C {devices/lab_pin.sym} 97320 -17170 0 0 {name=p96825 lab=_63942_/A }
C {devices/lab_pin.sym} 97320 -17130 0 0 {name=p96826 lab=_59403_/A }
C {devices/lab_pin.sym} 97320 -17090 0 0 {name=p96827 lab=_63958_/C }
C {devices/lab_pin.sym} 97440 -17130 0 1 {name=p96828 lab=_63926_/X }
C {sky130_stdcells/and3_4.sym} 97380 -17130 0 0 {name=X_63926_ }
C {devices/lab_pin.sym} 97290 -16990 0 0 {name=p96829 lab=_82961_/CLK }
C {devices/lab_pin.sym} 97290 -16970 0 0 {name=p96830 lab=_82760_/D }
C {devices/lab_pin.sym} 97470 -16990 0 1 {name=p96831 lab=_82760_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -16980 0 0 {name=X_82760_ }
C {devices/lab_pin.sym} 97300 -16880 0 0 {name=p96832 lab=_87396_/Q }
C {devices/lab_pin.sym} 97300 -16840 0 0 {name=p96833 lab=_67594_/X }
C {devices/lab_pin.sym} 97300 -16800 0 0 {name=p96834 lab=_67595_/X }
C {devices/lab_pin.sym} 97300 -16760 0 0 {name=p96835 lab=_67693_/X }
C {devices/lab_pin.sym} 97460 -16820 0 1 {name=p96836 lab=_67694_/X }
C {sky130_stdcells/a211o_4.sym} 97380 -16820 0 0 {name=X_67694_ }
C {devices/lab_pin.sym} 97340 -16670 0 0 {name=p96837 lab=clkbuf_9_141_0_CLK/X }
C {devices/lab_pin.sym} 97420 -16670 0 1 {name=p96838 lab=_83756_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 97380 -16670 0 0 {name=Xclkbuf_10_283_0_CLK }
C {devices/lab_pin.sym} 97290 -16550 0 0 {name=p96839 lab=_87348_/CLK }
C {devices/lab_pin.sym} 97290 -16530 0 0 {name=p96840 lab=_81711_/D }
C {devices/lab_pin.sym} 97470 -16550 0 1 {name=p96841 lab=_41207_/A }
C {sky130_stdcells/dfxtp_4.sym} 97380 -16540 0 0 {name=X_81711_ }
C {devices/lab_pin.sym} 97340 -16410 0 0 {name=p96842 lab=_69156_/A }
C {devices/lab_pin.sym} 97420 -16410 0 1 {name=p96843 lab=_69433_/X }
C {sky130_stdcells/buf_2.sym} 97380 -16410 0 0 {name=X_69433_ }
C {devices/lab_pin.sym} 97300 -16320 0 0 {name=p96844 lab=_87376_/Q }
C {devices/lab_pin.sym} 97300 -16280 0 0 {name=p96845 lab=_66642_/X }
C {devices/lab_pin.sym} 97300 -16240 0 0 {name=p96846 lab=_66643_/X }
C {devices/lab_pin.sym} 97300 -16200 0 0 {name=p96847 lab=_66644_/X }
C {devices/lab_pin.sym} 97460 -16260 0 1 {name=p96848 lab=_66645_/X }
C {sky130_stdcells/a211o_4.sym} 97380 -16260 0 0 {name=X_66645_ }
C {devices/lab_pin.sym} 97300 -16130 0 0 {name=p96849 lab=_51868_/Y }
C {devices/lab_pin.sym} 97300 -16090 0 0 {name=p96850 lab=_51850_/X }
C {devices/lab_pin.sym} 97300 -16050 0 0 {name=p96851 lab=_51870_/X }
C {devices/lab_pin.sym} 97460 -16090 0 1 {name=p96852 lab=_51871_/Y }
C {sky130_stdcells/a21oi_4.sym} 97380 -16090 0 0 {name=X_51871_ }
C {devices/lab_pin.sym} 97320 -15980 0 0 {name=p96853 lab=_64294_/B }
C {devices/lab_pin.sym} 97320 -15940 0 0 {name=p96854 lab=_63790_/X }
C {devices/lab_pin.sym} 97320 -15900 0 0 {name=p96855 lab=_63840_/C }
C {devices/lab_pin.sym} 97320 -15860 0 0 {name=p96856 lab=_63920_/D }
C {devices/lab_pin.sym} 97440 -15920 0 1 {name=p96857 lab=_63857_/Y }
C {sky130_stdcells/nand4_4.sym} 97380 -15920 0 0 {name=X_63857_ }
C {devices/lab_pin.sym} 97290 -15770 0 0 {name=p96858 lab=_82147_/CLK }
C {devices/lab_pin.sym} 97290 -15750 0 0 {name=p96859 lab=_78821_/X }
C {devices/lab_pin.sym} 97470 -15770 0 1 {name=p96860 lab=_82679_/D }
C {sky130_stdcells/dfxtp_4.sym} 97380 -15760 0 0 {name=X_82691_ }
C {devices/lab_pin.sym} 97340 -15630 0 0 {name=p96861 lab=_53846_/A }
C {devices/lab_pin.sym} 97420 -15630 0 1 {name=p96862 lab=_53610_/X }
C {sky130_stdcells/buf_2.sym} 97380 -15630 0 0 {name=X_53610_ }
C {devices/lab_pin.sym} 97290 -15510 0 0 {name=p96863 lab=_84430_/CLK }
C {devices/lab_pin.sym} 97290 -15490 0 0 {name=p96864 lab=_62145_/Y }
C {devices/lab_pin.sym} 97470 -15510 0 1 {name=p96865 lab=_78053_/B }
C {sky130_stdcells/dfxtp_4.sym} 97380 -15500 0 0 {name=X_84430_ }
C {devices/lab_pin.sym} 97320 -15380 0 0 {name=p96866 lab=_50822_/A }
C {devices/lab_pin.sym} 97320 -15340 0 0 {name=p96867 lab=_51328_/B }
C {devices/lab_pin.sym} 97440 -15360 0 1 {name=p96868 lab=_50822_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -15360 0 0 {name=X_50822_ }
C {devices/lab_pin.sym} 97340 -15230 0 0 {name=p96869 lab=_60217_/A }
C {devices/lab_pin.sym} 97420 -15230 0 1 {name=p96870 lab=_62808_/X }
C {sky130_stdcells/buf_2.sym} 97380 -15230 0 0 {name=X_62808_ }
C {devices/lab_pin.sym} 97290 -15110 0 0 {name=p96871 lab=_81275_/CLK }
C {devices/lab_pin.sym} 97290 -15090 0 0 {name=p96872 lab=_81674_/Q }
C {devices/lab_pin.sym} 97470 -15110 0 1 {name=p96873 lab=_81642_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -15100 0 0 {name=X_81642_ }
C {devices/lab_pin.sym} 97300 -14990 0 0 {name=p96874 lab=_69360_/X }
C {devices/lab_pin.sym} 97300 -14950 0 0 {name=p96875 lab=_69363_/X }
C {devices/lab_pin.sym} 97300 -14910 0 0 {name=p96876 lab=_69142_/X }
C {devices/lab_pin.sym} 97460 -14950 0 1 {name=p96877 lab=_69364_/Y }
C {sky130_stdcells/a21oi_4.sym} 97380 -14950 0 0 {name=X_69364_ }
C {devices/lab_pin.sym} 97340 -14810 0 0 {name=p96878 lab=_54537_/A }
C {devices/lab_pin.sym} 97420 -14810 0 1 {name=p96879 lab=_54591_/C }
C {sky130_stdcells/buf_2.sym} 97380 -14810 0 0 {name=X_54590_ }
C {devices/lab_pin.sym} 97340 -14690 0 0 {name=p96880 lab=clkbuf_9_32_0_CLK/X }
C {devices/lab_pin.sym} 97420 -14690 0 1 {name=p96881 lab=_80670_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 97380 -14690 0 0 {name=Xclkbuf_10_65_0_CLK }
C {devices/lab_pin.sym} 97340 -14570 0 0 {name=p96882 lab=_68742_/A }
C {devices/lab_pin.sym} 97420 -14570 0 1 {name=p96883 lab=_69223_/A }
C {sky130_stdcells/buf_2.sym} 97380 -14570 0 0 {name=X_66576_ }
C {devices/lab_pin.sym} 97340 -14450 0 0 {name=p96884 lab=_63751_/X }
C {devices/lab_pin.sym} 97420 -14450 0 1 {name=p96885 lab=_63820_/D }
C {sky130_stdcells/buf_2.sym} 97380 -14450 0 0 {name=X_63788_ }
C {devices/lab_pin.sym} 97300 -14350 0 0 {name=p96886 lab=_67941_/X }
C {devices/lab_pin.sym} 97300 -14310 0 0 {name=p96887 lab=_67944_/X }
C {devices/lab_pin.sym} 97300 -14270 0 0 {name=p96888 lab=_68283_/X }
C {devices/lab_pin.sym} 97460 -14310 0 1 {name=p96889 lab=_68315_/Y }
C {sky130_stdcells/a21oi_4.sym} 97380 -14310 0 0 {name=X_68315_ }
C {devices/lab_pin.sym} 97340 -14170 0 0 {name=p96890 lab=clkbuf_8_211_0_CLK/A }
C {devices/lab_pin.sym} 97420 -14170 0 1 {name=p96891 lab=clkbuf_9_423_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 97380 -14170 0 0 {name=Xclkbuf_8_211_0_CLK }
C {devices/lab_pin.sym} 97340 -14050 0 0 {name=p96892 lab=_53723_/A }
C {devices/lab_pin.sym} 97420 -14050 0 1 {name=p96893 lab=_53548_/A }
C {sky130_stdcells/buf_2.sym} 97380 -14050 0 0 {name=X_53541_ }
C {devices/lab_pin.sym} 97320 -13950 0 0 {name=p96894 lab=_65523_/X }
C {devices/lab_pin.sym} 97320 -13910 0 0 {name=p96895 lab=_65631_/B }
C {devices/lab_pin.sym} 97320 -13870 0 0 {name=p96896 lab=_65526_/X }
C {devices/lab_pin.sym} 97440 -13910 0 1 {name=p96897 lab=_65527_/Y }
C {sky130_stdcells/nand3_4.sym} 97380 -13910 0 0 {name=X_65527_ }
C {devices/lab_pin.sym} 97290 -13770 0 0 {name=p96898 lab=_83216_/CLK }
C {devices/lab_pin.sym} 97290 -13750 0 0 {name=p96899 lab=_84361_/D }
C {devices/lab_pin.sym} 97470 -13770 0 1 {name=p96900 lab=_79513_/A }
C {sky130_stdcells/dfxtp_4.sym} 97380 -13760 0 0 {name=X_84361_ }
C {devices/lab_pin.sym} 97320 -13640 0 0 {name=p96901 lab=_50799_/A }
C {devices/lab_pin.sym} 97320 -13600 0 0 {name=p96902 lab=_51261_/B }
C {devices/lab_pin.sym} 97440 -13620 0 1 {name=p96903 lab=_50753_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -13620 0 0 {name=X_50753_ }
C {devices/lab_pin.sym} 97300 -13530 0 0 {name=p96904 lab=_58248_/A }
C {devices/lab_pin.sym} 97300 -13490 0 0 {name=p96905 lab=_62689_/X }
C {devices/lab_pin.sym} 97300 -13450 0 0 {name=p96906 lab=_62708_/X }
C {devices/lab_pin.sym} 97300 -13410 0 0 {name=p96907 lab=_62699_/X }
C {devices/lab_pin.sym} 97300 -13380 0 0 {name=p96908 lab=_62738_/X }
C {devices/lab_pin.sym} 97460 -13450 0 1 {name=p96909 lab=_62739_/Y }
C {sky130_stdcells/a41oi_4.sym} 97380 -13450 0 0 {name=X_62739_ }
C {devices/lab_pin.sym} 97290 -13290 0 0 {name=p96910 lab=_84079_/CLK }
C {devices/lab_pin.sym} 97290 -13270 0 0 {name=p96911 lab=_65855_/C }
C {devices/lab_pin.sym} 97470 -13290 0 1 {name=p96912 lab=_76682_/A }
C {sky130_stdcells/dfxtp_4.sym} 97380 -13280 0 0 {name=X_81573_ }
C {devices/lab_pin.sym} 97340 -13150 0 0 {name=p96913 lab=_69575_/A }
C {devices/lab_pin.sym} 97420 -13150 0 1 {name=p96914 lab=_69295_/X }
C {sky130_stdcells/buf_2.sym} 97380 -13150 0 0 {name=X_69295_ }
C {devices/lab_pin.sym} 97340 -13030 0 0 {name=p96915 lab=clkbuf_9_149_0_CLK/X }
C {devices/lab_pin.sym} 97420 -13030 0 1 {name=p96916 lab=_84713_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 97380 -13030 0 0 {name=Xclkbuf_10_298_0_CLK }
C {devices/lab_pin.sym} 97290 -12910 0 0 {name=p96917 lab=_86100_/CLK }
C {devices/lab_pin.sym} 97290 -12890 0 0 {name=p96918 lab=_86100_/D }
C {devices/lab_pin.sym} 97470 -12910 0 1 {name=p96919 lab=_86100_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -12900 0 0 {name=X_86100_ }
C {devices/lab_pin.sym} 97290 -12770 0 0 {name=p96920 lab=_85547_/CLK }
C {devices/lab_pin.sym} 97290 -12750 0 0 {name=p96921 lab=_83312_/D }
C {devices/lab_pin.sym} 97470 -12770 0 1 {name=p96922 lab=_83312_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -12760 0 0 {name=X_83312_ }
C {devices/lab_pin.sym} 97300 -12650 0 0 {name=p96923 lab=_80518_/A }
C {devices/lab_pin.sym} 97300 -12610 0 0 {name=p96924 lab=_80518_/B }
C {devices/lab_pin.sym} 97300 -12570 0 0 {name=p96925 lab=_80523_/Y }
C {devices/lab_pin.sym} 97460 -12610 0 1 {name=p96926 lab=_80542_/A }
C {sky130_stdcells/a21boi_4.sym} 97380 -12610 0 0 {name=X_80524_ }
C {devices/lab_pin.sym} 97300 -12490 0 0 {name=p96927 lab=_56144_/X }
C {devices/lab_pin.sym} 97300 -12450 0 0 {name=p96928 lab=_56255_/X }
C {devices/lab_pin.sym} 97300 -12410 0 0 {name=p96929 lab=_56259_/Y }
C {devices/lab_pin.sym} 97460 -12450 0 1 {name=p96930 lab=_85256_/D }
C {sky130_stdcells/o21ai_4.sym} 97380 -12450 0 0 {name=X_56260_ }
C {devices/lab_pin.sym} 97340 -12310 0 0 {name=p96931 lab=_68376_/A }
C {devices/lab_pin.sym} 97420 -12310 0 1 {name=p96932 lab=_68246_/X }
C {sky130_stdcells/buf_2.sym} 97380 -12310 0 0 {name=X_68246_ }
C {devices/lab_pin.sym} 97290 -12190 0 0 {name=p96933 lab=_87083_/CLK }
C {devices/lab_pin.sym} 97290 -12170 0 0 {name=p96934 lab=_87080_/D }
C {devices/lab_pin.sym} 97470 -12190 0 1 {name=p96935 lab=_87080_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -12180 0 0 {name=X_87080_ }
C {devices/lab_pin.sym} 97340 -12050 0 0 {name=p96936 lab=_53982_/A }
C {devices/lab_pin.sym} 97420 -12050 0 1 {name=p96937 lab=_53472_/X }
C {sky130_stdcells/buf_2.sym} 97380 -12050 0 0 {name=X_53472_ }
C {devices/lab_pin.sym} 97300 -11950 0 0 {name=p96938 lab=_65452_/X }
C {devices/lab_pin.sym} 97300 -11910 0 0 {name=p96939 lab=_65456_/X }
C {devices/lab_pin.sym} 97300 -11870 0 0 {name=p96940 lab=_65457_/X }
C {devices/lab_pin.sym} 97460 -11910 0 1 {name=p96941 lab=_65458_/X }
C {sky130_stdcells/a21o_4.sym} 97380 -11910 0 0 {name=X_65458_ }
C {devices/lab_pin.sym} 97290 -11770 0 0 {name=p96942 lab=_84292_/CLK }
C {devices/lab_pin.sym} 97290 -11750 0 0 {name=p96943 lab=_63835_/Y }
C {devices/lab_pin.sym} 97470 -11770 0 1 {name=p96944 lab=_84292_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -11760 0 0 {name=X_84292_ }
C {devices/lab_pin.sym} 97320 -11640 0 0 {name=p96945 lab=_50640_/A }
C {devices/lab_pin.sym} 97320 -11600 0 0 {name=p96946 lab=_53902_/B }
C {devices/lab_pin.sym} 97440 -11620 0 1 {name=p96947 lab=_50684_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -11620 0 0 {name=X_50684_ }
C {devices/lab_pin.sym} 97320 -11500 0 0 {name=p96948 lab=_55149_/A }
C {devices/lab_pin.sym} 97320 -11460 0 0 {name=p96949 lab=_55211_/B }
C {devices/lab_pin.sym} 97440 -11480 0 1 {name=p96950 lab=_55211_/X }
C {sky130_stdcells/and2_4.sym} 97380 -11480 0 0 {name=X_55211_ }
C {devices/lab_pin.sym} 97290 -11350 0 0 {name=p96951 lab=_86424_/CLK }
C {devices/lab_pin.sym} 97290 -11330 0 0 {name=p96952 lab=_51327_/Y }
C {devices/lab_pin.sym} 97470 -11350 0 1 {name=p96953 lab=_86031_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -11340 0 0 {name=X_86031_ }
C {devices/lab_pin.sym} 97340 -11210 0 0 {name=p96954 lab=_52602_/A }
C {devices/lab_pin.sym} 97420 -11210 0 1 {name=p96955 lab=_52448_/A }
C {sky130_stdcells/buf_2.sym} 97380 -11210 0 0 {name=X_52423_ }
C {devices/lab_pin.sym} 97320 -11100 0 0 {name=p96956 lab=_58438_/A }
C {devices/lab_pin.sym} 97320 -11060 0 0 {name=p96957 lab=_64418_/B }
C {devices/lab_pin.sym} 97440 -11080 0 1 {name=p96958 lab=_64409_/Y }
C {sky130_stdcells/nor2_4.sym} 97380 -11080 0 0 {name=X_64409_ }
C {devices/lab_pin.sym} 97290 -10950 0 0 {name=p96959 lab=_84835_/CLK }
C {devices/lab_pin.sym} 97290 -10930 0 0 {name=p96960 lab=_83243_/D }
C {devices/lab_pin.sym} 97470 -10950 0 1 {name=p96961 lab=_83243_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -10940 0 0 {name=X_83243_ }
C {devices/lab_pin.sym} 97340 -10810 0 0 {name=p96962 lab=_56123_/A }
C {devices/lab_pin.sym} 97420 -10810 0 1 {name=p96963 lab=_56192_/B }
C {sky130_stdcells/buf_2.sym} 97380 -10810 0 0 {name=X_56191_ }
C {devices/lab_pin.sym} 97320 -10700 0 0 {name=p96964 lab=_80455_/A }
C {devices/lab_pin.sym} 97320 -10660 0 0 {name=p96965 lab=_80455_/B }
C {devices/lab_pin.sym} 97440 -10680 0 1 {name=p96966 lab=_80456_/B }
C {sky130_stdcells/xor2_4.sym} 97380 -10680 0 0 {name=X_80455_ }
C {devices/lab_pin.sym} 97300 -10570 0 0 {name=p96967 lab=_67109_/X }
C {devices/lab_pin.sym} 97300 -10530 0 0 {name=p96968 lab=_67112_/X }
C {devices/lab_pin.sym} 97300 -10490 0 0 {name=p96969 lab=_68169_/X }
C {devices/lab_pin.sym} 97460 -10530 0 1 {name=p96970 lab=_68177_/Y }
C {sky130_stdcells/a21oi_4.sym} 97380 -10530 0 0 {name=X_68177_ }
C {devices/lab_pin.sym} 97340 -10390 0 0 {name=p96971 lab=_64729_/A }
C {devices/lab_pin.sym} 97420 -10390 0 1 {name=p96972 lab=_65389_/X }
C {sky130_stdcells/buf_2.sym} 97380 -10390 0 0 {name=X_65389_ }
C {devices/lab_pin.sym} 97340 -10270 0 0 {name=p96973 lab=clkbuf_8_227_0_CLK/A }
C {devices/lab_pin.sym} 97420 -10270 0 1 {name=p96974 lab=clkbuf_8_226_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 97380 -10270 0 0 {name=Xclkbuf_8_226_0_CLK }
C {devices/lab_pin.sym} 97340 -10150 0 0 {name=p96975 lab=_55142_/A }
C {devices/lab_pin.sym} 97420 -10150 0 1 {name=p96976 lab=_55278_/A }
C {sky130_stdcells/buf_2.sym} 97380 -10150 0 0 {name=X_55142_ }
C {devices/lab_pin.sym} 97320 -10040 0 0 {name=p96977 lab=_67149_/A }
C {devices/lab_pin.sym} 97320 -10000 0 0 {name=p96978 lab=_67128_/B }
C {devices/lab_pin.sym} 97440 -10020 0 1 {name=p96979 lab=_67128_/X }
C {sky130_stdcells/and2_4.sym} 97380 -10020 0 0 {name=X_67128_ }
C {devices/lab_pin.sym} 97340 -9890 0 0 {name=p96980 lab=clkbuf_9_110_0_CLK/X }
C {devices/lab_pin.sym} 97420 -9890 0 1 {name=p96981 lab=_84624_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 97380 -9890 0 0 {name=Xclkbuf_10_221_0_CLK }
C {devices/lab_pin.sym} 97300 -9790 0 0 {name=p96982 lab=_85839_/Q }
C {devices/lab_pin.sym} 97300 -9750 0 0 {name=p96983 lab=_52347_/X }
C {devices/lab_pin.sym} 97300 -9710 0 0 {name=p96984 lab=_52353_/Y }
C {devices/lab_pin.sym} 97460 -9750 0 1 {name=p96985 lab=_52354_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -9750 0 0 {name=X_52354_ }
C {devices/lab_pin.sym} 97290 -9610 0 0 {name=p96986 lab=_83161_/CLK }
C {devices/lab_pin.sym} 97290 -9590 0 0 {name=p96987 lab=_83174_/D }
C {devices/lab_pin.sym} 97470 -9610 0 1 {name=p96988 lab=_83174_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -9600 0 0 {name=X_83174_ }
C {devices/lab_pin.sym} 97300 -9490 0 0 {name=p96989 lab=_80384_/Y }
C {devices/lab_pin.sym} 97300 -9450 0 0 {name=p96990 lab=_80366_/B }
C {devices/lab_pin.sym} 97300 -9410 0 0 {name=p96991 lab=_80385_/X }
C {devices/lab_pin.sym} 97460 -9450 0 1 {name=p96992 lab=_80386_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -9450 0 0 {name=X_80386_ }
C {devices/lab_pin.sym} 97340 -9310 0 0 {name=p96993 lab=clkbuf_9_425_0_CLK/X }
C {devices/lab_pin.sym} 97420 -9310 0 1 {name=p96994 lab=_85471_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 97380 -9310 0 0 {name=Xclkbuf_10_851_0_CLK }
C {devices/lab_pin.sym} 97300 -9210 0 0 {name=p96995 lab=_86035_/Q }
C {devices/lab_pin.sym} 97300 -9170 0 0 {name=p96996 lab=_51285_/X }
C {devices/lab_pin.sym} 97300 -9130 0 0 {name=p96997 lab=_51304_/Y }
C {devices/lab_pin.sym} 97460 -9170 0 1 {name=p96998 lab=_51305_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -9170 0 0 {name=X_51305_ }
C {devices/lab_pin.sym} 97290 -9030 0 0 {name=p96999 lab=_82485_/CLK }
C {devices/lab_pin.sym} 97290 -9010 0 0 {name=p97000 lab=_77831_/X }
C {devices/lab_pin.sym} 97470 -9030 0 1 {name=p97001 lab=_82125_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -9020 0 0 {name=X_82125_ }
C {devices/lab_pin.sym} 97340 -8890 0 0 {name=p97002 lab=_47838_/X }
C {devices/lab_pin.sym} 97420 -8890 0 1 {name=p97003 lab=_55093_/A }
C {sky130_stdcells/buf_2.sym} 97380 -8890 0 0 {name=X_55073_ }
C {devices/lab_pin.sym} 97320 -8800 0 0 {name=p97004 lab=_59913_/A }
C {devices/lab_pin.sym} 97320 -8760 0 0 {name=p97005 lab=_59950_/B }
C {devices/lab_pin.sym} 97320 -8720 0 0 {name=p97006 lab=_59950_/C }
C {devices/lab_pin.sym} 97320 -8680 0 0 {name=p97007 lab=_59973_/A }
C {devices/lab_pin.sym} 97440 -8740 0 1 {name=p97008 lab=_59951_/D }
C {sky130_stdcells/nand4_4.sym} 97380 -8740 0 0 {name=X_59950_ }
C {devices/lab_pin.sym} 97320 -8600 0 0 {name=p97009 lab=_66961_/X }
C {devices/lab_pin.sym} 97320 -8560 0 0 {name=p97010 lab=_86818_/Q }
C {devices/lab_pin.sym} 97440 -8580 0 1 {name=p97011 lab=_67059_/X }
C {sky130_stdcells/and2_4.sym} 97380 -8580 0 0 {name=X_67059_ }
C {devices/lab_pin.sym} 97320 -8470 0 0 {name=p97012 lab=_48928_/A }
C {devices/lab_pin.sym} 97320 -8430 0 0 {name=p97013 lab=_52267_/B }
C {devices/lab_pin.sym} 97320 -8390 0 0 {name=p97014 lab=_52267_/C }
C {devices/lab_pin.sym} 97440 -8430 0 1 {name=p97015 lab=_52285_/X }
C {sky130_stdcells/and3_4.sym} 97380 -8430 0 0 {name=X_52285_ }
C {devices/lab_pin.sym} 97290 -8290 0 0 {name=p97016 lab=_87472_/CLK }
C {devices/lab_pin.sym} 97290 -8270 0 0 {name=p97017 lab=_42198_/X }
C {devices/lab_pin.sym} 97470 -8290 0 1 {name=p97018 lab=_87982_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -8280 0 0 {name=X_87982_ }
C {devices/lab_pin.sym} 97300 -8170 0 0 {name=p97019 lab=_58877_/X }
C {devices/lab_pin.sym} 97300 -8130 0 0 {name=p97020 lab=_85927_/Q }
C {devices/lab_pin.sym} 97300 -8090 0 0 {name=p97021 lab=_58900_/X }
C {devices/lab_pin.sym} 97460 -8130 0 1 {name=p97022 lab=_58901_/X }
C {sky130_stdcells/o21a_4.sym} 97380 -8130 0 0 {name=X_58901_ }
C {devices/lab_pin.sym} 97320 -8000 0 0 {name=p97023 lab=_53942_/A }
C {devices/lab_pin.sym} 97320 -7960 0 0 {name=p97024 lab=_46441_/Y }
C {devices/lab_pin.sym} 97440 -7980 0 1 {name=p97025 lab=_54024_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -7980 0 0 {name=X_54024_ }
C {devices/lab_pin.sym} 97340 -7850 0 0 {name=p97026 lab=clkbuf_9_343_0_CLK/A }
C {devices/lab_pin.sym} 97420 -7850 0 1 {name=p97027 lab=clkbuf_9_342_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 97380 -7850 0 0 {name=Xclkbuf_9_342_0_CLK }
C {devices/lab_pin.sym} 97300 -7750 0 0 {name=p97028 lab=_64572_/B }
C {devices/lab_pin.sym} 97300 -7710 0 0 {name=p97029 lab=_51233_/X }
C {devices/lab_pin.sym} 97300 -7670 0 0 {name=p97030 lab=_51235_/Y }
C {devices/lab_pin.sym} 97460 -7710 0 1 {name=p97031 lab=_51236_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -7710 0 0 {name=X_51236_ }
C {devices/lab_pin.sym} 97300 -7590 0 0 {name=p97032 lab=_82538_/D }
C {devices/lab_pin.sym} 97300 -7550 0 0 {name=p97033 lab=_70067_/X }
C {devices/lab_pin.sym} 97300 -7510 0 0 {name=p97034 lab=_70069_/X }
C {devices/lab_pin.sym} 97460 -7550 0 1 {name=p97035 lab=_83858_/D }
C {sky130_stdcells/a21bo_4.sym} 97380 -7550 0 0 {name=X_70070_ }
C {devices/lab_pin.sym} 97290 -7410 0 0 {name=p97036 lab=_87188_/CLK }
C {devices/lab_pin.sym} 97290 -7390 0 0 {name=p97037 lab=_86933_/D }
C {devices/lab_pin.sym} 97470 -7410 0 1 {name=p97038 lab=_86933_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -7400 0 0 {name=X_86933_ }
C {devices/lab_pin.sym} 97290 -7270 0 0 {name=p97039 lab=_84014_/CLK }
C {devices/lab_pin.sym} 97290 -7250 0 0 {name=p97040 lab=_84016_/Q }
C {devices/lab_pin.sym} 97470 -7270 0 1 {name=p97041 lab=_77776_/A }
C {sky130_stdcells/dfxtp_4.sym} 97380 -7260 0 0 {name=X_82056_ }
C {devices/lab_pin.sym} 97340 -7130 0 0 {name=p97042 lab=_59880_/X }
C {devices/lab_pin.sym} 97420 -7130 0 1 {name=p97043 lab=_59881_/X }
C {sky130_stdcells/buf_2.sym} 97380 -7130 0 0 {name=X_59881_ }
C {devices/lab_pin.sym} 97340 -7010 0 0 {name=p97044 lab=clkbuf_9_118_0_CLK/X }
C {devices/lab_pin.sym} 97420 -7010 0 1 {name=p97045 lab=_81104_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 97380 -7010 0 0 {name=Xclkbuf_10_236_0_CLK }
C {devices/lab_pin.sym} 97290 -6890 0 0 {name=p97046 lab=_84177_/CLK }
C {devices/lab_pin.sym} 97290 -6870 0 0 {name=p97047 lab=_84215_/Q }
C {devices/lab_pin.sym} 97470 -6890 0 1 {name=p97048 lab=_81007_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -6880 0 0 {name=X_81007_ }
C {devices/lab_pin.sym} 97340 -6750 0 0 {name=p97049 lab=_58701_/A }
C {devices/lab_pin.sym} 97420 -6750 0 1 {name=p97050 lab=_58832_/X }
C {sky130_stdcells/buf_2.sym} 97380 -6750 0 0 {name=X_58832_ }
C {devices/lab_pin.sym} 97320 -6640 0 0 {name=p97051 lab=_51167_/A }
C {devices/lab_pin.sym} 97320 -6600 0 0 {name=p97052 lab=_52859_/B }
C {devices/lab_pin.sym} 97440 -6620 0 1 {name=p97053 lab=_51167_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -6620 0 0 {name=X_51167_ }
C {devices/lab_pin.sym} 97290 -6490 0 0 {name=p97054 lab=_86770_/CLK }
C {devices/lab_pin.sym} 97290 -6470 0 0 {name=p97055 lab=_45642_/Y }
C {devices/lab_pin.sym} 97470 -6490 0 1 {name=p97056 lab=_63182_/B }
C {sky130_stdcells/dfxtp_4.sym} 97380 -6480 0 0 {name=X_86864_ }
C {devices/lab_pin.sym} 97340 -6350 0 0 {name=p97057 lab=clkbuf_9_433_0_CLK/X }
C {devices/lab_pin.sym} 97420 -6350 0 1 {name=p97058 lab=_85915_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 97380 -6350 0 0 {name=Xclkbuf_10_866_0_CLK }
C {devices/lab_pin.sym} 97320 -6240 0 0 {name=p97059 lab=_50106_/A }
C {devices/lab_pin.sym} 97320 -6200 0 0 {name=p97060 lab=_53844_/B }
C {devices/lab_pin.sym} 97440 -6220 0 1 {name=p97061 lab=_50118_/X }
C {sky130_stdcells/and2_4.sym} 97380 -6220 0 0 {name=X_50118_ }
C {devices/lab_pin.sym} 97290 -6090 0 0 {name=p97062 lab=_85815_/CLK }
C {devices/lab_pin.sym} 97290 -6070 0 0 {name=p97063 lab=_52475_/Y }
C {devices/lab_pin.sym} 97470 -6090 0 1 {name=p97064 lab=_85815_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -6080 0 0 {name=X_85815_ }
C {devices/lab_pin.sym} 97340 -5950 0 0 {name=p97065 lab=clkbuf_9_9_0_CLK/X }
C {devices/lab_pin.sym} 97420 -5950 0 1 {name=p97066 lab=_83025_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 97380 -5950 0 0 {name=Xclkbuf_10_18_0_CLK }
C {devices/lab_pin.sym} 97320 -5840 0 0 {name=p97067 lab=_58763_/A }
C {devices/lab_pin.sym} 97320 -5800 0 0 {name=p97068 lab=_58763_/B }
C {devices/lab_pin.sym} 97440 -5820 0 1 {name=p97069 lab=_58763_/Y }
C {sky130_stdcells/nor2_4.sym} 97380 -5820 0 0 {name=X_58763_ }
C {devices/lab_pin.sym} 97300 -5710 0 0 {name=p97070 lab=_86074_/Q }
C {devices/lab_pin.sym} 97300 -5670 0 0 {name=p97071 lab=_51073_/X }
C {devices/lab_pin.sym} 97300 -5630 0 0 {name=p97072 lab=_51097_/Y }
C {devices/lab_pin.sym} 97460 -5670 0 1 {name=p97073 lab=_51098_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -5670 0 0 {name=X_51098_ }
C {devices/lab_pin.sym} 97340 -5530 0 0 {name=p97074 lab=_55975_/A }
C {devices/lab_pin.sym} 97420 -5530 0 1 {name=p97075 lab=_55975_/X }
C {sky130_stdcells/buf_2.sym} 97380 -5530 0 0 {name=X_55975_ }
C {devices/lab_pin.sym} 97290 -5410 0 0 {name=p97076 lab=_88245_/CLK }
C {devices/lab_pin.sym} 97290 -5390 0 0 {name=p97077 lab=_86795_/D }
C {devices/lab_pin.sym} 97470 -5410 0 1 {name=p97078 lab=_66830_/B }
C {sky130_stdcells/dfxtp_4.sym} 97380 -5400 0 0 {name=X_86795_ }
C {devices/lab_pin.sym} 97340 -5270 0 0 {name=p97079 lab=clkbuf_8_178_0_CLK/X }
C {devices/lab_pin.sym} 97420 -5270 0 1 {name=p97080 lab=clkbuf_9_357_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 97380 -5270 0 0 {name=Xclkbuf_9_357_0_CLK }
C {devices/lab_pin.sym} 97300 -5170 0 0 {name=p97081 lab=_57709_/X }
C {devices/lab_pin.sym} 97300 -5130 0 0 {name=p97082 lab=_86017_/Q }
C {devices/lab_pin.sym} 97300 -5090 0 0 {name=p97083 lab=_57713_/X }
C {devices/lab_pin.sym} 97460 -5130 0 1 {name=p97084 lab=_57714_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -5130 0 0 {name=X_57714_ }
C {devices/lab_pin.sym} 97300 -5030 0 0 {name=p97085 lab=_42916_/X }
C {devices/lab_pin.sym} 97300 -4990 0 0 {name=p97086 lab=_42917_/X }
C {devices/lab_pin.sym} 97300 -4950 0 0 {name=p97087 lab=_41773_/X }
C {devices/lab_pin.sym} 97300 -4910 0 0 {name=p97088 lab=_67985_/B }
C {devices/lab_pin.sym} 97300 -4870 0 0 {name=p97089 lab=_42934_/X }
C {devices/lab_pin.sym} 97460 -4950 0 1 {name=p97090 lab=_42940_/Y }
C {sky130_stdcells/o32ai_4.sym} 97380 -4950 0 0 {name=X_42940_ }
C {devices/lab_pin.sym} 97300 -4810 0 0 {name=p97091 lab=_72475_/B }
C {devices/lab_pin.sym} 97300 -4770 0 0 {name=p97092 lab=_48170_/X }
C {devices/lab_pin.sym} 97300 -4730 0 0 {name=p97093 lab=_50048_/Y }
C {devices/lab_pin.sym} 97460 -4770 0 1 {name=p97094 lab=_50049_/Y }
C {sky130_stdcells/o21ai_4.sym} 97380 -4770 0 0 {name=X_50049_ }
C {devices/lab_pin.sym} 97340 -4630 0 0 {name=p97095 lab=_51340_/A }
C {devices/lab_pin.sym} 97420 -4630 0 1 {name=p97096 lab=_54927_/A }
C {sky130_stdcells/buf_2.sym} 97380 -4630 0 0 {name=X_54926_ }
C {devices/lab_pin.sym} 97300 -4540 0 0 {name=p97097 lab=_73735_/X }
C {devices/lab_pin.sym} 97300 -4500 0 0 {name=p97098 lab=_85625_/Q }
C {devices/lab_pin.sym} 97300 -4460 0 0 {name=p97099 lab=_73661_/X }
C {devices/lab_pin.sym} 97300 -4420 0 0 {name=p97100 lab=_73759_/X }
C {devices/lab_pin.sym} 97460 -4480 0 1 {name=p97101 lab=_73760_/X }
C {sky130_stdcells/a211o_4.sym} 97380 -4480 0 0 {name=X_73760_ }
C {devices/lab_pin.sym} 97290 -4330 0 0 {name=p97102 lab=_85748_/CLK }
C {devices/lab_pin.sym} 97290 -4310 0 0 {name=p97103 lab=_52836_/Y }
C {devices/lab_pin.sym} 97470 -4330 0 1 {name=p97104 lab=_85746_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -4320 0 0 {name=X_85746_ }
C {devices/lab_pin.sym} 97320 -4210 0 0 {name=p97105 lab=_70976_/A }
C {devices/lab_pin.sym} 97320 -4170 0 0 {name=p97106 lab=_70949_/B }
C {devices/lab_pin.sym} 97320 -4130 0 0 {name=p97107 lab=_70969_/C }
C {devices/lab_pin.sym} 97440 -4170 0 1 {name=p97108 lab=_70972_/Y }
C {sky130_stdcells/nand3_4.sym} 97380 -4170 0 0 {name=X_70972_ }
C {devices/lab_pin.sym} 97290 -4030 0 0 {name=p97109 lab=_85778_/CLK }
C {devices/lab_pin.sym} 97290 -4010 0 0 {name=p97110 lab=_82766_/Q }
C {devices/lab_pin.sym} 97470 -4030 0 1 {name=p97111 lab=_82958_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -4020 0 0 {name=X_82958_ }
C {devices/lab_pin.sym} 97300 -3910 0 0 {name=p97112 lab=_58691_/Y }
C {devices/lab_pin.sym} 97300 -3870 0 0 {name=p97113 lab=_58693_/Y }
C {devices/lab_pin.sym} 97300 -3830 0 0 {name=p97114 lab=_58610_/X }
C {devices/lab_pin.sym} 97460 -3870 0 1 {name=p97115 lab=_58694_/X }
C {sky130_stdcells/a21o_4.sym} 97380 -3870 0 0 {name=X_58694_ }
C {devices/lab_pin.sym} 97300 -3750 0 0 {name=p97116 lab=_83182_/Q }
C {devices/lab_pin.sym} 97300 -3710 0 0 {name=p97117 lab=_72709_/X }
C {devices/lab_pin.sym} 97300 -3670 0 0 {name=p97118 lab=_72710_/X }
C {devices/lab_pin.sym} 97460 -3710 0 1 {name=p97119 lab=_83182_/D }
C {sky130_stdcells/a21o_4.sym} 97380 -3710 0 0 {name=X_72711_ }
C {devices/lab_pin.sym} 97300 -3590 0 0 {name=p97120 lab=_57643_/Y }
C {devices/lab_pin.sym} 97300 -3550 0 0 {name=p97121 lab=_57627_/X }
C {devices/lab_pin.sym} 97300 -3510 0 0 {name=p97122 lab=_57644_/Y }
C {devices/lab_pin.sym} 97460 -3550 0 1 {name=p97123 lab=_57645_/Y }
C {sky130_stdcells/a21boi_4.sym} 97380 -3550 0 0 {name=X_57645_ }
C {devices/lab_pin.sym} 97290 -3410 0 0 {name=p97124 lab=_82133_/CLK }
C {devices/lab_pin.sym} 97290 -3390 0 0 {name=p97125 lab=_81909_/D }
C {devices/lab_pin.sym} 97470 -3410 0 1 {name=p97126 lab=_82285_/D }
C {sky130_stdcells/dfxtp_4.sym} 97380 -3400 0 0 {name=X_81909_ }
C {devices/lab_pin.sym} 97300 -3300 0 0 {name=p97127 lab=_41580_/X }
C {devices/lab_pin.sym} 97300 -3260 0 0 {name=p97128 lab=_42866_/X }
C {devices/lab_pin.sym} 97300 -3220 0 0 {name=p97129 lab=_67118_/B }
C {devices/lab_pin.sym} 97300 -3180 0 0 {name=p97130 lab=_42867_/X }
C {devices/lab_pin.sym} 97460 -3240 0 1 {name=p97131 lab=_42871_/X }
C {sky130_stdcells/a2bb2o_4.sym} 97380 -3240 0 0 {name=X_42871_ }
C {devices/lab_pin.sym} 97320 -3120 0 0 {name=p97132 lab=_54857_/A }
C {devices/lab_pin.sym} 97320 -3080 0 0 {name=p97133 lab=_54857_/B }
C {devices/lab_pin.sym} 97320 -3040 0 0 {name=p97134 lab=_54857_/C }
C {devices/lab_pin.sym} 97320 -3000 0 0 {name=p97135 lab=_53165_/D }
C {devices/lab_pin.sym} 97440 -3060 0 1 {name=p97136 lab=_54857_/X }
C {sky130_stdcells/and4_4.sym} 97380 -3060 0 0 {name=X_54857_ }
C {devices/lab_pin.sym} 97320 -2920 0 0 {name=p97137 lab=_73688_/X }
C {devices/lab_pin.sym} 97320 -2880 0 0 {name=p97138 lab=_73690_/X }
C {devices/lab_pin.sym} 97440 -2900 0 1 {name=p97139 lab=_73692_/B }
C {sky130_stdcells/nand2_4.sym} 97380 -2900 0 0 {name=X_73691_ }
C {devices/lab_pin.sym} 97290 -2770 0 0 {name=p97140 lab=_84802_/CLK }
C {devices/lab_pin.sym} 97290 -2750 0 0 {name=p97141 lab=_85677_/D }
C {devices/lab_pin.sym} 97470 -2770 0 1 {name=p97142 lab=_85677_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -2760 0 0 {name=X_85677_ }
C {devices/lab_pin.sym} 97290 -2630 0 0 {name=p97143 lab=_82317_/CLK }
C {devices/lab_pin.sym} 97290 -2610 0 0 {name=p97144 lab=_78128_/B }
C {devices/lab_pin.sym} 97470 -2630 0 1 {name=p97145 lab=_82889_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -2620 0 0 {name=X_82889_ }
C {devices/lab_pin.sym} 97340 -2490 0 0 {name=p97146 lab=_44609_/Y }
C {devices/lab_pin.sym} 97420 -2490 0 1 {name=p97147 lab=_87035_/D }
C {sky130_stdcells/inv_2.sym} 97380 -2490 0 0 {name=X_44610_ }
C {devices/lab_pin.sym} 97340 -2370 0 0 {name=p97148 lab=_75430_/A }
C {devices/lab_pin.sym} 97420 -2370 0 1 {name=p97149 lab=_75430_/Y }
C {sky130_stdcells/inv_2.sym} 97380 -2370 0 0 {name=X_75430_ }
C {devices/lab_pin.sym} 97290 -2250 0 0 {name=p97150 lab=_87416_/CLK }
C {devices/lab_pin.sym} 97290 -2230 0 0 {name=p97151 lab=_43448_/X }
C {devices/lab_pin.sym} 97470 -2250 0 1 {name=p97152 lab=_87416_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -2240 0 0 {name=X_87416_ }
C {devices/lab_pin.sym} 97300 -2150 0 0 {name=p97153 lab=_41802_/X }
C {devices/lab_pin.sym} 97300 -2110 0 0 {name=p97154 lab=_41803_/X }
C {devices/lab_pin.sym} 97300 -2070 0 0 {name=p97155 lab=_40440_/X }
C {devices/lab_pin.sym} 97300 -2030 0 0 {name=p97156 lab=_88135_/Q }
C {devices/lab_pin.sym} 97300 -1990 0 0 {name=p97157 lab=_41821_/X }
C {devices/lab_pin.sym} 97460 -2070 0 1 {name=p97158 lab=_41822_/Y }
C {sky130_stdcells/o32ai_4.sym} 97380 -2070 0 0 {name=X_41822_ }
C {devices/lab_pin.sym} 97320 -1920 0 0 {name=p97159 lab=_53786_/A }
C {devices/lab_pin.sym} 97320 -1880 0 0 {name=p97160 lab=_48931_/A }
C {devices/lab_pin.sym} 97440 -1900 0 1 {name=p97161 lab=_53808_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -1900 0 0 {name=X_53808_ }
C {devices/lab_pin.sym} 97300 -1790 0 0 {name=p97162 lab=_70181_/A }
C {devices/lab_pin.sym} 97300 -1750 0 0 {name=p97163 lab=_72631_/X }
C {devices/lab_pin.sym} 97300 -1710 0 0 {name=p97164 lab=_72641_/Y }
C {devices/lab_pin.sym} 97460 -1750 0 1 {name=p97165 lab=_83206_/D }
C {sky130_stdcells/a21bo_4.sym} 97380 -1750 0 0 {name=X_72642_ }
C {devices/lab_pin.sym} 97290 -1610 0 0 {name=p97166 lab=_84645_/CLK }
C {devices/lab_pin.sym} 97290 -1590 0 0 {name=p97167 lab=_84628_/D }
C {devices/lab_pin.sym} 97470 -1610 0 1 {name=p97168 lab=_79658_/A }
C {sky130_stdcells/dfxtp_4.sym} 97380 -1600 0 0 {name=X_84628_ }
C {devices/lab_pin.sym} 97320 -1480 0 0 {name=p97169 lab=_45589_/Y }
C {devices/lab_pin.sym} 97320 -1440 0 0 {name=p97170 lab=_45590_/B }
C {devices/lab_pin.sym} 97440 -1460 0 1 {name=p97171 lab=_45590_/X }
C {sky130_stdcells/and2_4.sym} 97380 -1460 0 0 {name=X_45590_ }
C {devices/lab_pin.sym} 97320 -1340 0 0 {name=p97172 lab=_57597_/A }
C {devices/lab_pin.sym} 97320 -1300 0 0 {name=p97173 lab=_50322_/B }
C {devices/lab_pin.sym} 97440 -1320 0 1 {name=p97174 lab=_57576_/Y }
C {sky130_stdcells/nand2_4.sym} 97380 -1320 0 0 {name=X_57576_ }
C {devices/lab_pin.sym} 97290 -1190 0 0 {name=p97175 lab=_86834_/CLK }
C {devices/lab_pin.sym} 97290 -1170 0 0 {name=p97176 lab=_40405_/X }
C {devices/lab_pin.sym} 97470 -1190 0 1 {name=p97177 lab=_88396_/Q }
C {sky130_stdcells/dfxtp_4.sym} 97380 -1180 0 0 {name=X_88396_ }
C {devices/lab_pin.sym} 97320 -1080 0 0 {name=p97178 lab=_54798_/A }
C {devices/lab_pin.sym} 97320 -1040 0 0 {name=p97179 lab=_54788_/B }
C {devices/lab_pin.sym} 97320 -1000 0 0 {name=p97180 lab=_54798_/C }
C {devices/lab_pin.sym} 97320 -960 0 0 {name=p97181 lab=_47521_/A }
C {devices/lab_pin.sym} 97440 -1020 0 1 {name=p97182 lab=_54788_/X }
C {sky130_stdcells/and4_4.sym} 97380 -1020 0 0 {name=X_54788_ }
C {devices/lab_pin.sym} 97300 -900 0 0 {name=p97183 lab=_84752_/Q }
C {devices/lab_pin.sym} 97300 -860 0 0 {name=p97184 lab=_59268_/X }
C {devices/lab_pin.sym} 97300 -820 0 0 {name=p97185 lab=_59307_/X }
C {devices/lab_pin.sym} 97300 -780 0 0 {name=p97186 lab=_59314_/X }
C {devices/lab_pin.sym} 97460 -840 0 1 {name=p97187 lab=_84752_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 97380 -840 0 0 {name=X_59315_ }
C {devices/lab_pin.sym} 97300 -710 0 0 {name=p97188 lab=_56134_/X }
C {devices/lab_pin.sym} 97300 -670 0 0 {name=p97189 lab=_56515_/X }
C {devices/lab_pin.sym} 97300 -630 0 0 {name=p97190 lab=_56526_/Y }
C {devices/lab_pin.sym} 97460 -670 0 1 {name=p97191 lab=_85162_/D }
C {sky130_stdcells/o21ai_4.sym} 97380 -670 0 0 {name=X_56527_ }
C {devices/lab_pin.sym} 98220 -42190 0 0 {name=p97192 lab=_44496_/X }
C {devices/lab_pin.sym} 98220 -42150 0 0 {name=p97193 lab=_44497_/X }
C {devices/lab_pin.sym} 98220 -42110 0 0 {name=p97194 lab=_40814_/X }
C {devices/lab_pin.sym} 98220 -42070 0 0 {name=p97195 lab=_73024_/A }
C {devices/lab_pin.sym} 98220 -42030 0 0 {name=p97196 lab=_44498_/X }
C {devices/lab_pin.sym} 98380 -42110 0 1 {name=p97197 lab=_44542_/A }
C {sky130_stdcells/o32ai_4.sym} 98300 -42110 0 0 {name=X_44541_ }
C {devices/lab_pin.sym} 98240 -41960 0 0 {name=p97198 lab=_80694_/Q }
C {devices/lab_pin.sym} 98240 -41920 0 0 {name=p97199 lab=_80950_/D }
C {devices/lab_pin.sym} 98360 -41940 0 1 {name=p97200 lab=_75362_/B }
C {sky130_stdcells/xor2_4.sym} 98300 -41940 0 0 {name=X_75361_ }
C {devices/lab_pin.sym} 98210 -41810 0 0 {name=p97201 lab=_87345_/CLK }
C {devices/lab_pin.sym} 98210 -41790 0 0 {name=p97202 lab=_87347_/D }
C {devices/lab_pin.sym} 98390 -41810 0 1 {name=p97203 lab=_43587_/A }
C {sky130_stdcells/dfxtp_4.sym} 98300 -41800 0 0 {name=X_87347_ }
C {devices/lab_pin.sym} 98260 -41670 0 0 {name=p97204 lab=_41802_/A }
C {devices/lab_pin.sym} 98340 -41670 0 1 {name=p97205 lab=_41753_/X }
C {sky130_stdcells/buf_2.sym} 98300 -41670 0 0 {name=X_41753_ }
C {devices/lab_pin.sym} 98240 -41570 0 0 {name=p97206 lab=_52218_/A }
C {devices/lab_pin.sym} 98240 -41530 0 0 {name=p97207 lab=_53748_/B }
C {devices/lab_pin.sym} 98240 -41490 0 0 {name=p97208 lab=_53748_/C }
C {devices/lab_pin.sym} 98360 -41530 0 1 {name=p97209 lab=_53739_/X }
C {sky130_stdcells/and3_4.sym} 98300 -41530 0 0 {name=X_53739_ }
C {devices/lab_pin.sym} 98240 -41410 0 0 {name=p97210 lab=_72573_/A }
C {devices/lab_pin.sym} 98240 -41370 0 0 {name=p97211 lab=_72573_/B }
C {devices/lab_pin.sym} 98240 -41330 0 0 {name=p97212 lab=_79394_/B }
C {devices/lab_pin.sym} 98360 -41370 0 1 {name=p97213 lab=_72573_/Y }
C {sky130_stdcells/nor3_4.sym} 98300 -41370 0 0 {name=X_72573_ }
C {devices/lab_pin.sym} 98210 -41230 0 0 {name=p97214 lab=_84559_/CLK }
C {devices/lab_pin.sym} 98210 -41210 0 0 {name=p97215 lab=_84559_/D }
C {devices/lab_pin.sym} 98390 -41230 0 1 {name=p97216 lab=_60817_/C }
C {sky130_stdcells/dfxtp_4.sym} 98300 -41220 0 0 {name=X_84559_ }
C {devices/lab_pin.sym} 98260 -41090 0 0 {name=p97217 lab=clkbuf_9_402_0_CLK/X }
C {devices/lab_pin.sym} 98340 -41090 0 1 {name=p97218 lab=_82595_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 98300 -41090 0 0 {name=Xclkbuf_10_804_0_CLK }
C {devices/lab_pin.sym} 98220 -40990 0 0 {name=p97219 lab=_77091_/Y }
C {devices/lab_pin.sym} 98220 -40950 0 0 {name=p97220 lab=_77098_/Y }
C {devices/lab_pin.sym} 98220 -40910 0 0 {name=p97221 lab=_77099_/Y }
C {devices/lab_pin.sym} 98380 -40950 0 1 {name=p97222 lab=_77100_/X }
C {sky130_stdcells/o21a_4.sym} 98300 -40950 0 0 {name=X_77100_ }
C {devices/lab_pin.sym} 98240 -40830 0 0 {name=p97223 lab=_74302_/X }
C {devices/lab_pin.sym} 98240 -40790 0 0 {name=p97224 lab=_74310_/B }
C {devices/lab_pin.sym} 98240 -40750 0 0 {name=p97225 lab=_74312_/C }
C {devices/lab_pin.sym} 98360 -40790 0 1 {name=p97226 lab=_74312_/Y }
C {sky130_stdcells/nand3_4.sym} 98300 -40790 0 0 {name=X_74312_ }
C {devices/lab_pin.sym} 98260 -40650 0 0 {name=p97227 lab=_40703_/Y }
C {devices/lab_pin.sym} 98340 -40650 0 1 {name=p97228 lab=_40704_/Y }
C {sky130_stdcells/inv_2.sym} 98300 -40650 0 0 {name=X_40704_ }
C {devices/lab_pin.sym} 98260 -40530 0 0 {name=p97229 lab=_47260_/A }
C {devices/lab_pin.sym} 98340 -40530 0 1 {name=p97230 lab=_52944_/B }
C {sky130_stdcells/buf_2.sym} 98300 -40530 0 0 {name=X_47260_ }
C {devices/lab_pin.sym} 98220 -40450 0 0 {name=p97231 lab=_59115_/X }
C {devices/lab_pin.sym} 98220 -40410 0 0 {name=p97232 lab=_59244_/Y }
C {devices/lab_pin.sym} 98220 -40370 0 0 {name=p97233 lab=_59245_/Y }
C {devices/lab_pin.sym} 98220 -40330 0 0 {name=p97234 lab=_59133_/X }
C {devices/lab_pin.sym} 98220 -40290 0 0 {name=p97235 lab=_59119_/X }
C {devices/lab_pin.sym} 98380 -40370 0 1 {name=p97236 lab=_59246_/X }
C {sky130_stdcells/o32a_4.sym} 98300 -40370 0 0 {name=X_59246_ }
C {devices/lab_pin.sym} 98220 -40230 0 0 {name=p97237 lab=_53255_/B }
C {devices/lab_pin.sym} 98220 -40190 0 0 {name=p97238 lab=_71512_/A }
C {devices/lab_pin.sym} 98220 -40150 0 0 {name=p97239 lab=_71523_/Y }
C {devices/lab_pin.sym} 98380 -40190 0 1 {name=p97240 lab=_83467_/D }
C {sky130_stdcells/o21ai_4.sym} 98300 -40190 0 0 {name=X_71524_ }
C {devices/lab_pin.sym} 98240 -40060 0 0 {name=p97241 lab=_78080_/A }
C {devices/lab_pin.sym} 98240 -40020 0 0 {name=p97242 lab=_78080_/B }
C {devices/lab_pin.sym} 98360 -40040 0 1 {name=p97243 lab=_78080_/X }
C {sky130_stdcells/xor2_4.sym} 98300 -40040 0 0 {name=X_78080_ }
C {devices/lab_pin.sym} 98260 -39910 0 0 {name=p97244 lab=_44472_/A }
C {devices/lab_pin.sym} 98340 -39910 0 1 {name=p97245 lab=_87091_/D }
C {sky130_stdcells/inv_2.sym} 98300 -39910 0 0 {name=X_44472_ }
C {devices/lab_pin.sym} 98240 -39810 0 0 {name=p97246 lab=_56458_/A }
C {devices/lab_pin.sym} 98240 -39770 0 0 {name=p97247 lab=_56177_/B }
C {devices/lab_pin.sym} 98240 -39730 0 0 {name=p97248 lab=_56458_/C }
C {devices/lab_pin.sym} 98360 -39770 0 1 {name=p97249 lab=_56458_/Y }
C {sky130_stdcells/nand3_4.sym} 98300 -39770 0 0 {name=X_56458_ }
C {devices/lab_pin.sym} 98220 -39650 0 0 {name=p97250 lab=_75288_/Y }
C {devices/lab_pin.sym} 98220 -39610 0 0 {name=p97251 lab=_75291_/C }
C {devices/lab_pin.sym} 98220 -39570 0 0 {name=p97252 lab=_75287_/Y }
C {devices/lab_pin.sym} 98380 -39610 0 1 {name=p97253 lab=_75292_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -39610 0 0 {name=X_75292_ }
C {devices/lab_pin.sym} 98260 -39470 0 0 {name=p97254 lab=_41814_/A }
C {devices/lab_pin.sym} 98340 -39470 0 1 {name=p97255 lab=_41684_/X }
C {sky130_stdcells/buf_2.sym} 98300 -39470 0 0 {name=X_41684_ }
C {devices/lab_pin.sym} 98210 -39350 0 0 {name=p97256 lab=_88084_/CLK }
C {devices/lab_pin.sym} 98210 -39330 0 0 {name=p97257 lab=_87278_/D }
C {devices/lab_pin.sym} 98390 -39350 0 1 {name=p97258 lab=_69206_/B }
C {sky130_stdcells/dfxtp_4.sym} 98300 -39340 0 0 {name=X_87278_ }
C {devices/lab_pin.sym} 98260 -39210 0 0 {name=p97259 lab=_69611_/A }
C {devices/lab_pin.sym} 98340 -39210 0 1 {name=p97260 lab=_46212_/A }
C {sky130_stdcells/buf_2.sym} 98300 -39210 0 0 {name=X_46211_ }
C {sky130_stdcells/decap_3.sym} 98300 -39060 0 0 {name=XPHY_230 }
C {devices/lab_pin.sym} 98220 -38930 0 0 {name=p97261 lab=_77026_/Y }
C {devices/lab_pin.sym} 98220 -38890 0 0 {name=p97262 lab=_77034_/B }
C {devices/lab_pin.sym} 98220 -38850 0 0 {name=p97263 lab=_77030_/Y }
C {devices/lab_pin.sym} 98380 -38890 0 1 {name=p97264 lab=_77031_/Y }
C {sky130_stdcells/a21boi_4.sym} 98300 -38890 0 0 {name=X_77031_ }
C {devices/lab_pin.sym} 98220 -38790 0 0 {name=p97265 lab=_43422_/X }
C {devices/lab_pin.sym} 98220 -38750 0 0 {name=p97266 lab=_43404_/X }
C {devices/lab_pin.sym} 98220 -38710 0 0 {name=p97267 lab=_41536_/X }
C {devices/lab_pin.sym} 98220 -38670 0 0 {name=p97268 lab=_87428_/Q }
C {devices/lab_pin.sym} 98220 -38630 0 0 {name=p97269 lab=_43407_/X }
C {devices/lab_pin.sym} 98380 -38710 0 1 {name=p97270 lab=_43424_/A }
C {sky130_stdcells/o32ai_4.sym} 98300 -38710 0 0 {name=X_43423_ }
C {devices/lab_pin.sym} 98240 -38570 0 0 {name=p97271 lab=_55409_/A }
C {devices/lab_pin.sym} 98240 -38530 0 0 {name=p97272 lab=_55398_/Y }
C {devices/lab_pin.sym} 98240 -38490 0 0 {name=p97273 lab=_55397_/Y }
C {devices/lab_pin.sym} 98360 -38530 0 1 {name=p97274 lab=_55409_/Y }
C {sky130_stdcells/nand3_4.sym} 98300 -38530 0 0 {name=X_55409_ }
C {devices/lab_pin.sym} 98220 -38410 0 0 {name=p97275 lab=_70130_/B }
C {devices/lab_pin.sym} 98220 -38370 0 0 {name=p97276 lab=_74139_/X }
C {devices/lab_pin.sym} 98220 -38330 0 0 {name=p97277 lab=_74242_/Y }
C {devices/lab_pin.sym} 98380 -38370 0 1 {name=p97278 lab=_74243_/X }
C {sky130_stdcells/a21o_4.sym} 98300 -38370 0 0 {name=X_74243_ }
C {devices/lab_pin.sym} 98210 -38230 0 0 {name=p97279 lab=_86578_/CLK }
C {devices/lab_pin.sym} 98210 -38210 0 0 {name=p97280 lab=_86229_/D }
C {devices/lab_pin.sym} 98390 -38230 0 1 {name=p97281 lab=_86229_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -38220 0 0 {name=X_86229_ }
C {sky130_stdcells/decap_3.sym} 98300 -38060 0 0 {name=XPHY_241 }
C {devices/lab_pin.sym} 98260 -37910 0 0 {name=p97282 lab=_44733_/A }
C {devices/lab_pin.sym} 98340 -37910 0 1 {name=p97283 lab=_40635_/X }
C {sky130_stdcells/buf_2.sym} 98300 -37910 0 0 {name=X_40635_ }
C {devices/lab_pin.sym} 98260 -37790 0 0 {name=p97284 lab=_59061_/A }
C {devices/lab_pin.sym} 98340 -37790 0 1 {name=p97285 lab=_59177_/X }
C {sky130_stdcells/buf_2.sym} 98300 -37790 0 0 {name=X_59177_ }
C {devices/lab_pin.sym} 98220 -37690 0 0 {name=p97286 lab=_47186_/Y }
C {devices/lab_pin.sym} 98220 -37650 0 0 {name=p97287 lab=_47177_/X }
C {devices/lab_pin.sym} 98220 -37610 0 0 {name=p97288 lab=_47190_/X }
C {devices/lab_pin.sym} 98380 -37650 0 1 {name=p97289 lab=_47191_/Y }
C {sky130_stdcells/a21oi_4.sym} 98300 -37650 0 0 {name=X_47191_ }
C {devices/lab_pin.sym} 98220 -37530 0 0 {name=p97290 lab=_71445_/X }
C {devices/lab_pin.sym} 98220 -37490 0 0 {name=p97291 lab=_83493_/Q }
C {devices/lab_pin.sym} 98220 -37450 0 0 {name=p97292 lab=_71454_/Y }
C {devices/lab_pin.sym} 98380 -37490 0 1 {name=p97293 lab=_71455_/X }
C {sky130_stdcells/a21o_4.sym} 98300 -37490 0 0 {name=X_71455_ }
C {devices/lab_pin.sym} 98220 -37370 0 0 {name=p97294 lab=_56026_/X }
C {devices/lab_pin.sym} 98220 -37330 0 0 {name=p97295 lab=_56378_/X }
C {devices/lab_pin.sym} 98220 -37290 0 0 {name=p97296 lab=_56388_/Y }
C {devices/lab_pin.sym} 98380 -37330 0 1 {name=p97297 lab=_56389_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -37330 0 0 {name=X_56389_ }
C {sky130_stdcells/decap_3.sym} 98300 -37160 0 0 {name=XPHY_252 }
C {sky130_stdcells/decap_3.sym} 98300 -36980 0 0 {name=XPHY_263 }
C {sky130_stdcells/decap_3.sym} 98300 -36800 0 0 {name=XPHY_274 }
C {devices/lab_pin.sym} 98260 -36650 0 0 {name=p97298 lab=_70824_/A }
C {devices/lab_pin.sym} 98340 -36650 0 1 {name=p97299 lab=_74533_/A }
C {sky130_stdcells/buf_2.sym} 98300 -36650 0 0 {name=X_70406_ }
C {devices/lab_pin.sym} 98220 -36550 0 0 {name=p97300 lab=_58112_/X }
C {devices/lab_pin.sym} 98220 -36510 0 0 {name=p97301 lab=_85987_/Q }
C {devices/lab_pin.sym} 98220 -36470 0 0 {name=p97302 lab=_58127_/X }
C {devices/lab_pin.sym} 98380 -36510 0 1 {name=p97303 lab=_58128_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -36510 0 0 {name=X_58128_ }
C {devices/lab_pin.sym} 98260 -36370 0 0 {name=p97304 lab=_46099_/X }
C {devices/lab_pin.sym} 98340 -36370 0 1 {name=p97305 lab=_46143_/D }
C {sky130_stdcells/inv_2.sym} 98300 -36370 0 0 {name=X_46142_ }
C {sky130_stdcells/decap_3.sym} 98300 -36220 0 0 {name=XPHY_285 }
C {devices/lab_pin.sym} 98220 -36110 0 0 {name=p97306 lab=_43347_/X }
C {devices/lab_pin.sym} 98220 -36070 0 0 {name=p97307 lab=_43350_/X }
C {devices/lab_pin.sym} 98220 -36030 0 0 {name=p97308 lab=_41347_/X }
C {devices/lab_pin.sym} 98220 -35990 0 0 {name=p97309 lab=_87464_/Q }
C {devices/lab_pin.sym} 98220 -35950 0 0 {name=p97310 lab=_43353_/X }
C {devices/lab_pin.sym} 98380 -36030 0 1 {name=p97311 lab=_43355_/A }
C {sky130_stdcells/o32ai_4.sym} 98300 -36030 0 0 {name=X_43354_ }
C {devices/lab_pin.sym} 98240 -35880 0 0 {name=p97312 lab=_74152_/A }
C {devices/lab_pin.sym} 98240 -35840 0 0 {name=p97313 lab=_66285_/B }
C {devices/lab_pin.sym} 98360 -35860 0 1 {name=p97314 lab=_74174_/X }
C {sky130_stdcells/and2_4.sym} 98300 -35860 0 0 {name=X_74174_ }
C {devices/lab_pin.sym} 98260 -35730 0 0 {name=p97315 lab=_40565_/Y }
C {devices/lab_pin.sym} 98340 -35730 0 1 {name=p97316 lab=_40567_/A }
C {sky130_stdcells/inv_2.sym} 98300 -35730 0 0 {name=X_40566_ }
C {sky130_stdcells/decap_3.sym} 98300 -35580 0 0 {name=XPHY_296 }
C {devices/lab_pin.sym} 98240 -35450 0 0 {name=p97317 lab=_70682_/A }
C {devices/lab_pin.sym} 98240 -35410 0 0 {name=p97318 lab=_71386_/B }
C {devices/lab_pin.sym} 98240 -35370 0 0 {name=p97319 lab=_71377_/C }
C {devices/lab_pin.sym} 98360 -35410 0 1 {name=p97320 lab=_71386_/Y }
C {sky130_stdcells/nor3_4.sym} 98300 -35410 0 0 {name=X_71386_ }
C {devices/lab_pin.sym} 98260 -35270 0 0 {name=p97321 lab=clkbuf_9_409_0_CLK/X }
C {devices/lab_pin.sym} 98340 -35270 0 1 {name=p97322 lab=_81198_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 98300 -35270 0 0 {name=Xclkbuf_10_819_0_CLK }
C {devices/lab_pin.sym} 98260 -35150 0 0 {name=p97323 lab=_42304_/X }
C {devices/lab_pin.sym} 98340 -35150 0 1 {name=p97324 lab=_42305_/X }
C {sky130_stdcells/buf_2.sym} 98300 -35150 0 0 {name=X_42305_ }
C {devices/lab_pin.sym} 98220 -35060 0 0 {name=p97325 lab=_69749_/B }
C {devices/lab_pin.sym} 98220 -35020 0 0 {name=p97326 lab=_73104_/B }
C {devices/lab_pin.sym} 98220 -34980 0 0 {name=p97327 lab=_72944_/X }
C {devices/lab_pin.sym} 98220 -34940 0 0 {name=p97328 lab=_73124_/Y }
C {devices/lab_pin.sym} 98380 -35000 0 1 {name=p97329 lab=_73125_/X }
C {sky130_stdcells/a211o_4.sym} 98300 -35000 0 0 {name=X_73125_ }
C {devices/lab_pin.sym} 98220 -34880 0 0 {name=p97330 lab=_41591_/Y }
C {devices/lab_pin.sym} 98220 -34840 0 0 {name=p97331 lab=_46061_/X }
C {devices/lab_pin.sym} 98220 -34800 0 0 {name=p97332 lab=_86781_/Q }
C {devices/lab_pin.sym} 98220 -34760 0 0 {name=p97333 lab=_46062_/X }
C {devices/lab_pin.sym} 98380 -34820 0 1 {name=p97334 lab=_46073_/X }
C {sky130_stdcells/a2bb2o_4.sym} 98300 -34820 0 0 {name=X_46073_ }
C {devices/lab_pin.sym} 98260 -34670 0 0 {name=p97335 lab=_58676_/A }
C {devices/lab_pin.sym} 98340 -34670 0 1 {name=p97336 lab=_58136_/B }
C {sky130_stdcells/buf_2.sym} 98300 -34670 0 0 {name=X_58059_ }
C {devices/lab_pin.sym} 98260 -34550 0 0 {name=p97337 lab=_70337_/A }
C {devices/lab_pin.sym} 98340 -34550 0 1 {name=p97338 lab=_70337_/X }
C {sky130_stdcells/buf_2.sym} 98300 -34550 0 0 {name=X_70337_ }
C {devices/lab_pin.sym} 98220 -34460 0 0 {name=p97339 lab=_41161_/X }
C {devices/lab_pin.sym} 98220 -34420 0 0 {name=p97340 lab=_43277_/X }
C {devices/lab_pin.sym} 98220 -34380 0 0 {name=p97341 lab=_87498_/Q }
C {devices/lab_pin.sym} 98220 -34340 0 0 {name=p97342 lab=_43278_/X }
C {devices/lab_pin.sym} 98380 -34400 0 1 {name=p97343 lab=_43285_/X }
C {sky130_stdcells/a2bb2o_4.sym} 98300 -34400 0 0 {name=X_43285_ }
C {devices/lab_pin.sym} 98240 -34260 0 0 {name=p97344 lab=_82741_/Q }
C {devices/lab_pin.sym} 98240 -34220 0 0 {name=p97345 lab=_78982_/B }
C {devices/lab_pin.sym} 98360 -34240 0 1 {name=p97346 lab=_82709_/D }
C {sky130_stdcells/xor2_4.sym} 98300 -34240 0 0 {name=X_78982_ }
C {devices/lab_pin.sym} 98260 -34110 0 0 {name=p97347 lab=_40496_/Y }
C {devices/lab_pin.sym} 98340 -34110 0 1 {name=p97348 lab=_40497_/X }
C {sky130_stdcells/buf_2.sym} 98300 -34110 0 0 {name=X_40497_ }
C {devices/lab_pin.sym} 98240 -34000 0 0 {name=p97349 lab=_49901_/A }
C {devices/lab_pin.sym} 98240 -33960 0 0 {name=p97350 lab=_53115_/B }
C {devices/lab_pin.sym} 98360 -33980 0 1 {name=p97351 lab=_49901_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -33980 0 0 {name=X_49901_ }
C {devices/lab_pin.sym} 98220 -33870 0 0 {name=p97352 lab=_45017_/X }
C {devices/lab_pin.sym} 98220 -33830 0 0 {name=p97353 lab=_45021_/Y }
C {devices/lab_pin.sym} 98220 -33790 0 0 {name=p97354 lab=_45023_/Y }
C {devices/lab_pin.sym} 98380 -33830 0 1 {name=p97355 lab=_45024_/Y }
C {sky130_stdcells/a21oi_4.sym} 98300 -33830 0 0 {name=X_45024_ }
C {devices/lab_pin.sym} 98220 -33720 0 0 {name=p97356 lab=_41393_/X }
C {devices/lab_pin.sym} 98220 -33680 0 0 {name=p97357 lab=_42222_/X }
C {devices/lab_pin.sym} 98220 -33640 0 0 {name=p97358 lab=_87967_/Q }
C {devices/lab_pin.sym} 98220 -33600 0 0 {name=p97359 lab=_42224_/X }
C {devices/lab_pin.sym} 98380 -33660 0 1 {name=p97360 lab=_42236_/X }
C {sky130_stdcells/a2bb2o_4.sym} 98300 -33660 0 0 {name=X_42236_ }
C {devices/lab_pin.sym} 98240 -33540 0 0 {name=p97361 lab=_59613_/Y }
C {devices/lab_pin.sym} 98240 -33500 0 0 {name=p97362 lab=_61070_/B }
C {devices/lab_pin.sym} 98240 -33460 0 0 {name=p97363 lab=_61070_/C }
C {devices/lab_pin.sym} 98240 -33420 0 0 {name=p97364 lab=_59552_/C }
C {devices/lab_pin.sym} 98360 -33480 0 1 {name=p97365 lab=_61070_/X }
C {sky130_stdcells/and4_4.sym} 98300 -33480 0 0 {name=X_61070_ }
C {devices/lab_pin.sym} 98240 -33340 0 0 {name=p97366 lab=_77933_/A }
C {devices/lab_pin.sym} 98240 -33300 0 0 {name=p97367 lab=_77933_/B }
C {devices/lab_pin.sym} 98360 -33320 0 1 {name=p97368 lab=_77934_/B }
C {sky130_stdcells/xor2_4.sym} 98300 -33320 0 0 {name=X_77933_ }
C {devices/lab_pin.sym} 98240 -33200 0 0 {name=p97369 lab=_73056_/A }
C {devices/lab_pin.sym} 98240 -33160 0 0 {name=p97370 lab=_73003_/B }
C {devices/lab_pin.sym} 98360 -33180 0 1 {name=p97371 lab=_73056_/Y }
C {sky130_stdcells/nor2_4.sym} 98300 -33180 0 0 {name=X_73056_ }
C {devices/lab_pin.sym} 98220 -33070 0 0 {name=p97372 lab=_70255_/X }
C {devices/lab_pin.sym} 98220 -33030 0 0 {name=p97373 lab=_74807_/A }
C {devices/lab_pin.sym} 98220 -32990 0 0 {name=p97374 lab=_70267_/X }
C {devices/lab_pin.sym} 98380 -33030 0 1 {name=p97375 lab=_83817_/D }
C {sky130_stdcells/a21o_4.sym} 98300 -33030 0 0 {name=X_70268_ }
C {devices/lab_pin.sym} 98240 -32910 0 0 {name=p97376 lab=_60064_/A }
C {devices/lab_pin.sym} 98240 -32870 0 0 {name=p97377 lab=_59873_/B }
C {devices/lab_pin.sym} 98240 -32830 0 0 {name=p97378 lab=_60021_/C }
C {devices/lab_pin.sym} 98360 -32870 0 1 {name=p97379 lab=_60021_/Y }
C {sky130_stdcells/nor3_4.sym} 98300 -32870 0 0 {name=X_60021_ }
C {devices/lab_pin.sym} 98240 -32740 0 0 {name=p97380 lab=_72007_/A }
C {devices/lab_pin.sym} 98240 -32700 0 0 {name=p97381 lab=_72007_/B }
C {devices/lab_pin.sym} 98360 -32720 0 1 {name=p97382 lab=_72007_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -32720 0 0 {name=X_72007_ }
C {devices/lab_pin.sym} 98240 -32600 0 0 {name=p97383 lab=_49827_/X }
C {devices/lab_pin.sym} 98240 -32560 0 0 {name=p97384 lab=_53046_/B }
C {devices/lab_pin.sym} 98360 -32580 0 1 {name=p97385 lab=_49832_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -32580 0 0 {name=X_49832_ }
C {devices/lab_pin.sym} 98220 -32490 0 0 {name=p97386 lab=_42154_/X }
C {devices/lab_pin.sym} 98220 -32450 0 0 {name=p97387 lab=_42141_/X }
C {devices/lab_pin.sym} 98220 -32410 0 0 {name=p97388 lab=_41214_/X }
C {devices/lab_pin.sym} 98220 -32370 0 0 {name=p97389 lab=_88000_/Q }
C {devices/lab_pin.sym} 98220 -32330 0 0 {name=p97390 lab=_42142_/X }
C {devices/lab_pin.sym} 98380 -32410 0 1 {name=p97391 lab=_42167_/Y }
C {sky130_stdcells/o32ai_4.sym} 98300 -32410 0 0 {name=X_42167_ }
C {devices/lab_pin.sym} 98240 -32260 0 0 {name=p97392 lab=_82273_/Q }
C {devices/lab_pin.sym} 98240 -32220 0 0 {name=p97393 lab=_81985_/Q }
C {devices/lab_pin.sym} 98360 -32240 0 1 {name=p97394 lab=_77864_/Y }
C {sky130_stdcells/xnor2_4.sym} 98300 -32240 0 0 {name=X_77864_ }
C {devices/lab_pin.sym} 98220 -32130 0 0 {name=p97395 lab=_70195_/X }
C {devices/lab_pin.sym} 98220 -32090 0 0 {name=p97396 lab=_74799_/C }
C {devices/lab_pin.sym} 98220 -32050 0 0 {name=p97397 lab=_70198_/X }
C {devices/lab_pin.sym} 98380 -32090 0 1 {name=p97398 lab=_70199_/X }
C {sky130_stdcells/a21o_4.sym} 98300 -32090 0 0 {name=X_70199_ }
C {devices/lab_pin.sym} 98240 -31960 0 0 {name=p97399 lab=_65294_/C }
C {devices/lab_pin.sym} 98240 -31920 0 0 {name=p97400 lab=_83255_/Q }
C {devices/lab_pin.sym} 98360 -31940 0 1 {name=p97401 lab=_79603_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -31940 0 0 {name=X_79603_ }
C {devices/lab_pin.sym} 98260 -31810 0 0 {name=p97402 lab=_41118_/A }
C {devices/lab_pin.sym} 98340 -31810 0 1 {name=p97403 lab=_88275_/D }
C {sky130_stdcells/inv_2.sym} 98300 -31810 0 0 {name=X_41118_ }
C {devices/lab_pin.sym} 98220 -31720 0 0 {name=p97404 lab=_76806_/A }
C {devices/lab_pin.sym} 98220 -31680 0 0 {name=p97405 lab=_76792_/Y }
C {devices/lab_pin.sym} 98220 -31640 0 0 {name=p97406 lab=_76805_/A }
C {devices/lab_pin.sym} 98220 -31600 0 0 {name=p97407 lab=_76804_/Y }
C {devices/lab_pin.sym} 98380 -31660 0 1 {name=p97408 lab=_76815_/X }
C {sky130_stdcells/o22a_4.sym} 98300 -31660 0 0 {name=X_76815_ }
C {devices/lab_pin.sym} 98240 -31520 0 0 {name=p97409 lab=_49757_/A }
C {devices/lab_pin.sym} 98240 -31480 0 0 {name=p97410 lab=_52979_/B }
C {devices/lab_pin.sym} 98360 -31500 0 1 {name=p97411 lab=_49763_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -31500 0 0 {name=X_49763_ }
C {devices/lab_pin.sym} 98260 -31370 0 0 {name=p97412 lab=_46975_/A }
C {devices/lab_pin.sym} 98340 -31370 0 1 {name=p97413 lab=_54473_/B }
C {sky130_stdcells/inv_2.sym} 98300 -31370 0 0 {name=X_46975_ }
C {devices/lab_pin.sym} 98260 -31250 0 0 {name=p97414 lab=_42097_/Y }
C {devices/lab_pin.sym} 98340 -31250 0 1 {name=p97415 lab=_88037_/D }
C {sky130_stdcells/inv_2.sym} 98300 -31250 0 0 {name=X_42098_ }
C {devices/lab_pin.sym} 98240 -31140 0 0 {name=p97416 lab=_77809_/A }
C {devices/lab_pin.sym} 98240 -31100 0 0 {name=p97417 lab=_77819_/A }
C {devices/lab_pin.sym} 98360 -31120 0 1 {name=p97418 lab=_77795_/X }
C {sky130_stdcells/xor2_4.sym} 98300 -31120 0 0 {name=X_77795_ }
C {devices/lab_pin.sym} 98220 -31010 0 0 {name=p97419 lab=_65425_/B }
C {devices/lab_pin.sym} 98220 -30970 0 0 {name=p97420 lab=_48150_/X }
C {devices/lab_pin.sym} 98220 -30930 0 0 {name=p97421 lab=_48713_/Y }
C {devices/lab_pin.sym} 98380 -30970 0 1 {name=p97422 lab=_48714_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -30970 0 0 {name=X_48714_ }
C {devices/lab_pin.sym} 98240 -30840 0 0 {name=p97423 lab=_65397_/C }
C {devices/lab_pin.sym} 98240 -30800 0 0 {name=p97424 lab=_72465_/Y }
C {devices/lab_pin.sym} 98360 -30820 0 1 {name=p97425 lab=_79534_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -30820 0 0 {name=X_79534_ }
C {devices/lab_pin.sym} 98220 -30720 0 0 {name=p97426 lab=_64758_/X }
C {devices/lab_pin.sym} 98220 -30680 0 0 {name=p97427 lab=_83308_/Q }
C {devices/lab_pin.sym} 98220 -30640 0 0 {name=p97428 lab=_44171_/X }
C {devices/lab_pin.sym} 98220 -30600 0 0 {name=p97429 lab=_64759_/X }
C {devices/lab_pin.sym} 98380 -30660 0 1 {name=p97430 lab=_64760_/X }
C {sky130_stdcells/a211o_4.sym} 98300 -30660 0 0 {name=X_64760_ }
C {devices/lab_pin.sym} 98260 -30510 0 0 {name=p97431 lab=_64656_/A }
C {devices/lab_pin.sym} 98340 -30510 0 1 {name=p97432 lab=_45926_/X }
C {sky130_stdcells/buf_2.sym} 98300 -30510 0 0 {name=X_45926_ }
C {devices/lab_pin.sym} 98220 -30410 0 0 {name=p97433 lab=_41024_/X }
C {devices/lab_pin.sym} 98220 -30370 0 0 {name=p97434 lab=_81709_/Q }
C {devices/lab_pin.sym} 98220 -30330 0 0 {name=p97435 lab=_41048_/X }
C {devices/lab_pin.sym} 98380 -30370 0 1 {name=p97436 lab=_41050_/A }
C {sky130_stdcells/o21ai_4.sym} 98300 -30370 0 0 {name=X_41049_ }
C {devices/lab_pin.sym} 98260 -30230 0 0 {name=p97437 lab=_76746_/A }
C {devices/lab_pin.sym} 98340 -30230 0 1 {name=p97438 lab=_76746_/Y }
C {sky130_stdcells/inv_2.sym} 98300 -30230 0 0 {name=X_76746_ }
C {devices/lab_pin.sym} 98240 -30120 0 0 {name=p97439 lab=_49699_/A }
C {devices/lab_pin.sym} 98240 -30080 0 0 {name=p97440 lab=_47195_/X }
C {devices/lab_pin.sym} 98360 -30100 0 1 {name=p97441 lab=_49694_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -30100 0 0 {name=X_49694_ }
C {devices/lab_pin.sym} 98220 -29990 0 0 {name=p97442 lab=_73945_/X }
C {devices/lab_pin.sym} 98220 -29950 0 0 {name=p97443 lab=_73947_/X }
C {devices/lab_pin.sym} 98220 -29910 0 0 {name=p97444 lab=_73957_/X }
C {devices/lab_pin.sym} 98380 -29950 0 1 {name=p97445 lab=_73958_/X }
C {sky130_stdcells/a21o_4.sym} 98300 -29950 0 0 {name=X_73958_ }
C {devices/lab_pin.sym} 98240 -29840 0 0 {name=p97446 lab=_61957_/A }
C {devices/lab_pin.sym} 98240 -29800 0 0 {name=p97447 lab=_61967_/Y }
C {devices/lab_pin.sym} 98240 -29760 0 0 {name=p97448 lab=_61968_/Y }
C {devices/lab_pin.sym} 98240 -29720 0 0 {name=p97449 lab=_61971_/Y }
C {devices/lab_pin.sym} 98360 -29780 0 1 {name=p97450 lab=_61972_/Y }
C {sky130_stdcells/nand4_4.sym} 98300 -29780 0 0 {name=X_61972_ }
C {devices/lab_pin.sym} 98220 -29650 0 0 {name=p97451 lab=_63709_/Y }
C {devices/lab_pin.sym} 98220 -29610 0 0 {name=p97452 lab=_63679_/X }
C {devices/lab_pin.sym} 98220 -29570 0 0 {name=p97453 lab=_63710_/Y }
C {devices/lab_pin.sym} 98380 -29610 0 1 {name=p97454 lab=_63711_/Y }
C {sky130_stdcells/a21oi_4.sym} 98300 -29610 0 0 {name=X_63711_ }
C {devices/lab_pin.sym} 98240 -29490 0 0 {name=p97455 lab=_48845_/A }
C {devices/lab_pin.sym} 98240 -29450 0 0 {name=p97456 lab=_48657_/B }
C {devices/lab_pin.sym} 98240 -29410 0 0 {name=p97457 lab=_48657_/C }
C {devices/lab_pin.sym} 98360 -29450 0 1 {name=p97458 lab=_48645_/X }
C {sky130_stdcells/and3_4.sym} 98300 -29450 0 0 {name=X_48645_ }
C {devices/lab_pin.sym} 98220 -29330 0 0 {name=p97459 lab=_60918_/X }
C {devices/lab_pin.sym} 98220 -29290 0 0 {name=p97460 lab=_60921_/X }
C {devices/lab_pin.sym} 98220 -29250 0 0 {name=p97461 lab=_60994_/B }
C {devices/lab_pin.sym} 98380 -29290 0 1 {name=p97462 lab=_60923_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -29290 0 0 {name=X_60923_ }
C {devices/lab_pin.sym} 98260 -29150 0 0 {name=p97463 lab=_72909_/A }
C {devices/lab_pin.sym} 98340 -29150 0 1 {name=p97464 lab=_72909_/X }
C {sky130_stdcells/buf_2.sym} 98300 -29150 0 0 {name=X_72909_ }
C {devices/lab_pin.sym} 98220 -29050 0 0 {name=p97465 lab=_58623_/Y }
C {devices/lab_pin.sym} 98220 -29010 0 0 {name=p97466 lab=_66389_/C }
C {devices/lab_pin.sym} 98220 -28970 0 0 {name=p97467 lab=_79464_/Y }
C {devices/lab_pin.sym} 98380 -29010 0 1 {name=p97468 lab=_79484_/A }
C {sky130_stdcells/o21a_4.sym} 98300 -29010 0 0 {name=X_79465_ }
C {devices/lab_pin.sym} 98240 -28880 0 0 {name=p97469 lab=_55219_/B }
C {devices/lab_pin.sym} 98240 -28840 0 0 {name=p97470 lab=_45740_/B }
C {devices/lab_pin.sym} 98360 -28860 0 1 {name=p97471 lab=_45857_/Y }
C {sky130_stdcells/nor2_4.sym} 98300 -28860 0 0 {name=X_45857_ }
C {devices/lab_pin.sym} 98260 -28730 0 0 {name=p97472 lab=_58124_/A }
C {devices/lab_pin.sym} 98340 -28730 0 1 {name=p97473 lab=_64691_/X }
C {sky130_stdcells/buf_2.sym} 98300 -28730 0 0 {name=X_64691_ }
C {devices/lab_pin.sym} 98240 -28620 0 0 {name=p97474 lab=_81685_/Q }
C {devices/lab_pin.sym} 98240 -28580 0 0 {name=p97475 lab=_81397_/Q }
C {devices/lab_pin.sym} 98360 -28600 0 1 {name=p97476 lab=_76969_/A }
C {sky130_stdcells/xnor2_4.sym} 98300 -28600 0 0 {name=X_76677_ }
C {devices/lab_pin.sym} 98220 -28490 0 0 {name=p97477 lab=_73887_/X }
C {devices/lab_pin.sym} 98220 -28450 0 0 {name=p97478 lab=_73888_/Y }
C {devices/lab_pin.sym} 98220 -28410 0 0 {name=p97479 lab=_73839_/X }
C {devices/lab_pin.sym} 98380 -28450 0 1 {name=p97480 lab=_73889_/X }
C {sky130_stdcells/a21o_4.sym} 98300 -28450 0 0 {name=X_73889_ }
C {devices/lab_pin.sym} 98220 -28330 0 0 {name=p97481 lab=_66427_/Y }
C {devices/lab_pin.sym} 98220 -28290 0 0 {name=p97482 lab=_66414_/X }
C {devices/lab_pin.sym} 98220 -28250 0 0 {name=p97483 lab=_66429_/Y }
C {devices/lab_pin.sym} 98380 -28290 0 1 {name=p97484 lab=_84125_/D }
C {sky130_stdcells/a21o_4.sym} 98300 -28290 0 0 {name=X_66430_ }
C {devices/lab_pin.sym} 98240 -28160 0 0 {name=p97485 lab=_78416_/A }
C {devices/lab_pin.sym} 98240 -28120 0 0 {name=p97486 lab=_82761_/D }
C {devices/lab_pin.sym} 98360 -28140 0 1 {name=p97487 lab=_82473_/D }
C {sky130_stdcells/xor2_4.sym} 98300 -28140 0 0 {name=X_78416_ }
C {devices/lab_pin.sym} 98260 -28010 0 0 {name=p97488 lab=_43896_/X }
C {devices/lab_pin.sym} 98340 -28010 0 1 {name=p97489 lab=_44808_/X }
C {sky130_stdcells/buf_2.sym} 98300 -28010 0 0 {name=X_44808_ }
C {devices/lab_pin.sym} 98220 -27930 0 0 {name=p97490 lab=_63638_/Y }
C {devices/lab_pin.sym} 98220 -27890 0 0 {name=p97491 lab=_63639_/Y }
C {devices/lab_pin.sym} 98220 -27850 0 0 {name=p97492 lab=_63641_/X }
C {devices/lab_pin.sym} 98220 -27810 0 0 {name=p97493 lab=_58465_/A }
C {devices/lab_pin.sym} 98220 -27770 0 0 {name=p97494 lab=_63363_/X }
C {devices/lab_pin.sym} 98380 -27850 0 1 {name=p97495 lab=_63642_/Y }
C {sky130_stdcells/o32ai_4.sym} 98300 -27850 0 0 {name=X_63642_ }
C {devices/lab_pin.sym} 98240 -27700 0 0 {name=p97496 lab=_75628_/A }
C {devices/lab_pin.sym} 98240 -27660 0 0 {name=p97497 lab=_75628_/B }
C {devices/lab_pin.sym} 98360 -27680 0 1 {name=p97498 lab=_80968_/D }
C {sky130_stdcells/xor2_4.sym} 98300 -27680 0 0 {name=X_75628_ }
C {devices/lab_pin.sym} 98240 -27560 0 0 {name=p97499 lab=_48576_/A }
C {devices/lab_pin.sym} 98240 -27520 0 0 {name=p97500 lab=_48565_/B }
C {devices/lab_pin.sym} 98360 -27540 0 1 {name=p97501 lab=_48576_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -27540 0 0 {name=X_48576_ }
C {devices/lab_pin.sym} 98260 -27410 0 0 {name=p97502 lab=_60853_/X }
C {devices/lab_pin.sym} 98340 -27410 0 1 {name=p97503 lab=_60854_/Y }
C {sky130_stdcells/inv_2.sym} 98300 -27410 0 0 {name=X_60854_ }
C {devices/lab_pin.sym} 98240 -27300 0 0 {name=p97504 lab=_79392_/X }
C {devices/lab_pin.sym} 98240 -27260 0 0 {name=p97505 lab=_79396_/B }
C {devices/lab_pin.sym} 98360 -27280 0 1 {name=p97506 lab=_79418_/B }
C {sky130_stdcells/xor2_4.sym} 98300 -27280 0 0 {name=X_79396_ }
C {devices/lab_pin.sym} 98220 -27170 0 0 {name=p97507 lab=_45785_/X }
C {devices/lab_pin.sym} 98220 -27130 0 0 {name=p97508 lab=_45787_/Y }
C {devices/lab_pin.sym} 98220 -27090 0 0 {name=p97509 lab=_45714_/X }
C {devices/lab_pin.sym} 98380 -27130 0 1 {name=p97510 lab=_45788_/Y }
C {sky130_stdcells/a21oi_4.sym} 98300 -27130 0 0 {name=X_45788_ }
C {devices/lab_pin.sym} 98260 -26990 0 0 {name=p97511 lab=_47526_/Y }
C {devices/lab_pin.sym} 98340 -26990 0 1 {name=p97512 lab=_53101_/B }
C {sky130_stdcells/buf_2.sym} 98300 -26990 0 0 {name=X_47527_ }
C {devices/lab_pin.sym} 98240 -26890 0 0 {name=p97513 lab=_65910_/X }
C {devices/lab_pin.sym} 98240 -26850 0 0 {name=p97514 lab=_66367_/B }
C {devices/lab_pin.sym} 98240 -26810 0 0 {name=p97515 lab=_65912_/X }
C {devices/lab_pin.sym} 98360 -26850 0 1 {name=p97516 lab=_66361_/Y }
C {sky130_stdcells/nand3_4.sym} 98300 -26850 0 0 {name=X_66361_ }
C {devices/lab_pin.sym} 98220 -26730 0 0 {name=p97517 lab=_78333_/Y }
C {devices/lab_pin.sym} 98220 -26690 0 0 {name=p97518 lab=_78329_/A }
C {devices/lab_pin.sym} 98220 -26650 0 0 {name=p97519 lab=_78332_/A }
C {devices/lab_pin.sym} 98380 -26690 0 1 {name=p97520 lab=_78347_/X }
C {sky130_stdcells/o21a_4.sym} 98300 -26690 0 0 {name=X_78347_ }
C {devices/lab_pin.sym} 98220 -26590 0 0 {name=p97521 lab=_49210_/A }
C {devices/lab_pin.sym} 98220 -26550 0 0 {name=p97522 lab=_50731_/B }
C {devices/lab_pin.sym} 98220 -26510 0 0 {name=p97523 lab=_40739_/A }
C {devices/lab_pin.sym} 98220 -26470 0 0 {name=p97524 lab=_44738_/Y }
C {devices/lab_pin.sym} 98220 -26430 0 0 {name=p97525 lab=_44736_/X }
