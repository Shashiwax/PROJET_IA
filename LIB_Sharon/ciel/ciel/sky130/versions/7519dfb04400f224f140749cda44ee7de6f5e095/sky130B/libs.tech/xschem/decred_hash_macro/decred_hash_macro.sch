C {sky130_stdcells/or2_4.sym} 141540 -20700 0 0 {name=X_41624_ }
C {devices/lab_pin.sym} 141460 -20590 0 0 {name=p140643 lab=_48174_/Y }
C {devices/lab_pin.sym} 141460 -20550 0 0 {name=p140644 lab=_48175_/X }
C {devices/lab_pin.sym} 141460 -20510 0 0 {name=p140645 lab=_48179_/Y }
C {devices/lab_pin.sym} 141620 -20550 0 1 {name=p140646 lab=_48180_/Y }
C {sky130_stdcells/a21boi_4.sym} 141540 -20550 0 0 {name=X_48180_ }
C {devices/lab_pin.sym} 141460 -20440 0 0 {name=p140647 lab=_83254_/Q }
C {devices/lab_pin.sym} 141460 -20400 0 0 {name=p140648 lab=_72381_/X }
C {devices/lab_pin.sym} 141460 -20360 0 0 {name=p140649 lab=_72438_/X }
C {devices/lab_pin.sym} 141460 -20320 0 0 {name=p140650 lab=_72443_/X }
C {devices/lab_pin.sym} 141620 -20380 0 1 {name=p140651 lab=_72444_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 141540 -20380 0 0 {name=X_72444_ }
C {devices/lab_pin.sym} 141460 -20260 0 0 {name=p140652 lab=_55635_/B }
C {devices/lab_pin.sym} 141460 -20220 0 0 {name=p140653 lab=_45388_/X }
C {devices/lab_pin.sym} 141460 -20180 0 0 {name=p140654 lab=_45390_/X }
C {devices/lab_pin.sym} 141460 -20140 0 0 {name=p140655 lab=_45391_/Y }
C {devices/lab_pin.sym} 141620 -20200 0 1 {name=p140656 lab=_45392_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -20200 0 0 {name=X_45392_ }
C {devices/lab_pin.sym} 141500 -20050 0 0 {name=p140657 lab=_57377_/X }
C {devices/lab_pin.sym} 141580 -20050 0 1 {name=p140658 lab=_73916_/B }
C {sky130_stdcells/buf_2.sym} 141540 -20050 0 0 {name=X_57378_ }
C {devices/lab_pin.sym} 141450 -19930 0 0 {name=p140659 lab=_88201_/CLK }
C {devices/lab_pin.sym} 141450 -19910 0 0 {name=p140660 lab=_88198_/D }
C {devices/lab_pin.sym} 141630 -19930 0 1 {name=p140661 lab=_88198_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -19920 0 0 {name=X_88198_ }
C {devices/lab_pin.sym} 141500 -19790 0 0 {name=p140662 lab=_82379_/Q }
C {devices/lab_pin.sym} 141580 -19790 0 1 {name=p140663 lab=_54565_/D }
C {sky130_stdcells/inv_2.sym} 141540 -19790 0 0 {name=X_47131_ }
C {devices/lab_pin.sym} 141480 -19680 0 0 {name=p140664 lab=_59117_/A }
C {devices/lab_pin.sym} 141480 -19640 0 0 {name=p140665 lab=_86359_/Q }
C {devices/lab_pin.sym} 141600 -19660 0 1 {name=p140666 lab=_59117_/Y }
C {sky130_stdcells/nor2_4.sym} 141540 -19660 0 0 {name=X_59117_ }
C {devices/lab_pin.sym} 141460 -19560 0 0 {name=p140667 lab=_41693_/X }
C {devices/lab_pin.sym} 141460 -19520 0 0 {name=p140668 lab=_44326_/X }
C {devices/lab_pin.sym} 141460 -19480 0 0 {name=p140669 lab=_87156_/Q }
C {devices/lab_pin.sym} 141460 -19440 0 0 {name=p140670 lab=_44327_/X }
C {devices/lab_pin.sym} 141620 -19500 0 1 {name=p140671 lab=_87156_/D }
C {sky130_stdcells/a2bb2o_4.sym} 141540 -19500 0 0 {name=X_44343_ }
C {devices/lab_pin.sym} 141460 -19370 0 0 {name=p140672 lab=_56085_/X }
C {devices/lab_pin.sym} 141460 -19330 0 0 {name=p140673 lab=_56321_/X }
C {devices/lab_pin.sym} 141460 -19290 0 0 {name=p140674 lab=_56328_/Y }
C {devices/lab_pin.sym} 141620 -19330 0 1 {name=p140675 lab=_56329_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -19330 0 0 {name=X_56329_ }
C {devices/lab_pin.sym} 141500 -19190 0 0 {name=p140676 lab=_75162_/X }
C {devices/lab_pin.sym} 141580 -19190 0 1 {name=p140677 lab=_75163_/X }
C {sky130_stdcells/buf_2.sym} 141540 -19190 0 0 {name=X_75163_ }
C {devices/lab_pin.sym} 141450 -19070 0 0 {name=p140678 lab=_87149_/CLK }
C {devices/lab_pin.sym} 141450 -19050 0 0 {name=p140679 lab=_44358_/X }
C {devices/lab_pin.sym} 141630 -19070 0 1 {name=p140680 lab=_87149_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -19060 0 0 {name=X_87149_ }
C {devices/lab_pin.sym} 141460 -18950 0 0 {name=p140681 lab=_41548_/X }
C {devices/lab_pin.sym} 141460 -18910 0 0 {name=p140682 lab=_82319_/Q }
C {devices/lab_pin.sym} 141460 -18870 0 0 {name=p140683 lab=_41554_/X }
C {devices/lab_pin.sym} 141620 -18910 0 1 {name=p140684 lab=_41555_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -18910 0 0 {name=X_41555_ }
C {devices/lab_pin.sym} 141460 -18790 0 0 {name=p140685 lab=_72327_/X }
C {devices/lab_pin.sym} 141460 -18750 0 0 {name=p140686 lab=_85964_/Q }
C {devices/lab_pin.sym} 141460 -18710 0 0 {name=p140687 lab=_72374_/X }
C {devices/lab_pin.sym} 141620 -18750 0 1 {name=p140688 lab=_72375_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -18750 0 0 {name=X_72375_ }
C {devices/lab_pin.sym} 141480 -18620 0 0 {name=p140689 lab=_74111_/X }
C {devices/lab_pin.sym} 141480 -18580 0 0 {name=p140690 lab=_74114_/B }
C {devices/lab_pin.sym} 141600 -18600 0 1 {name=p140691 lab=_74115_/B }
C {sky130_stdcells/nand2_4.sym} 141540 -18600 0 0 {name=X_74114_ }
C {devices/lab_pin.sym} 141460 -18490 0 0 {name=p140692 lab=_40504_/X }
C {devices/lab_pin.sym} 141460 -18450 0 0 {name=p140693 lab=_82314_/Q }
C {devices/lab_pin.sym} 141460 -18410 0 0 {name=p140694 lab=_40505_/X }
C {devices/lab_pin.sym} 141620 -18450 0 1 {name=p140695 lab=_40506_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -18450 0 0 {name=X_40506_ }
C {devices/lab_pin.sym} 141500 -18310 0 0 {name=p140696 lab=_58877_/A }
C {devices/lab_pin.sym} 141580 -18310 0 1 {name=p140697 lab=_59048_/X }
C {sky130_stdcells/buf_2.sym} 141540 -18310 0 0 {name=X_59048_ }
C {devices/lab_pin.sym} 141500 -18190 0 0 {name=p140698 lab=_53345_/B }
C {devices/lab_pin.sym} 141580 -18190 0 1 {name=p140699 lab=_52833_/B }
C {sky130_stdcells/buf_2.sym} 141540 -18190 0 0 {name=X_47062_ }
C {devices/lab_pin.sym} 141500 -18070 0 0 {name=p140700 lab=_71196_/A }
C {devices/lab_pin.sym} 141580 -18070 0 1 {name=p140701 lab=_71335_/B }
C {sky130_stdcells/buf_2.sym} 141540 -18070 0 0 {name=X_71326_ }
C {devices/lab_pin.sym} 141480 -17980 0 0 {name=p140702 lab=_44120_/Y }
C {devices/lab_pin.sym} 141480 -17940 0 0 {name=p140703 lab=_44010_/A }
C {devices/lab_pin.sym} 141480 -17900 0 0 {name=p140704 lab=_72896_/B }
C {devices/lab_pin.sym} 141480 -17860 0 0 {name=p140705 lab=_44274_/D }
C {devices/lab_pin.sym} 141600 -17920 0 1 {name=p140706 lab=_44274_/X }
C {sky130_stdcells/and4_4.sym} 141540 -17920 0 0 {name=X_44274_ }
C {devices/lab_pin.sym} 141480 -17780 0 0 {name=p140707 lab=_80771_/Q }
C {devices/lab_pin.sym} 141480 -17740 0 0 {name=p140708 lab=_81027_/D }
C {devices/lab_pin.sym} 141600 -17760 0 1 {name=p140709 lab=_75094_/X }
C {sky130_stdcells/xor2_4.sym} 141540 -17760 0 0 {name=X_75094_ }
C {devices/lab_pin.sym} 141480 -17640 0 0 {name=p140710 lab=_84927_/Q }
C {devices/lab_pin.sym} 141480 -17600 0 0 {name=p140711 lab=_84175_/Q }
C {devices/lab_pin.sym} 141600 -17620 0 1 {name=p140712 lab=_79971_/X }
C {sky130_stdcells/or2_4.sym} 141540 -17620 0 0 {name=X_79971_ }
C {devices/lab_pin.sym} 141500 -17490 0 0 {name=p140713 lab=_41486_/A }
C {devices/lab_pin.sym} 141580 -17490 0 1 {name=p140714 lab=_41486_/X }
C {sky130_stdcells/buf_2.sym} 141540 -17490 0 0 {name=X_41486_ }
C {devices/lab_pin.sym} 141500 -17370 0 0 {name=p140715 lab=_40556_/A }
C {devices/lab_pin.sym} 141580 -17370 0 1 {name=p140716 lab=_46013_/X }
C {sky130_stdcells/buf_2.sym} 141540 -17370 0 0 {name=X_46013_ }
C {devices/lab_pin.sym} 141460 -17280 0 0 {name=p140717 lab=_40986_/X }
C {devices/lab_pin.sym} 141460 -17240 0 0 {name=p140718 lab=_43216_/X }
C {devices/lab_pin.sym} 141460 -17200 0 0 {name=p140719 lab=_87529_/Q }
C {devices/lab_pin.sym} 141460 -17160 0 0 {name=p140720 lab=_43218_/X }
C {devices/lab_pin.sym} 141620 -17220 0 1 {name=p140721 lab=_43225_/X }
C {sky130_stdcells/a2bb2o_4.sym} 141540 -17220 0 0 {name=X_43225_ }
C {devices/lab_pin.sym} 141480 -17080 0 0 {name=p140722 lab=_82847_/Q }
C {devices/lab_pin.sym} 141480 -17040 0 0 {name=p140723 lab=_82559_/Q }
C {devices/lab_pin.sym} 141600 -17060 0 1 {name=p140724 lab=_78923_/B }
C {sky130_stdcells/xnor2_4.sym} 141540 -17060 0 0 {name=X_78922_ }
C {devices/lab_pin.sym} 141480 -16940 0 0 {name=p140725 lab=_74045_/A }
C {devices/lab_pin.sym} 141480 -16900 0 0 {name=p140726 lab=_74045_/B }
C {devices/lab_pin.sym} 141600 -16920 0 1 {name=p140727 lab=_74046_/B }
C {sky130_stdcells/nand2_4.sym} 141540 -16920 0 0 {name=X_74045_ }
C {devices/lab_pin.sym} 141500 -16790 0 0 {name=p140728 lab=_44733_/A }
C {devices/lab_pin.sym} 141580 -16790 0 1 {name=p140729 lab=_40437_/X }
C {sky130_stdcells/buf_2.sym} 141540 -16790 0 0 {name=X_40437_ }
C {devices/lab_pin.sym} 141460 -16690 0 0 {name=p140730 lab=_50260_/B }
C {devices/lab_pin.sym} 141460 -16650 0 0 {name=p140731 lab=_71239_/A }
C {devices/lab_pin.sym} 141460 -16610 0 0 {name=p140732 lab=_71256_/Y }
C {devices/lab_pin.sym} 141620 -16650 0 1 {name=p140733 lab=_71257_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -16650 0 0 {name=X_71257_ }
C {devices/lab_pin.sym} 141460 -16530 0 0 {name=p140734 lab=_60998_/X }
C {devices/lab_pin.sym} 141460 -16490 0 0 {name=p140735 lab=_60992_/X }
C {devices/lab_pin.sym} 141460 -16450 0 0 {name=p140736 lab=_60905_/Y }
C {devices/lab_pin.sym} 141620 -16490 0 1 {name=p140737 lab=_61010_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -16490 0 0 {name=X_61010_ }
C {devices/lab_pin.sym} 141460 -16370 0 0 {name=p140738 lab=_70195_/X }
C {devices/lab_pin.sym} 141460 -16330 0 0 {name=p140739 lab=_74773_/C }
C {devices/lab_pin.sym} 141460 -16290 0 0 {name=p140740 lab=_70207_/X }
C {devices/lab_pin.sym} 141620 -16330 0 1 {name=p140741 lab=_83837_/D }
C {sky130_stdcells/a21o_4.sym} 141540 -16330 0 0 {name=X_70208_ }
C {devices/lab_pin.sym} 141500 -16190 0 0 {name=p140742 lab=clkbuf_9_291_0_CLK/X }
C {devices/lab_pin.sym} 141580 -16190 0 1 {name=p140743 lab=_83973_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 141540 -16190 0 0 {name=Xclkbuf_10_582_0_CLK }
C {devices/lab_pin.sym} 141500 -16070 0 0 {name=p140744 lab=_43156_/A }
C {devices/lab_pin.sym} 141580 -16070 0 1 {name=p140745 lab=_43156_/Y }
C {sky130_stdcells/inv_2.sym} 141540 -16070 0 0 {name=X_43156_ }
C {devices/lab_pin.sym} 141480 -15960 0 0 {name=p140746 lab=_78865_/B }
C {devices/lab_pin.sym} 141480 -15920 0 0 {name=p140747 lab=_78852_/X }
C {devices/lab_pin.sym} 141600 -15940 0 1 {name=p140748 lab=_78866_/A }
C {sky130_stdcells/xnor2_4.sym} 141540 -15940 0 0 {name=X_78853_ }
C {devices/lab_pin.sym} 141500 -15810 0 0 {name=p140749 lab=_40420_/A }
C {devices/lab_pin.sym} 141580 -15810 0 1 {name=p140750 lab=_40368_/X }
C {sky130_stdcells/buf_2.sym} 141540 -15810 0 0 {name=X_40368_ }
C {devices/lab_pin.sym} 141500 -15690 0 0 {name=p140751 lab=_71191_/A }
C {devices/lab_pin.sym} 141580 -15690 0 1 {name=p140752 lab=_71189_/B }
C {sky130_stdcells/buf_2.sym} 141540 -15690 0 0 {name=X_71188_ }
C {devices/lab_pin.sym} 141500 -15570 0 0 {name=p140753 lab=_42106_/Y }
C {devices/lab_pin.sym} 141580 -15570 0 1 {name=p140754 lab=_88033_/D }
C {sky130_stdcells/inv_2.sym} 141540 -15570 0 0 {name=X_42107_ }
C {devices/lab_pin.sym} 141480 -15460 0 0 {name=p140755 lab=_77795_/X }
C {devices/lab_pin.sym} 141480 -15420 0 0 {name=p140756 lab=_77817_/A }
C {devices/lab_pin.sym} 141600 -15440 0 1 {name=p140757 lab=_77805_/B }
C {sky130_stdcells/xor2_4.sym} 141540 -15440 0 0 {name=X_77804_ }
C {devices/lab_pin.sym} 141480 -15340 0 0 {name=p140758 lab=_70139_/A }
C {devices/lab_pin.sym} 141480 -15300 0 0 {name=p140759 lab=_70139_/B }
C {devices/lab_pin.sym} 141480 -15260 0 0 {name=p140760 lab=_70139_/C }
C {devices/lab_pin.sym} 141480 -15220 0 0 {name=p140761 lab=_70139_/D }
C {devices/lab_pin.sym} 141600 -15280 0 1 {name=p140762 lab=_70154_/A }
C {sky130_stdcells/and4_4.sym} 141540 -15280 0 0 {name=X_70139_ }
C {devices/lab_pin.sym} 141460 -15150 0 0 {name=p140763 lab=_47904_/X }
C {devices/lab_pin.sym} 141460 -15110 0 0 {name=p140764 lab=_46389_/A }
C {devices/lab_pin.sym} 141460 -15070 0 0 {name=p140765 lab=_47963_/X }
C {devices/lab_pin.sym} 141620 -15110 0 1 {name=p140766 lab=_47965_/B }
C {sky130_stdcells/o21ai_4.sym} 141540 -15110 0 0 {name=X_47964_ }
C {devices/lab_pin.sym} 141500 -14970 0 0 {name=p140767 lab=_87581_/Q }
C {devices/lab_pin.sym} 141580 -14970 0 1 {name=p140768 lab=_43087_/Y }
C {sky130_stdcells/inv_2.sym} 141540 -14970 0 0 {name=X_43087_ }
C {devices/lab_pin.sym} 141500 -14850 0 0 {name=p140769 lab=_78784_/A }
C {devices/lab_pin.sym} 141580 -14850 0 1 {name=p140770 lab=_78784_/Y }
C {sky130_stdcells/inv_2.sym} 141540 -14850 0 0 {name=X_78784_ }
C {devices/lab_pin.sym} 141480 -14740 0 0 {name=p140771 lab=_81516_/Q }
C {devices/lab_pin.sym} 141480 -14700 0 0 {name=p140772 lab=_81740_/D }
C {devices/lab_pin.sym} 141600 -14720 0 1 {name=p140773 lab=_75996_/X }
C {sky130_stdcells/xor2_4.sym} 141540 -14720 0 0 {name=X_75996_ }
C {devices/lab_pin.sym} 141480 -14600 0 0 {name=p140774 lab=_49699_/A }
C {devices/lab_pin.sym} 141480 -14560 0 0 {name=p140775 lab=_52918_/B }
C {devices/lab_pin.sym} 141600 -14580 0 1 {name=p140776 lab=_49703_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -14580 0 0 {name=X_49703_ }
C {devices/lab_pin.sym} 141500 -14450 0 0 {name=p140777 lab=_46915_/A }
C {devices/lab_pin.sym} 141580 -14450 0 1 {name=p140778 lab=_46915_/X }
C {sky130_stdcells/buf_2.sym} 141540 -14450 0 0 {name=X_46915_ }
C {devices/lab_pin.sym} 141460 -14370 0 0 {name=p140779 lab=_42035_/X }
C {devices/lab_pin.sym} 141460 -14330 0 0 {name=p140780 lab=_42010_/X }
C {devices/lab_pin.sym} 141460 -14290 0 0 {name=p140781 lab=_40881_/X }
C {devices/lab_pin.sym} 141460 -14250 0 0 {name=p140782 lab=_42036_/Y }
C {devices/lab_pin.sym} 141460 -14210 0 0 {name=p140783 lab=_42037_/X }
C {devices/lab_pin.sym} 141620 -14290 0 1 {name=p140784 lab=_88062_/D }
C {sky130_stdcells/o32ai_4.sym} 141540 -14290 0 0 {name=X_42038_ }
C {devices/lab_pin.sym} 141480 -14140 0 0 {name=p140785 lab=_77734_/Y }
C {devices/lab_pin.sym} 141480 -14100 0 0 {name=p140786 lab=_82259_/Q }
C {devices/lab_pin.sym} 141600 -14120 0 1 {name=p140787 lab=_78045_/A }
C {sky130_stdcells/nand2_4.sym} 141540 -14120 0 0 {name=X_77735_ }
C {devices/lab_pin.sym} 141480 -14010 0 0 {name=p140788 lab=_62988_/A }
C {devices/lab_pin.sym} 141480 -13970 0 0 {name=p140789 lab=_62988_/B }
C {devices/lab_pin.sym} 141480 -13930 0 0 {name=p140790 lab=_84366_/Q }
C {devices/lab_pin.sym} 141600 -13970 0 1 {name=p140791 lab=_62961_/Y }
C {sky130_stdcells/nor3_4.sym} 141540 -13970 0 0 {name=X_62961_ }
C {devices/lab_pin.sym} 141480 -13840 0 0 {name=p140792 lab=_74947_/A }
C {devices/lab_pin.sym} 141480 -13800 0 0 {name=p140793 lab=_74946_/X }
C {devices/lab_pin.sym} 141600 -13820 0 1 {name=p140794 lab=_74959_/A }
C {sky130_stdcells/nand2_4.sym} 141540 -13820 0 0 {name=X_74947_ }
C {devices/lab_pin.sym} 141480 -13700 0 0 {name=p140795 lab=_47887_/A }
C {devices/lab_pin.sym} 141480 -13660 0 0 {name=p140796 lab=_47895_/B }
C {devices/lab_pin.sym} 141600 -13680 0 1 {name=p140797 lab=_47895_/X }
C {sky130_stdcells/and2_4.sym} 141540 -13680 0 0 {name=X_47895_ }
C {devices/lab_pin.sym} 141500 -13550 0 0 {name=p140798 lab=clkbuf_9_298_0_CLK/X }
C {devices/lab_pin.sym} 141580 -13550 0 1 {name=p140799 lab=_81928_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 141540 -13550 0 0 {name=Xclkbuf_10_597_0_CLK }
C {devices/lab_pin.sym} 141460 -13460 0 0 {name=p140800 lab=_64696_/X }
C {devices/lab_pin.sym} 141460 -13420 0 0 {name=p140801 lab=_85533_/Q }
C {devices/lab_pin.sym} 141460 -13380 0 0 {name=p140802 lab=_64697_/X }
C {devices/lab_pin.sym} 141460 -13340 0 0 {name=p140803 lab=_64699_/X }
C {devices/lab_pin.sym} 141620 -13400 0 1 {name=p140804 lab=_64700_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -13400 0 0 {name=X_64700_ }
C {devices/lab_pin.sym} 141480 -13260 0 0 {name=p140805 lab=_49638_/A }
C {devices/lab_pin.sym} 141480 -13220 0 0 {name=p140806 lab=_52850_/B }
C {devices/lab_pin.sym} 141600 -13240 0 1 {name=p140807 lab=_49634_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -13240 0 0 {name=X_49634_ }
C {devices/lab_pin.sym} 141460 -13150 0 0 {name=p140808 lab=_61901_/X }
C {devices/lab_pin.sym} 141460 -13110 0 0 {name=p140809 lab=_61906_/X }
C {devices/lab_pin.sym} 141460 -13070 0 0 {name=p140810 lab=_61911_/Y }
C {devices/lab_pin.sym} 141460 -13030 0 0 {name=p140811 lab=_84742_/Q }
C {devices/lab_pin.sym} 141460 -12990 0 0 {name=p140812 lab=_61895_/X }
C {devices/lab_pin.sym} 141620 -13070 0 1 {name=p140813 lab=_61912_/Y }
C {sky130_stdcells/o32ai_4.sym} 141540 -13070 0 0 {name=X_61912_ }
C {devices/lab_pin.sym} 141500 -12910 0 0 {name=p140814 lab=_82953_/Q }
C {devices/lab_pin.sym} 141580 -12910 0 1 {name=p140815 lab=_46846_/Y }
C {sky130_stdcells/inv_2.sym} 141540 -12910 0 0 {name=X_46846_ }
C {devices/lab_pin.sym} 141500 -12790 0 0 {name=p140816 lab=_65680_/A }
C {devices/lab_pin.sym} 141580 -12790 0 1 {name=p140817 lab=_65757_/A }
C {sky130_stdcells/buf_2.sym} 141540 -12790 0 0 {name=X_65680_ }
C {devices/lab_pin.sym} 141480 -12680 0 0 {name=p140818 lab=_77666_/A }
C {devices/lab_pin.sym} 141480 -12640 0 0 {name=p140819 lab=_77666_/B }
C {devices/lab_pin.sym} 141600 -12660 0 1 {name=p140820 lab=_77667_/C }
C {sky130_stdcells/or2_4.sym} 141540 -12660 0 0 {name=X_77666_ }
C {devices/lab_pin.sym} 141480 -12540 0 0 {name=p140821 lab=_74897_/B }
C {devices/lab_pin.sym} 141480 -12500 0 0 {name=p140822 lab=_74878_/B }
C {devices/lab_pin.sym} 141600 -12520 0 1 {name=p140823 lab=_74879_/B }
C {sky130_stdcells/xnor2_4.sym} 141540 -12520 0 0 {name=X_74878_ }
C {devices/lab_pin.sym} 141460 -12430 0 0 {name=p140824 lab=_62885_/X }
C {devices/lab_pin.sym} 141460 -12390 0 0 {name=p140825 lab=_62886_/X }
C {devices/lab_pin.sym} 141460 -12350 0 0 {name=p140826 lab=_62888_/Y }
C {devices/lab_pin.sym} 141460 -12310 0 0 {name=p140827 lab=_62889_/Y }
C {devices/lab_pin.sym} 141460 -12280 0 0 {name=p140828 lab=_62891_/X }
C {devices/lab_pin.sym} 141620 -12350 0 1 {name=p140829 lab=_62892_/X }
C {sky130_stdcells/a41o_4.sym} 141540 -12350 0 0 {name=X_62892_ }
C {devices/lab_pin.sym} 141480 -12200 0 0 {name=p140830 lab=_84351_/Q }
C {devices/lab_pin.sym} 141480 -12160 0 0 {name=p140831 lab=_79405_/B }
C {devices/lab_pin.sym} 141600 -12180 0 1 {name=p140832 lab=_79405_/X }
C {sky130_stdcells/xor2_4.sym} 141540 -12180 0 0 {name=X_79405_ }
C {devices/lab_pin.sym} 141480 -12060 0 0 {name=p140833 lab=_64684_/A }
C {devices/lab_pin.sym} 141480 -12020 0 0 {name=p140834 lab=_86464_/Q }
C {devices/lab_pin.sym} 141600 -12040 0 1 {name=p140835 lab=_64631_/X }
C {sky130_stdcells/and2_4.sym} 141540 -12040 0 0 {name=X_64631_ }
C {devices/lab_pin.sym} 141460 -11930 0 0 {name=p140836 lab=_76614_/C }
C {devices/lab_pin.sym} 141460 -11890 0 0 {name=p140837 lab=_76602_/Y }
C {devices/lab_pin.sym} 141460 -11850 0 0 {name=p140838 lab=_76614_/B }
C {devices/lab_pin.sym} 141620 -11890 0 1 {name=p140839 lab=_76624_/B }
C {sky130_stdcells/a21bo_4.sym} 141540 -11890 0 0 {name=X_76617_ }
C {devices/lab_pin.sym} 141480 -11780 0 0 {name=p140840 lab=_49561_/A }
C {devices/lab_pin.sym} 141480 -11740 0 0 {name=p140841 lab=_49561_/B }
C {devices/lab_pin.sym} 141480 -11700 0 0 {name=p140842 lab=_49548_/X }
C {devices/lab_pin.sym} 141480 -11660 0 0 {name=p140843 lab=_52779_/D }
C {devices/lab_pin.sym} 141600 -11720 0 1 {name=p140844 lab=_49565_/X }
C {sky130_stdcells/and4_4.sym} 141540 -11720 0 0 {name=X_49565_ }
C {devices/lab_pin.sym} 141500 -11570 0 0 {name=p140845 lab=_73709_/X }
C {devices/lab_pin.sym} 141580 -11570 0 1 {name=p140846 lab=_73829_/X }
C {sky130_stdcells/buf_2.sym} 141540 -11570 0 0 {name=X_73829_ }
C {devices/lab_pin.sym} 141480 -11480 0 0 {name=p140847 lab=_61417_/B }
C {devices/lab_pin.sym} 141480 -11440 0 0 {name=p140848 lab=_61843_/B }
C {devices/lab_pin.sym} 141480 -11400 0 0 {name=p140849 lab=_61795_/C }
C {devices/lab_pin.sym} 141480 -11360 0 0 {name=p140850 lab=_61778_/X }
C {devices/lab_pin.sym} 141600 -11420 0 1 {name=p140851 lab=_61843_/Y }
C {sky130_stdcells/nand4_4.sym} 141540 -11420 0 0 {name=X_61843_ }
C {devices/lab_pin.sym} 141460 -11290 0 0 {name=p140852 lab=_46772_/Y }
C {devices/lab_pin.sym} 141460 -11250 0 0 {name=p140853 lab=_46751_/X }
C {devices/lab_pin.sym} 141460 -11210 0 0 {name=p140854 lab=_46776_/X }
C {devices/lab_pin.sym} 141620 -11250 0 1 {name=p140855 lab=_86705_/D }
C {sky130_stdcells/a21oi_4.sym} 141540 -11250 0 0 {name=X_46777_ }
C {devices/lab_pin.sym} 141480 -11120 0 0 {name=p140856 lab=_81946_/Q }
C {devices/lab_pin.sym} 141480 -11080 0 0 {name=p140857 lab=_82202_/D }
C {devices/lab_pin.sym} 141600 -11100 0 1 {name=p140858 lab=_81914_/D }
C {sky130_stdcells/xor2_4.sym} 141540 -11100 0 0 {name=X_77597_ }
C {devices/lab_pin.sym} 141480 -10980 0 0 {name=p140859 lab=_43985_/X }
C {devices/lab_pin.sym} 141480 -10940 0 0 {name=p140860 lab=_43988_/X }
C {devices/lab_pin.sym} 141600 -10960 0 1 {name=p140861 lab=_43989_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -10960 0 0 {name=X_43989_ }
C {devices/lab_pin.sym} 141460 -10850 0 0 {name=p140862 lab=_86515_/Q }
C {devices/lab_pin.sym} 141460 -10810 0 0 {name=p140863 lab=_48478_/X }
C {devices/lab_pin.sym} 141460 -10770 0 0 {name=p140864 lab=_48515_/Y }
C {devices/lab_pin.sym} 141620 -10810 0 1 {name=p140865 lab=_48516_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -10810 0 0 {name=X_48516_ }
C {devices/lab_pin.sym} 141460 -10700 0 0 {name=p140866 lab=_87167_/Q }
C {devices/lab_pin.sym} 141460 -10660 0 0 {name=p140867 lab=_67348_/X }
C {devices/lab_pin.sym} 141460 -10620 0 0 {name=p140868 lab=_67278_/X }
C {devices/lab_pin.sym} 141460 -10580 0 0 {name=p140869 lab=_67349_/X }
C {devices/lab_pin.sym} 141620 -10640 0 1 {name=p140870 lab=_67350_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -10640 0 0 {name=X_67350_ }
C {devices/lab_pin.sym} 141480 -10500 0 0 {name=p140871 lab=_79322_/Y }
C {devices/lab_pin.sym} 141480 -10460 0 0 {name=p140872 lab=_79336_/B }
C {devices/lab_pin.sym} 141600 -10480 0 1 {name=p140873 lab=_79336_/X }
C {sky130_stdcells/and2_4.sym} 141540 -10480 0 0 {name=X_79336_ }
C {devices/lab_pin.sym} 141500 -10350 0 0 {name=p140874 lab=clkbuf_9_260_0_CLK/X }
C {devices/lab_pin.sym} 141580 -10350 0 1 {name=p140875 lab=_81433_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 141540 -10350 0 0 {name=Xclkbuf_10_520_0_CLK }
C {devices/lab_pin.sym} 141480 -10240 0 0 {name=p140876 lab=_45728_/A }
C {devices/lab_pin.sym} 141480 -10200 0 0 {name=p140877 lab=_45746_/B }
C {devices/lab_pin.sym} 141600 -10220 0 1 {name=p140878 lab=_45728_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -10220 0 0 {name=X_45728_ }
C {devices/lab_pin.sym} 141500 -10090 0 0 {name=p140879 lab=_45924_/A }
C {devices/lab_pin.sym} 141580 -10090 0 1 {name=p140880 lab=_64665_/A }
C {sky130_stdcells/buf_2.sym} 141540 -10090 0 0 {name=X_64562_ }
C {devices/lab_pin.sym} 141480 -9980 0 0 {name=p140881 lab=_76548_/A }
C {devices/lab_pin.sym} 141480 -9940 0 0 {name=p140882 lab=_76547_/Y }
C {devices/lab_pin.sym} 141600 -9960 0 1 {name=p140883 lab=_76548_/X }
C {sky130_stdcells/xor2_4.sym} 141540 -9960 0 0 {name=X_76548_ }
C {devices/lab_pin.sym} 141500 -9830 0 0 {name=p140884 lab=clkbuf_5_5_0_CLK/X }
C {devices/lab_pin.sym} 141580 -9830 0 1 {name=p140885 lab=clkbuf_7_23_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 141540 -9830 0 0 {name=Xclkbuf_6_11_0_CLK }
C {devices/lab_pin.sym} 141500 -9710 0 0 {name=p140886 lab=_49496_/A }
C {devices/lab_pin.sym} 141580 -9710 0 1 {name=p140887 lab=_49496_/X }
C {sky130_stdcells/buf_2.sym} 141540 -9710 0 0 {name=X_49496_ }
C {devices/lab_pin.sym} 141500 -9590 0 0 {name=p140888 lab=_62185_/B }
C {devices/lab_pin.sym} 141580 -9590 0 1 {name=p140889 lab=_61794_/B }
C {sky130_stdcells/buf_2.sym} 141540 -9590 0 0 {name=X_61774_ }
C {devices/lab_pin.sym} 141480 -9480 0 0 {name=p140890 lab=_66326_/A }
C {devices/lab_pin.sym} 141480 -9440 0 0 {name=p140891 lab=_66301_/B }
C {devices/lab_pin.sym} 141600 -9460 0 1 {name=p140892 lab=_66301_/X }
C {sky130_stdcells/and2_4.sym} 141540 -9460 0 0 {name=X_66301_ }
C {devices/lab_pin.sym} 141460 -9360 0 0 {name=p140893 lab=_61479_/B }
C {devices/lab_pin.sym} 141460 -9320 0 0 {name=p140894 lab=_63487_/X }
C {devices/lab_pin.sym} 141460 -9280 0 0 {name=p140895 lab=_63511_/X }
C {devices/lab_pin.sym} 141460 -9240 0 0 {name=p140896 lab=_63512_/X }
C {devices/lab_pin.sym} 141620 -9300 0 1 {name=p140897 lab=_63513_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -9300 0 0 {name=X_63513_ }
C {devices/lab_pin.sym} 141480 -9160 0 0 {name=p140898 lab=_60725_/A }
C {devices/lab_pin.sym} 141480 -9120 0 0 {name=p140899 lab=_60725_/B }
C {devices/lab_pin.sym} 141600 -9140 0 1 {name=p140900 lab=_60725_/Y }
C {sky130_stdcells/nor2_4.sym} 141540 -9140 0 0 {name=X_60725_ }
C {devices/lab_pin.sym} 141460 -9030 0 0 {name=p140901 lab=_72993_/B }
C {devices/lab_pin.sym} 141460 -8990 0 0 {name=p140902 lab=_48419_/X }
C {devices/lab_pin.sym} 141460 -8950 0 0 {name=p140903 lab=_48446_/Y }
C {devices/lab_pin.sym} 141620 -8990 0 1 {name=p140904 lab=_48447_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -8990 0 0 {name=X_48447_ }
C {devices/lab_pin.sym} 141460 -8870 0 0 {name=p140905 lab=_67277_/X }
C {devices/lab_pin.sym} 141460 -8830 0 0 {name=p140906 lab=_67280_/X }
C {devices/lab_pin.sym} 141460 -8790 0 0 {name=p140907 lab=_67255_/X }
C {devices/lab_pin.sym} 141620 -8830 0 1 {name=p140908 lab=_67281_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -8830 0 0 {name=X_67281_ }
C {devices/lab_pin.sym} 141480 -8700 0 0 {name=p140909 lab=_79267_/A }
C {devices/lab_pin.sym} 141480 -8660 0 0 {name=p140910 lab=_79267_/B }
C {devices/lab_pin.sym} 141600 -8680 0 1 {name=p140911 lab=_79276_/B }
C {sky130_stdcells/xor2_4.sym} 141540 -8680 0 0 {name=X_79267_ }
C {devices/lab_pin.sym} 141500 -8550 0 0 {name=p140912 lab=_45659_/A }
C {devices/lab_pin.sym} 141580 -8550 0 1 {name=p140913 lab=_45659_/Y }
C {sky130_stdcells/inv_2.sym} 141540 -8550 0 0 {name=X_45659_ }
C {devices/lab_pin.sym} 141480 -8450 0 0 {name=p140914 lab=_76474_/X }
C {devices/lab_pin.sym} 141480 -8410 0 0 {name=p140915 lab=_76479_/B }
C {devices/lab_pin.sym} 141480 -8370 0 0 {name=p140916 lab=_76479_/C }
C {devices/lab_pin.sym} 141600 -8410 0 1 {name=p140917 lab=_76513_/C }
C {sky130_stdcells/nand3_4.sym} 141540 -8410 0 0 {name=X_76479_ }
C {devices/lab_pin.sym} 141480 -8300 0 0 {name=p140918 lab=_64363_/A }
C {devices/lab_pin.sym} 141480 -8260 0 0 {name=p140919 lab=_64363_/B }
C {devices/lab_pin.sym} 141480 -8220 0 0 {name=p140920 lab=_58187_/A }
C {devices/lab_pin.sym} 141480 -8180 0 0 {name=p140921 lab=_61145_/X }
C {devices/lab_pin.sym} 141600 -8240 0 1 {name=p140922 lab=_64493_/X }
C {sky130_stdcells/and4_4.sym} 141540 -8240 0 0 {name=X_64493_ }
C {devices/lab_pin.sym} 141460 -8110 0 0 {name=p140923 lab=_83951_/Q }
C {devices/lab_pin.sym} 141460 -8070 0 0 {name=p140924 lab=_68954_/X }
C {devices/lab_pin.sym} 141460 -8030 0 0 {name=p140925 lab=_69019_/X }
C {devices/lab_pin.sym} 141620 -8070 0 1 {name=p140926 lab=_83951_/D }
C {sky130_stdcells/a21bo_4.sym} 141540 -8070 0 0 {name=X_69020_ }
C {devices/lab_pin.sym} 141480 -7950 0 0 {name=p140927 lab=_66231_/X }
C {devices/lab_pin.sym} 141480 -7910 0 0 {name=p140928 lab=_66151_/B }
C {devices/lab_pin.sym} 141480 -7870 0 0 {name=p140929 lab=_80397_/B }
C {devices/lab_pin.sym} 141600 -7910 0 1 {name=p140930 lab=_66232_/X }
C {sky130_stdcells/and3_4.sym} 141540 -7910 0 0 {name=X_66232_ }
C {devices/lab_pin.sym} 141480 -7780 0 0 {name=p140931 lab=_82677_/Q }
C {devices/lab_pin.sym} 141480 -7740 0 0 {name=p140932 lab=_78218_/B }
C {devices/lab_pin.sym} 141600 -7760 0 1 {name=p140933 lab=_78218_/X }
C {sky130_stdcells/xor2_4.sym} 141540 -7760 0 0 {name=X_78218_ }
C {devices/lab_pin.sym} 141480 -7660 0 0 {name=p140934 lab=_64282_/A }
C {devices/lab_pin.sym} 141480 -7620 0 0 {name=p140935 lab=_63465_/B }
C {devices/lab_pin.sym} 141480 -7580 0 0 {name=p140936 lab=_63465_/C }
C {devices/lab_pin.sym} 141480 -7540 0 0 {name=p140937 lab=_63465_/D }
C {devices/lab_pin.sym} 141600 -7600 0 1 {name=p140938 lab=_63444_/Y }
C {sky130_stdcells/nand4_4.sym} 141540 -7600 0 0 {name=X_63444_ }
C {devices/lab_pin.sym} 141460 -7470 0 0 {name=p140939 lab=_48370_/Y }
C {devices/lab_pin.sym} 141460 -7430 0 0 {name=p140940 lab=_48302_/X }
C {devices/lab_pin.sym} 141460 -7390 0 0 {name=p140941 lab=_48377_/X }
C {devices/lab_pin.sym} 141620 -7430 0 1 {name=p140942 lab=_48378_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -7430 0 0 {name=X_48378_ }
C {devices/lab_pin.sym} 141500 -7290 0 0 {name=p140943 lab=_60702_/C }
C {devices/lab_pin.sym} 141580 -7290 0 1 {name=p140944 lab=_60713_/A }
C {sky130_stdcells/buf_2.sym} 141540 -7290 0 0 {name=X_60656_ }
C {devices/lab_pin.sym} 141480 -7180 0 0 {name=p140945 lab=_79198_/A }
C {devices/lab_pin.sym} 141480 -7140 0 0 {name=p140946 lab=_79198_/B }
C {devices/lab_pin.sym} 141600 -7160 0 1 {name=p140947 lab=_79198_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -7160 0 0 {name=X_79198_ }
C {devices/lab_pin.sym} 141500 -7030 0 0 {name=p140948 lab=clkbuf_9_267_0_CLK/X }
C {devices/lab_pin.sym} 141580 -7030 0 1 {name=p140949 lab=_81507_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 141540 -7030 0 0 {name=Xclkbuf_10_535_0_CLK }
C {devices/lab_pin.sym} 141500 -6910 0 0 {name=p140950 lab=_47329_/A }
C {devices/lab_pin.sym} 141580 -6910 0 1 {name=p140951 lab=_52989_/D }
C {sky130_stdcells/buf_2.sym} 141540 -6910 0 0 {name=X_47329_ }
C {devices/lab_pin.sym} 141500 -6790 0 0 {name=p140952 lab=_84152_/Q }
C {devices/lab_pin.sym} 141580 -6790 0 1 {name=p140953 lab=_66164_/C }
C {sky130_stdcells/inv_2.sym} 141540 -6790 0 0 {name=X_66163_ }
C {devices/lab_pin.sym} 141500 -6670 0 0 {name=p140954 lab=clkbuf_6_27_0_CLK/A }
C {devices/lab_pin.sym} 141580 -6670 0 1 {name=p140955 lab=clkbuf_6_26_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 141540 -6670 0 0 {name=Xclkbuf_6_26_0_CLK }
C {devices/lab_pin.sym} 141480 -6560 0 0 {name=p140956 lab=_82571_/Q }
C {devices/lab_pin.sym} 141480 -6520 0 0 {name=p140957 lab=_82483_/Q }
C {devices/lab_pin.sym} 141600 -6540 0 1 {name=p140958 lab=_78149_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -6540 0 0 {name=X_78149_ }
C {devices/lab_pin.sym} 141500 -6410 0 0 {name=p140959 lab=_63375_/A }
C {devices/lab_pin.sym} 141580 -6410 0 1 {name=p140960 lab=_63400_/A }
C {sky130_stdcells/buf_2.sym} 141540 -6410 0 0 {name=X_63375_ }
C {devices/lab_pin.sym} 141460 -6320 0 0 {name=p140961 lab=_79133_/A }
C {devices/lab_pin.sym} 141460 -6280 0 0 {name=p140962 lab=_60577_/X }
C {devices/lab_pin.sym} 141460 -6240 0 0 {name=p140963 lab=_60586_/X }
C {devices/lab_pin.sym} 141460 -6200 0 0 {name=p140964 lab=_60563_/X }
C {devices/lab_pin.sym} 141620 -6260 0 1 {name=p140965 lab=_60587_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 141540 -6260 0 0 {name=X_60587_ }
C {devices/lab_pin.sym} 141460 -6130 0 0 {name=p140966 lab=_65112_/Y }
C {devices/lab_pin.sym} 141460 -6090 0 0 {name=p140967 lab=_65070_/X }
C {devices/lab_pin.sym} 141460 -6050 0 0 {name=p140968 lab=_65113_/X }
C {devices/lab_pin.sym} 141620 -6090 0 1 {name=p140969 lab=_65114_/X }
C {sky130_stdcells/a21o_4.sym} 141540 -6090 0 0 {name=X_65114_ }
C {devices/lab_pin.sym} 141460 -5970 0 0 {name=p140970 lab=_50336_/Y }
C {devices/lab_pin.sym} 141460 -5930 0 0 {name=p140971 lab=_50313_/X }
C {devices/lab_pin.sym} 141460 -5890 0 0 {name=p140972 lab=_50339_/X }
C {devices/lab_pin.sym} 141620 -5930 0 1 {name=p140973 lab=_86221_/D }
C {sky130_stdcells/a21oi_4.sym} 141540 -5930 0 0 {name=X_50340_ }
C {devices/lab_pin.sym} 141460 -5830 0 0 {name=p140974 lab=_62315_/X }
C {devices/lab_pin.sym} 141460 -5790 0 0 {name=p140975 lab=_62322_/Y }
C {devices/lab_pin.sym} 141460 -5750 0 0 {name=p140976 lab=_62325_/X }
C {devices/lab_pin.sym} 141460 -5710 0 0 {name=p140977 lab=_58177_/A }
C {devices/lab_pin.sym} 141460 -5670 0 0 {name=p140978 lab=_62300_/X }
C {devices/lab_pin.sym} 141620 -5750 0 1 {name=p140979 lab=_62326_/Y }
C {sky130_stdcells/o32ai_4.sym} 141540 -5750 0 0 {name=X_62326_ }
C {devices/lab_pin.sym} 141450 -5590 0 0 {name=p140980 lab=_81160_/CLK }
C {devices/lab_pin.sym} 141450 -5570 0 0 {name=p140981 lab=_74890_/B }
C {devices/lab_pin.sym} 141630 -5590 0 1 {name=p140982 lab=_40518_/B }
C {sky130_stdcells/dfxtp_4.sym} 141540 -5580 0 0 {name=X_81160_ }
C {devices/lab_pin.sym} 141480 -5460 0 0 {name=p140983 lab=_65992_/A }
C {devices/lab_pin.sym} 141480 -5420 0 0 {name=p140984 lab=_66094_/B }
C {devices/lab_pin.sym} 141600 -5440 0 1 {name=p140985 lab=_66094_/X }
C {sky130_stdcells/and2_4.sym} 141540 -5440 0 0 {name=X_66094_ }
C {devices/lab_pin.sym} 141480 -5320 0 0 {name=p140986 lab=_60064_/C }
C {devices/lab_pin.sym} 141480 -5280 0 0 {name=p140987 lab=_80111_/B }
C {devices/lab_pin.sym} 141600 -5300 0 1 {name=p140988 lab=_80121_/B }
C {sky130_stdcells/xor2_4.sym} 141540 -5300 0 0 {name=X_80111_ }
C {devices/lab_pin.sym} 141500 -5170 0 0 {name=p140989 lab=_65045_/A }
C {devices/lab_pin.sym} 141580 -5170 0 1 {name=p140990 lab=_65047_/B }
C {sky130_stdcells/buf_2.sym} 141540 -5170 0 0 {name=X_65045_ }
C {devices/lab_pin.sym} 141460 -5070 0 0 {name=p140991 lab=_69919_/X }
C {devices/lab_pin.sym} 141460 -5030 0 0 {name=p140992 lab=_69921_/X }
C {devices/lab_pin.sym} 141460 -4990 0 0 {name=p140993 lab=_68470_/X }
C {devices/lab_pin.sym} 141620 -5030 0 1 {name=p140994 lab=_69922_/X }
C {sky130_stdcells/a21o_4.sym} 141540 -5030 0 0 {name=X_69922_ }
C {devices/lab_pin.sym} 141460 -4910 0 0 {name=p140995 lab=_50269_/Y }
C {devices/lab_pin.sym} 141460 -4870 0 0 {name=p140996 lab=_50243_/X }
C {devices/lab_pin.sym} 141460 -4830 0 0 {name=p140997 lab=_50270_/X }
C {devices/lab_pin.sym} 141620 -4870 0 1 {name=p140998 lab=_50271_/Y }
C {sky130_stdcells/a21oi_4.sym} 141540 -4870 0 0 {name=X_50271_ }
C {devices/lab_pin.sym} 141480 -4760 0 0 {name=p140999 lab=_62478_/A }
C {devices/lab_pin.sym} 141480 -4720 0 0 {name=p141000 lab=_59995_/A }
C {devices/lab_pin.sym} 141480 -4680 0 0 {name=p141001 lab=_64246_/B }
C {devices/lab_pin.sym} 141480 -4640 0 0 {name=p141002 lab=_60025_/X }
C {devices/lab_pin.sym} 141600 -4700 0 1 {name=p141003 lab=_62257_/X }
C {sky130_stdcells/and4_4.sym} 141540 -4700 0 0 {name=X_62257_ }
C {devices/lab_pin.sym} 141450 -4550 0 0 {name=p141004 lab=_82084_/CLK }
C {devices/lab_pin.sym} 141450 -4530 0 0 {name=p141005 lab=_79893_/X }
C {devices/lab_pin.sym} 141630 -4550 0 1 {name=p141006 lab=_81091_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -4540 0 0 {name=X_81091_ }
C {devices/lab_pin.sym} 141460 -4430 0 0 {name=p141007 lab=_85906_/Q }
C {devices/lab_pin.sym} 141460 -4390 0 0 {name=p141008 lab=_51945_/X }
C {devices/lab_pin.sym} 141460 -4350 0 0 {name=p141009 lab=_52009_/Y }
C {devices/lab_pin.sym} 141620 -4390 0 1 {name=p141010 lab=_52010_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -4390 0 0 {name=X_52010_ }
C {devices/lab_pin.sym} 141460 -4270 0 0 {name=p141011 lab=_61195_/A }
C {devices/lab_pin.sym} 141460 -4230 0 0 {name=p141012 lab=_61207_/X }
C {devices/lab_pin.sym} 141460 -4190 0 0 {name=p141013 lab=_61086_/X }
C {devices/lab_pin.sym} 141620 -4230 0 1 {name=p141014 lab=_61208_/Y }
C {sky130_stdcells/o21ai_4.sym} 141540 -4230 0 0 {name=X_61208_ }
C {devices/lab_pin.sym} 141480 -4100 0 0 {name=p141015 lab=_80042_/A }
C {devices/lab_pin.sym} 141480 -4060 0 0 {name=p141016 lab=_80041_/Y }
C {devices/lab_pin.sym} 141600 -4080 0 1 {name=p141017 lab=_80052_/B }
C {sky130_stdcells/xor2_4.sym} 141540 -4080 0 0 {name=X_80042_ }
C {devices/lab_pin.sym} 141480 -3960 0 0 {name=p141018 lab=_69853_/A }
C {devices/lab_pin.sym} 141480 -3920 0 0 {name=p141019 lab=_88318_/Q }
C {devices/lab_pin.sym} 141600 -3940 0 1 {name=p141020 lab=_69853_/X }
C {sky130_stdcells/and2_4.sym} 141540 -3940 0 0 {name=X_69853_ }
C {devices/lab_pin.sym} 141480 -3840 0 0 {name=p141021 lab=_61715_/A }
C {devices/lab_pin.sym} 141480 -3800 0 0 {name=p141022 lab=_62188_/B }
C {devices/lab_pin.sym} 141480 -3760 0 0 {name=p141023 lab=_62188_/C }
C {devices/lab_pin.sym} 141480 -3720 0 0 {name=p141024 lab=_62187_/Y }
C {devices/lab_pin.sym} 141600 -3780 0 1 {name=p141025 lab=_62188_/Y }
C {sky130_stdcells/nand4_4.sym} 141540 -3780 0 0 {name=X_62188_ }
C {devices/lab_pin.sym} 141480 -3640 0 0 {name=p141026 lab=_68366_/X }
C {devices/lab_pin.sym} 141480 -3600 0 0 {name=p141027 lab=_43641_/Y }
C {devices/lab_pin.sym} 141600 -3620 0 1 {name=p141028 lab=_68804_/Y }
C {sky130_stdcells/nor2_4.sym} 141540 -3620 0 0 {name=X_68804_ }
C {devices/lab_pin.sym} 141450 -3490 0 0 {name=p141029 lab=_84732_/CLK }
C {devices/lab_pin.sym} 141450 -3470 0 0 {name=p141030 lab=_84850_/D }
C {devices/lab_pin.sym} 141630 -3490 0 1 {name=p141031 lab=_84850_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -3480 0 0 {name=X_84850_ }
C {devices/lab_pin.sym} 141460 -3390 0 0 {name=p141032 lab=_60933_/X }
C {devices/lab_pin.sym} 141460 -3350 0 0 {name=p141033 lab=_61238_/B }
C {devices/lab_pin.sym} 141460 -3310 0 0 {name=p141034 lab=_61110_/Y }
C {devices/lab_pin.sym} 141460 -3270 0 0 {name=p141035 lab=_61131_/Y }
C {devices/lab_pin.sym} 141460 -3240 0 0 {name=p141036 lab=_61138_/Y }
C {devices/lab_pin.sym} 141620 -3310 0 1 {name=p141037 lab=_61139_/Y }
C {sky130_stdcells/a41oi_4.sym} 141540 -3310 0 0 {name=X_61139_ }
C {devices/lab_pin.sym} 141460 -3180 0 0 {name=p141038 lab=_87055_/Q }
C {devices/lab_pin.sym} 141460 -3140 0 0 {name=p141039 lab=_69664_/X }
C {devices/lab_pin.sym} 141460 -3100 0 0 {name=p141040 lab=_69665_/X }
C {devices/lab_pin.sym} 141460 -3060 0 0 {name=p141041 lab=_69783_/X }
C {devices/lab_pin.sym} 141620 -3120 0 1 {name=p141042 lab=_69785_/B }
C {sky130_stdcells/a211o_4.sym} 141540 -3120 0 0 {name=X_69784_ }
C {devices/lab_pin.sym} 141460 -3000 0 0 {name=p141043 lab=_87873_/Q }
C {devices/lab_pin.sym} 141460 -2960 0 0 {name=p141044 lab=_66994_/X }
C {devices/lab_pin.sym} 141460 -2920 0 0 {name=p141045 lab=_66926_/X }
C {devices/lab_pin.sym} 141460 -2880 0 0 {name=p141046 lab=_66995_/X }
C {devices/lab_pin.sym} 141620 -2940 0 1 {name=p141047 lab=_66996_/X }
C {sky130_stdcells/a211o_4.sym} 141540 -2940 0 0 {name=X_66996_ }
C {devices/lab_pin.sym} 141450 -2790 0 0 {name=p141048 lab=_83819_/CLK }
C {devices/lab_pin.sym} 141450 -2770 0 0 {name=p141049 lab=_70314_/X }
C {devices/lab_pin.sym} 141630 -2790 0 1 {name=p141050 lab=_74808_/B }
C {sky130_stdcells/dfxtp_4.sym} 141540 -2780 0 0 {name=X_83801_ }
C {devices/lab_pin.sym} 141480 -2660 0 0 {name=p141051 lab=_68735_/A }
C {devices/lab_pin.sym} 141480 -2620 0 0 {name=p141052 lab=_68735_/B }
C {devices/lab_pin.sym} 141600 -2640 0 1 {name=p141053 lab=_68735_/X }
C {sky130_stdcells/and2_4.sym} 141540 -2640 0 0 {name=X_68735_ }
C {devices/lab_pin.sym} 141480 -2520 0 0 {name=p141054 lab=_53942_/A }
C {devices/lab_pin.sym} 141480 -2480 0 0 {name=p141055 lab=_46295_/A }
C {devices/lab_pin.sym} 141600 -2500 0 1 {name=p141056 lab=_53961_/Y }
C {sky130_stdcells/nand2_4.sym} 141540 -2500 0 0 {name=X_53961_ }
C {devices/lab_pin.sym} 141480 -2380 0 0 {name=p141057 lab=_65934_/X }
C {devices/lab_pin.sym} 141480 -2340 0 0 {name=p141058 lab=_73638_/B }
C {devices/lab_pin.sym} 141600 -2360 0 1 {name=p141059 lab=_65947_/X }
C {sky130_stdcells/and2_4.sym} 141540 -2360 0 0 {name=X_65947_ }
C {devices/lab_pin.sym} 141450 -2230 0 0 {name=p141060 lab=_83438_/CLK }
C {devices/lab_pin.sym} 141450 -2210 0 0 {name=p141061 lab=_84781_/D }
C {devices/lab_pin.sym} 141630 -2230 0 1 {name=p141062 lab=_58983_/A }
C {sky130_stdcells/dfxtp_4.sym} 141540 -2220 0 0 {name=X_84781_ }
C {devices/lab_pin.sym} 141450 -2090 0 0 {name=p141063 lab=_81989_/CLK }
C {devices/lab_pin.sym} 141450 -2070 0 0 {name=p141064 lab=_81993_/D }
C {devices/lab_pin.sym} 141630 -2090 0 1 {name=p141065 lab=_77054_/A }
C {sky130_stdcells/dfxtp_4.sym} 141540 -2080 0 0 {name=X_81993_ }
C {devices/lab_pin.sym} 141480 -1960 0 0 {name=p141066 lab=_55700_/A }
C {devices/lab_pin.sym} 141480 -1920 0 0 {name=p141067 lab=_55700_/B }
C {devices/lab_pin.sym} 141600 -1940 0 1 {name=p141068 lab=_55701_/A }
C {sky130_stdcells/and2_4.sym} 141540 -1940 0 0 {name=X_55700_ }
C {devices/lab_pin.sym} 141450 -1810 0 0 {name=p141069 lab=_83584_/CLK }
C {devices/lab_pin.sym} 141450 -1790 0 0 {name=p141070 lab=_86520_/D }
C {devices/lab_pin.sym} 141630 -1810 0 1 {name=p141071 lab=_73016_/B }
C {sky130_stdcells/dfxtp_4.sym} 141540 -1800 0 0 {name=X_86520_ }
C {devices/lab_pin.sym} 141480 -1700 0 0 {name=p141072 lab=_52895_/A }
C {devices/lab_pin.sym} 141480 -1660 0 0 {name=p141073 lab=_52916_/B }
C {devices/lab_pin.sym} 141480 -1620 0 0 {name=p141074 lab=_52900_/C }
C {devices/lab_pin.sym} 141480 -1580 0 0 {name=p141075 lab=_51220_/D }
C {devices/lab_pin.sym} 141600 -1640 0 1 {name=p141076 lab=_52912_/X }
C {sky130_stdcells/and4_4.sym} 141540 -1640 0 0 {name=X_52912_ }
C {devices/lab_pin.sym} 141450 -1490 0 0 {name=p141077 lab=_84930_/CLK }
C {devices/lab_pin.sym} 141450 -1470 0 0 {name=p141078 lab=_83732_/D }
C {devices/lab_pin.sym} 141630 -1490 0 1 {name=p141079 lab=_83732_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -1480 0 0 {name=X_83732_ }
C {devices/lab_pin.sym} 141500 -1350 0 0 {name=p141080 lab=_56680_/A }
C {devices/lab_pin.sym} 141580 -1350 0 1 {name=p141081 lab=_56684_/B }
C {sky130_stdcells/buf_2.sym} 141540 -1350 0 0 {name=X_56680_ }
C {devices/lab_pin.sym} 141450 -1230 0 0 {name=p141082 lab=_80849_/CLK }
C {devices/lab_pin.sym} 141450 -1210 0 0 {name=p141083 lab=_80944_/D }
C {devices/lab_pin.sym} 141630 -1230 0 1 {name=p141084 lab=_80944_/Q }
C {sky130_stdcells/dfxtp_4.sym} 141540 -1220 0 0 {name=X_80944_ }
C {devices/lab_pin.sym} 141500 -1090 0 0 {name=p141085 lab=_69146_/A }
C {devices/lab_pin.sym} 141580 -1090 0 1 {name=p141086 lab=_68666_/X }
C {sky130_stdcells/buf_2.sym} 141540 -1090 0 0 {name=X_68666_ }
C {devices/lab_pin.sym} 141500 -970 0 0 {name=p141087 lab=_53773_/A }
C {devices/lab_pin.sym} 141580 -970 0 1 {name=p141088 lab=_53892_/X }
C {sky130_stdcells/buf_2.sym} 141540 -970 0 0 {name=X_53892_ }
C {devices/lab_pin.sym} 141480 -860 0 0 {name=p141089 lab=_65878_/A }
C {devices/lab_pin.sym} 141480 -820 0 0 {name=p141090 lab=_86467_/Q }
C {devices/lab_pin.sym} 141600 -840 0 1 {name=p141091 lab=_65878_/X }
C {sky130_stdcells/and2_4.sym} 141540 -840 0 0 {name=X_65878_ }
C {devices/lab_pin.sym} 141480 -720 0 0 {name=p141092 lab=_44085_/C }
C {devices/lab_pin.sym} 141480 -680 0 0 {name=p141093 lab=_85152_/Q }
C {devices/lab_pin.sym} 141600 -700 0 1 {name=p141094 lab=_55631_/X }
C {sky130_stdcells/and2_4.sym} 141540 -700 0 0 {name=X_55631_ }
C {devices/lab_pin.sym} 142380 -42180 0 0 {name=p141095 lab=_87463_/Q }
C {devices/lab_pin.sym} 142380 -42140 0 0 {name=p141096 lab=_67594_/X }
C {devices/lab_pin.sym} 142380 -42100 0 0 {name=p141097 lab=_67595_/X }
C {devices/lab_pin.sym} 142380 -42060 0 0 {name=p141098 lab=_67616_/X }
C {devices/lab_pin.sym} 142540 -42120 0 1 {name=p141099 lab=_67617_/X }
C {sky130_stdcells/a211o_4.sym} 142460 -42120 0 0 {name=X_67617_ }
C {devices/lab_pin.sym} 142370 -41970 0 0 {name=p141100 lab=_85555_/CLK }
C {devices/lab_pin.sym} 142370 -41950 0 0 {name=p141101 lab=_86451_/D }
C {devices/lab_pin.sym} 142550 -41970 0 1 {name=p141102 lab=_64992_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -41960 0 0 {name=X_86451_ }
C {devices/lab_pin.sym} 142400 -41840 0 0 {name=p141103 lab=_52843_/A }
C {devices/lab_pin.sym} 142400 -41800 0 0 {name=p141104 lab=_52843_/B }
C {devices/lab_pin.sym} 142520 -41820 0 1 {name=p141105 lab=_52843_/Y }
C {sky130_stdcells/nand2_4.sym} 142460 -41820 0 0 {name=X_52843_ }
C {devices/lab_pin.sym} 142420 -41690 0 0 {name=p141106 lab=_64829_/A }
C {devices/lab_pin.sym} 142500 -41690 0 1 {name=p141107 lab=_64829_/X }
C {sky130_stdcells/buf_2.sym} 142460 -41690 0 0 {name=X_64829_ }
C {devices/lab_pin.sym} 142370 -41570 0 0 {name=p141108 lab=_83663_/CLK }
C {devices/lab_pin.sym} 142370 -41550 0 0 {name=p141109 lab=_83663_/D }
C {devices/lab_pin.sym} 142550 -41570 0 1 {name=p141110 lab=_46861_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -41560 0 0 {name=X_83663_ }
C {devices/lab_pin.sym} 142370 -41430 0 0 {name=p141111 lab=_80754_/CLK }
C {devices/lab_pin.sym} 142370 -41410 0 0 {name=p141112 lab=_75655_/B }
C {devices/lab_pin.sym} 142550 -41430 0 1 {name=p141113 lab=_80875_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -41420 0 0 {name=X_80875_ }
C {devices/lab_pin.sym} 142400 -41300 0 0 {name=p141114 lab=_68597_/A }
C {devices/lab_pin.sym} 142400 -41260 0 0 {name=p141115 lab=_68596_/X }
C {devices/lab_pin.sym} 142520 -41280 0 1 {name=p141116 lab=_68597_/Y }
C {sky130_stdcells/nand2_4.sym} 142460 -41280 0 0 {name=X_68597_ }
C {devices/lab_pin.sym} 142370 -41150 0 0 {name=p141117 lab=_83745_/CLK }
C {devices/lab_pin.sym} 142370 -41130 0 0 {name=p141118 lab=_85402_/D }
C {devices/lab_pin.sym} 142550 -41150 0 1 {name=p141119 lab=_85402_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -41140 0 0 {name=X_85402_ }
C {devices/lab_pin.sym} 142420 -41010 0 0 {name=p141120 lab=_58350_/A }
C {devices/lab_pin.sym} 142500 -41010 0 1 {name=p141121 lab=_58350_/Y }
C {sky130_stdcells/inv_2.sym} 142460 -41010 0 0 {name=X_58350_ }
C {devices/lab_pin.sym} 142370 -40890 0 0 {name=p141122 lab=_82617_/CLK }
C {devices/lab_pin.sym} 142370 -40870 0 0 {name=p141123 lab=_78994_/B }
C {devices/lab_pin.sym} 142550 -40890 0 1 {name=p141124 lab=_82614_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -40880 0 0 {name=X_82614_ }
C {devices/lab_pin.sym} 142380 -40770 0 0 {name=p141125 lab=_55559_/X }
C {devices/lab_pin.sym} 142380 -40730 0 0 {name=p141126 lab=_55561_/X }
C {devices/lab_pin.sym} 142380 -40690 0 0 {name=p141127 lab=_44113_/X }
C {devices/lab_pin.sym} 142540 -40730 0 1 {name=p141128 lab=_55562_/X }
C {sky130_stdcells/a21o_4.sym} 142460 -40730 0 0 {name=X_55562_ }
C {devices/lab_pin.sym} 142380 -40620 0 0 {name=p141129 lab=_87466_/Q }
C {devices/lab_pin.sym} 142380 -40580 0 0 {name=p141130 lab=_67476_/X }
C {devices/lab_pin.sym} 142380 -40540 0 0 {name=p141131 lab=_67477_/X }
C {devices/lab_pin.sym} 142380 -40500 0 0 {name=p141132 lab=_67547_/X }
C {devices/lab_pin.sym} 142540 -40560 0 1 {name=p141133 lab=_67548_/X }
C {sky130_stdcells/a211o_4.sym} 142460 -40560 0 0 {name=X_67548_ }
C {devices/lab_pin.sym} 142370 -40410 0 0 {name=p141134 lab=_86384_/CLK }
C {devices/lab_pin.sym} 142370 -40390 0 0 {name=p141135 lab=_86382_/D }
C {devices/lab_pin.sym} 142550 -40410 0 1 {name=p141136 lab=_58804_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -40400 0 0 {name=X_86382_ }
C {devices/lab_pin.sym} 142380 -40290 0 0 {name=p141137 lab=_85757_/Q }
C {devices/lab_pin.sym} 142380 -40250 0 0 {name=p141138 lab=_52765_/X }
C {devices/lab_pin.sym} 142380 -40210 0 0 {name=p141139 lab=_52773_/Y }
C {devices/lab_pin.sym} 142540 -40250 0 1 {name=p141140 lab=_52774_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -40250 0 0 {name=X_52774_ }
C {devices/lab_pin.sym} 142370 -40110 0 0 {name=p141141 lab=_83594_/CLK }
C {devices/lab_pin.sym} 142370 -40090 0 0 {name=p141142 lab=_71134_/Y }
C {devices/lab_pin.sym} 142550 -40110 0 1 {name=p141143 lab=_49195_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -40100 0 0 {name=X_83594_ }
C {devices/lab_pin.sym} 142380 -40000 0 0 {name=p141144 lab=_57280_/X }
C {devices/lab_pin.sym} 142380 -39960 0 0 {name=p141145 lab=_57297_/X }
C {devices/lab_pin.sym} 142380 -39920 0 0 {name=p141146 lab=_57298_/Y }
C {devices/lab_pin.sym} 142380 -39880 0 0 {name=p141147 lab=_57300_/Y }
C {devices/lab_pin.sym} 142540 -39940 0 1 {name=p141148 lab=_57302_/A }
C {sky130_stdcells/a211o_4.sym} 142460 -39940 0 0 {name=X_57301_ }
C {devices/lab_pin.sym} 142370 -39790 0 0 {name=p141149 lab=_88121_/CLK }
C {devices/lab_pin.sym} 142370 -39770 0 0 {name=p141150 lab=_88121_/D }
C {devices/lab_pin.sym} 142550 -39790 0 1 {name=p141151 lab=_67206_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -39780 0 0 {name=X_88121_ }
C {devices/lab_pin.sym} 142420 -39650 0 0 {name=p141152 lab=_54486_/A }
C {devices/lab_pin.sym} 142500 -39650 0 1 {name=p141153 lab=_54518_/A }
C {sky130_stdcells/buf_2.sym} 142460 -39650 0 0 {name=X_54513_ }
C {devices/lab_pin.sym} 142370 -39530 0 0 {name=p141154 lab=_83627_/CLK }
C {devices/lab_pin.sym} 142370 -39510 0 0 {name=p141155 lab=_55027_/Y }
C {devices/lab_pin.sym} 142550 -39530 0 1 {name=p141156 lab=_85333_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -39520 0 0 {name=X_85333_ }
C {devices/lab_pin.sym} 142380 -39410 0 0 {name=p141157 lab=_85957_/Q }
C {devices/lab_pin.sym} 142380 -39370 0 0 {name=p141158 lab=_51701_/X }
C {devices/lab_pin.sym} 142380 -39330 0 0 {name=p141159 lab=_51724_/Y }
C {devices/lab_pin.sym} 142540 -39370 0 1 {name=p141160 lab=_51725_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -39370 0 0 {name=X_51725_ }
C {devices/lab_pin.sym} 142380 -39250 0 0 {name=p141161 lab=_58271_/X }
C {devices/lab_pin.sym} 142380 -39210 0 0 {name=p141162 lab=_83409_/Q }
C {devices/lab_pin.sym} 142380 -39170 0 0 {name=p141163 lab=_58280_/Y }
C {devices/lab_pin.sym} 142540 -39210 0 1 {name=p141164 lab=_58281_/X }
C {sky130_stdcells/o21a_4.sym} 142460 -39210 0 0 {name=X_58281_ }
C {devices/lab_pin.sym} 142370 -39070 0 0 {name=p141165 lab=_83133_/CLK }
C {devices/lab_pin.sym} 142370 -39050 0 0 {name=p141166 lab=_82545_/D }
C {devices/lab_pin.sym} 142550 -39070 0 1 {name=p141167 lab=_82545_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -39060 0 0 {name=X_82545_ }
C {devices/lab_pin.sym} 142400 -38940 0 0 {name=p141168 lab=_44061_/X }
C {devices/lab_pin.sym} 142400 -38900 0 0 {name=p141169 lab=_45581_/Y }
C {devices/lab_pin.sym} 142520 -38920 0 1 {name=p141170 lab=_55493_/Y }
C {sky130_stdcells/nor2_4.sym} 142460 -38920 0 0 {name=X_55493_ }
C {devices/lab_pin.sym} 142380 -38820 0 0 {name=p141171 lab=_87405_/Q }
C {devices/lab_pin.sym} 142380 -38780 0 0 {name=p141172 lab=_67476_/X }
C {devices/lab_pin.sym} 142380 -38740 0 0 {name=p141173 lab=_67477_/X }
C {devices/lab_pin.sym} 142380 -38700 0 0 {name=p141174 lab=_67478_/X }
C {devices/lab_pin.sym} 142540 -38760 0 1 {name=p141175 lab=_67479_/X }
C {sky130_stdcells/a211o_4.sym} 142460 -38760 0 0 {name=X_67479_ }
C {devices/lab_pin.sym} 142380 -38640 0 0 {name=p141176 lab=_55211_/B }
C {devices/lab_pin.sym} 142380 -38600 0 0 {name=p141177 lab=_57192_/A }
C {devices/lab_pin.sym} 142380 -38560 0 0 {name=p141178 lab=_57230_/Y }
C {devices/lab_pin.sym} 142380 -38520 0 0 {name=p141179 lab=_57231_/X }
C {devices/lab_pin.sym} 142540 -38580 0 1 {name=p141180 lab=_85058_/D }
C {sky130_stdcells/a211o_4.sym} 142460 -38580 0 0 {name=X_57232_ }
C {devices/lab_pin.sym} 142400 -38440 0 0 {name=p141181 lab=_69191_/A }
C {devices/lab_pin.sym} 142400 -38400 0 0 {name=p141182 lab=_69218_/B }
C {devices/lab_pin.sym} 142520 -38420 0 1 {name=p141183 lab=_69218_/X }
C {sky130_stdcells/and2_4.sym} 142460 -38420 0 0 {name=X_69218_ }
C {devices/lab_pin.sym} 142370 -38290 0 0 {name=p141184 lab=_88085_/CLK }
C {devices/lab_pin.sym} 142370 -38270 0 0 {name=p141185 lab=_42064_/Y }
C {devices/lab_pin.sym} 142550 -38290 0 1 {name=p141186 lab=_42063_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -38280 0 0 {name=X_88052_ }
C {devices/lab_pin.sym} 142400 -38180 0 0 {name=p141187 lab=_54435_/A }
C {devices/lab_pin.sym} 142400 -38140 0 0 {name=p141188 lab=_54440_/B }
C {devices/lab_pin.sym} 142400 -38100 0 0 {name=p141189 lab=_54429_/C }
C {devices/lab_pin.sym} 142400 -38060 0 0 {name=p141190 lab=_46924_/Y }
C {devices/lab_pin.sym} 142520 -38120 0 1 {name=p141191 lab=_54444_/X }
C {sky130_stdcells/and4_4.sym} 142460 -38120 0 0 {name=X_54444_ }
C {devices/lab_pin.sym} 142370 -37970 0 0 {name=p141192 lab=_85167_/CLK }
C {devices/lab_pin.sym} 142370 -37950 0 0 {name=p141193 lab=_85264_/D }
C {devices/lab_pin.sym} 142550 -37970 0 1 {name=p141194 lab=_85264_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -37960 0 0 {name=X_85264_ }
C {devices/lab_pin.sym} 142420 -37830 0 0 {name=p141195 lab=_52620_/A }
C {devices/lab_pin.sym} 142500 -37830 0 1 {name=p141196 lab=_52593_/A }
C {sky130_stdcells/buf_2.sym} 142460 -37830 0 0 {name=X_51656_ }
C {devices/lab_pin.sym} 142380 -37730 0 0 {name=p141197 lab=_58372_/Y }
C {devices/lab_pin.sym} 142380 -37690 0 0 {name=p141198 lab=_70458_/X }
C {devices/lab_pin.sym} 142380 -37650 0 0 {name=p141199 lab=_70489_/Y }
C {devices/lab_pin.sym} 142540 -37690 0 1 {name=p141200 lab=_83762_/D }
C {sky130_stdcells/o21ai_4.sym} 142460 -37690 0 0 {name=X_70490_ }
C {devices/lab_pin.sym} 142370 -37550 0 0 {name=p141201 lab=_82498_/CLK }
C {devices/lab_pin.sym} 142370 -37530 0 0 {name=p141202 lab=_78454_/X }
C {devices/lab_pin.sym} 142550 -37550 0 1 {name=p141203 lab=_78088_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -37540 0 0 {name=X_82476_ }
C {devices/lab_pin.sym} 142370 -37410 0 0 {name=p141204 lab=_86984_/CLK }
C {devices/lab_pin.sym} 142370 -37390 0 0 {name=p141205 lab=_44678_/Y }
C {devices/lab_pin.sym} 142550 -37410 0 1 {name=p141206 lab=_87003_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -37400 0 0 {name=X_87003_ }
C {devices/lab_pin.sym} 142370 -37270 0 0 {name=p141207 lab=_84220_/CLK }
C {devices/lab_pin.sym} 142370 -37250 0 0 {name=p141208 lab=_84215_/D }
C {devices/lab_pin.sym} 142550 -37270 0 1 {name=p141209 lab=_84215_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -37260 0 0 {name=X_84215_ }
C {devices/lab_pin.sym} 142400 -37140 0 0 {name=p141210 lab=_50607_/A }
C {devices/lab_pin.sym} 142400 -37100 0 0 {name=p141211 lab=_52307_/B }
C {devices/lab_pin.sym} 142520 -37120 0 1 {name=p141212 lab=_50607_/Y }
C {sky130_stdcells/nand2_4.sym} 142460 -37120 0 0 {name=X_50607_ }
C {devices/lab_pin.sym} 142400 -37020 0 0 {name=p141213 lab=_57170_/A }
C {devices/lab_pin.sym} 142400 -36980 0 0 {name=p141214 lab=_56737_/X }
C {devices/lab_pin.sym} 142400 -36940 0 0 {name=p141215 lab=_57163_/C }
C {devices/lab_pin.sym} 142400 -36900 0 0 {name=p141216 lab=_57156_/X }
C {devices/lab_pin.sym} 142520 -36960 0 1 {name=p141217 lab=_57163_/Y }
C {sky130_stdcells/nand4_4.sym} 142460 -36960 0 0 {name=X_57163_ }
C {devices/lab_pin.sym} 142370 -36810 0 0 {name=p141218 lab=_83926_/CLK }
C {devices/lab_pin.sym} 142370 -36790 0 0 {name=p141219 lab=_81459_/Q }
C {devices/lab_pin.sym} 142550 -36810 0 1 {name=p141220 lab=_76041_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -36800 0 0 {name=X_81427_ }
C {devices/lab_pin.sym} 142420 -36670 0 0 {name=p141221 lab=_45915_/X }
C {devices/lab_pin.sym} 142500 -36670 0 1 {name=p141222 lab=_69755_/A }
C {sky130_stdcells/buf_2.sym} 142460 -36670 0 0 {name=X_69149_ }
C {devices/lab_pin.sym} 142420 -36550 0 0 {name=p141223 lab=_54034_/A }
C {devices/lab_pin.sym} 142500 -36550 0 1 {name=p141224 lab=_54376_/A }
C {sky130_stdcells/buf_2.sym} 142460 -36550 0 0 {name=X_54375_ }
C {devices/lab_pin.sym} 142370 -36430 0 0 {name=p141225 lab=_80671_/CLK }
C {devices/lab_pin.sym} 142370 -36410 0 0 {name=p141226 lab=_85195_/D }
C {devices/lab_pin.sym} 142550 -36430 0 1 {name=p141227 lab=_85195_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -36420 0 0 {name=X_85195_ }
C {devices/lab_pin.sym} 142420 -36290 0 0 {name=p141228 lab=_51694_/A }
C {devices/lab_pin.sym} 142500 -36290 0 1 {name=p141229 lab=_51603_/B }
C {sky130_stdcells/buf_2.sym} 142460 -36290 0 0 {name=X_51587_ }
C {devices/lab_pin.sym} 142420 -36170 0 0 {name=p141230 lab=_56114_/A }
C {devices/lab_pin.sym} 142500 -36170 0 1 {name=p141231 lab=_56114_/X }
C {sky130_stdcells/buf_2.sym} 142460 -36170 0 0 {name=X_56114_ }
C {devices/lab_pin.sym} 142380 -36070 0 0 {name=p141232 lab=_41242_/X }
C {devices/lab_pin.sym} 142380 -36030 0 0 {name=p141233 lab=_82903_/Q }
C {devices/lab_pin.sym} 142380 -35990 0 0 {name=p141234 lab=_41339_/X }
C {devices/lab_pin.sym} 142540 -36030 0 1 {name=p141235 lab=_41340_/X }
C {sky130_stdcells/o21a_4.sym} 142460 -36030 0 0 {name=X_41340_ }
C {devices/lab_pin.sym} 142400 -35900 0 0 {name=p141236 lab=_53332_/A }
C {devices/lab_pin.sym} 142400 -35860 0 0 {name=p141237 lab=_47023_/Y }
C {devices/lab_pin.sym} 142520 -35880 0 1 {name=p141238 lab=_53326_/Y }
C {sky130_stdcells/nand2_4.sym} 142460 -35880 0 0 {name=X_53326_ }
C {devices/lab_pin.sym} 142400 -35760 0 0 {name=p141239 lab=_59238_/X }
C {devices/lab_pin.sym} 142400 -35720 0 0 {name=p141240 lab=_72160_/B }
C {devices/lab_pin.sym} 142520 -35740 0 1 {name=p141241 lab=_72160_/Y }
C {sky130_stdcells/nor2_4.sym} 142460 -35740 0 0 {name=X_72160_ }
C {devices/lab_pin.sym} 142370 -35610 0 0 {name=p141242 lab=_84231_/CLK }
C {devices/lab_pin.sym} 142370 -35590 0 0 {name=p141243 lab=_84146_/D }
C {devices/lab_pin.sym} 142550 -35610 0 1 {name=p141244 lab=_66247_/C }
C {sky130_stdcells/dfxtp_4.sym} 142460 -35600 0 0 {name=X_84146_ }
C {devices/lab_pin.sym} 142420 -35470 0 0 {name=p141245 lab=_50538_/A }
C {devices/lab_pin.sym} 142500 -35470 0 1 {name=p141246 lab=_50552_/C }
C {sky130_stdcells/buf_2.sym} 142460 -35470 0 0 {name=X_50538_ }
C {devices/lab_pin.sym} 142420 -35350 0 0 {name=p141247 lab=_57093_/Y }
C {devices/lab_pin.sym} 142500 -35350 0 1 {name=p141248 lab=_57192_/A }
C {sky130_stdcells/buf_2.sym} 142460 -35350 0 0 {name=X_57094_ }
C {devices/lab_pin.sym} 142370 -35230 0 0 {name=p141249 lab=_81492_/CLK }
C {devices/lab_pin.sym} 142370 -35210 0 0 {name=p141250 lab=_81358_/D }
C {devices/lab_pin.sym} 142550 -35230 0 1 {name=p141251 lab=_81358_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -35220 0 0 {name=X_81358_ }
C {devices/lab_pin.sym} 142380 -35110 0 0 {name=p141252 lab=_50674_/B }
C {devices/lab_pin.sym} 142380 -35070 0 0 {name=p141253 lab=_71095_/A }
C {devices/lab_pin.sym} 142380 -35030 0 0 {name=p141254 lab=_71110_/Y }
C {devices/lab_pin.sym} 142540 -35070 0 1 {name=p141255 lab=_71111_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -35070 0 0 {name=X_71111_ }
C {devices/lab_pin.sym} 142400 -34960 0 0 {name=p141256 lab=_55997_/X }
C {devices/lab_pin.sym} 142400 -34920 0 0 {name=p141257 lab=_74312_/C }
C {devices/lab_pin.sym} 142400 -34880 0 0 {name=p141258 lab=_74310_/C }
C {devices/lab_pin.sym} 142400 -34840 0 0 {name=p141259 lab=_56044_/X }
C {devices/lab_pin.sym} 142520 -34900 0 1 {name=p141260 lab=_56045_/Y }
C {sky130_stdcells/nand4_4.sym} 142460 -34900 0 0 {name=X_56045_ }
C {devices/lab_pin.sym} 142420 -34750 0 0 {name=p141261 lab=_80308_/B }
C {devices/lab_pin.sym} 142500 -34750 0 1 {name=p141262 lab=_80309_/Y }
C {sky130_stdcells/inv_2.sym} 142460 -34750 0 0 {name=X_80309_ }
C {devices/lab_pin.sym} 142380 -34650 0 0 {name=p141263 lab=_41255_/X }
C {devices/lab_pin.sym} 142380 -34610 0 0 {name=p141264 lab=_81124_/Q }
C {devices/lab_pin.sym} 142380 -34570 0 0 {name=p141265 lab=_41270_/X }
C {devices/lab_pin.sym} 142540 -34610 0 1 {name=p141266 lab=_41271_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -34610 0 0 {name=X_41271_ }
C {devices/lab_pin.sym} 142400 -34500 0 0 {name=p141267 lab=_53243_/X }
C {devices/lab_pin.sym} 142400 -34460 0 0 {name=p141268 lab=_51747_/A }
C {devices/lab_pin.sym} 142400 -34420 0 0 {name=p141269 lab=_53266_/C }
C {devices/lab_pin.sym} 142400 -34380 0 0 {name=p141270 lab=_53257_/D }
C {devices/lab_pin.sym} 142520 -34440 0 1 {name=p141271 lab=_53257_/X }
C {sky130_stdcells/and4_4.sym} 142460 -34440 0 0 {name=X_53257_ }
C {devices/lab_pin.sym} 142420 -34290 0 0 {name=p141272 lab=_72052_/A }
C {devices/lab_pin.sym} 142500 -34290 0 1 {name=p141273 lab=_72091_/X }
C {sky130_stdcells/buf_2.sym} 142460 -34290 0 0 {name=X_72091_ }
C {devices/lab_pin.sym} 142370 -34170 0 0 {name=p141274 lab=_82067_/CLK }
C {devices/lab_pin.sym} 142370 -34150 0 0 {name=p141275 lab=_67258_/X }
C {devices/lab_pin.sym} 142550 -34170 0 1 {name=p141276 lab=_80901_/D }
C {sky130_stdcells/dfxtp_4.sym} 142460 -34160 0 0 {name=X_84077_ }
C {devices/lab_pin.sym} 142400 -34050 0 0 {name=p141277 lab=_50469_/A }
C {devices/lab_pin.sym} 142400 -34010 0 0 {name=p141278 lab=_50492_/B }
C {devices/lab_pin.sym} 142400 -33970 0 0 {name=p141279 lab=_50497_/C }
C {devices/lab_pin.sym} 142520 -34010 0 1 {name=p141280 lab=_50469_/X }
C {sky130_stdcells/and3_4.sym} 142460 -34010 0 0 {name=X_50469_ }
C {devices/lab_pin.sym} 142370 -33870 0 0 {name=p141281 lab=_81603_/CLK }
C {devices/lab_pin.sym} 142370 -33850 0 0 {name=p141282 lab=_76977_/X }
C {devices/lab_pin.sym} 142550 -33870 0 1 {name=p141283 lab=_81257_/D }
C {sky130_stdcells/dfxtp_4.sym} 142460 -33860 0 0 {name=X_81289_ }
C {devices/lab_pin.sym} 142380 -33760 0 0 {name=p141284 lab=_40542_/X }
C {devices/lab_pin.sym} 142380 -33720 0 0 {name=p141285 lab=_51934_/A }
C {devices/lab_pin.sym} 142380 -33680 0 0 {name=p141286 lab=_67285_/B }
C {devices/lab_pin.sym} 142380 -33640 0 0 {name=p141287 lab=_42634_/A }
C {devices/lab_pin.sym} 142540 -33700 0 1 {name=p141288 lab=_87605_/D }
C {sky130_stdcells/a2bb2o_4.sym} 142460 -33700 0 0 {name=X_43010_ }
C {devices/lab_pin.sym} 142400 -33560 0 0 {name=p141289 lab=_52188_/A }
C {devices/lab_pin.sym} 142400 -33520 0 0 {name=p141290 lab=_50503_/B }
C {devices/lab_pin.sym} 142520 -33540 0 1 {name=p141291 lab=_52208_/Y }
C {sky130_stdcells/nand2_4.sym} 142460 -33540 0 0 {name=X_52208_ }
C {devices/lab_pin.sym} 142420 -33410 0 0 {name=p141292 lab=_71026_/A }
C {devices/lab_pin.sym} 142500 -33410 0 1 {name=p141293 lab=_71276_/C }
C {sky130_stdcells/buf_2.sym} 142460 -33410 0 0 {name=X_71042_ }
C {devices/lab_pin.sym} 142370 -33290 0 0 {name=p141294 lab=_85269_/CLK }
C {devices/lab_pin.sym} 142370 -33270 0 0 {name=p141295 lab=_74579_/Y }
C {devices/lab_pin.sym} 142550 -33290 0 1 {name=p141296 lab=_45107_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -33280 0 0 {name=X_83028_ }
C {devices/lab_pin.sym} 142370 -33150 0 0 {name=p141297 lab=_87646_/CLK }
C {devices/lab_pin.sym} 142370 -33130 0 0 {name=p141298 lab=_87905_/D }
C {devices/lab_pin.sym} 142550 -33150 0 1 {name=p141299 lab=_87905_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -33140 0 0 {name=X_87905_ }
C {devices/lab_pin.sym} 142420 -33010 0 0 {name=p141300 lab=clkbuf_8_9_0_CLK/A }
C {devices/lab_pin.sym} 142500 -33010 0 1 {name=p141301 lab=clkbuf_8_9_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 142460 -33010 0 0 {name=Xclkbuf_8_9_0_CLK }
C {devices/lab_pin.sym} 142380 -32910 0 0 {name=p141302 lab=_85680_/Q }
C {devices/lab_pin.sym} 142380 -32870 0 0 {name=p141303 lab=_53172_/X }
C {devices/lab_pin.sym} 142380 -32830 0 0 {name=p141304 lab=_53187_/Y }
C {devices/lab_pin.sym} 142540 -32870 0 1 {name=p141305 lab=_53188_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -32870 0 0 {name=X_53188_ }
C {devices/lab_pin.sym} 142380 -32750 0 0 {name=p141306 lab=_80455_/A }
C {devices/lab_pin.sym} 142380 -32710 0 0 {name=p141307 lab=_59803_/X }
C {devices/lab_pin.sym} 142380 -32670 0 0 {name=p141308 lab=_59631_/Y }
C {devices/lab_pin.sym} 142540 -32710 0 1 {name=p141309 lab=_59804_/X }
C {sky130_stdcells/a21bo_4.sym} 142460 -32710 0 0 {name=X_59804_ }
C {devices/lab_pin.sym} 142420 -32570 0 0 {name=p141310 lab=_52139_/A }
C {devices/lab_pin.sym} 142500 -32570 0 1 {name=p141311 lab=_52198_/A }
C {sky130_stdcells/buf_2.sym} 142460 -32570 0 0 {name=X_52139_ }
C {devices/lab_pin.sym} 142400 -32460 0 0 {name=p141312 lab=_75850_/A }
C {devices/lab_pin.sym} 142400 -32420 0 0 {name=p141313 lab=_75849_/Y }
C {devices/lab_pin.sym} 142520 -32440 0 1 {name=p141314 lab=_75850_/Y }
C {sky130_stdcells/nand2_4.sym} 142460 -32440 0 0 {name=X_75850_ }
C {devices/lab_pin.sym} 142370 -32310 0 0 {name=p141315 lab=_87834_/CLK }
C {devices/lab_pin.sym} 142370 -32290 0 0 {name=p141316 lab=_87836_/D }
C {devices/lab_pin.sym} 142550 -32310 0 1 {name=p141317 lab=_42518_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -32300 0 0 {name=X_87836_ }
C {devices/lab_pin.sym} 142420 -32170 0 0 {name=p141318 lab=_84933_/Q }
C {devices/lab_pin.sym} 142500 -32170 0 1 {name=p141319 lab=_57996_/Y }
C {sky130_stdcells/inv_2.sym} 142460 -32170 0 0 {name=X_57996_ }
C {devices/lab_pin.sym} 142400 -32080 0 0 {name=p141320 lab=_71266_/X }
C {devices/lab_pin.sym} 142400 -32040 0 0 {name=p141321 lab=_74801_/B }
C {devices/lab_pin.sym} 142400 -32000 0 0 {name=p141322 lab=_71846_/A }
C {devices/lab_pin.sym} 142400 -31960 0 0 {name=p141323 lab=_70500_/B }
C {devices/lab_pin.sym} 142520 -32020 0 1 {name=p141324 lab=_74801_/X }
C {sky130_stdcells/and4_4.sym} 142460 -32020 0 0 {name=X_74801_ }
C {devices/lab_pin.sym} 142420 -31870 0 0 {name=p141325 lab=_65515_/A }
C {devices/lab_pin.sym} 142500 -31870 0 1 {name=p141326 lab=_59842_/A }
C {sky130_stdcells/buf_2.sym} 142460 -31870 0 0 {name=X_59735_ }
C {devices/lab_pin.sym} 142380 -31770 0 0 {name=p141327 lab=_85213_/Q }
C {devices/lab_pin.sym} 142380 -31730 0 0 {name=p141328 lab=_44945_/X }
C {devices/lab_pin.sym} 142380 -31690 0 0 {name=p141329 lab=_44960_/X }
C {devices/lab_pin.sym} 142540 -31730 0 1 {name=p141330 lab=_44961_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -31730 0 0 {name=X_44961_ }
C {devices/lab_pin.sym} 142420 -31590 0 0 {name=p141331 lab=_56940_/Y }
C {devices/lab_pin.sym} 142500 -31590 0 1 {name=p141332 lab=_56947_/X }
C {sky130_stdcells/buf_2.sym} 142460 -31590 0 0 {name=X_56947_ }
C {devices/lab_pin.sym} 142420 -31470 0 0 {name=p141333 lab=_75769_/Y }
C {devices/lab_pin.sym} 142500 -31470 0 1 {name=p141334 lab=_75781_/Y }
C {sky130_stdcells/inv_2.sym} 142460 -31470 0 0 {name=X_75781_ }
C {devices/lab_pin.sym} 142370 -31350 0 0 {name=p141335 lab=_87767_/CLK }
C {devices/lab_pin.sym} 142370 -31330 0 0 {name=p141336 lab=_42693_/X }
C {devices/lab_pin.sym} 142550 -31350 0 1 {name=p141337 lab=_69521_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -31340 0 0 {name=X_87767_ }
C {devices/lab_pin.sym} 142400 -31220 0 0 {name=p141338 lab=_73186_/A }
C {devices/lab_pin.sym} 142400 -31180 0 0 {name=p141339 lab=_72993_/B }
C {devices/lab_pin.sym} 142520 -31200 0 1 {name=p141340 lab=_72993_/X }
C {sky130_stdcells/and2_4.sym} 142460 -31200 0 0 {name=X_72993_ }
C {devices/lab_pin.sym} 142370 -31070 0 0 {name=p141341 lab=_86549_/CLK }
C {devices/lab_pin.sym} 142370 -31050 0 0 {name=p141342 lab=_84979_/D }
C {devices/lab_pin.sym} 142550 -31070 0 1 {name=p141343 lab=_84979_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -31060 0 0 {name=X_84979_ }
C {devices/lab_pin.sym} 142420 -30930 0 0 {name=p141344 lab=_46700_/A }
C {devices/lab_pin.sym} 142500 -30930 0 1 {name=p141345 lab=_54314_/B }
C {sky130_stdcells/inv_2.sym} 142460 -30930 0 0 {name=X_46700_ }
C {devices/lab_pin.sym} 142400 -30820 0 0 {name=p141346 lab=_77516_/X }
C {devices/lab_pin.sym} 142400 -30780 0 0 {name=p141347 lab=_77520_/B }
C {devices/lab_pin.sym} 142520 -30800 0 1 {name=p141348 lab=_77520_/X }
C {sky130_stdcells/xor2_4.sym} 142460 -30800 0 0 {name=X_77520_ }
C {devices/lab_pin.sym} 142380 -30710 0 0 {name=p141349 lab=_43895_/X }
C {devices/lab_pin.sym} 142380 -30670 0 0 {name=p141350 lab=_43902_/X }
C {devices/lab_pin.sym} 142380 -30630 0 0 {name=p141351 lab=_41376_/X }
C {devices/lab_pin.sym} 142380 -30590 0 0 {name=p141352 lab=_67752_/B }
C {devices/lab_pin.sym} 142380 -30550 0 0 {name=p141353 lab=_43897_/X }
C {devices/lab_pin.sym} 142540 -30630 0 1 {name=p141354 lab=_43913_/A }
C {sky130_stdcells/o32ai_4.sym} 142460 -30630 0 0 {name=X_43912_ }
C {devices/lab_pin.sym} 142380 -30500 0 0 {name=p141355 lab=_70192_/Y }
C {devices/lab_pin.sym} 142380 -30460 0 0 {name=p141356 lab=_70692_/C }
C {devices/lab_pin.sym} 142380 -30420 0 0 {name=p141357 lab=_83834_/Q }
C {devices/lab_pin.sym} 142380 -30380 0 0 {name=p141358 lab=_74731_/X }
C {devices/lab_pin.sym} 142540 -30440 0 1 {name=p141359 lab=_74732_/X }
C {sky130_stdcells/a2bb2o_4.sym} 142460 -30440 0 0 {name=X_74732_ }
C {devices/lab_pin.sym} 142370 -30290 0 0 {name=p141360 lab=_86398_/CLK }
C {devices/lab_pin.sym} 142370 -30270 0 0 {name=p141361 lab=_46648_/Y }
C {devices/lab_pin.sym} 142550 -30290 0 1 {name=p141362 lab=_58601_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -30280 0 0 {name=X_86718_ }
C {devices/lab_pin.sym} 142400 -30160 0 0 {name=p141363 lab=_47696_/A }
C {devices/lab_pin.sym} 142400 -30120 0 0 {name=p141364 lab=_53183_/B }
C {devices/lab_pin.sym} 142520 -30140 0 1 {name=p141365 lab=_47680_/Y }
C {sky130_stdcells/nand2_4.sym} 142460 -30140 0 0 {name=X_47680_ }
C {devices/lab_pin.sym} 142380 -30030 0 0 {name=p141366 lab=_71942_/Y }
C {devices/lab_pin.sym} 142380 -29990 0 0 {name=p141367 lab=_83320_/Q }
C {devices/lab_pin.sym} 142380 -29950 0 0 {name=p141368 lab=_71943_/Y }
C {devices/lab_pin.sym} 142540 -29990 0 1 {name=p141369 lab=_71944_/X }
C {sky130_stdcells/a21o_4.sym} 142460 -29990 0 0 {name=X_71944_ }
C {devices/lab_pin.sym} 142420 -29850 0 0 {name=p141370 lab=_59666_/A }
C {devices/lab_pin.sym} 142500 -29850 0 1 {name=p141371 lab=_59687_/B }
C {sky130_stdcells/inv_2.sym} 142460 -29850 0 0 {name=X_59666_ }
C {devices/lab_pin.sym} 142420 -29730 0 0 {name=p141372 lab=_44891_/X }
C {devices/lab_pin.sym} 142500 -29730 0 1 {name=p141373 lab=_44892_/X }
C {sky130_stdcells/buf_2.sym} 142460 -29730 0 0 {name=X_44892_ }
C {devices/lab_pin.sym} 142420 -29610 0 0 {name=p141374 lab=_56877_/X }
C {devices/lab_pin.sym} 142500 -29610 0 1 {name=p141375 lab=_56878_/Y }
C {sky130_stdcells/inv_2.sym} 142460 -29610 0 0 {name=X_56878_ }
C {devices/lab_pin.sym} 142370 -29490 0 0 {name=p141376 lab=_87950_/CLK }
C {devices/lab_pin.sym} 142370 -29470 0 0 {name=p141377 lab=_42826_/X }
C {devices/lab_pin.sym} 142550 -29490 0 1 {name=p141378 lab=_87698_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -29480 0 0 {name=X_87698_ }
C {devices/lab_pin.sym} 142400 -29380 0 0 {name=p141379 lab=_46670_/A }
C {devices/lab_pin.sym} 142400 -29340 0 0 {name=p141380 lab=_46647_/B }
C {devices/lab_pin.sym} 142400 -29300 0 0 {name=p141381 lab=_46659_/C }
C {devices/lab_pin.sym} 142400 -29260 0 0 {name=p141382 lab=_51756_/D }
C {devices/lab_pin.sym} 142520 -29320 0 1 {name=p141383 lab=_46631_/X }
C {sky130_stdcells/and4_4.sym} 142460 -29320 0 0 {name=X_46631_ }
C {devices/lab_pin.sym} 142380 -29190 0 0 {name=p141384 lab=_58591_/X }
C {devices/lab_pin.sym} 142380 -29150 0 0 {name=p141385 lab=_85469_/Q }
C {devices/lab_pin.sym} 142380 -29110 0 0 {name=p141386 lab=_58616_/X }
C {devices/lab_pin.sym} 142540 -29150 0 1 {name=p141387 lab=_58617_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -29150 0 0 {name=X_58617_ }
C {devices/lab_pin.sym} 142380 -29030 0 0 {name=p141388 lab=_77433_/Y }
C {devices/lab_pin.sym} 142380 -28990 0 0 {name=p141389 lab=_77439_/Y }
C {devices/lab_pin.sym} 142380 -28950 0 0 {name=p141390 lab=_77431_/Y }
C {devices/lab_pin.sym} 142540 -28990 0 1 {name=p141391 lab=_77451_/X }
C {sky130_stdcells/o21a_4.sym} 142460 -28990 0 0 {name=X_77451_ }
C {devices/lab_pin.sym} 142420 -28850 0 0 {name=p141392 lab=_43802_/A }
C {devices/lab_pin.sym} 142500 -28850 0 1 {name=p141393 lab=_43843_/X }
C {sky130_stdcells/buf_2.sym} 142460 -28850 0 0 {name=X_43843_ }
C {devices/lab_pin.sym} 142400 -28760 0 0 {name=p141394 lab=_55802_/X }
C {devices/lab_pin.sym} 142400 -28720 0 0 {name=p141395 lab=_55811_/X }
C {devices/lab_pin.sym} 142400 -28680 0 0 {name=p141396 lab=_56108_/A }
C {devices/lab_pin.sym} 142400 -28640 0 0 {name=p141397 lab=_55828_/X }
C {devices/lab_pin.sym} 142520 -28700 0 1 {name=p141398 lab=_55830_/A }
C {sky130_stdcells/and4_4.sym} 142460 -28700 0 0 {name=X_55829_ }
C {devices/lab_pin.sym} 142380 -28570 0 0 {name=p141399 lab=_82992_/Q }
C {devices/lab_pin.sym} 142380 -28530 0 0 {name=p141400 lab=_74641_/X }
C {devices/lab_pin.sym} 142380 -28490 0 0 {name=p141401 lab=_74662_/Y }
C {devices/lab_pin.sym} 142540 -28530 0 1 {name=p141402 lab=_74664_/A }
C {sky130_stdcells/o21ai_4.sym} 142460 -28530 0 0 {name=X_74663_ }
C {devices/lab_pin.sym} 142370 -28390 0 0 {name=p141403 lab=_86647_/CLK }
C {devices/lab_pin.sym} 142370 -28370 0 0 {name=p141404 lab=_86649_/D }
C {devices/lab_pin.sym} 142550 -28390 0 1 {name=p141405 lab=_57846_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -28380 0 0 {name=X_86649_ }
C {devices/lab_pin.sym} 142380 -28270 0 0 {name=p141406 lab=_71871_/X }
C {devices/lab_pin.sym} 142380 -28230 0 0 {name=p141407 lab=_83345_/Q }
C {devices/lab_pin.sym} 142380 -28190 0 0 {name=p141408 lab=_71874_/Y }
C {devices/lab_pin.sym} 142540 -28230 0 1 {name=p141409 lab=_71875_/X }
C {sky130_stdcells/a21o_4.sym} 142460 -28230 0 0 {name=X_71875_ }
C {devices/lab_pin.sym} 142400 -28110 0 0 {name=p141410 lab=_59557_/X }
C {devices/lab_pin.sym} 142400 -28070 0 0 {name=p141411 lab=_59564_/B }
C {devices/lab_pin.sym} 142400 -28030 0 0 {name=p141412 lab=_59544_/D }
C {devices/lab_pin.sym} 142520 -28070 0 1 {name=p141413 lab=_60630_/A }
C {sky130_stdcells/nand3_4.sym} 142460 -28070 0 0 {name=X_59597_ }
C {devices/lab_pin.sym} 142420 -27930 0 0 {name=p141414 lab=_76401_/X }
C {devices/lab_pin.sym} 142500 -27930 0 1 {name=p141415 lab=_76403_/B }
C {sky130_stdcells/inv_2.sym} 142460 -27930 0 0 {name=X_76402_ }
C {devices/lab_pin.sym} 142400 -27820 0 0 {name=p141416 lab=_48917_/X }
C {devices/lab_pin.sym} 142400 -27780 0 0 {name=p141417 lab=_52565_/B }
C {devices/lab_pin.sym} 142520 -27800 0 1 {name=p141418 lab=_49350_/Y }
C {sky130_stdcells/nand2_4.sym} 142460 -27800 0 0 {name=X_49350_ }
C {devices/lab_pin.sym} 142420 -27670 0 0 {name=p141419 lab=_73614_/A }
C {devices/lab_pin.sym} 142500 -27670 0 1 {name=p141420 lab=_73614_/X }
C {sky130_stdcells/buf_2.sym} 142460 -27670 0 0 {name=X_73614_ }
C {devices/lab_pin.sym} 142380 -27570 0 0 {name=p141421 lab=_52918_/B }
C {devices/lab_pin.sym} 142380 -27530 0 0 {name=p141422 lab=_70802_/A }
C {devices/lab_pin.sym} 142380 -27490 0 0 {name=p141423 lab=_70825_/Y }
C {devices/lab_pin.sym} 142540 -27530 0 1 {name=p141424 lab=_83690_/D }
C {sky130_stdcells/o21ai_4.sym} 142460 -27530 0 0 {name=X_70826_ }
C {devices/lab_pin.sym} 142380 -27410 0 0 {name=p141425 lab=_46557_/Y }
C {devices/lab_pin.sym} 142380 -27370 0 0 {name=p141426 lab=_46523_/X }
C {devices/lab_pin.sym} 142380 -27330 0 0 {name=p141427 lab=_46561_/Y }
C {devices/lab_pin.sym} 142540 -27370 0 1 {name=p141428 lab=_86726_/D }
C {sky130_stdcells/a21boi_4.sym} 142460 -27370 0 0 {name=X_46562_ }
C {devices/lab_pin.sym} 142400 -27240 0 0 {name=p141429 lab=_58548_/A }
C {devices/lab_pin.sym} 142400 -27200 0 0 {name=p141430 lab=_58548_/B }
C {devices/lab_pin.sym} 142520 -27220 0 1 {name=p141431 lab=_58548_/Y }
C {sky130_stdcells/nor2_4.sym} 142460 -27220 0 0 {name=X_58548_ }
C {devices/lab_pin.sym} 142400 -27110 0 0 {name=p141432 lab=_77382_/A }
C {devices/lab_pin.sym} 142400 -27070 0 0 {name=p141433 lab=_77382_/B }
C {devices/lab_pin.sym} 142400 -27030 0 0 {name=p141434 lab=_77381_/Y }
C {devices/lab_pin.sym} 142520 -27070 0 1 {name=p141435 lab=_77382_/X }
C {sky130_stdcells/or3_4.sym} 142460 -27070 0 0 {name=X_77382_ }
C {devices/lab_pin.sym} 142420 -26930 0 0 {name=p141436 lab=_43774_/A }
C {devices/lab_pin.sym} 142500 -26930 0 1 {name=p141437 lab=_43774_/X }
C {sky130_stdcells/buf_2.sym} 142460 -26930 0 0 {name=X_43774_ }
C {devices/lab_pin.sym} 142380 -26840 0 0 {name=p141438 lab=_74591_/X }
C {devices/lab_pin.sym} 142380 -26800 0 0 {name=p141439 lab=_74583_/X }
C {devices/lab_pin.sym} 142380 -26760 0 0 {name=p141440 lab=_56109_/A }
C {devices/lab_pin.sym} 142380 -26720 0 0 {name=p141441 lab=_74584_/X }
C {devices/lab_pin.sym} 142540 -26780 0 1 {name=p141442 lab=_74594_/X }
C {sky130_stdcells/a211o_4.sym} 142460 -26780 0 0 {name=X_74594_ }
C {devices/lab_pin.sym} 142420 -26630 0 0 {name=p141443 lab=_40985_/Y }
C {devices/lab_pin.sym} 142500 -26630 0 1 {name=p141444 lab=_40986_/X }
C {sky130_stdcells/buf_2.sym} 142460 -26630 0 0 {name=X_40986_ }
C {devices/lab_pin.sym} 142380 -26530 0 0 {name=p141445 lab=_86539_/Q }
C {devices/lab_pin.sym} 142380 -26490 0 0 {name=p141446 lab=_48263_/X }
C {devices/lab_pin.sym} 142380 -26450 0 0 {name=p141447 lab=_48300_/Y }
C {devices/lab_pin.sym} 142540 -26490 0 1 {name=p141448 lab=_48301_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -26490 0 0 {name=X_48301_ }
C {devices/lab_pin.sym} 142420 -26350 0 0 {name=p141449 lab=_78804_/B }
C {devices/lab_pin.sym} 142500 -26350 0 1 {name=p141450 lab=_82498_/D }
C {sky130_stdcells/inv_2.sym} 142460 -26350 0 0 {name=X_79121_ }
C {devices/lab_pin.sym} 142380 -26250 0 0 {name=p141451 lab=_45511_/X }
C {devices/lab_pin.sym} 142380 -26210 0 0 {name=p141452 lab=_61421_/A }
C {devices/lab_pin.sym} 142380 -26170 0 0 {name=p141453 lab=_45452_/X }
C {devices/lab_pin.sym} 142540 -26210 0 1 {name=p141454 lab=_45513_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -26210 0 0 {name=X_45513_ }
C {devices/lab_pin.sym} 142420 -26070 0 0 {name=p141455 lab=_76332_/Y }
C {devices/lab_pin.sym} 142500 -26070 0 1 {name=p141456 lab=_76333_/Y }
C {sky130_stdcells/inv_2.sym} 142460 -26070 0 0 {name=X_76333_ }
C {devices/lab_pin.sym} 142370 -25950 0 0 {name=p141457 lab=_88056_/CLK }
C {devices/lab_pin.sym} 142370 -25930 0 0 {name=p141458 lab=_88319_/D }
C {devices/lab_pin.sym} 142550 -25950 0 1 {name=p141459 lab=_69842_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -25940 0 0 {name=X_88319_ }
C {devices/lab_pin.sym} 142420 -25810 0 0 {name=p141460 lab=_42725_/A }
C {devices/lab_pin.sym} 142500 -25810 0 1 {name=p141461 lab=_42725_/Y }
C {sky130_stdcells/inv_2.sym} 142460 -25810 0 0 {name=X_42725_ }
C {devices/lab_pin.sym} 142420 -25690 0 0 {name=p141462 lab=_49405_/A }
C {devices/lab_pin.sym} 142500 -25690 0 1 {name=p141463 lab=_49281_/X }
C {sky130_stdcells/buf_2.sym} 142460 -25690 0 0 {name=X_49281_ }
C {devices/lab_pin.sym} 142400 -25590 0 0 {name=p141464 lab=_73543_/X }
C {devices/lab_pin.sym} 142400 -25550 0 0 {name=p141465 lab=_73532_/X }
C {devices/lab_pin.sym} 142400 -25510 0 0 {name=p141466 lab=_73534_/X }
C {devices/lab_pin.sym} 142520 -25550 0 1 {name=p141467 lab=_73545_/Y }
C {sky130_stdcells/nand3_4.sym} 142460 -25550 0 0 {name=X_73545_ }
C {devices/lab_pin.sym} 142420 -25410 0 0 {name=p141468 lab=_48606_/A }
C {devices/lab_pin.sym} 142500 -25410 0 1 {name=p141469 lab=_46493_/X }
C {sky130_stdcells/buf_2.sym} 142460 -25410 0 0 {name=X_46493_ }
C {devices/lab_pin.sym} 142420 -25290 0 0 {name=p141470 lab=_70416_/Y }
C {devices/lab_pin.sym} 142500 -25290 0 1 {name=p141471 lab=_70758_/C }
C {sky130_stdcells/buf_2.sym} 142460 -25290 0 0 {name=X_70757_ }
C {devices/lab_pin.sym} 142380 -25190 0 0 {name=p141472 lab=_58467_/X }
C {devices/lab_pin.sym} 142380 -25150 0 0 {name=p141473 lab=_58476_/Y }
C {devices/lab_pin.sym} 142380 -25110 0 0 {name=p141474 lab=_58478_/Y }
C {devices/lab_pin.sym} 142540 -25150 0 1 {name=p141475 lab=_84839_/D }
C {sky130_stdcells/a21oi_4.sym} 142460 -25150 0 0 {name=X_58479_ }
C {devices/lab_pin.sym} 142380 -25030 0 0 {name=p141476 lab=_86551_/Q }
C {devices/lab_pin.sym} 142380 -24990 0 0 {name=p141477 lab=_48188_/X }
C {devices/lab_pin.sym} 142380 -24950 0 0 {name=p141478 lab=_48231_/Y }
C {devices/lab_pin.sym} 142540 -24990 0 1 {name=p141479 lab=_48232_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -24990 0 0 {name=X_48232_ }
C {devices/lab_pin.sym} 142380 -24890 0 0 {name=p141480 lab=_63252_/B }
C {devices/lab_pin.sym} 142380 -24850 0 0 {name=p141481 lab=_60570_/B }
C {devices/lab_pin.sym} 142380 -24810 0 0 {name=p141482 lab=_60627_/A }
C {devices/lab_pin.sym} 142380 -24770 0 0 {name=p141483 lab=_60626_/A }
C {devices/lab_pin.sym} 142380 -24730 0 0 {name=p141484 lab=_60509_/Y }
C {devices/lab_pin.sym} 142540 -24810 0 1 {name=p141485 lab=_60510_/Y }
C {sky130_stdcells/a2111oi_4.sym} 142460 -24810 0 0 {name=X_60510_ }
C {devices/lab_pin.sym} 142400 -24660 0 0 {name=p141486 lab=_79053_/B }
C {devices/lab_pin.sym} 142400 -24620 0 0 {name=p141487 lab=_79053_/A }
C {devices/lab_pin.sym} 142520 -24640 0 1 {name=p141488 lab=_79055_/A }
C {sky130_stdcells/nor2_4.sym} 142460 -24640 0 0 {name=X_79052_ }
C {devices/lab_pin.sym} 142400 -24520 0 0 {name=p141489 lab=_45444_/A }
C {devices/lab_pin.sym} 142400 -24480 0 0 {name=p141490 lab=_45397_/X }
C {devices/lab_pin.sym} 142520 -24500 0 1 {name=p141491 lab=_45444_/Y }
C {sky130_stdcells/nor2_4.sym} 142460 -24500 0 0 {name=X_45444_ }
C {devices/lab_pin.sym} 142420 -24370 0 0 {name=p141492 lab=_76264_/A }
C {devices/lab_pin.sym} 142500 -24370 0 1 {name=p141493 lab=_76264_/Y }
C {sky130_stdcells/inv_2.sym} 142460 -24370 0 0 {name=X_76264_ }
C {devices/lab_pin.sym} 142380 -24290 0 0 {name=p141494 lab=_42647_/X }
C {devices/lab_pin.sym} 142380 -24250 0 0 {name=p141495 lab=_42648_/X }
C {devices/lab_pin.sym} 142380 -24210 0 0 {name=p141496 lab=_40994_/X }
C {devices/lab_pin.sym} 142380 -24170 0 0 {name=p141497 lab=_87784_/Q }
C {devices/lab_pin.sym} 142380 -24130 0 0 {name=p141498 lab=_42637_/X }
C {devices/lab_pin.sym} 142540 -24210 0 1 {name=p141499 lab=_42657_/A }
C {sky130_stdcells/o32ai_4.sym} 142460 -24210 0 0 {name=X_42656_ }
C {devices/lab_pin.sym} 142420 -24050 0 0 {name=p141500 lab=_84820_/Q }
C {devices/lab_pin.sym} 142500 -24050 0 1 {name=p141501 lab=_61490_/X }
C {sky130_stdcells/buf_2.sym} 142460 -24050 0 0 {name=X_61490_ }
C {devices/lab_pin.sym} 142400 -23940 0 0 {name=p141502 lab=_73476_/A }
C {devices/lab_pin.sym} 142400 -23900 0 0 {name=p141503 lab=_86501_/Q }
C {devices/lab_pin.sym} 142520 -23920 0 1 {name=p141504 lab=_73476_/X }
C {sky130_stdcells/and2_4.sym} 142460 -23920 0 0 {name=X_73476_ }
C {devices/lab_pin.sym} 142420 -23790 0 0 {name=p141505 lab=_71887_/A }
C {devices/lab_pin.sym} 142500 -23790 0 1 {name=p141506 lab=_70689_/A }
C {sky130_stdcells/buf_2.sym} 142460 -23790 0 0 {name=X_70688_ }
C {devices/lab_pin.sym} 142420 -23670 0 0 {name=p141507 lab=_78003_/A }
C {devices/lab_pin.sym} 142500 -23670 0 1 {name=p141508 lab=_78003_/Y }
C {sky130_stdcells/inv_2.sym} 142460 -23670 0 0 {name=X_78003_ }
C {devices/lab_pin.sym} 142400 -23560 0 0 {name=p141509 lab=_75212_/Y }
C {devices/lab_pin.sym} 142400 -23520 0 0 {name=p141510 lab=_75233_/B }
C {devices/lab_pin.sym} 142520 -23540 0 1 {name=p141511 lab=_75216_/A }
C {sky130_stdcells/xor2_4.sym} 142460 -23540 0 0 {name=X_75215_ }
C {devices/lab_pin.sym} 142420 -23410 0 0 {name=p141512 lab=_40567_/A }
C {devices/lab_pin.sym} 142500 -23410 0 1 {name=p141513 lab=_41607_/X }
C {sky130_stdcells/buf_2.sym} 142460 -23410 0 0 {name=X_41607_ }
C {devices/lab_pin.sym} 142400 -23310 0 0 {name=p141514 lab=_60439_/X }
C {devices/lab_pin.sym} 142400 -23270 0 0 {name=p141515 lab=_60441_/B }
C {devices/lab_pin.sym} 142400 -23230 0 0 {name=p141516 lab=_60440_/X }
C {devices/lab_pin.sym} 142520 -23270 0 1 {name=p141517 lab=_60442_/C }
C {sky130_stdcells/and3_4.sym} 142460 -23270 0 0 {name=X_60441_ }
C {devices/lab_pin.sym} 142400 -23140 0 0 {name=p141518 lab=_72414_/X }
C {devices/lab_pin.sym} 142400 -23100 0 0 {name=p141519 lab=_72427_/B }
C {devices/lab_pin.sym} 142520 -23120 0 1 {name=p141520 lab=_72427_/Y }
C {sky130_stdcells/nor2_4.sym} 142460 -23120 0 0 {name=X_72427_ }
C {devices/lab_pin.sym} 142420 -22990 0 0 {name=p141521 lab=_48186_/A }
C {devices/lab_pin.sym} 142500 -22990 0 1 {name=p141522 lab=_48163_/X }
C {sky130_stdcells/buf_2.sym} 142460 -22990 0 0 {name=X_48163_ }
C {devices/lab_pin.sym} 142380 -22890 0 0 {name=p141523 lab=_55738_/B }
C {devices/lab_pin.sym} 142380 -22850 0 0 {name=p141524 lab=_45357_/X }
C {devices/lab_pin.sym} 142380 -22810 0 0 {name=p141525 lab=_45339_/X }
C {devices/lab_pin.sym} 142540 -22850 0 1 {name=p141526 lab=_45375_/X }
C {sky130_stdcells/o21a_4.sym} 142460 -22850 0 0 {name=X_45375_ }
C {devices/lab_pin.sym} 142380 -22730 0 0 {name=p141527 lab=_76192_/X }
C {devices/lab_pin.sym} 142380 -22690 0 0 {name=p141528 lab=_76196_/B }
C {devices/lab_pin.sym} 142380 -22650 0 0 {name=p141529 lab=_76194_/Y }
C {devices/lab_pin.sym} 142540 -22690 0 1 {name=p141530 lab=_76195_/X }
C {sky130_stdcells/a21o_4.sym} 142460 -22690 0 0 {name=X_76195_ }
C {devices/lab_pin.sym} 142380 -22590 0 0 {name=p141531 lab=_42573_/X }
C {devices/lab_pin.sym} 142380 -22550 0 0 {name=p141532 lab=_42574_/X }
C {devices/lab_pin.sym} 142380 -22510 0 0 {name=p141533 lab=_40854_/X }
C {devices/lab_pin.sym} 142380 -22470 0 0 {name=p141534 lab=_69790_/A }
C {devices/lab_pin.sym} 142380 -22430 0 0 {name=p141535 lab=_42580_/X }
C {devices/lab_pin.sym} 142540 -22510 0 1 {name=p141536 lab=_42588_/A }
C {sky130_stdcells/o32ai_4.sym} 142460 -22510 0 0 {name=X_42587_ }
C {devices/lab_pin.sym} 142420 -22350 0 0 {name=p141537 lab=clkbuf_4_1_0_CLK/X }
C {devices/lab_pin.sym} 142500 -22350 0 1 {name=p141538 lab=clkbuf_5_2_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 142460 -22350 0 0 {name=Xclkbuf_4_1_1_CLK }
C {devices/lab_pin.sym} 142380 -22250 0 0 {name=p141539 lab=_47110_/Y }
C {devices/lab_pin.sym} 142380 -22210 0 0 {name=p141540 lab=_47081_/X }
C {devices/lab_pin.sym} 142380 -22170 0 0 {name=p141541 lab=_47113_/X }
C {devices/lab_pin.sym} 142540 -22210 0 1 {name=p141542 lab=_86669_/D }
C {sky130_stdcells/a21oi_4.sym} 142460 -22210 0 0 {name=X_47114_ }
C {devices/lab_pin.sym} 142420 -22070 0 0 {name=p141543 lab=_40409_/X }
C {devices/lab_pin.sym} 142500 -22070 0 1 {name=p141544 lab=_44326_/X }
C {sky130_stdcells/buf_2.sym} 142460 -22070 0 0 {name=X_44326_ }
C {devices/lab_pin.sym} 142420 -21950 0 0 {name=p141545 lab=_60489_/X }
C {devices/lab_pin.sym} 142500 -21950 0 1 {name=p141546 lab=_63161_/C }
C {sky130_stdcells/buf_2.sym} 142460 -21950 0 0 {name=X_63160_ }
C {devices/lab_pin.sym} 142420 -21830 0 0 {name=p141547 lab=_75145_/Y }
C {devices/lab_pin.sym} 142500 -21830 0 1 {name=p141548 lab=_75146_/Y }
C {sky130_stdcells/inv_2.sym} 142460 -21830 0 0 {name=X_75146_ }
C {devices/lab_pin.sym} 142380 -21750 0 0 {name=p141549 lab=_41489_/X }
C {devices/lab_pin.sym} 142380 -21710 0 0 {name=p141550 lab=_41490_/X }
C {devices/lab_pin.sym} 142380 -21670 0 0 {name=p141551 lab=_41536_/X }
C {devices/lab_pin.sym} 142380 -21630 0 0 {name=p141552 lab=_66932_/B }
C {devices/lab_pin.sym} 142380 -21590 0 0 {name=p141553 lab=_41537_/X }
C {devices/lab_pin.sym} 142540 -21670 0 1 {name=p141554 lab=_41538_/Y }
C {sky130_stdcells/o32ai_4.sym} 142460 -21670 0 0 {name=X_41538_ }
C {devices/lab_pin.sym} 142420 -21510 0 0 {name=p141555 lab=_48094_/A }
C {devices/lab_pin.sym} 142500 -21510 0 1 {name=p141556 lab=_48642_/B }
C {sky130_stdcells/inv_2.sym} 142460 -21510 0 0 {name=X_48094_ }
C {devices/lab_pin.sym} 142380 -21430 0 0 {name=p141557 lab=_60331_/D }
C {devices/lab_pin.sym} 142380 -21390 0 0 {name=p141558 lab=_60331_/B }
C {devices/lab_pin.sym} 142380 -21350 0 0 {name=p141559 lab=_60224_/Y }
C {devices/lab_pin.sym} 142380 -21310 0 0 {name=p141560 lab=_60371_/X }
C {devices/lab_pin.sym} 142380 -21270 0 0 {name=p141561 lab=_57703_/X }
C {devices/lab_pin.sym} 142540 -21350 0 1 {name=p141562 lab=_60372_/Y }
C {sky130_stdcells/o32ai_4.sym} 142460 -21350 0 0 {name=X_60372_ }
C {devices/lab_pin.sym} 142420 -21190 0 0 {name=p141563 lab=_72358_/A }
C {devices/lab_pin.sym} 142500 -21190 0 1 {name=p141564 lab=_72358_/X }
C {sky130_stdcells/buf_2.sym} 142460 -21190 0 0 {name=X_72358_ }
C {devices/lab_pin.sym} 142420 -21070 0 0 {name=p141565 lab=_59692_/Y }
C {devices/lab_pin.sym} 142500 -21070 0 1 {name=p141566 lab=_62161_/B }
C {sky130_stdcells/buf_2.sym} 142460 -21070 0 0 {name=X_62111_ }
C {devices/lab_pin.sym} 142420 -20950 0 0 {name=p141567 lab=_46903_/A }
C {devices/lab_pin.sym} 142500 -20950 0 1 {name=p141568 lab=_47048_/C }
C {sky130_stdcells/buf_2.sym} 142460 -20950 0 0 {name=X_47045_ }
C {devices/lab_pin.sym} 142420 -20830 0 0 {name=p141569 lab=_71196_/A }
C {devices/lab_pin.sym} 142500 -20830 0 1 {name=p141570 lab=_71314_/B }
C {sky130_stdcells/buf_2.sym} 142460 -20830 0 0 {name=X_71309_ }
C {devices/lab_pin.sym} 142380 -20740 0 0 {name=p141571 lab=_43948_/B }
C {devices/lab_pin.sym} 142380 -20700 0 0 {name=p141572 lab=_44254_/X }
C {devices/lab_pin.sym} 142380 -20660 0 0 {name=p141573 lab=_44227_/Y }
C {devices/lab_pin.sym} 142380 -20620 0 0 {name=p141574 lab=_44218_/X }
C {devices/lab_pin.sym} 142540 -20680 0 1 {name=p141575 lab=_44258_/A }
C {sky130_stdcells/o22a_4.sym} 142460 -20680 0 0 {name=X_44257_ }
C {devices/lab_pin.sym} 142420 -20530 0 0 {name=p141576 lab=_60508_/A }
C {devices/lab_pin.sym} 142500 -20530 0 1 {name=p141577 lab=_63092_/D }
C {sky130_stdcells/buf_2.sym} 142460 -20530 0 0 {name=X_63091_ }
C {devices/lab_pin.sym} 142420 -20410 0 0 {name=p141578 lab=_75076_/Y }
C {devices/lab_pin.sym} 142500 -20410 0 1 {name=p141579 lab=_75077_/Y }
C {sky130_stdcells/inv_2.sym} 142460 -20410 0 0 {name=X_75077_ }
C {devices/lab_pin.sym} 142400 -20300 0 0 {name=p141580 lab=_84926_/Q }
C {devices/lab_pin.sym} 142400 -20260 0 0 {name=p141581 lab=_84174_/Q }
C {devices/lab_pin.sym} 142520 -20280 0 1 {name=p141582 lab=_79957_/C }
C {sky130_stdcells/nand2_4.sym} 142460 -20280 0 0 {name=X_79954_ }
C {devices/lab_pin.sym} 142420 -20150 0 0 {name=p141583 lab=_41468_/Y }
C {devices/lab_pin.sym} 142500 -20150 0 1 {name=p141584 lab=_41469_/X }
C {sky130_stdcells/buf_2.sym} 142460 -20150 0 0 {name=X_41469_ }
C {devices/lab_pin.sym} 142380 -20050 0 0 {name=p141585 lab=_72264_/X }
C {devices/lab_pin.sym} 142380 -20010 0 0 {name=p141586 lab=_85363_/Q }
C {devices/lab_pin.sym} 142380 -19970 0 0 {name=p141587 lab=_72288_/X }
C {devices/lab_pin.sym} 142540 -20010 0 1 {name=p141588 lab=_72289_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -20010 0 0 {name=X_72289_ }
C {devices/lab_pin.sym} 142400 -19900 0 0 {name=p141589 lab=_61570_/B }
C {devices/lab_pin.sym} 142400 -19860 0 0 {name=p141590 lab=_62007_/X }
C {devices/lab_pin.sym} 142400 -19820 0 0 {name=p141591 lab=_62149_/C }
C {devices/lab_pin.sym} 142400 -19780 0 0 {name=p141592 lab=_62008_/X }
C {devices/lab_pin.sym} 142520 -19840 0 1 {name=p141593 lab=_62047_/B }
C {sky130_stdcells/nand4_4.sym} 142460 -19840 0 0 {name=X_62042_ }
C {devices/lab_pin.sym} 142380 -19730 0 0 {name=p141594 lab=_43196_/X }
C {devices/lab_pin.sym} 142380 -19690 0 0 {name=p141595 lab=_43207_/X }
C {devices/lab_pin.sym} 142380 -19650 0 0 {name=p141596 lab=_40950_/X }
C {devices/lab_pin.sym} 142380 -19610 0 0 {name=p141597 lab=_87537_/Q }
C {devices/lab_pin.sym} 142380 -19570 0 0 {name=p141598 lab=_43172_/X }
C {devices/lab_pin.sym} 142540 -19650 0 1 {name=p141599 lab=_43209_/A }
C {sky130_stdcells/o32ai_4.sym} 142460 -19650 0 0 {name=X_43208_ }
C {devices/lab_pin.sym} 142400 -19510 0 0 {name=p141600 lab=_74026_/X }
C {devices/lab_pin.sym} 142400 -19470 0 0 {name=p141601 lab=_74028_/B }
C {devices/lab_pin.sym} 142400 -19430 0 0 {name=p141602 lab=_74028_/C }
C {devices/lab_pin.sym} 142520 -19470 0 1 {name=p141603 lab=_74028_/Y }
C {sky130_stdcells/nand3_4.sym} 142460 -19470 0 0 {name=X_74028_ }
C {devices/lab_pin.sym} 142420 -19330 0 0 {name=p141604 lab=_78892_/B }
C {devices/lab_pin.sym} 142500 -19330 0 1 {name=p141605 lab=_82508_/D }
C {sky130_stdcells/inv_2.sym} 142460 -19330 0 0 {name=X_78905_ }
C {devices/lab_pin.sym} 142420 -19210 0 0 {name=p141606 lab=_72720_/A }
C {devices/lab_pin.sym} 142500 -19210 0 1 {name=p141607 lab=_72806_/A }
C {sky130_stdcells/buf_2.sym} 142460 -19210 0 0 {name=X_44188_ }
C {devices/lab_pin.sym} 142400 -19100 0 0 {name=p141608 lab=_81024_/D }
C {devices/lab_pin.sym} 142400 -19060 0 0 {name=p141609 lab=_83280_/Q }
C {devices/lab_pin.sym} 142520 -19080 0 1 {name=p141610 lab=_79885_/Y }
C {sky130_stdcells/nand2_4.sym} 142460 -19080 0 0 {name=X_79885_ }
C {devices/lab_pin.sym} 142380 -18990 0 0 {name=p141611 lab=_43100_/X }
C {devices/lab_pin.sym} 142380 -18950 0 0 {name=p141612 lab=_43110_/X }
C {devices/lab_pin.sym} 142380 -18910 0 0 {name=p141613 lab=_40814_/X }
C {devices/lab_pin.sym} 142380 -18870 0 0 {name=p141614 lab=_73036_/A }
C {devices/lab_pin.sym} 142380 -18830 0 0 {name=p141615 lab=_43121_/X }
C {devices/lab_pin.sym} 142540 -18910 0 1 {name=p141616 lab=_43140_/A }
C {sky130_stdcells/o32ai_4.sym} 142460 -18910 0 0 {name=X_43139_ }
C {devices/lab_pin.sym} 142420 -18750 0 0 {name=p141617 lab=_66971_/A }
C {devices/lab_pin.sym} 142500 -18750 0 1 {name=p141618 lab=_66850_/X }
C {sky130_stdcells/buf_2.sym} 142460 -18750 0 0 {name=X_66850_ }
C {devices/lab_pin.sym} 142380 -18650 0 0 {name=p141619 lab=_78835_/Y }
C {devices/lab_pin.sym} 142380 -18610 0 0 {name=p141620 lab=_78830_/A }
C {devices/lab_pin.sym} 142380 -18570 0 0 {name=p141621 lab=_78829_/A }
C {devices/lab_pin.sym} 142540 -18610 0 1 {name=p141622 lab=_78837_/B }
C {sky130_stdcells/o21ai_4.sym} 142460 -18610 0 0 {name=X_78836_ }
C {devices/lab_pin.sym} 142400 -18480 0 0 {name=p141623 lab=_48996_/A }
C {devices/lab_pin.sym} 142400 -18440 0 0 {name=p141624 lab=_49009_/B }
C {devices/lab_pin.sym} 142520 -18460 0 1 {name=p141625 lab=_48996_/Y }
C {sky130_stdcells/nor2_4.sym} 142460 -18460 0 0 {name=X_48996_ }
C {devices/lab_pin.sym} 142420 -18330 0 0 {name=p141626 lab=_84177_/Q }
C {devices/lab_pin.sym} 142500 -18330 0 1 {name=p141627 lab=_65802_/C }
C {sky130_stdcells/inv_2.sym} 142460 -18330 0 0 {name=X_65801_ }
C {devices/lab_pin.sym} 142380 -18230 0 0 {name=p141628 lab=_47942_/Y }
C {devices/lab_pin.sym} 142380 -18190 0 0 {name=p141629 lab=_47903_/X }
C {devices/lab_pin.sym} 142380 -18150 0 0 {name=p141630 lab=_47946_/X }
C {devices/lab_pin.sym} 142540 -18190 0 1 {name=p141631 lab=_47947_/Y }
C {sky130_stdcells/a21oi_4.sym} 142460 -18190 0 0 {name=X_47947_ }
C {devices/lab_pin.sym} 142380 -18070 0 0 {name=p141632 lab=_80921_/D }
C {devices/lab_pin.sym} 142380 -18030 0 0 {name=p141633 lab=_66734_/X }
C {devices/lab_pin.sym} 142380 -17990 0 0 {name=p141634 lab=_66780_/X }
C {devices/lab_pin.sym} 142540 -18030 0 1 {name=p141635 lab=_84097_/D }
C {sky130_stdcells/a21bo_4.sym} 142460 -18030 0 0 {name=X_66781_ }
C {devices/lab_pin.sym} 142400 -17910 0 0 {name=p141636 lab=_78764_/Y }
C {devices/lab_pin.sym} 142400 -17870 0 0 {name=p141637 lab=_78767_/B }
C {devices/lab_pin.sym} 142400 -17830 0 0 {name=p141638 lab=_78765_/Y }
C {devices/lab_pin.sym} 142520 -17870 0 1 {name=p141639 lab=_78767_/Y }
C {sky130_stdcells/nand3_4.sym} 142460 -17870 0 0 {name=X_78767_ }
C {devices/lab_pin.sym} 142380 -17750 0 0 {name=p141640 lab=_75963_/C }
C {devices/lab_pin.sym} 142380 -17710 0 0 {name=p141641 lab=_75975_/Y }
C {devices/lab_pin.sym} 142380 -17670 0 0 {name=p141642 lab=_75978_/Y }
C {devices/lab_pin.sym} 142540 -17710 0 1 {name=p141643 lab=_75980_/B }
C {sky130_stdcells/o21a_4.sym} 142460 -17710 0 0 {name=X_75979_ }
C {devices/lab_pin.sym} 142380 -17610 0 0 {name=p141644 lab=_63985_/X }
C {devices/lab_pin.sym} 142380 -17570 0 0 {name=p141645 lab=_63969_/X }
C {devices/lab_pin.sym} 142380 -17530 0 0 {name=p141646 lab=_63987_/Y }
C {devices/lab_pin.sym} 142380 -17490 0 0 {name=p141647 lab=_63990_/Y }
C {devices/lab_pin.sym} 142380 -17460 0 0 {name=p141648 lab=_63992_/X }
C {devices/lab_pin.sym} 142540 -17530 0 1 {name=p141649 lab=_63993_/X }
C {sky130_stdcells/a41o_4.sym} 142460 -17530 0 0 {name=X_63993_ }
C {devices/lab_pin.sym} 142400 -17380 0 0 {name=p141650 lab=_66053_/A }
C {devices/lab_pin.sym} 142400 -17340 0 0 {name=p141651 lab=_68520_/B }
C {devices/lab_pin.sym} 142520 -17360 0 1 {name=p141652 lab=_68520_/Y }
C {sky130_stdcells/nor2_4.sym} 142460 -17360 0 0 {name=X_68520_ }
C {devices/lab_pin.sym} 142380 -17260 0 0 {name=p141653 lab=_65654_/X }
C {devices/lab_pin.sym} 142380 -17220 0 0 {name=p141654 lab=_86189_/Q }
C {devices/lab_pin.sym} 142380 -17180 0 0 {name=p141655 lab=_65576_/X }
C {devices/lab_pin.sym} 142380 -17140 0 0 {name=p141656 lab=_65731_/X }
C {devices/lab_pin.sym} 142540 -17200 0 1 {name=p141657 lab=_65732_/X }
C {sky130_stdcells/a211o_4.sym} 142460 -17200 0 0 {name=X_65732_ }
C {devices/lab_pin.sym} 142400 -17060 0 0 {name=p141658 lab=_77718_/A }
C {devices/lab_pin.sym} 142400 -17020 0 0 {name=p141659 lab=_77718_/B }
C {devices/lab_pin.sym} 142520 -17040 0 1 {name=p141660 lab=_77723_/A }
C {sky130_stdcells/nand2_4.sym} 142460 -17040 0 0 {name=X_77718_ }
C {devices/lab_pin.sym} 142380 -16930 0 0 {name=p141661 lab=_62941_/X }
C {devices/lab_pin.sym} 142380 -16890 0 0 {name=p141662 lab=_62942_/X }
C {devices/lab_pin.sym} 142380 -16850 0 0 {name=p141663 lab=_62943_/Y }
C {devices/lab_pin.sym} 142540 -16890 0 1 {name=p141664 lab=_84368_/D }
C {sky130_stdcells/a21oi_4.sym} 142460 -16890 0 0 {name=X_62944_ }
C {devices/lab_pin.sym} 142400 -16770 0 0 {name=p141665 lab=_48196_/A }
C {devices/lab_pin.sym} 142400 -16730 0 0 {name=p141666 lab=_49312_/C }
C {devices/lab_pin.sym} 142400 -16690 0 0 {name=p141667 lab=_53697_/C }
C {devices/lab_pin.sym} 142520 -16730 0 1 {name=p141668 lab=_47878_/X }
C {sky130_stdcells/and3_4.sym} 142460 -16730 0 0 {name=X_47878_ }
C {devices/lab_pin.sym} 142400 -16610 0 0 {name=p141669 lab=_78693_/X }
C {devices/lab_pin.sym} 142400 -16570 0 0 {name=p141670 lab=_78696_/Y }
C {devices/lab_pin.sym} 142400 -16530 0 0 {name=p141671 lab=_78694_/Y }
C {devices/lab_pin.sym} 142520 -16570 0 1 {name=p141672 lab=_78722_/A }
C {sky130_stdcells/nand3_4.sym} 142460 -16570 0 0 {name=X_78698_ }
C {devices/lab_pin.sym} 142400 -16440 0 0 {name=p141673 lab=_49607_/X }
C {devices/lab_pin.sym} 142400 -16400 0 0 {name=p141674 lab=_52833_/B }
C {devices/lab_pin.sym} 142520 -16420 0 1 {name=p141675 lab=_49617_/Y }
C {sky130_stdcells/nand2_4.sym} 142460 -16420 0 0 {name=X_49617_ }
C {devices/lab_pin.sym} 142420 -16290 0 0 {name=p141676 lab=_68451_/A }
C {devices/lab_pin.sym} 142500 -16290 0 1 {name=p141677 lab=_68452_/A }
C {sky130_stdcells/buf_2.sym} 142460 -16290 0 0 {name=X_68451_ }
C {devices/lab_pin.sym} 142420 -16170 0 0 {name=p141678 lab=_46828_/Y }
C {devices/lab_pin.sym} 142500 -16170 0 1 {name=p141679 lab=_52698_/D }
C {sky130_stdcells/buf_2.sym} 142460 -16170 0 0 {name=X_46829_ }
C {devices/lab_pin.sym} 142400 -16070 0 0 {name=p141680 lab=_65659_/X }
C {devices/lab_pin.sym} 142400 -16030 0 0 {name=p141681 lab=_65663_/B }
C {devices/lab_pin.sym} 142400 -15990 0 0 {name=p141682 lab=_65662_/X }
C {devices/lab_pin.sym} 142520 -16030 0 1 {name=p141683 lab=_65663_/Y }
C {sky130_stdcells/nand3_4.sym} 142460 -16030 0 0 {name=X_65663_ }
C {devices/lab_pin.sym} 142420 -15890 0 0 {name=p141684 lab=_77648_/Y }
C {devices/lab_pin.sym} 142500 -15890 0 1 {name=p141685 lab=_77650_/B }
C {sky130_stdcells/inv_2.sym} 142460 -15890 0 0 {name=X_77649_ }
C {devices/lab_pin.sym} 142420 -15770 0 0 {name=p141686 lab=_60335_/Y }
C {devices/lab_pin.sym} 142500 -15770 0 1 {name=p141687 lab=_62875_/X }
C {sky130_stdcells/buf_2.sym} 142460 -15770 0 0 {name=X_62875_ }
C {devices/lab_pin.sym} 142380 -15670 0 0 {name=p141688 lab=_67397_/X }
C {devices/lab_pin.sym} 142380 -15630 0 0 {name=p141689 lab=_67400_/X }
C {devices/lab_pin.sym} 142380 -15590 0 0 {name=p141690 lab=_67401_/X }
C {devices/lab_pin.sym} 142540 -15630 0 1 {name=p141691 lab=_67402_/Y }
C {sky130_stdcells/a21oi_4.sym} 142460 -15630 0 0 {name=X_67402_ }
C {devices/lab_pin.sym} 142420 -15490 0 0 {name=p141692 lab=_65117_/A }
C {devices/lab_pin.sym} 142500 -15490 0 1 {name=p141693 lab=_64615_/A }
C {sky130_stdcells/buf_2.sym} 142460 -15490 0 0 {name=X_64614_ }
C {devices/lab_pin.sym} 142420 -15370 0 0 {name=p141694 lab=_59605_/Y }
C {devices/lab_pin.sym} 142500 -15370 0 1 {name=p141695 lab=_61839_/C }
C {sky130_stdcells/buf_2.sym} 142460 -15370 0 0 {name=X_61826_ }
C {devices/lab_pin.sym} 142420 -15250 0 0 {name=p141696 lab=_49548_/A }
C {devices/lab_pin.sym} 142500 -15250 0 1 {name=p141697 lab=_49548_/X }
C {sky130_stdcells/buf_2.sym} 142460 -15250 0 0 {name=X_49548_ }
C {devices/lab_pin.sym} 142370 -15130 0 0 {name=p141698 lab=_80657_/CLK }
C {devices/lab_pin.sym} 142370 -15110 0 0 {name=p141699 lab=_74826_/Y }
C {devices/lab_pin.sym} 142550 -15130 0 1 {name=p141700 lab=_46111_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -15120 0 0 {name=X_80660_ }
C {devices/lab_pin.sym} 142380 -15020 0 0 {name=p141701 lab=_88114_/Q }
C {devices/lab_pin.sym} 142380 -14980 0 0 {name=p141702 lab=_68377_/X }
C {devices/lab_pin.sym} 142380 -14940 0 0 {name=p141703 lab=_68379_/X }
C {devices/lab_pin.sym} 142380 -14900 0 0 {name=p141704 lab=_68381_/Y }
C {devices/lab_pin.sym} 142540 -14960 0 1 {name=p141705 lab=_68382_/X }
C {sky130_stdcells/a211o_4.sym} 142460 -14960 0 0 {name=X_68382_ }
C {devices/lab_pin.sym} 142380 -14830 0 0 {name=p141706 lab=_65591_/X }
C {devices/lab_pin.sym} 142380 -14790 0 0 {name=p141707 lab=_65593_/X }
C {devices/lab_pin.sym} 142380 -14750 0 0 {name=p141708 lab=_65457_/X }
C {devices/lab_pin.sym} 142540 -14790 0 1 {name=p141709 lab=_65599_/A }
C {sky130_stdcells/a21o_4.sym} 142460 -14790 0 0 {name=X_65594_ }
C {devices/lab_pin.sym} 142380 -14670 0 0 {name=p141710 lab=_79309_/X }
C {devices/lab_pin.sym} 142380 -14630 0 0 {name=p141711 lab=_79311_/B }
C {devices/lab_pin.sym} 142380 -14590 0 0 {name=p141712 lab=_79318_/Y }
C {devices/lab_pin.sym} 142540 -14630 0 1 {name=p141713 lab=_79336_/B }
C {sky130_stdcells/a21boi_4.sym} 142460 -14630 0 0 {name=X_79319_ }
C {devices/lab_pin.sym} 142400 -14500 0 0 {name=p141714 lab=_67333_/A }
C {devices/lab_pin.sym} 142400 -14460 0 0 {name=p141715 lab=_67333_/B }
C {devices/lab_pin.sym} 142520 -14480 0 1 {name=p141716 lab=_67333_/X }
C {sky130_stdcells/and2_4.sym} 142460 -14480 0 0 {name=X_67333_ }
C {devices/lab_pin.sym} 142400 -14370 0 0 {name=p141717 lab=_64545_/A }
C {devices/lab_pin.sym} 142400 -14330 0 0 {name=p141718 lab=_64545_/B }
C {devices/lab_pin.sym} 142400 -14290 0 0 {name=p141719 lab=_64545_/C }
C {devices/lab_pin.sym} 142520 -14330 0 1 {name=p141720 lab=_64545_/X }
C {sky130_stdcells/and3_4.sym} 142460 -14330 0 0 {name=X_64545_ }
C {devices/lab_pin.sym} 142400 -14220 0 0 {name=p141721 lab=_49467_/A }
C {devices/lab_pin.sym} 142400 -14180 0 0 {name=p141722 lab=_49500_/B }
C {devices/lab_pin.sym} 142400 -14140 0 0 {name=p141723 lab=_49467_/C }
C {devices/lab_pin.sym} 142400 -14100 0 0 {name=p141724 lab=_52694_/D }
C {devices/lab_pin.sym} 142520 -14160 0 1 {name=p141725 lab=_49479_/X }
C {sky130_stdcells/and4_4.sym} 142460 -14160 0 0 {name=X_49479_ }
C {devices/lab_pin.sym} 142400 -14040 0 0 {name=p141726 lab=_61730_/X }
C {devices/lab_pin.sym} 142400 -14000 0 0 {name=p141727 lab=_61791_/B }
C {devices/lab_pin.sym} 142400 -13960 0 0 {name=p141728 lab=_61732_/X }
C {devices/lab_pin.sym} 142400 -13920 0 0 {name=p141729 lab=_63030_/B }
C {devices/lab_pin.sym} 142520 -13980 0 1 {name=p141730 lab=_61757_/X }
C {sky130_stdcells/and4_4.sym} 142460 -13980 0 0 {name=X_61757_ }
C {devices/lab_pin.sym} 142420 -13830 0 0 {name=p141731 lab=_80617_/A }
C {devices/lab_pin.sym} 142500 -13830 0 1 {name=p141732 lab=_80601_/A }
C {sky130_stdcells/inv_2.sym} 142460 -13830 0 0 {name=X_80591_ }
C {devices/lab_pin.sym} 142380 -13730 0 0 {name=p141733 lab=_51508_/Y }
C {devices/lab_pin.sym} 142380 -13690 0 0 {name=p141734 lab=_51503_/X }
C {devices/lab_pin.sym} 142380 -13650 0 0 {name=p141735 lab=_51509_/X }
C {devices/lab_pin.sym} 142540 -13690 0 1 {name=p141736 lab=_85997_/D }
C {sky130_stdcells/a21oi_4.sym} 142460 -13690 0 0 {name=X_51510_ }
C {devices/lab_pin.sym} 142370 -13550 0 0 {name=p141737 lab=_82284_/CLK }
C {devices/lab_pin.sym} 142370 -13530 0 0 {name=p141738 lab=_77178_/B }
C {devices/lab_pin.sym} 142550 -13550 0 1 {name=p141739 lab=_82330_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -13540 0 0 {name=X_82330_ }
C {devices/lab_pin.sym} 142420 -13410 0 0 {name=p141740 lab=clkbuf_9_237_0_CLK/X }
C {devices/lab_pin.sym} 142500 -13410 0 1 {name=p141741 lab=_86701_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 142460 -13410 0 0 {name=Xclkbuf_10_474_0_CLK }
C {devices/lab_pin.sym} 142400 -13320 0 0 {name=p141742 lab=_60712_/B }
C {devices/lab_pin.sym} 142400 -13280 0 0 {name=p141743 lab=_60694_/C }
C {devices/lab_pin.sym} 142400 -13240 0 0 {name=p141744 lab=_60711_/A }
C {devices/lab_pin.sym} 142400 -13200 0 0 {name=p141745 lab=_60660_/A }
C {devices/lab_pin.sym} 142520 -13260 0 1 {name=p141746 lab=_60708_/Y }
C {sky130_stdcells/nand4_4.sym} 142460 -13260 0 0 {name=X_60708_ }
C {devices/lab_pin.sym} 142420 -13110 0 0 {name=p141747 lab=_67025_/X }
C {devices/lab_pin.sym} 142500 -13110 0 1 {name=p141748 lab=_67264_/X }
C {sky130_stdcells/buf_2.sym} 142460 -13110 0 0 {name=X_67264_ }
C {devices/lab_pin.sym} 142400 -13000 0 0 {name=p141749 lab=_52476_/A }
C {devices/lab_pin.sym} 142400 -12960 0 0 {name=p141750 lab=_46411_/A }
C {devices/lab_pin.sym} 142520 -12980 0 1 {name=p141751 lab=_52490_/Y }
C {sky130_stdcells/nand2_4.sym} 142460 -12980 0 0 {name=X_52490_ }
C {devices/lab_pin.sym} 142400 -12870 0 0 {name=p141752 lab=_61232_/X }
C {devices/lab_pin.sym} 142400 -12830 0 0 {name=p141753 lab=_61607_/B }
C {devices/lab_pin.sym} 142400 -12790 0 0 {name=p141754 lab=_61207_/X }
C {devices/lab_pin.sym} 142520 -12830 0 1 {name=p141755 lab=_64477_/D }
C {sky130_stdcells/nand3_4.sym} 142460 -12830 0 0 {name=X_64476_ }
C {devices/lab_pin.sym} 142420 -12690 0 0 {name=p141756 lab=_61688_/A }
C {devices/lab_pin.sym} 142500 -12690 0 1 {name=p141757 lab=_61688_/Y }
C {sky130_stdcells/inv_2.sym} 142460 -12690 0 0 {name=X_61688_ }
C {devices/lab_pin.sym} 142380 -12590 0 0 {name=p141758 lab=_69000_/X }
C {devices/lab_pin.sym} 142380 -12550 0 0 {name=p141759 lab=_69002_/X }
C {devices/lab_pin.sym} 142380 -12510 0 0 {name=p141760 lab=_68390_/X }
C {devices/lab_pin.sym} 142540 -12550 0 1 {name=p141761 lab=_69003_/X }
C {sky130_stdcells/a21o_4.sym} 142460 -12550 0 0 {name=X_69003_ }
C {devices/lab_pin.sym} 142380 -12440 0 0 {name=p141762 lab=_57761_/X }
C {devices/lab_pin.sym} 142380 -12400 0 0 {name=p141763 lab=_84972_/Q }
C {devices/lab_pin.sym} 142380 -12360 0 0 {name=p141764 lab=_65309_/X }
C {devices/lab_pin.sym} 142380 -12320 0 0 {name=p141765 lab=_66214_/X }
C {devices/lab_pin.sym} 142540 -12380 0 1 {name=p141766 lab=_66216_/C }
C {sky130_stdcells/a211o_4.sym} 142460 -12380 0 0 {name=X_66215_ }
C {devices/lab_pin.sym} 142380 -12250 0 0 {name=p141767 lab=_86009_/Q }
C {devices/lab_pin.sym} 142380 -12210 0 0 {name=p141768 lab=_51429_/X }
C {devices/lab_pin.sym} 142380 -12170 0 0 {name=p141769 lab=_51440_/Y }
C {devices/lab_pin.sym} 142540 -12210 0 1 {name=p141770 lab=_51441_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -12210 0 0 {name=X_51441_ }
C {devices/lab_pin.sym} 142400 -12080 0 0 {name=p141771 lab=_63427_/A }
C {devices/lab_pin.sym} 142400 -12040 0 0 {name=p141772 lab=_61811_/X }
C {devices/lab_pin.sym} 142520 -12060 0 1 {name=p141773 lab=_63427_/X }
C {sky130_stdcells/and2_4.sym} 142460 -12060 0 0 {name=X_63427_ }
C {devices/lab_pin.sym} 142370 -11930 0 0 {name=p141774 lab=_82253_/CLK }
C {devices/lab_pin.sym} 142370 -11910 0 0 {name=p141775 lab=_82261_/D }
C {devices/lab_pin.sym} 142550 -11930 0 1 {name=p141776 lab=_82261_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -11920 0 0 {name=X_82261_ }
C {devices/lab_pin.sym} 142420 -11790 0 0 {name=p141777 lab=_60639_/A }
C {devices/lab_pin.sym} 142500 -11790 0 1 {name=p141778 lab=_61075_/C }
C {sky130_stdcells/buf_2.sym} 142460 -11790 0 0 {name=X_60639_ }
C {devices/lab_pin.sym} 142400 -11680 0 0 {name=p141779 lab=_67149_/A }
C {devices/lab_pin.sym} 142400 -11640 0 0 {name=p141780 lab=_88185_/Q }
C {devices/lab_pin.sym} 142520 -11660 0 1 {name=p141781 lab=_67195_/X }
C {sky130_stdcells/and2_4.sym} 142460 -11660 0 0 {name=X_67195_ }
C {devices/lab_pin.sym} 142370 -11530 0 0 {name=p141782 lab=_81755_/CLK }
C {devices/lab_pin.sym} 142370 -11510 0 0 {name=p141783 lab=_68253_/X }
C {devices/lab_pin.sym} 142550 -11530 0 1 {name=p141784 lab=_82648_/D }
C {sky130_stdcells/dfxtp_4.sym} 142460 -11520 0 0 {name=X_84000_ }
C {devices/lab_pin.sym} 142370 -11390 0 0 {name=p141785 lab=_82284_/CLK }
C {devices/lab_pin.sym} 142370 -11370 0 0 {name=p141786 lab=_74853_/X }
C {devices/lab_pin.sym} 142550 -11390 0 1 {name=p141787 lab=_46318_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -11380 0 0 {name=X_81212_ }
C {devices/lab_pin.sym} 142400 -11280 0 0 {name=p141788 lab=_54160_/A }
C {devices/lab_pin.sym} 142400 -11240 0 0 {name=p141789 lab=_54160_/B }
C {devices/lab_pin.sym} 142400 -11200 0 0 {name=p141790 lab=_54146_/X }
C {devices/lab_pin.sym} 142400 -11160 0 0 {name=p141791 lab=_52993_/D }
C {devices/lab_pin.sym} 142520 -11220 0 1 {name=p141792 lab=_54160_/X }
C {sky130_stdcells/and4_4.sym} 142460 -11220 0 0 {name=X_54160_ }
C {devices/lab_pin.sym} 142400 -11080 0 0 {name=p141793 lab=_66011_/X }
C {devices/lab_pin.sym} 142400 -11040 0 0 {name=p141794 lab=_86545_/Q }
C {devices/lab_pin.sym} 142520 -11060 0 1 {name=p141795 lab=_66146_/X }
C {sky130_stdcells/and2_4.sym} 142460 -11060 0 0 {name=X_66146_ }
C {devices/lab_pin.sym} 142400 -10940 0 0 {name=p141796 lab=_51367_/X }
C {devices/lab_pin.sym} 142400 -10900 0 0 {name=p141797 lab=_51372_/B }
C {devices/lab_pin.sym} 142520 -10920 0 1 {name=p141798 lab=_51372_/X }
C {sky130_stdcells/and2_4.sym} 142460 -10920 0 0 {name=X_51372_ }
C {devices/lab_pin.sym} 142420 -10790 0 0 {name=p141799 lab=_63357_/X }
C {devices/lab_pin.sym} 142500 -10790 0 1 {name=p141800 lab=_63358_/X }
C {sky130_stdcells/buf_2.sym} 142460 -10790 0 0 {name=X_63358_ }
C {devices/lab_pin.sym} 142370 -10670 0 0 {name=p141801 lab=_82386_/CLK }
C {devices/lab_pin.sym} 142370 -10650 0 0 {name=p141802 lab=_82192_/D }
C {devices/lab_pin.sym} 142550 -10670 0 1 {name=p141803 lab=_82192_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -10660 0 0 {name=X_82192_ }
C {devices/lab_pin.sym} 142420 -10530 0 0 {name=p141804 lab=_53111_/A }
C {devices/lab_pin.sym} 142500 -10530 0 1 {name=p141805 lab=_53111_/X }
C {sky130_stdcells/buf_2.sym} 142460 -10530 0 0 {name=X_53111_ }
C {devices/lab_pin.sym} 142420 -10410 0 0 {name=p141806 lab=clkbuf_9_244_0_CLK/X }
C {devices/lab_pin.sym} 142500 -10410 0 1 {name=p141807 lab=_85961_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 142460 -10410 0 0 {name=Xclkbuf_10_489_0_CLK }
C {devices/lab_pin.sym} 142380 -10310 0 0 {name=p141808 lab=_50319_/Y }
C {devices/lab_pin.sym} 142380 -10270 0 0 {name=p141809 lab=_50299_/X }
C {devices/lab_pin.sym} 142380 -10230 0 0 {name=p141810 lab=_50322_/Y }
C {devices/lab_pin.sym} 142540 -10270 0 1 {name=p141811 lab=_86224_/D }
C {sky130_stdcells/a21boi_4.sym} 142460 -10270 0 0 {name=X_50323_ }
C {devices/lab_pin.sym} 142400 -10160 0 0 {name=p141812 lab=_61399_/X }
C {devices/lab_pin.sym} 142400 -10120 0 0 {name=p141813 lab=_62309_/B }
C {devices/lab_pin.sym} 142400 -10080 0 0 {name=p141814 lab=_62309_/C }
C {devices/lab_pin.sym} 142400 -10040 0 0 {name=p141815 lab=_62211_/D }
C {devices/lab_pin.sym} 142520 -10100 0 1 {name=p141816 lab=_62310_/D }
C {sky130_stdcells/nand4_4.sym} 142460 -10100 0 0 {name=X_62309_ }
C {devices/lab_pin.sym} 142370 -9950 0 0 {name=p141817 lab=_86758_/CLK }
C {devices/lab_pin.sym} 142370 -9930 0 0 {name=p141818 lab=_81143_/D }
C {devices/lab_pin.sym} 142550 -9950 0 1 {name=p141819 lab=_40644_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -9940 0 0 {name=X_81143_ }
C {devices/lab_pin.sym} 142400 -9830 0 0 {name=p141820 lab=_54091_/A }
C {devices/lab_pin.sym} 142400 -9790 0 0 {name=p141821 lab=_54043_/B }
C {devices/lab_pin.sym} 142400 -9750 0 0 {name=p141822 lab=_51749_/X }
C {devices/lab_pin.sym} 142520 -9790 0 1 {name=p141823 lab=_54091_/X }
C {sky130_stdcells/and3_4.sym} 142460 -9790 0 0 {name=X_54091_ }
C {devices/lab_pin.sym} 142380 -9670 0 0 {name=p141824 lab=_66068_/X }
C {devices/lab_pin.sym} 142380 -9630 0 0 {name=p141825 lab=_65599_/Y }
C {devices/lab_pin.sym} 142380 -9590 0 0 {name=p141826 lab=_66076_/Y }
C {devices/lab_pin.sym} 142540 -9630 0 1 {name=p141827 lab=_66077_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -9630 0 0 {name=X_66077_ }
C {devices/lab_pin.sym} 142420 -9490 0 0 {name=p141828 lab=_60502_/Y }
C {devices/lab_pin.sym} 142500 -9490 0 1 {name=p141829 lab=_63289_/X }
C {sky130_stdcells/buf_2.sym} 142460 -9490 0 0 {name=X_63289_ }
C {devices/lab_pin.sym} 142380 -9390 0 0 {name=p141830 lab=_85708_/Q }
C {devices/lab_pin.sym} 142380 -9350 0 0 {name=p141831 lab=_53038_/X }
C {devices/lab_pin.sym} 142380 -9310 0 0 {name=p141832 lab=_53041_/Y }
C {devices/lab_pin.sym} 142540 -9350 0 1 {name=p141833 lab=_53042_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -9350 0 0 {name=X_53042_ }
C {devices/lab_pin.sym} 142380 -9230 0 0 {name=p141834 lab=_83888_/Q }
C {devices/lab_pin.sym} 142380 -9190 0 0 {name=p141835 lab=_69894_/X }
C {devices/lab_pin.sym} 142380 -9150 0 0 {name=p141836 lab=_69904_/X }
C {devices/lab_pin.sym} 142540 -9190 0 1 {name=p141837 lab=_69905_/X }
C {sky130_stdcells/a21bo_4.sym} 142460 -9190 0 0 {name=X_69905_ }
C {devices/lab_pin.sym} 142420 -9050 0 0 {name=p141838 lab=_64772_/A }
C {devices/lab_pin.sym} 142500 -9050 0 1 {name=p141839 lab=_65028_/X }
C {sky130_stdcells/buf_2.sym} 142460 -9050 0 0 {name=X_65028_ }
C {devices/lab_pin.sym} 142420 -8930 0 0 {name=p141840 lab=_74458_/A }
C {devices/lab_pin.sym} 142500 -8930 0 1 {name=p141841 lab=_54043_/B }
C {sky130_stdcells/buf_2.sym} 142460 -8930 0 0 {name=X_50254_ }
C {devices/lab_pin.sym} 142370 -8810 0 0 {name=p141842 lab=_85514_/CLK }
C {devices/lab_pin.sym} 142370 -8790 0 0 {name=p141843 lab=_51762_/Y }
C {devices/lab_pin.sym} 142550 -8810 0 1 {name=p141844 lab=_85951_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -8800 0 0 {name=X_85951_ }
C {devices/lab_pin.sym} 142370 -8670 0 0 {name=p141845 lab=_81074_/CLK }
C {devices/lab_pin.sym} 142370 -8650 0 0 {name=p141846 lab=_75574_/A }
C {devices/lab_pin.sym} 142550 -8670 0 1 {name=p141847 lab=_75299_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -8660 0 0 {name=X_81074_ }
C {devices/lab_pin.sym} 142380 -8550 0 0 {name=p141848 lab=_80019_/A }
C {devices/lab_pin.sym} 142380 -8510 0 0 {name=p141849 lab=_80018_/X }
C {devices/lab_pin.sym} 142380 -8470 0 0 {name=p141850 lab=_80024_/Y }
C {devices/lab_pin.sym} 142540 -8510 0 1 {name=p141851 lab=_80025_/Y }
C {sky130_stdcells/a21boi_4.sym} 142460 -8510 0 0 {name=X_80025_ }
C {devices/lab_pin.sym} 142370 -8370 0 0 {name=p141852 lab=_84360_/CLK }
C {devices/lab_pin.sym} 142370 -8350 0 0 {name=p141853 lab=_84902_/D }
C {devices/lab_pin.sym} 142550 -8370 0 1 {name=p141854 lab=_63400_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -8360 0 0 {name=X_84902_ }
C {devices/lab_pin.sym} 142380 -8250 0 0 {name=p141855 lab=_57824_/X }
C {devices/lab_pin.sym} 142380 -8210 0 0 {name=p141856 lab=_85497_/Q }
C {devices/lab_pin.sym} 142380 -8170 0 0 {name=p141857 lab=_57849_/X }
C {devices/lab_pin.sym} 142540 -8210 0 1 {name=p141858 lab=_57850_/X }
C {sky130_stdcells/o21a_4.sym} 142460 -8210 0 0 {name=X_57850_ }
C {devices/lab_pin.sym} 142420 -8070 0 0 {name=p141859 lab=clkbuf_9_206_0_CLK/X }
C {devices/lab_pin.sym} 142500 -8070 0 1 {name=p141860 lab=_85334_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 142460 -8070 0 0 {name=Xclkbuf_10_412_0_CLK }
C {devices/lab_pin.sym} 142380 -7980 0 0 {name=p141861 lab=_73273_/A }
C {devices/lab_pin.sym} 142380 -7940 0 0 {name=p141862 lab=_69833_/X }
C {devices/lab_pin.sym} 142380 -7900 0 0 {name=p141863 lab=_69617_/X }
C {devices/lab_pin.sym} 142380 -7860 0 0 {name=p141864 lab=_69835_/Y }
C {devices/lab_pin.sym} 142540 -7920 0 1 {name=p141865 lab=_69836_/X }
C {sky130_stdcells/a211o_4.sym} 142460 -7920 0 0 {name=X_69836_ }
C {devices/lab_pin.sym} 142420 -7770 0 0 {name=p141866 lab=_50113_/A }
C {devices/lab_pin.sym} 142500 -7770 0 1 {name=p141867 lab=_50185_/X }
C {sky130_stdcells/buf_2.sym} 142460 -7770 0 0 {name=X_50185_ }
C {devices/lab_pin.sym} 142370 -7650 0 0 {name=p141868 lab=_85879_/CLK }
C {devices/lab_pin.sym} 142370 -7630 0 0 {name=p141869 lab=_52136_/Y }
C {devices/lab_pin.sym} 142550 -7650 0 1 {name=p141870 lab=_72957_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -7640 0 0 {name=X_85882_ }
C {devices/lab_pin.sym} 142420 -7510 0 0 {name=p141871 lab=_56800_/X }
C {devices/lab_pin.sym} 142500 -7510 0 1 {name=p141872 lab=_56801_/X }
C {sky130_stdcells/buf_2.sym} 142460 -7510 0 0 {name=X_56801_ }
C {devices/lab_pin.sym} 142370 -7390 0 0 {name=p141873 lab=_88394_/CLK }
C {devices/lab_pin.sym} 142370 -7370 0 0 {name=p141874 lab=_87621_/D }
C {devices/lab_pin.sym} 142550 -7390 0 1 {name=p141875 lab=_87621_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -7380 0 0 {name=X_87621_ }
C {devices/lab_pin.sym} 142370 -7250 0 0 {name=p141876 lab=_84714_/CLK }
C {devices/lab_pin.sym} 142370 -7230 0 0 {name=p141877 lab=_58503_/Y }
C {devices/lab_pin.sym} 142550 -7250 0 1 {name=p141878 lab=_64307_/C }
C {sky130_stdcells/dfxtp_4.sym} 142460 -7240 0 0 {name=X_84833_ }
C {devices/lab_pin.sym} 142420 -7110 0 0 {name=p141879 lab=_58631_/A }
C {devices/lab_pin.sym} 142500 -7110 0 1 {name=p141880 lab=_57781_/X }
C {sky130_stdcells/buf_2.sym} 142460 -7110 0 0 {name=X_57781_ }
C {devices/lab_pin.sym} 142380 -7020 0 0 {name=p141881 lab=_88068_/Q }
C {devices/lab_pin.sym} 142380 -6980 0 0 {name=p141882 lab=_69751_/X }
C {devices/lab_pin.sym} 142380 -6940 0 0 {name=p141883 lab=_69088_/X }
C {devices/lab_pin.sym} 142380 -6900 0 0 {name=p141884 lab=_69766_/Y }
C {devices/lab_pin.sym} 142540 -6960 0 1 {name=p141885 lab=_69767_/X }
C {sky130_stdcells/a211o_4.sym} 142460 -6960 0 0 {name=X_69767_ }
C {devices/lab_pin.sym} 142380 -6830 0 0 {name=p141886 lab=_54990_/Y }
C {devices/lab_pin.sym} 142380 -6790 0 0 {name=p141887 lab=_54971_/X }
C {devices/lab_pin.sym} 142380 -6750 0 0 {name=p141888 lab=_54992_/X }
C {devices/lab_pin.sym} 142540 -6790 0 1 {name=p141889 lab=_54993_/Y }
C {sky130_stdcells/a21oi_4.sym} 142460 -6790 0 0 {name=X_54993_ }
C {devices/lab_pin.sym} 142380 -6680 0 0 {name=p141890 lab=_88386_/Q }
C {devices/lab_pin.sym} 142380 -6640 0 0 {name=p141891 lab=_66954_/X }
C {devices/lab_pin.sym} 142380 -6600 0 0 {name=p141892 lab=_66955_/X }
C {devices/lab_pin.sym} 142380 -6560 0 0 {name=p141893 lab=_66978_/X }
C {devices/lab_pin.sym} 142540 -6620 0 1 {name=p141894 lab=_66979_/X }
C {sky130_stdcells/a211o_4.sym} 142460 -6620 0 0 {name=X_66979_ }
C {devices/lab_pin.sym} 142420 -6470 0 0 {name=p141895 lab=_59520_/A }
C {devices/lab_pin.sym} 142500 -6470 0 1 {name=p141896 lab=_59536_/A }
C {sky130_stdcells/buf_2.sym} 142460 -6470 0 0 {name=X_59520_ }
C {devices/lab_pin.sym} 142420 -6350 0 0 {name=p141897 lab=_57023_/A }
C {devices/lab_pin.sym} 142500 -6350 0 1 {name=p141898 lab=_56732_/X }
C {sky130_stdcells/buf_2.sym} 142460 -6350 0 0 {name=X_56732_ }
C {devices/lab_pin.sym} 142400 -6240 0 0 {name=p141899 lab=_69906_/A }
C {devices/lab_pin.sym} 142400 -6200 0 0 {name=p141900 lab=_68718_/B }
C {devices/lab_pin.sym} 142520 -6220 0 1 {name=p141901 lab=_68718_/X }
C {sky130_stdcells/and2_4.sym} 142460 -6220 0 0 {name=X_68718_ }
C {devices/lab_pin.sym} 142370 -6090 0 0 {name=p141902 lab=_87814_/CLK }
C {devices/lab_pin.sym} 142370 -6070 0 0 {name=p141903 lab=_43164_/Y }
C {devices/lab_pin.sym} 142550 -6090 0 1 {name=p141904 lab=_73252_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -6080 0 0 {name=X_87552_ }
C {devices/lab_pin.sym} 142400 -5970 0 0 {name=p141905 lab=_53944_/A }
C {devices/lab_pin.sym} 142400 -5930 0 0 {name=p141906 lab=_57491_/B }
C {devices/lab_pin.sym} 142400 -5890 0 0 {name=p141907 lab=_53944_/C }
C {devices/lab_pin.sym} 142520 -5930 0 1 {name=p141908 lab=_53944_/Y }
C {sky130_stdcells/nor3_4.sym} 142460 -5930 0 0 {name=X_53944_ }
C {devices/lab_pin.sym} 142370 -5790 0 0 {name=p141909 lab=_84760_/CLK }
C {devices/lab_pin.sym} 142370 -5770 0 0 {name=p141910 lab=_59171_/Y }
C {devices/lab_pin.sym} 142550 -5790 0 1 {name=p141911 lab=_59159_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -5780 0 0 {name=X_84764_ }
C {devices/lab_pin.sym} 142370 -5650 0 0 {name=p141912 lab=_81928_/CLK }
C {devices/lab_pin.sym} 142370 -5630 0 0 {name=p141913 lab=_81976_/D }
C {devices/lab_pin.sym} 142550 -5650 0 1 {name=p141914 lab=_77775_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -5640 0 0 {name=X_81976_ }
C {devices/lab_pin.sym} 142400 -5520 0 0 {name=p141915 lab=_64696_/A }
C {devices/lab_pin.sym} 142400 -5480 0 0 {name=p141916 lab=_69698_/B }
C {devices/lab_pin.sym} 142520 -5500 0 1 {name=p141917 lab=_69698_/Y }
C {sky130_stdcells/nor2_4.sym} 142460 -5500 0 0 {name=X_69698_ }
C {devices/lab_pin.sym} 142370 -5370 0 0 {name=p141918 lab=_86499_/CLK }
C {devices/lab_pin.sym} 142370 -5350 0 0 {name=p141919 lab=_48658_/Y }
C {devices/lab_pin.sym} 142550 -5370 0 1 {name=p141920 lab=_86503_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -5360 0 0 {name=X_86503_ }
C {devices/lab_pin.sym} 142420 -5230 0 0 {name=p141921 lab=clkbuf_9_213_0_CLK/X }
C {devices/lab_pin.sym} 142500 -5230 0 1 {name=p141922 lab=_83238_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 142460 -5230 0 0 {name=Xclkbuf_10_427_0_CLK }
C {devices/lab_pin.sym} 142400 -5120 0 0 {name=p141923 lab=_59450_/Y }
C {devices/lab_pin.sym} 142400 -5080 0 0 {name=p141924 lab=_59444_/X }
C {devices/lab_pin.sym} 142520 -5100 0 1 {name=p141925 lab=_59451_/Y }
C {sky130_stdcells/nand2_4.sym} 142460 -5100 0 0 {name=X_59451_ }
C {devices/lab_pin.sym} 142370 -4970 0 0 {name=p141926 lab=_85436_/CLK }
C {devices/lab_pin.sym} 142370 -4950 0 0 {name=p141927 lab=_70725_/Y }
C {devices/lab_pin.sym} 142550 -4970 0 1 {name=p141928 lab=_46975_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -4960 0 0 {name=X_83715_ }
C {devices/lab_pin.sym} 142420 -4830 0 0 {name=p141929 lab=_56663_/A }
C {devices/lab_pin.sym} 142500 -4830 0 1 {name=p141930 lab=_56663_/X }
C {sky130_stdcells/buf_2.sym} 142460 -4830 0 0 {name=X_56663_ }
C {devices/lab_pin.sym} 142370 -4710 0 0 {name=p141931 lab=_81169_/CLK }
C {devices/lab_pin.sym} 142370 -4690 0 0 {name=p141932 lab=_80927_/D }
C {devices/lab_pin.sym} 142550 -4710 0 1 {name=p141933 lab=_80927_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -4700 0 0 {name=X_80927_ }
C {devices/lab_pin.sym} 142420 -4570 0 0 {name=p141934 lab=_68649_/A }
C {devices/lab_pin.sym} 142500 -4570 0 1 {name=p141935 lab=_68649_/X }
C {sky130_stdcells/buf_2.sym} 142460 -4570 0 0 {name=X_68649_ }
C {devices/lab_pin.sym} 142370 -4450 0 0 {name=p141936 lab=_87484_/CLK }
C {devices/lab_pin.sym} 142370 -4430 0 0 {name=p141937 lab=_87483_/D }
C {devices/lab_pin.sym} 142550 -4450 0 1 {name=p141938 lab=_87483_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -4440 0 0 {name=X_87483_ }
C {devices/lab_pin.sym} 142400 -4330 0 0 {name=p141939 lab=_52355_/A }
C {devices/lab_pin.sym} 142400 -4290 0 0 {name=p141940 lab=_53875_/B }
C {devices/lab_pin.sym} 142400 -4250 0 0 {name=p141941 lab=_53806_/C }
C {devices/lab_pin.sym} 142520 -4290 0 1 {name=p141942 lab=_53875_/X }
C {sky130_stdcells/and3_4.sym} 142460 -4290 0 0 {name=X_53875_ }
C {devices/lab_pin.sym} 142370 -4150 0 0 {name=p141943 lab=_84355_/CLK }
C {devices/lab_pin.sym} 142370 -4130 0 0 {name=p141944 lab=_84695_/D }
C {devices/lab_pin.sym} 142550 -4150 0 1 {name=p141945 lab=_80433_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -4140 0 0 {name=X_84695_ }
C {devices/lab_pin.sym} 142420 -4010 0 0 {name=p141946 lab=_84857_/Q }
C {devices/lab_pin.sym} 142500 -4010 0 1 {name=p141947 lab=_58403_/A }
C {sky130_stdcells/inv_2.sym} 142460 -4010 0 0 {name=X_58402_ }
C {devices/lab_pin.sym} 142420 -3890 0 0 {name=p141948 lab=_44115_/A }
C {devices/lab_pin.sym} 142500 -3890 0 1 {name=p141949 lab=_55615_/A }
C {sky130_stdcells/buf_2.sym} 142460 -3890 0 0 {name=X_55614_ }
C {devices/lab_pin.sym} 142370 -3770 0 0 {name=p141950 lab=_83594_/CLK }
C {devices/lab_pin.sym} 142370 -3750 0 0 {name=p141951 lab=_86434_/D }
C {devices/lab_pin.sym} 142550 -3770 0 1 {name=p141952 lab=_86434_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -3760 0 0 {name=X_86434_ }
C {devices/lab_pin.sym} 142380 -3670 0 0 {name=p141953 lab=_40835_/X }
C {devices/lab_pin.sym} 142380 -3630 0 0 {name=p141954 lab=_40836_/X }
C {devices/lab_pin.sym} 142380 -3590 0 0 {name=p141955 lab=_40839_/X }
C {devices/lab_pin.sym} 142380 -3550 0 0 {name=p141956 lab=_69756_/B }
C {devices/lab_pin.sym} 142380 -3510 0 0 {name=p141957 lab=_40832_/X }
C {devices/lab_pin.sym} 142540 -3590 0 1 {name=p141958 lab=_40840_/Y }
C {sky130_stdcells/o32ai_4.sym} 142460 -3590 0 0 {name=X_40840_ }
C {devices/lab_pin.sym} 142420 -3430 0 0 {name=p141959 lab=_52852_/A }
C {devices/lab_pin.sym} 142500 -3430 0 1 {name=p141960 lab=_52831_/B }
C {sky130_stdcells/buf_2.sym} 142460 -3430 0 0 {name=X_52826_ }
C {devices/lab_pin.sym} 142370 -3310 0 0 {name=p141961 lab=_86422_/CLK }
C {devices/lab_pin.sym} 142370 -3290 0 0 {name=p141962 lab=_83646_/D }
C {devices/lab_pin.sym} 142550 -3310 0 1 {name=p141963 lab=_83646_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -3300 0 0 {name=X_83646_ }
C {devices/lab_pin.sym} 142380 -3190 0 0 {name=p141964 lab=_59311_/X }
C {devices/lab_pin.sym} 142380 -3150 0 0 {name=p141965 lab=_85730_/Q }
C {devices/lab_pin.sym} 142380 -3110 0 0 {name=p141966 lab=_59334_/X }
C {devices/lab_pin.sym} 142540 -3150 0 1 {name=p141967 lab=_59382_/X }
C {sky130_stdcells/o21a_4.sym} 142460 -3150 0 0 {name=X_59382_ }
C {devices/lab_pin.sym} 142400 -3030 0 0 {name=p141968 lab=_71660_/A }
C {devices/lab_pin.sym} 142400 -2990 0 0 {name=p141969 lab=_71228_/B }
C {devices/lab_pin.sym} 142400 -2950 0 0 {name=p141970 lab=_71660_/C }
C {devices/lab_pin.sym} 142520 -2990 0 1 {name=p141971 lab=_71660_/Y }
C {sky130_stdcells/nand3_4.sym} 142460 -2990 0 0 {name=X_71660_ }
C {devices/lab_pin.sym} 142420 -2850 0 0 {name=p141972 lab=_55504_/Y }
C {devices/lab_pin.sym} 142500 -2850 0 1 {name=p141973 lab=_56629_/B }
C {sky130_stdcells/buf_2.sym} 142460 -2850 0 0 {name=X_56594_ }
C {devices/lab_pin.sym} 142370 -2730 0 0 {name=p141974 lab=_80740_/CLK }
C {devices/lab_pin.sym} 142370 -2710 0 0 {name=p141975 lab=_80890_/Q }
C {devices/lab_pin.sym} 142550 -2730 0 1 {name=p141976 lab=_75016_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -2720 0 0 {name=X_80858_ }
C {devices/lab_pin.sym} 142420 -2590 0 0 {name=p141977 lab=_70773_/A }
C {devices/lab_pin.sym} 142500 -2590 0 1 {name=p141978 lab=_70611_/X }
C {sky130_stdcells/buf_2.sym} 142460 -2590 0 0 {name=X_70611_ }
C {devices/lab_pin.sym} 142420 -2470 0 0 {name=p141979 lab=_56995_/X }
C {devices/lab_pin.sym} 142500 -2470 0 1 {name=p141980 lab=_58334_/A }
C {sky130_stdcells/buf_2.sym} 142460 -2470 0 0 {name=X_58333_ }
C {devices/lab_pin.sym} 142380 -2380 0 0 {name=p141981 lab=_57254_/B }
C {devices/lab_pin.sym} 142380 -2340 0 0 {name=p141982 lab=_55510_/X }
C {devices/lab_pin.sym} 142380 -2300 0 0 {name=p141983 lab=_55512_/X }
C {devices/lab_pin.sym} 142380 -2260 0 0 {name=p141984 lab=_55544_/Y }
C {devices/lab_pin.sym} 142540 -2320 0 1 {name=p141985 lab=_55545_/X }
C {sky130_stdcells/a211o_4.sym} 142460 -2320 0 0 {name=X_55545_ }
C {devices/lab_pin.sym} 142370 -2170 0 0 {name=p141986 lab=_83716_/CLK }
C {devices/lab_pin.sym} 142370 -2150 0 0 {name=p141987 lab=_49562_/Y }
C {devices/lab_pin.sym} 142550 -2170 0 1 {name=p141988 lab=_59044_/B }
C {sky130_stdcells/dfxtp_4.sym} 142460 -2160 0 0 {name=X_86365_ }
C {devices/lab_pin.sym} 142420 -2030 0 0 {name=p141989 lab=_40770_/Y }
C {devices/lab_pin.sym} 142500 -2030 0 1 {name=p141990 lab=_40771_/X }
C {sky130_stdcells/buf_2.sym} 142460 -2030 0 0 {name=X_40771_ }
C {devices/lab_pin.sym} 142420 -1910 0 0 {name=p141991 lab=_52757_/A }
C {devices/lab_pin.sym} 142500 -1910 0 1 {name=p141992 lab=_52775_/A }
C {sky130_stdcells/buf_2.sym} 142460 -1910 0 0 {name=X_52757_ }
C {devices/lab_pin.sym} 142380 -1810 0 0 {name=p141993 lab=_71581_/X }
C {devices/lab_pin.sym} 142380 -1770 0 0 {name=p141994 lab=_83446_/Q }
C {devices/lab_pin.sym} 142380 -1730 0 0 {name=p141995 lab=_71590_/Y }
C {devices/lab_pin.sym} 142540 -1770 0 1 {name=p141996 lab=_83446_/D }
C {sky130_stdcells/a21o_4.sym} 142460 -1770 0 0 {name=X_71591_ }
C {devices/lab_pin.sym} 142370 -1630 0 0 {name=p141997 lab=_86505_/CLK }
C {devices/lab_pin.sym} 142370 -1610 0 0 {name=p141998 lab=_83577_/D }
C {devices/lab_pin.sym} 142550 -1630 0 1 {name=p141999 lab=_48538_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -1620 0 0 {name=X_83577_ }
C {devices/lab_pin.sym} 142370 -1490 0 0 {name=p142000 lab=_80813_/CLK }
C {devices/lab_pin.sym} 142370 -1470 0 0 {name=p142001 lab=_75754_/Y }
C {devices/lab_pin.sym} 142550 -1490 0 1 {name=p142002 lab=_75358_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -1480 0 0 {name=X_80789_ }
C {devices/lab_pin.sym} 142380 -1390 0 0 {name=p142003 lab=_42486_/X }
C {devices/lab_pin.sym} 142380 -1350 0 0 {name=p142004 lab=_42501_/X }
C {devices/lab_pin.sym} 142380 -1310 0 0 {name=p142005 lab=_40696_/X }
C {devices/lab_pin.sym} 142380 -1270 0 0 {name=p142006 lab=_42509_/Y }
C {devices/lab_pin.sym} 142380 -1230 0 0 {name=p142007 lab=_42489_/X }
C {devices/lab_pin.sym} 142540 -1310 0 1 {name=p142008 lab=_42510_/Y }
C {sky130_stdcells/o32ai_4.sym} 142460 -1310 0 0 {name=X_42510_ }
C {devices/lab_pin.sym} 142370 -1150 0 0 {name=p142009 lab=_88104_/CLK }
C {devices/lab_pin.sym} 142370 -1130 0 0 {name=p142010 lab=_88104_/D }
C {devices/lab_pin.sym} 142550 -1150 0 1 {name=p142011 lab=_41922_/A }
C {sky130_stdcells/dfxtp_4.sym} 142460 -1140 0 0 {name=X_88104_ }
C {devices/lab_pin.sym} 142380 -1040 0 0 {name=p142012 lab=_72870_/X }
C {devices/lab_pin.sym} 142380 -1000 0 0 {name=p142013 lab=_86187_/Q }
C {devices/lab_pin.sym} 142380 -960 0 0 {name=p142014 lab=_72905_/X }
C {devices/lab_pin.sym} 142380 -920 0 0 {name=p142015 lab=_73329_/X }
C {devices/lab_pin.sym} 142540 -980 0 1 {name=p142016 lab=_73330_/X }
C {sky130_stdcells/a211o_4.sym} 142460 -980 0 0 {name=X_73330_ }
C {devices/lab_pin.sym} 142370 -830 0 0 {name=p142017 lab=_85346_/CLK }
C {devices/lab_pin.sym} 142370 -810 0 0 {name=p142018 lab=_55113_/Y }
C {devices/lab_pin.sym} 142550 -830 0 1 {name=p142019 lab=_85316_/Q }
C {sky130_stdcells/dfxtp_4.sym} 142460 -820 0 0 {name=X_85316_ }
C {devices/lab_pin.sym} 142380 -710 0 0 {name=p142020 lab=_85960_/Q }
C {devices/lab_pin.sym} 142380 -670 0 0 {name=p142021 lab=_51701_/X }
C {devices/lab_pin.sym} 142380 -630 0 0 {name=p142022 lab=_51707_/Y }
C {devices/lab_pin.sym} 142540 -670 0 1 {name=p142023 lab=_51708_/Y }
C {sky130_stdcells/o21ai_4.sym} 142460 -670 0 0 {name=X_51708_ }
C {devices/lab_pin.sym} 143300 -42170 0 0 {name=p142024 lab=_70533_/X }
C {devices/lab_pin.sym} 143300 -42130 0 0 {name=p142025 lab=_83753_/Q }
C {devices/lab_pin.sym} 143300 -42090 0 0 {name=p142026 lab=_70541_/Y }
C {devices/lab_pin.sym} 143460 -42130 0 1 {name=p142027 lab=_70542_/X }
C {sky130_stdcells/a21o_4.sym} 143380 -42130 0 0 {name=X_70542_ }
C {devices/lab_pin.sym} 143340 -41990 0 0 {name=p142028 lab=_58264_/A }
C {devices/lab_pin.sym} 143420 -41990 0 1 {name=p142029 lab=_58264_/Y }
C {sky130_stdcells/inv_2.sym} 143380 -41990 0 0 {name=X_58264_ }
C {devices/lab_pin.sym} 143290 -41870 0 0 {name=p142030 lab=_82529_/CLK }
C {devices/lab_pin.sym} 143290 -41850 0 0 {name=p142031 lab=_79101_/Y }
C {devices/lab_pin.sym} 143470 -41870 0 1 {name=p142032 lab=_82528_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -41860 0 0 {name=X_82528_ }
C {devices/lab_pin.sym} 143340 -41730 0 0 {name=p142033 lab=_43490_/A }
C {devices/lab_pin.sym} 143420 -41730 0 1 {name=p142034 lab=_87396_/D }
C {sky130_stdcells/inv_2.sym} 143380 -41730 0 0 {name=X_43490_ }
C {devices/lab_pin.sym} 143340 -41610 0 0 {name=p142035 lab=_55826_/A }
C {devices/lab_pin.sym} 143420 -41610 0 1 {name=p142036 lab=_55477_/A }
C {sky130_stdcells/buf_2.sym} 143380 -41610 0 0 {name=X_55476_ }
C {devices/lab_pin.sym} 143290 -41490 0 0 {name=p142037 lab=_86297_/CLK }
C {devices/lab_pin.sym} 143290 -41470 0 0 {name=p142038 lab=_49939_/Y }
C {devices/lab_pin.sym} 143470 -41490 0 1 {name=p142039 lab=_72232_/B }
C {sky130_stdcells/dfxtp_4.sym} 143380 -41480 0 0 {name=X_86296_ }
C {devices/lab_pin.sym} 143340 -41350 0 0 {name=p142040 lab=_52688_/A }
C {devices/lab_pin.sym} 143420 -41350 0 1 {name=p142041 lab=_52770_/A }
C {sky130_stdcells/buf_2.sym} 143380 -41350 0 0 {name=X_52688_ }
C {devices/lab_pin.sym} 143300 -41250 0 0 {name=p142042 lab=_56893_/B }
C {devices/lab_pin.sym} 143300 -41210 0 0 {name=p142043 lab=_56877_/X }
C {devices/lab_pin.sym} 143300 -41170 0 0 {name=p142044 lab=_56860_/X }
C {devices/lab_pin.sym} 143460 -41210 0 1 {name=p142045 lab=_57215_/X }
C {sky130_stdcells/a21o_4.sym} 143380 -41210 0 0 {name=X_57215_ }
C {devices/lab_pin.sym} 143290 -41070 0 0 {name=p142046 lab=_87789_/CLK }
C {devices/lab_pin.sym} 143290 -41050 0 0 {name=p142047 lab=_42102_/X }
C {devices/lab_pin.sym} 143470 -41070 0 1 {name=p142048 lab=_88035_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -41060 0 0 {name=X_88035_ }
C {devices/lab_pin.sym} 143340 -40930 0 0 {name=p142049 lab=_42440_/Y }
C {devices/lab_pin.sym} 143420 -40930 0 1 {name=p142050 lab=_87863_/D }
C {sky130_stdcells/inv_2.sym} 143380 -40930 0 0 {name=X_42441_ }
C {devices/lab_pin.sym} 143340 -40810 0 0 {name=p142051 lab=_54399_/A }
C {devices/lab_pin.sym} 143420 -40810 0 1 {name=p142052 lab=_54435_/A }
C {sky130_stdcells/buf_2.sym} 143380 -40810 0 0 {name=X_54427_ }
C {devices/lab_pin.sym} 143300 -40720 0 0 {name=p142053 lab=_73210_/X }
C {devices/lab_pin.sym} 143300 -40680 0 0 {name=p142054 lab=_85582_/Q }
C {devices/lab_pin.sym} 143300 -40640 0 0 {name=p142055 lab=_73092_/X }
C {devices/lab_pin.sym} 143300 -40600 0 0 {name=p142056 lab=_73260_/X }
C {devices/lab_pin.sym} 143460 -40660 0 1 {name=p142057 lab=_73261_/X }
C {sky130_stdcells/a211o_4.sym} 143380 -40660 0 0 {name=X_73261_ }
C {devices/lab_pin.sym} 143290 -40510 0 0 {name=p142058 lab=_85184_/CLK }
C {devices/lab_pin.sym} 143290 -40490 0 0 {name=p142059 lab=_56294_/Y }
C {devices/lab_pin.sym} 143470 -40510 0 1 {name=p142060 lab=_85247_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -40500 0 0 {name=X_85247_ }
C {devices/lab_pin.sym} 143340 -40370 0 0 {name=p142061 lab=_51639_/A }
C {devices/lab_pin.sym} 143420 -40370 0 1 {name=p142062 lab=_51639_/X }
C {sky130_stdcells/buf_2.sym} 143380 -40370 0 0 {name=X_51639_ }
C {devices/lab_pin.sym} 143320 -40270 0 0 {name=p142063 lab=_71323_/A }
C {devices/lab_pin.sym} 143320 -40230 0 0 {name=p142064 lab=_71500_/C }
C {devices/lab_pin.sym} 143320 -40190 0 0 {name=p142065 lab=_70472_/X }
C {devices/lab_pin.sym} 143440 -40230 0 1 {name=p142066 lab=_70473_/Y }
C {sky130_stdcells/nand3_4.sym} 143380 -40230 0 0 {name=X_70473_ }
C {devices/lab_pin.sym} 143300 -40110 0 0 {name=p142067 lab=_58191_/X }
C {devices/lab_pin.sym} 143300 -40070 0 0 {name=p142068 lab=_58192_/Y }
C {devices/lab_pin.sym} 143300 -40030 0 0 {name=p142069 lab=_58194_/Y }
C {devices/lab_pin.sym} 143460 -40070 0 1 {name=p142070 lab=_58195_/Y }
C {sky130_stdcells/a21oi_4.sym} 143380 -40070 0 0 {name=X_58195_ }
C {devices/lab_pin.sym} 143290 -39930 0 0 {name=p142071 lab=_83520_/CLK }
C {devices/lab_pin.sym} 143290 -39910 0 0 {name=p142072 lab=_79151_/X }
C {devices/lab_pin.sym} 143470 -39930 0 1 {name=p142073 lab=_82427_/D }
C {sky130_stdcells/dfxtp_4.sym} 143380 -39920 0 0 {name=X_82459_ }
C {devices/lab_pin.sym} 143320 -39800 0 0 {name=p142074 lab=_74986_/X }
C {devices/lab_pin.sym} 143320 -39760 0 0 {name=p142075 lab=_74994_/X }
C {devices/lab_pin.sym} 143440 -39780 0 1 {name=p142076 lab=_75000_/X }
C {sky130_stdcells/and2_4.sym} 143380 -39780 0 0 {name=X_75000_ }
C {devices/lab_pin.sym} 143300 -39670 0 0 {name=p142077 lab=_72208_/Y }
C {devices/lab_pin.sym} 143300 -39630 0 0 {name=p142078 lab=_72211_/Y }
C {devices/lab_pin.sym} 143300 -39590 0 0 {name=p142079 lab=_72201_/X }
C {devices/lab_pin.sym} 143460 -39630 0 1 {name=p142080 lab=_72212_/X }
C {sky130_stdcells/a21o_4.sym} 143380 -39630 0 0 {name=X_72212_ }
C {devices/lab_pin.sym} 143300 -39510 0 0 {name=p142081 lab=_45152_/X }
C {devices/lab_pin.sym} 143300 -39470 0 0 {name=p142082 lab=_45157_/Y }
C {devices/lab_pin.sym} 143300 -39430 0 0 {name=p142083 lab=_45159_/Y }
C {devices/lab_pin.sym} 143460 -39470 0 1 {name=p142084 lab=_45160_/Y }
C {sky130_stdcells/a21oi_4.sym} 143380 -39470 0 0 {name=X_45160_ }
C {devices/lab_pin.sym} 143320 -39350 0 0 {name=p142085 lab=_57416_/A }
C {devices/lab_pin.sym} 143320 -39310 0 0 {name=p142086 lab=_57158_/C }
C {devices/lab_pin.sym} 143320 -39270 0 0 {name=p142087 lab=_57416_/C }
C {devices/lab_pin.sym} 143440 -39310 0 1 {name=p142088 lab=_57146_/Y }
C {sky130_stdcells/nand3_4.sym} 143380 -39310 0 0 {name=X_57146_ }
C {devices/lab_pin.sym} 143340 -39170 0 0 {name=p142089 lab=_42371_/Y }
C {devices/lab_pin.sym} 143420 -39170 0 1 {name=p142090 lab=_87896_/D }
C {sky130_stdcells/inv_2.sym} 143380 -39170 0 0 {name=X_42372_ }
C {devices/lab_pin.sym} 143320 -39080 0 0 {name=p142091 lab=_54362_/A }
C {devices/lab_pin.sym} 143320 -39040 0 0 {name=p142092 lab=_54362_/B }
C {devices/lab_pin.sym} 143320 -39000 0 0 {name=p142093 lab=_54362_/C }
C {devices/lab_pin.sym} 143320 -38960 0 0 {name=p142094 lab=_46774_/Y }
C {devices/lab_pin.sym} 143440 -39020 0 1 {name=p142095 lab=_54358_/X }
C {sky130_stdcells/and4_4.sym} 143380 -39020 0 0 {name=X_54358_ }
C {devices/lab_pin.sym} 143300 -38890 0 0 {name=p142096 lab=_83161_/Q }
C {devices/lab_pin.sym} 143300 -38850 0 0 {name=p142097 lab=_73079_/X }
C {devices/lab_pin.sym} 143300 -38810 0 0 {name=p142098 lab=_73191_/X }
C {devices/lab_pin.sym} 143460 -38850 0 1 {name=p142099 lab=_73192_/X }
C {sky130_stdcells/a21o_4.sym} 143380 -38850 0 0 {name=X_73192_ }
C {devices/lab_pin.sym} 143290 -38710 0 0 {name=p142100 lab=_85241_/CLK }
C {devices/lab_pin.sym} 143290 -38690 0 0 {name=p142101 lab=_56486_/Y }
C {devices/lab_pin.sym} 143470 -38710 0 1 {name=p142102 lab=_85178_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -38700 0 0 {name=X_85178_ }
C {devices/lab_pin.sym} 143340 -38570 0 0 {name=p142103 lab=_44110_/X }
C {devices/lab_pin.sym} 143420 -38570 0 1 {name=p142104 lab=_44111_/X }
C {sky130_stdcells/buf_2.sym} 143380 -38570 0 0 {name=X_44111_ }
C {devices/lab_pin.sym} 143320 -38460 0 0 {name=p142105 lab=_53298_/A }
C {devices/lab_pin.sym} 143320 -38420 0 0 {name=p142106 lab=_53309_/B }
C {devices/lab_pin.sym} 143440 -38440 0 1 {name=p142107 lab=_53309_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -38440 0 0 {name=X_53309_ }
C {devices/lab_pin.sym} 143340 -38310 0 0 {name=p142108 lab=_41322_/Y }
C {devices/lab_pin.sym} 143420 -38310 0 1 {name=p142109 lab=_41323_/Y }
C {sky130_stdcells/inv_2.sym} 143380 -38310 0 0 {name=X_41323_ }
C {devices/lab_pin.sym} 143340 -38190 0 0 {name=p142110 lab=_57759_/X }
C {devices/lab_pin.sym} 143420 -38190 0 1 {name=p142111 lab=_72143_/X }
C {sky130_stdcells/buf_2.sym} 143380 -38190 0 0 {name=X_72143_ }
C {devices/lab_pin.sym} 143290 -38070 0 0 {name=p142112 lab=_85346_/CLK }
C {devices/lab_pin.sym} 143290 -38050 0 0 {name=p142113 lab=_84129_/D }
C {devices/lab_pin.sym} 143470 -38070 0 1 {name=p142114 lab=_84129_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -38060 0 0 {name=X_84129_ }
C {devices/lab_pin.sym} 143300 -37950 0 0 {name=p142115 lab=_56407_/C }
C {devices/lab_pin.sym} 143300 -37910 0 0 {name=p142116 lab=_45027_/X }
C {devices/lab_pin.sym} 143300 -37870 0 0 {name=p142117 lab=_45090_/X }
C {devices/lab_pin.sym} 143460 -37910 0 1 {name=p142118 lab=_45091_/Y }
C {sky130_stdcells/o21ai_4.sym} 143380 -37910 0 0 {name=X_45091_ }
C {devices/lab_pin.sym} 143320 -37780 0 0 {name=p142119 lab=_56903_/X }
C {devices/lab_pin.sym} 143320 -37740 0 0 {name=p142120 lab=_57075_/Y }
C {devices/lab_pin.sym} 143440 -37760 0 1 {name=p142121 lab=_57077_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -37760 0 0 {name=X_57077_ }
C {devices/lab_pin.sym} 143300 -37650 0 0 {name=p142122 lab=_85469_/Q }
C {devices/lab_pin.sym} 143300 -37610 0 0 {name=p142123 lab=_54266_/X }
C {devices/lab_pin.sym} 143300 -37570 0 0 {name=p142124 lab=_54288_/Y }
C {devices/lab_pin.sym} 143460 -37610 0 1 {name=p142125 lab=_54289_/Y }
C {sky130_stdcells/o21ai_4.sym} 143380 -37610 0 0 {name=X_54289_ }
C {devices/lab_pin.sym} 143340 -37470 0 0 {name=p142126 lab=_80665_/Q }
C {devices/lab_pin.sym} 143420 -37470 0 1 {name=p142127 lab=_55133_/A }
C {sky130_stdcells/inv_2.sym} 143380 -37470 0 0 {name=X_44042_ }
C {devices/lab_pin.sym} 143300 -37370 0 0 {name=p142128 lab=_55688_/X }
C {devices/lab_pin.sym} 143300 -37330 0 0 {name=p142129 lab=_56026_/X }
C {devices/lab_pin.sym} 143300 -37290 0 0 {name=p142130 lab=_56027_/Y }
C {devices/lab_pin.sym} 143460 -37330 0 1 {name=p142131 lab=_85309_/D }
C {sky130_stdcells/o21ai_4.sym} 143380 -37330 0 0 {name=X_56028_ }
C {devices/lab_pin.sym} 143300 -37220 0 0 {name=p142132 lab=_41250_/X }
C {devices/lab_pin.sym} 143300 -37180 0 0 {name=p142133 lab=_41251_/X }
C {devices/lab_pin.sym} 143300 -37140 0 0 {name=p142134 lab=_68984_/B }
C {devices/lab_pin.sym} 143300 -37100 0 0 {name=p142135 lab=_41253_/X }
C {devices/lab_pin.sym} 143460 -37160 0 1 {name=p142136 lab=_88250_/D }
C {sky130_stdcells/a2bb2o_4.sym} 143380 -37160 0 0 {name=X_41254_ }
C {devices/lab_pin.sym} 143340 -37010 0 0 {name=p142137 lab=_71993_/A }
C {devices/lab_pin.sym} 143420 -37010 0 1 {name=p142138 lab=_72075_/A }
C {sky130_stdcells/buf_2.sym} 143380 -37010 0 0 {name=X_72074_ }
C {devices/lab_pin.sym} 143340 -36890 0 0 {name=p142139 lab=_76951_/A }
C {devices/lab_pin.sym} 143420 -36890 0 1 {name=p142140 lab=_76952_/B }
C {sky130_stdcells/inv_2.sym} 143380 -36890 0 0 {name=X_76951_ }
C {devices/lab_pin.sym} 143340 -36770 0 0 {name=p142141 lab=_70773_/A }
C {devices/lab_pin.sym} 143420 -36770 0 1 {name=p142142 lab=_71026_/A }
C {sky130_stdcells/buf_2.sym} 143380 -36770 0 0 {name=X_71025_ }
C {devices/lab_pin.sym} 143320 -36660 0 0 {name=p142143 lab=_75902_/A }
C {devices/lab_pin.sym} 143320 -36620 0 0 {name=p142144 lab=_84372_/Q }
C {devices/lab_pin.sym} 143440 -36640 0 1 {name=p142145 lab=_75902_/X }
C {sky130_stdcells/xor2_4.sym} 143380 -36640 0 0 {name=X_75902_ }
C {devices/lab_pin.sym} 143300 -36530 0 0 {name=p142146 lab=_48848_/Y }
C {devices/lab_pin.sym} 143300 -36490 0 0 {name=p142147 lab=_48840_/X }
C {devices/lab_pin.sym} 143300 -36450 0 0 {name=p142148 lab=_48849_/X }
C {devices/lab_pin.sym} 143460 -36490 0 1 {name=p142149 lab=_48850_/Y }
C {sky130_stdcells/a21oi_4.sym} 143380 -36490 0 0 {name=X_48850_ }
C {devices/lab_pin.sym} 143320 -36360 0 0 {name=p142150 lab=_84213_/Q }
C {devices/lab_pin.sym} 143320 -36320 0 0 {name=p142151 lab=_72357_/A }
C {devices/lab_pin.sym} 143440 -36340 0 1 {name=p142152 lab=_79670_/X }
C {sky130_stdcells/xor2_4.sym} 143380 -36340 0 0 {name=X_79670_ }
C {devices/lab_pin.sym} 143340 -36210 0 0 {name=p142153 lab=_40947_/A }
C {devices/lab_pin.sym} 143420 -36210 0 1 {name=p142154 lab=_41186_/A }
C {sky130_stdcells/buf_2.sym} 143380 -36210 0 0 {name=X_41185_ }
C {devices/lab_pin.sym} 143320 -36110 0 0 {name=p142155 lab=_76881_/C }
C {devices/lab_pin.sym} 143320 -36070 0 0 {name=p142156 lab=_81498_/Q }
C {devices/lab_pin.sym} 143320 -36030 0 0 {name=p142157 lab=_81370_/D }
C {devices/lab_pin.sym} 143440 -36070 0 1 {name=p142158 lab=_76882_/Y }
C {sky130_stdcells/nand3_4.sym} 143380 -36070 0 0 {name=X_76882_ }
C {devices/lab_pin.sym} 143340 -35930 0 0 {name=p142159 lab=_47661_/A }
C {devices/lab_pin.sym} 143420 -35930 0 1 {name=p142160 lab=_50886_/C }
C {sky130_stdcells/buf_2.sym} 143380 -35930 0 0 {name=X_47801_ }
C {devices/lab_pin.sym} 143340 -35810 0 0 {name=p142161 lab=_78621_/A }
C {devices/lab_pin.sym} 143420 -35810 0 1 {name=p142162 lab=_78621_/Y }
C {sky130_stdcells/inv_2.sym} 143380 -35810 0 0 {name=X_78621_ }
C {devices/lab_pin.sym} 143300 -35710 0 0 {name=p142163 lab=_75815_/A }
C {devices/lab_pin.sym} 143300 -35670 0 0 {name=p142164 lab=_75820_/A }
C {devices/lab_pin.sym} 143300 -35630 0 0 {name=p142165 lab=_75821_/A }
C {devices/lab_pin.sym} 143460 -35670 0 1 {name=p142166 lab=_75833_/Y }
C {sky130_stdcells/a21oi_4.sym} 143380 -35670 0 0 {name=X_75833_ }
C {devices/lab_pin.sym} 143290 -35530 0 0 {name=p142167 lab=_87821_/CLK }
C {devices/lab_pin.sym} 143290 -35510 0 0 {name=p142168 lab=_87819_/D }
C {devices/lab_pin.sym} 143470 -35530 0 1 {name=p142169 lab=_87819_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -35520 0 0 {name=X_87819_ }
C {devices/lab_pin.sym} 143340 -35390 0 0 {name=p142170 lab=_48781_/A }
C {devices/lab_pin.sym} 143420 -35390 0 1 {name=p142171 lab=_48781_/X }
C {sky130_stdcells/buf_2.sym} 143380 -35390 0 0 {name=X_48781_ }
C {devices/lab_pin.sym} 143340 -35270 0 0 {name=p142172 lab=_45992_/Y }
C {devices/lab_pin.sym} 143420 -35270 0 1 {name=p142173 lab=_86824_/D }
C {sky130_stdcells/inv_2.sym} 143380 -35270 0 0 {name=X_45993_ }
C {devices/lab_pin.sym} 143300 -35180 0 0 {name=p142174 lab=_84935_/Q }
C {devices/lab_pin.sym} 143300 -35140 0 0 {name=p142175 lab=_57896_/X }
C {devices/lab_pin.sym} 143300 -35100 0 0 {name=p142176 lab=_57973_/X }
C {devices/lab_pin.sym} 143300 -35060 0 0 {name=p142177 lab=_57978_/X }
C {devices/lab_pin.sym} 143460 -35120 0 1 {name=p142178 lab=_84935_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 143380 -35120 0 0 {name=X_57979_ }
C {devices/lab_pin.sym} 143300 -34990 0 0 {name=p142179 lab=_47728_/Y }
C {devices/lab_pin.sym} 143300 -34950 0 0 {name=p142180 lab=_47698_/X }
C {devices/lab_pin.sym} 143300 -34910 0 0 {name=p142181 lab=_47731_/X }
C {devices/lab_pin.sym} 143460 -34950 0 1 {name=p142182 lab=_86604_/D }
C {sky130_stdcells/a21oi_4.sym} 143380 -34950 0 0 {name=X_47732_ }
C {devices/lab_pin.sym} 143320 -34830 0 0 {name=p142183 lab=_59696_/A }
C {devices/lab_pin.sym} 143320 -34790 0 0 {name=p142184 lab=_59711_/B }
C {devices/lab_pin.sym} 143320 -34750 0 0 {name=p142185 lab=_80568_/A }
C {devices/lab_pin.sym} 143440 -34790 0 1 {name=p142186 lab=_59718_/Y }
C {sky130_stdcells/nor3_4.sym} 143380 -34790 0 0 {name=X_59718_ }
C {devices/lab_pin.sym} 143340 -34650 0 0 {name=p142187 lab=_78552_/A }
C {devices/lab_pin.sym} 143420 -34650 0 1 {name=p142188 lab=_78552_/Y }
C {sky130_stdcells/inv_2.sym} 143380 -34650 0 0 {name=X_78552_ }
C {devices/lab_pin.sym} 143300 -34550 0 0 {name=p142189 lab=_85278_/Q }
C {devices/lab_pin.sym} 143300 -34510 0 0 {name=p142190 lab=_44911_/X }
C {devices/lab_pin.sym} 143300 -34470 0 0 {name=p142191 lab=_44943_/X }
C {devices/lab_pin.sym} 143460 -34510 0 1 {name=p142192 lab=_44944_/Y }
C {sky130_stdcells/o21ai_4.sym} 143380 -34510 0 0 {name=X_44944_ }
C {devices/lab_pin.sym} 143320 -34380 0 0 {name=p142193 lab=_75751_/A }
C {devices/lab_pin.sym} 143320 -34340 0 0 {name=p142194 lab=_75750_/Y }
C {devices/lab_pin.sym} 143440 -34360 0 1 {name=p142195 lab=_75764_/Y }
C {sky130_stdcells/nor2_4.sym} 143380 -34360 0 0 {name=X_75764_ }
C {devices/lab_pin.sym} 143320 -34250 0 0 {name=p142196 lab=_60969_/X }
C {devices/lab_pin.sym} 143320 -34210 0 0 {name=p142197 lab=_60835_/X }
C {devices/lab_pin.sym} 143320 -34170 0 0 {name=p142198 lab=_84544_/Q }
C {devices/lab_pin.sym} 143440 -34210 0 1 {name=p142199 lab=_60990_/X }
C {sky130_stdcells/or3_4.sym} 143380 -34210 0 0 {name=X_60990_ }
C {devices/lab_pin.sym} 143320 -34080 0 0 {name=p142200 lab=_87819_/Q }
C {devices/lab_pin.sym} 143320 -34040 0 0 {name=p142201 lab=_72894_/X }
C {devices/lab_pin.sym} 143440 -34060 0 1 {name=p142202 lab=_72976_/Y }
C {sky130_stdcells/nor2_4.sym} 143380 -34060 0 0 {name=X_72976_ }
C {devices/lab_pin.sym} 143320 -33940 0 0 {name=p142203 lab=_81940_/Q }
C {devices/lab_pin.sym} 143320 -33900 0 0 {name=p142204 lab=_82196_/D }
C {devices/lab_pin.sym} 143440 -33920 0 1 {name=p142205 lab=_81908_/D }
C {sky130_stdcells/xor2_4.sym} 143380 -33920 0 0 {name=X_77503_ }
C {devices/lab_pin.sym} 143340 -33790 0 0 {name=p142206 lab=MACRO_RD_SELECT }
C {devices/lab_pin.sym} 143420 -33790 0 1 {name=p142207 lab=_74715_/Y }
C {sky130_stdcells/inv_2.sym} 143380 -33790 0 0 {name=X_74715_ }
C {devices/lab_pin.sym} 143340 -33670 0 0 {name=p142208 lab=clkbuf_8_55_0_CLK/A }
C {devices/lab_pin.sym} 143420 -33670 0 1 {name=p142209 lab=clkbuf_8_54_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 143380 -33670 0 0 {name=Xclkbuf_8_54_0_CLK }
C {devices/lab_pin.sym} 143340 -33550 0 0 {name=p142210 lab=_47663_/A }
C {devices/lab_pin.sym} 143420 -33550 0 1 {name=p142211 lab=_53177_/D }
C {sky130_stdcells/buf_2.sym} 143380 -33550 0 0 {name=X_47663_ }
C {devices/lab_pin.sym} 143300 -33450 0 0 {name=p142212 lab=_56721_/A }
C {devices/lab_pin.sym} 143300 -33410 0 0 {name=p142213 lab=_71917_/X }
C {devices/lab_pin.sym} 143300 -33370 0 0 {name=p142214 lab=_71926_/Y }
C {devices/lab_pin.sym} 143460 -33410 0 1 {name=p142215 lab=_83326_/D }
C {sky130_stdcells/o21ai_4.sym} 143380 -33410 0 0 {name=X_71927_ }
C {devices/lab_pin.sym} 143320 -33290 0 0 {name=p142216 lab=_59649_/A }
C {devices/lab_pin.sym} 143320 -33250 0 0 {name=p142217 lab=_59628_/A }
C {devices/lab_pin.sym} 143320 -33210 0 0 {name=p142218 lab=_59743_/B }
C {devices/lab_pin.sym} 143440 -33250 0 1 {name=p142219 lab=_59649_/Y }
C {sky130_stdcells/nor3_4.sym} 143380 -33250 0 0 {name=X_59649_ }
C {devices/lab_pin.sym} 143320 -33120 0 0 {name=p142220 lab=_82510_/Q }
C {devices/lab_pin.sym} 143320 -33080 0 0 {name=p142221 lab=_82766_/D }
C {devices/lab_pin.sym} 143440 -33100 0 1 {name=p142222 lab=_78483_/X }
C {sky130_stdcells/xor2_4.sym} 143380 -33100 0 0 {name=X_78483_ }
C {devices/lab_pin.sym} 143340 -32970 0 0 {name=p142223 lab=_80671_/Q }
C {devices/lab_pin.sym} 143420 -32970 0 1 {name=p142224 lab=_44875_/X }
C {sky130_stdcells/buf_2.sym} 143380 -32970 0 0 {name=X_44875_ }
C {devices/lab_pin.sym} 143320 -32860 0 0 {name=p142225 lab=_81120_/Q }
C {devices/lab_pin.sym} 143320 -32820 0 0 {name=p142226 lab=_75695_/B }
C {devices/lab_pin.sym} 143440 -32840 0 1 {name=p142227 lab=_75695_/Y }
C {sky130_stdcells/xnor2_4.sym} 143380 -32840 0 0 {name=X_75695_ }
C {devices/lab_pin.sym} 143300 -32730 0 0 {name=p142228 lab=_49400_/Y }
C {devices/lab_pin.sym} 143300 -32690 0 0 {name=p142229 lab=_49378_/X }
C {devices/lab_pin.sym} 143300 -32650 0 0 {name=p142230 lab=_49401_/X }
C {devices/lab_pin.sym} 143460 -32690 0 1 {name=p142231 lab=_86394_/D }
C {sky130_stdcells/a21oi_4.sym} 143380 -32690 0 0 {name=X_49402_ }
C {devices/lab_pin.sym} 143340 -32550 0 0 {name=p142232 lab=_46892_/A }
C {devices/lab_pin.sym} 143420 -32550 0 1 {name=p142233 lab=_46614_/X }
C {sky130_stdcells/buf_2.sym} 143380 -32550 0 0 {name=X_46614_ }
C {devices/lab_pin.sym} 143320 -32440 0 0 {name=p142234 lab=_77416_/X }
C {devices/lab_pin.sym} 143320 -32400 0 0 {name=p142235 lab=_77434_/B }
C {devices/lab_pin.sym} 143440 -32420 0 1 {name=p142236 lab=_77434_/Y }
C {sky130_stdcells/nor2_4.sym} 143380 -32420 0 0 {name=X_77434_ }
C {devices/lab_pin.sym} 143340 -32290 0 0 {name=p142237 lab=_43826_/A }
C {devices/lab_pin.sym} 143420 -32290 0 1 {name=p142238 lab=_87249_/D }
C {sky130_stdcells/inv_2.sym} 143380 -32290 0 0 {name=X_43826_ }
C {devices/lab_pin.sym} 143340 -32170 0 0 {name=p142239 lab=_62886_/A }
C {devices/lab_pin.sym} 143420 -32170 0 1 {name=p142240 lab=_62660_/X }
C {sky130_stdcells/buf_2.sym} 143380 -32170 0 0 {name=X_62660_ }
C {devices/lab_pin.sym} 143300 -32080 0 0 {name=p142241 lab=_74638_/X }
C {devices/lab_pin.sym} 143300 -32040 0 0 {name=p142242 lab=_56607_/A }
C {devices/lab_pin.sym} 143300 -32000 0 0 {name=p142243 lab=_83002_/Q }
C {devices/lab_pin.sym} 143300 -31960 0 0 {name=p142244 lab=_74645_/X }
C {devices/lab_pin.sym} 143460 -32020 0 1 {name=p142245 lab=_83002_/D }
C {sky130_stdcells/a2bb2o_4.sym} 143380 -32020 0 0 {name=X_74646_ }
C {devices/lab_pin.sym} 143340 -31870 0 0 {name=p142246 lab=_47594_/A }
C {devices/lab_pin.sym} 143420 -31870 0 1 {name=p142247 lab=_53139_/D }
C {sky130_stdcells/buf_2.sym} 143380 -31870 0 0 {name=X_47594_ }
C {devices/lab_pin.sym} 143300 -31770 0 0 {name=p142248 lab=_71848_/X }
C {devices/lab_pin.sym} 143300 -31730 0 0 {name=p142249 lab=_83351_/Q }
C {devices/lab_pin.sym} 143300 -31690 0 0 {name=p142250 lab=_71857_/Y }
C {devices/lab_pin.sym} 143460 -31730 0 1 {name=p142251 lab=_83351_/D }
C {sky130_stdcells/a21o_4.sym} 143380 -31730 0 0 {name=X_71858_ }
C {devices/lab_pin.sym} 143300 -31610 0 0 {name=p142252 lab=_49331_/Y }
C {devices/lab_pin.sym} 143300 -31570 0 0 {name=p142253 lab=_49326_/X }
C {devices/lab_pin.sym} 143300 -31530 0 0 {name=p142254 lab=_49332_/Y }
C {devices/lab_pin.sym} 143460 -31570 0 1 {name=p142255 lab=_49333_/Y }
C {sky130_stdcells/a21boi_4.sym} 143380 -31570 0 0 {name=X_49333_ }
C {devices/lab_pin.sym} 143320 -31460 0 0 {name=p142256 lab=_61611_/A }
C {devices/lab_pin.sym} 143320 -31420 0 0 {name=p142257 lab=_61611_/B }
C {devices/lab_pin.sym} 143320 -31380 0 0 {name=p142258 lab=_61611_/C }
C {devices/lab_pin.sym} 143320 -31340 0 0 {name=p142259 lab=_61572_/D }
C {devices/lab_pin.sym} 143440 -31400 0 1 {name=p142260 lab=_61611_/Y }
C {sky130_stdcells/nand4_4.sym} 143380 -31400 0 0 {name=X_61611_ }
C {devices/lab_pin.sym} 143340 -31250 0 0 {name=p142261 lab=_46545_/A }
C {devices/lab_pin.sym} 143420 -31250 0 1 {name=p142262 lab=_54069_/B }
C {sky130_stdcells/inv_2.sym} 143380 -31250 0 0 {name=X_46545_ }
C {devices/lab_pin.sym} 143340 -31130 0 0 {name=p142263 lab=_70809_/A }
C {devices/lab_pin.sym} 143420 -31130 0 1 {name=p142264 lab=_70942_/B }
C {sky130_stdcells/buf_2.sym} 143380 -31130 0 0 {name=X_70809_ }
C {devices/lab_pin.sym} 143320 -31020 0 0 {name=p142265 lab=_81931_/Q }
C {devices/lab_pin.sym} 143320 -30980 0 0 {name=p142266 lab=_82187_/D }
C {devices/lab_pin.sym} 143440 -31000 0 1 {name=p142267 lab=_81899_/D }
C {sky130_stdcells/xor2_4.sym} 143380 -31000 0 0 {name=X_77365_ }
C {devices/lab_pin.sym} 143300 -30910 0 0 {name=p142268 lab=_43005_/X }
C {devices/lab_pin.sym} 143300 -30870 0 0 {name=p142269 lab=_43563_/X }
C {devices/lab_pin.sym} 143300 -30830 0 0 {name=p142270 lab=_40950_/X }
C {devices/lab_pin.sym} 143300 -30790 0 0 {name=p142271 lab=_69165_/B }
C {devices/lab_pin.sym} 143300 -30750 0 0 {name=p142272 lab=_43756_/X }
C {devices/lab_pin.sym} 143460 -30830 0 1 {name=p142273 lab=_43757_/Y }
C {sky130_stdcells/o32ai_4.sym} 143380 -30830 0 0 {name=X_43757_ }
C {devices/lab_pin.sym} 143300 -30710 0 0 {name=p142274 lab=_61649_/B }
C {devices/lab_pin.sym} 143300 -30670 0 0 {name=p142275 lab=_62548_/C }
C {devices/lab_pin.sym} 143300 -30630 0 0 {name=p142276 lab=_62507_/X }
C {devices/lab_pin.sym} 143300 -30590 0 0 {name=p142277 lab=_62548_/B }
C {devices/lab_pin.sym} 143300 -30560 0 0 {name=p142278 lab=_62590_/X }
C {devices/lab_pin.sym} 143460 -30630 0 1 {name=p142279 lab=_62591_/X }
C {sky130_stdcells/a41o_4.sym} 143380 -30630 0 0 {name=X_62591_ }
C {devices/lab_pin.sym} 143300 -30490 0 0 {name=p142280 lab=_45095_/A }
C {devices/lab_pin.sym} 143300 -30450 0 0 {name=p142281 lab=_74568_/X }
C {devices/lab_pin.sym} 143300 -30410 0 0 {name=p142282 lab=_74576_/X }
C {devices/lab_pin.sym} 143460 -30450 0 1 {name=p142283 lab=_83029_/D }
C {sky130_stdcells/o21ai_4.sym} 143380 -30450 0 0 {name=X_74577_ }
C {devices/lab_pin.sym} 143300 -30340 0 0 {name=p142284 lab=_40968_/X }
C {devices/lab_pin.sym} 143300 -30300 0 0 {name=p142285 lab=_40941_/X }
C {devices/lab_pin.sym} 143300 -30260 0 0 {name=p142286 lab=_69224_/B }
C {devices/lab_pin.sym} 143300 -30220 0 0 {name=p142287 lab=_40942_/X }
C {devices/lab_pin.sym} 143460 -30280 0 1 {name=p142288 lab=_40969_/X }
C {sky130_stdcells/a2bb2o_4.sym} 143380 -30280 0 0 {name=X_40969_ }
C {devices/lab_pin.sym} 143300 -30150 0 0 {name=p142289 lab=_58186_/Y }
C {devices/lab_pin.sym} 143300 -30110 0 0 {name=p142290 lab=_71784_/X }
C {devices/lab_pin.sym} 143300 -30070 0 0 {name=p142291 lab=_71788_/Y }
C {devices/lab_pin.sym} 143460 -30110 0 1 {name=p142292 lab=_83376_/D }
C {sky130_stdcells/o21ai_4.sym} 143380 -30110 0 0 {name=X_71789_ }
C {devices/lab_pin.sym} 143320 -29980 0 0 {name=p142293 lab=_79109_/A }
C {devices/lab_pin.sym} 143320 -29940 0 0 {name=p142294 lab=_79109_/B }
C {devices/lab_pin.sym} 143440 -29960 0 1 {name=p142295 lab=_79104_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -29960 0 0 {name=X_79104_ }
C {devices/lab_pin.sym} 143340 -29830 0 0 {name=p142296 lab=clkbuf_8_69_0_CLK/A }
C {devices/lab_pin.sym} 143420 -29830 0 1 {name=p142297 lab=clkbuf_8_69_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 143380 -29830 0 0 {name=Xclkbuf_8_69_0_CLK }
C {devices/lab_pin.sym} 143300 -29730 0 0 {name=p142298 lab=_79784_/B }
C {devices/lab_pin.sym} 143300 -29690 0 0 {name=p142299 lab=_64314_/X }
C {devices/lab_pin.sym} 143300 -29650 0 0 {name=p142300 lab=_64329_/X }
C {devices/lab_pin.sym} 143460 -29690 0 1 {name=p142301 lab=_84256_/D }
C {sky130_stdcells/a21o_4.sym} 143380 -29690 0 0 {name=X_64330_ }
C {devices/lab_pin.sym} 143320 -29560 0 0 {name=p142302 lab=_76316_/A }
C {devices/lab_pin.sym} 143320 -29520 0 0 {name=p142303 lab=_76315_/X }
C {devices/lab_pin.sym} 143440 -29540 0 1 {name=p142304 lab=_76317_/B }
C {sky130_stdcells/xor2_4.sym} 143380 -29540 0 0 {name=X_76316_ }
C {devices/lab_pin.sym} 143300 -29450 0 0 {name=p142305 lab=_42687_/X }
C {devices/lab_pin.sym} 143300 -29410 0 0 {name=p142306 lab=_42688_/X }
C {devices/lab_pin.sym} 143300 -29370 0 0 {name=p142307 lab=_41139_/X }
C {devices/lab_pin.sym} 143300 -29330 0 0 {name=p142308 lab=_87758_/Q }
C {devices/lab_pin.sym} 143300 -29290 0 0 {name=p142309 lab=_42700_/X }
C {devices/lab_pin.sym} 143460 -29370 0 1 {name=p142310 lab=_42709_/A }
C {sky130_stdcells/o32ai_4.sym} 143380 -29370 0 0 {name=X_42708_ }
C {devices/lab_pin.sym} 143320 -29240 0 0 {name=p142311 lab=_61542_/A }
C {devices/lab_pin.sym} 143320 -29200 0 0 {name=p142312 lab=_61542_/B }
C {devices/lab_pin.sym} 143320 -29160 0 0 {name=p142313 lab=_61542_/C }
C {devices/lab_pin.sym} 143320 -29120 0 0 {name=p142314 lab=_61512_/X }
C {devices/lab_pin.sym} 143440 -29180 0 1 {name=p142315 lab=_61542_/Y }
C {sky130_stdcells/nand4_4.sym} 143380 -29180 0 0 {name=X_61542_ }
C {devices/lab_pin.sym} 143300 -29050 0 0 {name=p142316 lab=_49262_/Y }
C {devices/lab_pin.sym} 143300 -29010 0 0 {name=p142317 lab=_49247_/X }
C {devices/lab_pin.sym} 143300 -28970 0 0 {name=p142318 lab=_49263_/Y }
C {devices/lab_pin.sym} 143460 -29010 0 1 {name=p142319 lab=_49264_/Y }
C {sky130_stdcells/a21boi_4.sym} 143380 -29010 0 0 {name=X_49264_ }
C {devices/lab_pin.sym} 143300 -28900 0 0 {name=p142320 lab=_42063_/Y }
C {devices/lab_pin.sym} 143300 -28860 0 0 {name=p142321 lab=_72974_/X }
C {devices/lab_pin.sym} 143300 -28820 0 0 {name=p142322 lab=_73393_/X }
C {devices/lab_pin.sym} 143300 -28780 0 0 {name=p142323 lab=_73527_/Y }
C {devices/lab_pin.sym} 143460 -28840 0 1 {name=p142324 lab=_73528_/X }
C {sky130_stdcells/a211o_4.sym} 143380 -28840 0 0 {name=X_73528_ }
C {devices/lab_pin.sym} 143340 -28690 0 0 {name=p142325 lab=_46476_/A }
C {devices/lab_pin.sym} 143420 -28690 0 1 {name=p142326 lab=_52522_/B }
C {sky130_stdcells/inv_2.sym} 143380 -28690 0 0 {name=X_46476_ }
C {devices/lab_pin.sym} 143320 -28590 0 0 {name=p142327 lab=_77296_/A }
C {devices/lab_pin.sym} 143320 -28550 0 0 {name=p142328 lab=_77312_/A }
C {devices/lab_pin.sym} 143320 -28510 0 0 {name=p142329 lab=_77294_/Y }
C {devices/lab_pin.sym} 143440 -28550 0 1 {name=p142330 lab=_77296_/Y }
C {sky130_stdcells/nand3_4.sym} 143380 -28550 0 0 {name=X_77296_ }
C {devices/lab_pin.sym} 143300 -28440 0 0 {name=p142331 lab=_40798_/X }
C {devices/lab_pin.sym} 143300 -28400 0 0 {name=p142332 lab=_43685_/X }
C {devices/lab_pin.sym} 143300 -28360 0 0 {name=p142333 lab=_72924_/A }
C {devices/lab_pin.sym} 143300 -28320 0 0 {name=p142334 lab=_43686_/X }
C {devices/lab_pin.sym} 143460 -28380 0 1 {name=p142335 lab=_87309_/D }
C {sky130_stdcells/a2bb2o_4.sym} 143380 -28380 0 0 {name=X_43688_ }
C {devices/lab_pin.sym} 143320 -28240 0 0 {name=p142336 lab=_48190_/A }
C {devices/lab_pin.sym} 143320 -28200 0 0 {name=p142337 lab=_50268_/B }
C {devices/lab_pin.sym} 143440 -28220 0 1 {name=p142338 lab=_48215_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -28220 0 0 {name=X_48215_ }
C {devices/lab_pin.sym} 143320 -28100 0 0 {name=p142339 lab=_82747_/Q }
C {devices/lab_pin.sym} 143320 -28060 0 0 {name=p142340 lab=_79035_/B }
C {devices/lab_pin.sym} 143440 -28080 0 1 {name=p142341 lab=_79035_/X }
C {sky130_stdcells/xor2_4.sym} 143380 -28080 0 0 {name=X_79035_ }
C {devices/lab_pin.sym} 143300 -27980 0 0 {name=p142342 lab=_45425_/Y }
C {devices/lab_pin.sym} 143300 -27940 0 0 {name=p142343 lab=_45412_/X }
C {devices/lab_pin.sym} 143300 -27900 0 0 {name=p142344 lab=_45396_/X }
C {devices/lab_pin.sym} 143300 -27860 0 0 {name=p142345 lab=_45426_/Y }
C {devices/lab_pin.sym} 143460 -27920 0 1 {name=p142346 lab=_45427_/X }
C {sky130_stdcells/a211o_4.sym} 143380 -27920 0 0 {name=X_45427_ }
C {devices/lab_pin.sym} 143320 -27790 0 0 {name=p142347 lab=_64275_/A }
C {devices/lab_pin.sym} 143320 -27750 0 0 {name=p142348 lab=_63049_/B }
C {devices/lab_pin.sym} 143320 -27710 0 0 {name=p142349 lab=_64223_/C }
C {devices/lab_pin.sym} 143440 -27750 0 1 {name=p142350 lab=_64261_/X }
C {sky130_stdcells/and3_4.sym} 143380 -27750 0 0 {name=X_64261_ }
C {devices/lab_pin.sym} 143340 -27610 0 0 {name=p142351 lab=_76251_/C }
C {devices/lab_pin.sym} 143420 -27610 0 1 {name=p142352 lab=_76247_/Y }
C {sky130_stdcells/inv_2.sym} 143380 -27610 0 0 {name=X_76247_ }
C {devices/lab_pin.sym} 143340 -27490 0 0 {name=p142353 lab=_42639_/A }
C {devices/lab_pin.sym} 143420 -27490 0 1 {name=p142354 lab=_42639_/Y }
C {sky130_stdcells/inv_2.sym} 143380 -27490 0 0 {name=X_42639_ }
C {devices/lab_pin.sym} 143340 -27370 0 0 {name=p142355 lab=_49195_/A }
C {devices/lab_pin.sym} 143420 -27370 0 1 {name=p142356 lab=_53936_/B }
C {sky130_stdcells/inv_2.sym} 143380 -27370 0 0 {name=X_49195_ }
C {devices/lab_pin.sym} 143300 -27290 0 0 {name=p142357 lab=_61460_/Y }
C {devices/lab_pin.sym} 143300 -27250 0 0 {name=p142358 lab=_61463_/Y }
C {devices/lab_pin.sym} 143300 -27210 0 0 {name=p142359 lab=_61464_/X }
C {devices/lab_pin.sym} 143300 -27170 0 0 {name=p142360 lab=_61468_/Y }
C {devices/lab_pin.sym} 143300 -27140 0 0 {name=p142361 lab=_61472_/Y }
C {devices/lab_pin.sym} 143460 -27210 0 1 {name=p142362 lab=_61473_/X }
C {sky130_stdcells/a41o_4.sym} 143380 -27210 0 0 {name=X_61473_ }
C {devices/lab_pin.sym} 143320 -27060 0 0 {name=p142363 lab=_73445_/Y }
C {devices/lab_pin.sym} 143320 -27020 0 0 {name=p142364 lab=_73458_/X }
C {devices/lab_pin.sym} 143440 -27040 0 1 {name=p142365 lab=_73460_/B }
C {sky130_stdcells/xnor2_4.sym} 143380 -27040 0 0 {name=X_73459_ }
C {devices/lab_pin.sym} 143320 -26930 0 0 {name=p142366 lab=_65523_/X }
C {devices/lab_pin.sym} 143320 -26890 0 0 {name=p142367 lab=_66062_/B }
C {devices/lab_pin.sym} 143320 -26850 0 0 {name=p142368 lab=_65526_/X }
C {devices/lab_pin.sym} 143440 -26890 0 1 {name=p142369 lab=_66000_/Y }
C {sky130_stdcells/nand3_4.sym} 143380 -26890 0 0 {name=X_66000_ }
C {devices/lab_pin.sym} 143300 -26790 0 0 {name=p142370 lab=_58383_/A }
C {devices/lab_pin.sym} 143300 -26750 0 0 {name=p142371 lab=_63190_/X }
C {devices/lab_pin.sym} 143300 -26710 0 0 {name=p142372 lab=_63175_/X }
C {devices/lab_pin.sym} 143300 -26670 0 0 {name=p142373 lab=_58259_/A }
C {devices/lab_pin.sym} 143300 -26630 0 0 {name=p142374 lab=_63176_/X }
C {devices/lab_pin.sym} 143460 -26710 0 1 {name=p142375 lab=_63212_/Y }
C {sky130_stdcells/o32ai_4.sym} 143380 -26710 0 0 {name=X_63212_ }
C {devices/lab_pin.sym} 143320 -26560 0 0 {name=p142376 lab=_48146_/A }
C {devices/lab_pin.sym} 143320 -26520 0 0 {name=p142377 lab=_48136_/B }
C {devices/lab_pin.sym} 143440 -26540 0 1 {name=p142378 lab=_48146_/X }
C {sky130_stdcells/or2_4.sym} 143380 -26540 0 0 {name=X_48146_ }
C {devices/lab_pin.sym} 143300 -26450 0 0 {name=p142379 lab=_60376_/X }
C {devices/lab_pin.sym} 143300 -26410 0 0 {name=p142380 lab=_60399_/Y }
C {devices/lab_pin.sym} 143300 -26370 0 0 {name=p142381 lab=_60414_/Y }
C {devices/lab_pin.sym} 143300 -26330 0 0 {name=p142382 lab=_60532_/A }
C {devices/lab_pin.sym} 143300 -26290 0 0 {name=p142383 lab=_60423_/X }
C {devices/lab_pin.sym} 143460 -26370 0 1 {name=p142384 lab=_60424_/X }
C {sky130_stdcells/o41a_4.sym} 143380 -26370 0 0 {name=X_60424_ }
C {devices/lab_pin.sym} 143300 -26230 0 0 {name=p142385 lab=_55715_/B }
C {devices/lab_pin.sym} 143300 -26190 0 0 {name=p142386 lab=_45357_/X }
C {devices/lab_pin.sym} 143300 -26150 0 0 {name=p142387 lab=_45339_/X }
C {devices/lab_pin.sym} 143460 -26190 0 1 {name=p142388 lab=_45358_/X }
C {sky130_stdcells/o21a_4.sym} 143380 -26190 0 0 {name=X_45358_ }
C {devices/lab_pin.sym} 143320 -26080 0 0 {name=p142389 lab=_62629_/A }
C {devices/lab_pin.sym} 143320 -26040 0 0 {name=p142390 lab=_64192_/B }
C {devices/lab_pin.sym} 143320 -26000 0 0 {name=p142391 lab=_64192_/C }
C {devices/lab_pin.sym} 143320 -25960 0 0 {name=p142392 lab=_64192_/D }
C {devices/lab_pin.sym} 143440 -26020 0 1 {name=p142393 lab=_64193_/D }
C {sky130_stdcells/nand4_4.sym} 143380 -26020 0 0 {name=X_64192_ }
C {devices/lab_pin.sym} 143320 -25880 0 0 {name=p142394 lab=_76161_/Y }
C {devices/lab_pin.sym} 143320 -25840 0 0 {name=p142395 lab=_76159_/Y }
C {devices/lab_pin.sym} 143440 -25860 0 1 {name=p142396 lab=_76178_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -25860 0 0 {name=X_76178_ }
C {devices/lab_pin.sym} 143340 -25730 0 0 {name=p142397 lab=_44308_/X }
C {devices/lab_pin.sym} 143420 -25730 0 1 {name=p142398 lab=_57470_/B }
C {sky130_stdcells/buf_2.sym} 143380 -25730 0 0 {name=X_44309_ }
C {devices/lab_pin.sym} 143340 -25610 0 0 {name=p142399 lab=_75129_/A }
C {devices/lab_pin.sym} 143420 -25610 0 1 {name=p142400 lab=_75129_/Y }
C {sky130_stdcells/inv_2.sym} 143380 -25610 0 0 {name=X_75129_ }
C {devices/lab_pin.sym} 143320 -25520 0 0 {name=p142401 lab=_63097_/A }
C {devices/lab_pin.sym} 143320 -25480 0 0 {name=p142402 lab=_64353_/B }
C {devices/lab_pin.sym} 143320 -25440 0 0 {name=p142403 lab=_63108_/C }
C {devices/lab_pin.sym} 143320 -25400 0 0 {name=p142404 lab=_63121_/D }
C {devices/lab_pin.sym} 143440 -25460 0 1 {name=p142405 lab=_63143_/X }
C {sky130_stdcells/and4_4.sym} 143380 -25460 0 0 {name=X_63143_ }
C {devices/lab_pin.sym} 143320 -25320 0 0 {name=p142406 lab=_48077_/A }
C {devices/lab_pin.sym} 143320 -25280 0 0 {name=p142407 lab=_48086_/B }
C {devices/lab_pin.sym} 143440 -25300 0 1 {name=p142408 lab=_48077_/X }
C {sky130_stdcells/or2_4.sym} 143380 -25300 0 0 {name=X_48077_ }
C {devices/lab_pin.sym} 143320 -25190 0 0 {name=p142409 lab=_59552_/C }
C {devices/lab_pin.sym} 143320 -25150 0 0 {name=p142410 lab=_60407_/C }
C {devices/lab_pin.sym} 143320 -25110 0 0 {name=p142411 lab=_60132_/A }
C {devices/lab_pin.sym} 143440 -25150 0 1 {name=p142412 lab=_60355_/Y }
C {sky130_stdcells/nand3_4.sym} 143380 -25150 0 0 {name=X_60355_ }
C {devices/lab_pin.sym} 143300 -25030 0 0 {name=p142413 lab=_56145_/C }
C {devices/lab_pin.sym} 143300 -24990 0 0 {name=p142414 lab=_45269_/X }
C {devices/lab_pin.sym} 143300 -24950 0 0 {name=p142415 lab=_45229_/X }
C {devices/lab_pin.sym} 143460 -24990 0 1 {name=p142416 lab=_45289_/X }
C {sky130_stdcells/o21a_4.sym} 143380 -24990 0 0 {name=X_45289_ }
C {devices/lab_pin.sym} 143340 -24850 0 0 {name=p142417 lab=_54503_/D }
C {devices/lab_pin.sym} 143420 -24850 0 1 {name=p142418 lab=_52811_/D }
C {sky130_stdcells/buf_2.sym} 143380 -24850 0 0 {name=X_47028_ }
C {devices/lab_pin.sym} 143300 -24770 0 0 {name=p142419 lab=_58424_/Y }
C {devices/lab_pin.sym} 143300 -24730 0 0 {name=p142420 lab=_63073_/X }
C {devices/lab_pin.sym} 143300 -24690 0 0 {name=p142421 lab=_63059_/X }
C {devices/lab_pin.sym} 143300 -24650 0 0 {name=p142422 lab=_59471_/A }
C {devices/lab_pin.sym} 143300 -24610 0 0 {name=p142423 lab=_63060_/X }
C {devices/lab_pin.sym} 143460 -24690 0 1 {name=p142424 lab=_63074_/Y }
C {sky130_stdcells/o32ai_4.sym} 143380 -24690 0 0 {name=X_63074_ }
C {devices/lab_pin.sym} 143320 -24540 0 0 {name=p142425 lab=_67972_/A }
C {devices/lab_pin.sym} 143320 -24500 0 0 {name=p142426 lab=_87705_/Q }
C {devices/lab_pin.sym} 143440 -24520 0 1 {name=p142427 lab=_67951_/X }
C {sky130_stdcells/and2_4.sym} 143380 -24520 0 0 {name=X_67951_ }
C {devices/lab_pin.sym} 143320 -24400 0 0 {name=p142428 lab=_79937_/A }
C {devices/lab_pin.sym} 143320 -24360 0 0 {name=p142429 lab=_79937_/B }
C {devices/lab_pin.sym} 143440 -24380 0 1 {name=p142430 lab=_79937_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -24380 0 0 {name=X_79937_ }
C {devices/lab_pin.sym} 143300 -24270 0 0 {name=p142431 lab=_60273_/X }
C {devices/lab_pin.sym} 143300 -24230 0 0 {name=p142432 lab=_60259_/A }
C {devices/lab_pin.sym} 143300 -24190 0 0 {name=p142433 lab=_60285_/Y }
C {devices/lab_pin.sym} 143460 -24230 0 1 {name=p142434 lab=_60286_/X }
C {sky130_stdcells/a21o_4.sym} 143380 -24230 0 0 {name=X_60286_ }
C {devices/lab_pin.sym} 143340 -24090 0 0 {name=p142435 lab=_68614_/A }
C {devices/lab_pin.sym} 143420 -24090 0 1 {name=p142436 lab=_66902_/X }
C {sky130_stdcells/buf_2.sym} 143380 -24090 0 0 {name=X_66902_ }
C {devices/lab_pin.sym} 143320 -24000 0 0 {name=p142437 lab=_61560_/B }
C {devices/lab_pin.sym} 143320 -23960 0 0 {name=p142438 lab=_62007_/X }
C {devices/lab_pin.sym} 143320 -23920 0 0 {name=p142439 lab=_61967_/C }
C {devices/lab_pin.sym} 143320 -23880 0 0 {name=p142440 lab=_62008_/X }
C {devices/lab_pin.sym} 143440 -23940 0 1 {name=p142441 lab=_62025_/Y }
C {sky130_stdcells/nand4_4.sym} 143380 -23940 0 0 {name=X_62025_ }
C {devices/lab_pin.sym} 143320 -23800 0 0 {name=p142442 lab=_79875_/B }
C {devices/lab_pin.sym} 143320 -23760 0 0 {name=p142443 lab=_79868_/B }
C {devices/lab_pin.sym} 143440 -23780 0 1 {name=p142444 lab=_79868_/X }
C {sky130_stdcells/xor2_4.sym} 143380 -23780 0 0 {name=X_79868_ }
C {devices/lab_pin.sym} 143320 -23660 0 0 {name=p142445 lab=_67955_/A }
C {devices/lab_pin.sym} 143320 -23620 0 0 {name=p142446 lab=_86920_/Q }
C {devices/lab_pin.sym} 143440 -23640 0 1 {name=p142447 lab=_67882_/X }
C {sky130_stdcells/and2_4.sym} 143380 -23640 0 0 {name=X_67882_ }
C {devices/lab_pin.sym} 143340 -23510 0 0 {name=p142448 lab=_57803_/A }
C {devices/lab_pin.sym} 143420 -23510 0 1 {name=p142449 lab=_69908_/A }
C {sky130_stdcells/buf_2.sym} 143380 -23510 0 0 {name=X_69621_ }
C {devices/lab_pin.sym} 143340 -23390 0 0 {name=p142450 lab=_69457_/A }
C {devices/lab_pin.sym} 143420 -23390 0 1 {name=p142451 lab=_66833_/X }
C {sky130_stdcells/buf_2.sym} 143380 -23390 0 0 {name=X_66833_ }
C {devices/lab_pin.sym} 143320 -23280 0 0 {name=p142452 lab=_78817_/Y }
C {devices/lab_pin.sym} 143320 -23240 0 0 {name=p142453 lab=_78818_/Y }
C {devices/lab_pin.sym} 143440 -23260 0 1 {name=p142454 lab=_78820_/B }
C {sky130_stdcells/nand2_4.sym} 143380 -23260 0 0 {name=X_78819_ }
C {devices/lab_pin.sym} 143320 -23150 0 0 {name=p142455 lab=_48979_/A }
C {devices/lab_pin.sym} 143320 -23110 0 0 {name=p142456 lab=_48940_/B }
C {devices/lab_pin.sym} 143320 -23070 0 0 {name=p142457 lab=_48928_/C }
C {devices/lab_pin.sym} 143440 -23110 0 1 {name=p142458 lab=_48979_/X }
C {sky130_stdcells/and3_4.sym} 143380 -23110 0 0 {name=X_48979_ }
C {devices/lab_pin.sym} 143320 -22980 0 0 {name=p142459 lab=_79795_/X }
C {devices/lab_pin.sym} 143320 -22940 0 0 {name=p142460 lab=_79798_/Y }
C {devices/lab_pin.sym} 143440 -22960 0 1 {name=p142461 lab=_79799_/X }
C {sky130_stdcells/xor2_4.sym} 143380 -22960 0 0 {name=X_79799_ }
C {devices/lab_pin.sym} 143300 -22850 0 0 {name=p142462 lab=_83915_/Q }
C {devices/lab_pin.sym} 143300 -22810 0 0 {name=p142463 lab=_69504_/X }
C {devices/lab_pin.sym} 143300 -22770 0 0 {name=p142464 lab=_69551_/X }
C {devices/lab_pin.sym} 143460 -22810 0 1 {name=p142465 lab=_69552_/X }
C {sky130_stdcells/a21bo_4.sym} 143380 -22810 0 0 {name=X_69552_ }
C {devices/lab_pin.sym} 143290 -22670 0 0 {name=p142466 lab=_82211_/CLK }
C {devices/lab_pin.sym} 143290 -22650 0 0 {name=p142467 lab=_81862_/Q }
C {devices/lab_pin.sym} 143470 -22670 0 1 {name=p142468 lab=_77279_/A }
C {sky130_stdcells/dfxtp_4.sym} 143380 -22660 0 0 {name=X_81830_ }
C {devices/lab_pin.sym} 143340 -22530 0 0 {name=p142469 lab=_66879_/A }
C {devices/lab_pin.sym} 143420 -22530 0 1 {name=p142470 lab=_66764_/X }
C {sky130_stdcells/buf_2.sym} 143380 -22530 0 0 {name=X_66764_ }
C {devices/lab_pin.sym} 143320 -22420 0 0 {name=p142471 lab=_51961_/X }
C {devices/lab_pin.sym} 143320 -22380 0 0 {name=p142472 lab=_48236_/B }
C {devices/lab_pin.sym} 143440 -22400 0 1 {name=p142473 lab=_51990_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -22400 0 0 {name=X_51990_ }
C {devices/lab_pin.sym} 143320 -22290 0 0 {name=p142474 lab=_63960_/A }
C {devices/lab_pin.sym} 143320 -22250 0 0 {name=p142475 lab=_63960_/B }
C {devices/lab_pin.sym} 143320 -22210 0 0 {name=p142476 lab=_80102_/B }
C {devices/lab_pin.sym} 143440 -22250 0 1 {name=p142477 lab=_63976_/Y }
C {sky130_stdcells/nor3_4.sym} 143380 -22250 0 0 {name=X_63976_ }
C {devices/lab_pin.sym} 143300 -22140 0 0 {name=p142478 lab=_88014_/Q }
C {devices/lab_pin.sym} 143300 -22100 0 0 {name=p142479 lab=_68402_/X }
C {devices/lab_pin.sym} 143300 -22060 0 0 {name=p142480 lab=_68501_/X }
C {devices/lab_pin.sym} 143300 -22020 0 0 {name=p142481 lab=_68502_/X }
C {devices/lab_pin.sym} 143460 -22080 0 1 {name=p142482 lab=_68503_/X }
C {sky130_stdcells/a211o_4.sym} 143380 -22080 0 0 {name=X_68503_ }
C {devices/lab_pin.sym} 143320 -21940 0 0 {name=p142483 lab=_65777_/A }
C {devices/lab_pin.sym} 143320 -21900 0 0 {name=p142484 lab=_85870_/Q }
C {devices/lab_pin.sym} 143440 -21920 0 1 {name=p142485 lab=_65715_/X }
C {sky130_stdcells/and2_4.sym} 143380 -21920 0 0 {name=X_65715_ }
C {devices/lab_pin.sym} 143320 -21820 0 0 {name=p142486 lab=_50941_/A }
C {devices/lab_pin.sym} 143320 -21780 0 0 {name=p142487 lab=_50941_/B }
C {devices/lab_pin.sym} 143320 -21740 0 0 {name=p142488 lab=_50948_/C }
C {devices/lab_pin.sym} 143320 -21700 0 0 {name=p142489 lab=_46716_/X }
C {devices/lab_pin.sym} 143440 -21760 0 1 {name=p142490 lab=_50941_/X }
C {sky130_stdcells/and4_4.sym} 143380 -21760 0 0 {name=X_50941_ }
C {devices/lab_pin.sym} 143320 -21630 0 0 {name=p142491 lab=_62927_/A }
C {devices/lab_pin.sym} 143320 -21590 0 0 {name=p142492 lab=_62926_/B }
C {devices/lab_pin.sym} 143320 -21550 0 0 {name=p142493 lab=_84785_/Q }
C {devices/lab_pin.sym} 143440 -21590 0 1 {name=p142494 lab=_62928_/D }
C {sky130_stdcells/nand3_4.sym} 143380 -21590 0 0 {name=X_62927_ }
C {devices/lab_pin.sym} 143290 -21450 0 0 {name=p142495 lab=_81412_/CLK }
C {devices/lab_pin.sym} 143290 -21430 0 0 {name=p142496 lab=_76150_/X }
C {devices/lab_pin.sym} 143470 -21450 0 1 {name=p142497 lab=_41286_/A }
C {sky130_stdcells/dfxtp_4.sym} 143380 -21440 0 0 {name=X_81761_ }
C {devices/lab_pin.sym} 143300 -21340 0 0 {name=p142498 lab=_87514_/Q }
C {devices/lab_pin.sym} 143300 -21300 0 0 {name=p142499 lab=_69356_/X }
C {devices/lab_pin.sym} 143300 -21260 0 0 {name=p142500 lab=_69371_/X }
C {devices/lab_pin.sym} 143300 -21220 0 0 {name=p142501 lab=_69482_/X }
C {devices/lab_pin.sym} 143460 -21280 0 1 {name=p142502 lab=_69483_/X }
C {sky130_stdcells/a211o_4.sym} 143380 -21280 0 0 {name=X_69483_ }
C {devices/lab_pin.sym} 143300 -21160 0 0 {name=p142503 lab=_87130_/Q }
C {devices/lab_pin.sym} 143300 -21120 0 0 {name=p142504 lab=_66593_/X }
C {devices/lab_pin.sym} 143300 -21080 0 0 {name=p142505 lab=_66594_/X }
C {devices/lab_pin.sym} 143300 -21040 0 0 {name=p142506 lab=_66694_/X }
C {devices/lab_pin.sym} 143460 -21100 0 1 {name=p142507 lab=_66695_/X }
C {sky130_stdcells/a211o_4.sym} 143380 -21100 0 0 {name=X_66695_ }
C {devices/lab_pin.sym} 143290 -20950 0 0 {name=p142508 lab=_84223_/CLK }
C {devices/lab_pin.sym} 143290 -20930 0 0 {name=p142509 lab=_83500_/D }
C {devices/lab_pin.sym} 143470 -20950 0 1 {name=p142510 lab=_83500_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -20940 0 0 {name=X_83500_ }
C {devices/lab_pin.sym} 143290 -20810 0 0 {name=p142511 lab=_80681_/CLK }
C {devices/lab_pin.sym} 143290 -20790 0 0 {name=p142512 lab=_75898_/X }
C {devices/lab_pin.sym} 143470 -20810 0 1 {name=p142513 lab=_80680_/D }
C {sky130_stdcells/dfxtp_4.sym} 143380 -20800 0 0 {name=X_80712_ }
C {devices/lab_pin.sym} 143300 -20700 0 0 {name=p142514 lab=_68376_/X }
C {devices/lab_pin.sym} 143300 -20660 0 0 {name=p142515 lab=_66524_/B }
C {devices/lab_pin.sym} 143300 -20620 0 0 {name=p142516 lab=_68424_/Y }
C {devices/lab_pin.sym} 143300 -20580 0 0 {name=p142517 lab=_68433_/Y }
C {devices/lab_pin.sym} 143460 -20640 0 1 {name=p142518 lab=_68434_/X }
C {sky130_stdcells/a211o_4.sym} 143380 -20640 0 0 {name=X_68434_ }
C {devices/lab_pin.sym} 143340 -20490 0 0 {name=p142519 lab=_53687_/A }
C {devices/lab_pin.sym} 143420 -20490 0 1 {name=p142520 lab=_53660_/X }
C {sky130_stdcells/buf_2.sym} 143380 -20490 0 0 {name=X_53660_ }
C {devices/lab_pin.sym} 143320 -20380 0 0 {name=p142521 lab=_65646_/A }
C {devices/lab_pin.sym} 143320 -20340 0 0 {name=p142522 lab=_65645_/X }
C {devices/lab_pin.sym} 143440 -20360 0 1 {name=p142523 lab=_65646_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -20360 0 0 {name=X_65646_ }
C {devices/lab_pin.sym} 143290 -20230 0 0 {name=p142524 lab=_84481_/CLK }
C {devices/lab_pin.sym} 143290 -20210 0 0 {name=p142525 lab=_61446_/Y }
C {devices/lab_pin.sym} 143470 -20230 0 1 {name=p142526 lab=_79148_/B }
C {sky130_stdcells/dfxtp_4.sym} 143380 -20220 0 0 {name=X_84480_ }
C {devices/lab_pin.sym} 143320 -20100 0 0 {name=p142527 lab=_50228_/X }
C {devices/lab_pin.sym} 143320 -20060 0 0 {name=p142528 lab=_52565_/B }
C {devices/lab_pin.sym} 143440 -20080 0 1 {name=p142529 lab=_50872_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -20080 0 0 {name=X_50872_ }
C {devices/lab_pin.sym} 143340 -19950 0 0 {name=p142530 lab=_62646_/B }
C {devices/lab_pin.sym} 143420 -19950 0 1 {name=p142531 lab=_62858_/X }
C {sky130_stdcells/buf_2.sym} 143380 -19950 0 0 {name=X_62858_ }
C {devices/lab_pin.sym} 143290 -19830 0 0 {name=p142532 lab=_81695_/CLK }
C {devices/lab_pin.sym} 143290 -19810 0 0 {name=p142533 lab=_80202_/X }
C {devices/lab_pin.sym} 143470 -19830 0 1 {name=p142534 lab=_81692_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -19820 0 0 {name=X_81692_ }
C {devices/lab_pin.sym} 143300 -19710 0 0 {name=p142535 lab=_52609_/Y }
C {devices/lab_pin.sym} 143300 -19670 0 0 {name=p142536 lab=_52592_/X }
C {devices/lab_pin.sym} 143300 -19630 0 0 {name=p142537 lab=_52610_/X }
C {devices/lab_pin.sym} 143460 -19670 0 1 {name=p142538 lab=_52611_/Y }
C {sky130_stdcells/a21oi_4.sym} 143380 -19670 0 0 {name=X_52611_ }
C {devices/lab_pin.sym} 143290 -19530 0 0 {name=p142539 lab=_83431_/CLK }
C {devices/lab_pin.sym} 143290 -19510 0 0 {name=p142540 lab=_71636_/Y }
C {devices/lab_pin.sym} 143470 -19530 0 1 {name=p142541 lab=_59484_/A }
C {sky130_stdcells/dfxtp_4.sym} 143380 -19520 0 0 {name=X_83431_ }
C {devices/lab_pin.sym} 143320 -19420 0 0 {name=p142542 lab=_61387_/X }
C {devices/lab_pin.sym} 143320 -19380 0 0 {name=p142543 lab=_61794_/B }
C {devices/lab_pin.sym} 143320 -19340 0 0 {name=p142544 lab=_61809_/C }
C {devices/lab_pin.sym} 143320 -19300 0 0 {name=p142545 lab=_61776_/D }
C {devices/lab_pin.sym} 143440 -19360 0 1 {name=p142546 lab=_61809_/Y }
C {sky130_stdcells/nand4_4.sym} 143380 -19360 0 0 {name=X_61809_ }
C {devices/lab_pin.sym} 143340 -19200 0 0 {name=p142547 lab=_80643_/A }
C {devices/lab_pin.sym} 143340 -19160 0 0 {name=p142548 lab=_74715_/Y }
C {devices/lab_pin.sym} 143420 -19200 0 1 {name=p142549 lab=DATA_FROM_HASH[0] }
C {sky130_stdcells/ebufn_2.sym} 143380 -19200 0 0 {name=X_80643_ }
C {devices/lab_pin.sym} 143340 -19070 0 0 {name=p142550 lab=_68757_/A }
C {devices/lab_pin.sym} 143420 -19070 0 1 {name=p142551 lab=_68365_/X }
C {sky130_stdcells/buf_2.sym} 143380 -19070 0 0 {name=X_68365_ }
C {devices/lab_pin.sym} 143340 -18950 0 0 {name=p142552 lab=_64903_/A }
C {devices/lab_pin.sym} 143420 -18950 0 1 {name=p142553 lab=_65731_/A }
C {sky130_stdcells/buf_2.sym} 143380 -18950 0 0 {name=X_65577_ }
C {devices/lab_pin.sym} 143320 -18840 0 0 {name=p142554 lab=_53604_/A }
C {devices/lab_pin.sym} 143320 -18800 0 0 {name=p142555 lab=_50368_/B }
C {devices/lab_pin.sym} 143440 -18820 0 1 {name=p142556 lab=_53591_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -18820 0 0 {name=X_53591_ }
C {devices/lab_pin.sym} 143320 -18720 0 0 {name=p142557 lab=_62789_/A }
C {devices/lab_pin.sym} 143320 -18680 0 0 {name=p142558 lab=_63139_/A }
C {devices/lab_pin.sym} 143320 -18640 0 0 {name=p142559 lab=_62744_/X }
C {devices/lab_pin.sym} 143320 -18600 0 0 {name=p142560 lab=_62789_/D }
C {devices/lab_pin.sym} 143440 -18660 0 1 {name=p142561 lab=_62789_/X }
C {sky130_stdcells/and4_4.sym} 143380 -18660 0 0 {name=X_62789_ }
C {devices/lab_pin.sym} 143300 -18530 0 0 {name=p142562 lab=_55328_/C }
C {devices/lab_pin.sym} 143300 -18490 0 0 {name=p142563 lab=_55384_/A }
C {devices/lab_pin.sym} 143300 -18450 0 0 {name=p142564 lab=_55316_/X }
C {devices/lab_pin.sym} 143460 -18490 0 1 {name=p142565 lab=_55330_/X }
C {sky130_stdcells/a21bo_4.sym} 143380 -18490 0 0 {name=X_55330_ }
C {devices/lab_pin.sym} 143320 -18360 0 0 {name=p142566 lab=_67316_/A }
C {devices/lab_pin.sym} 143320 -18320 0 0 {name=p142567 lab=_67315_/X }
C {devices/lab_pin.sym} 143440 -18340 0 1 {name=p142568 lab=_67316_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -18340 0 0 {name=X_67316_ }
C {devices/lab_pin.sym} 143290 -18210 0 0 {name=p142569 lab=_85542_/CLK }
C {devices/lab_pin.sym} 143290 -18190 0 0 {name=p142570 lab=_50705_/Y }
C {devices/lab_pin.sym} 143470 -18210 0 1 {name=p142571 lab=_86150_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -18200 0 0 {name=X_86150_ }
C {devices/lab_pin.sym} 143340 -18070 0 0 {name=p142572 lab=_52319_/A }
C {devices/lab_pin.sym} 143420 -18070 0 1 {name=p142573 lab=_52542_/X }
C {sky130_stdcells/buf_2.sym} 143380 -18070 0 0 {name=X_52542_ }
C {devices/lab_pin.sym} 143300 -17990 0 0 {name=p142574 lab=_64523_/X }
C {devices/lab_pin.sym} 143300 -17950 0 0 {name=p142575 lab=_64524_/X }
C {devices/lab_pin.sym} 143300 -17910 0 0 {name=p142576 lab=_64525_/X }
C {devices/lab_pin.sym} 143300 -17870 0 0 {name=p142577 lab=_64527_/Y }
C {devices/lab_pin.sym} 143300 -17830 0 0 {name=p142578 lab=_64521_/X }
C {devices/lab_pin.sym} 143460 -17910 0 1 {name=p142579 lab=_64528_/X }
C {sky130_stdcells/o41a_4.sym} 143380 -17910 0 0 {name=X_64528_ }
C {devices/lab_pin.sym} 143290 -17750 0 0 {name=p142580 lab=_83362_/CLK }
C {devices/lab_pin.sym} 143290 -17730 0 0 {name=p142581 lab=_71822_/X }
C {devices/lab_pin.sym} 143470 -17750 0 1 {name=p142582 lab=_83362_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -17740 0 0 {name=X_83362_ }
C {sky130_stdcells/decap_3.sym} 143380 -17580 0 0 {name=XPHY_207 }
C {devices/lab_pin.sym} 143300 -17450 0 0 {name=p142583 lab=_80554_/Y }
C {devices/lab_pin.sym} 143300 -17410 0 0 {name=p142584 lab=_80571_/X }
C {devices/lab_pin.sym} 143300 -17370 0 0 {name=p142585 lab=_80573_/X }
C {devices/lab_pin.sym} 143460 -17410 0 1 {name=p142586 lab=_80574_/Y }
C {sky130_stdcells/a21boi_4.sym} 143380 -17410 0 0 {name=X_80574_ }
C {devices/lab_pin.sym} 143300 -17290 0 0 {name=p142587 lab=_67824_/X }
C {devices/lab_pin.sym} 143300 -17250 0 0 {name=p142588 lab=_67827_/X }
C {devices/lab_pin.sym} 143300 -17210 0 0 {name=p142589 lab=_68295_/X }
C {devices/lab_pin.sym} 143460 -17250 0 1 {name=p142590 lab=_68296_/Y }
C {sky130_stdcells/a21oi_4.sym} 143380 -17250 0 0 {name=X_68296_ }
C {sky130_stdcells/decap_3.sym} 143380 -17080 0 0 {name=XPHY_218 }
C {devices/lab_pin.sym} 143290 -16930 0 0 {name=p142591 lab=_85037_/CLK }
C {devices/lab_pin.sym} 143290 -16910 0 0 {name=p142592 lab=_85101_/D }
C {devices/lab_pin.sym} 143470 -16930 0 1 {name=p142593 lab=_85101_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -16920 0 0 {name=X_85101_ }
C {sky130_stdcells/decap_3.sym} 143380 -16760 0 0 {name=XPHY_229 }
C {devices/lab_pin.sym} 143290 -16610 0 0 {name=p142594 lab=_82335_/CLK }
C {devices/lab_pin.sym} 143290 -16590 0 0 {name=p142595 lab=_77049_/B }
C {devices/lab_pin.sym} 143470 -16610 0 1 {name=p142596 lab=_82313_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -16600 0 0 {name=X_82313_ }
C {devices/lab_pin.sym} 143320 -16480 0 0 {name=p142597 lab=_55252_/A }
C {devices/lab_pin.sym} 143320 -16440 0 0 {name=p142598 lab=_85129_/Q }
C {devices/lab_pin.sym} 143440 -16460 0 1 {name=p142599 lab=_55261_/X }
C {sky130_stdcells/and2_4.sym} 143380 -16460 0 0 {name=X_55261_ }
C {devices/lab_pin.sym} 143320 -16340 0 0 {name=p142600 lab=_67247_/A }
C {devices/lab_pin.sym} 143320 -16300 0 0 {name=p142601 lab=_67246_/X }
C {devices/lab_pin.sym} 143440 -16320 0 1 {name=p142602 lab=_67247_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -16320 0 0 {name=X_67247_ }
C {devices/lab_pin.sym} 143290 -16190 0 0 {name=p142603 lab=_85761_/CLK }
C {devices/lab_pin.sym} 143290 -16170 0 0 {name=p142604 lab=_51062_/Y }
C {devices/lab_pin.sym} 143470 -16190 0 1 {name=p142605 lab=_86081_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -16180 0 0 {name=X_86081_ }
C {devices/lab_pin.sym} 143300 -16070 0 0 {name=p142606 lab=_85815_/Q }
C {devices/lab_pin.sym} 143300 -16030 0 0 {name=p142607 lab=_52470_/X }
C {devices/lab_pin.sym} 143300 -15990 0 0 {name=p142608 lab=_52472_/Y }
C {devices/lab_pin.sym} 143460 -16030 0 1 {name=p142609 lab=_52473_/Y }
C {sky130_stdcells/o21ai_4.sym} 143380 -16030 0 0 {name=X_52473_ }
C {devices/lab_pin.sym} 143320 -15920 0 0 {name=p142610 lab=_58393_/Y }
C {devices/lab_pin.sym} 143320 -15880 0 0 {name=p142611 lab=_61082_/X }
C {devices/lab_pin.sym} 143320 -15840 0 0 {name=p142612 lab=_61179_/A }
C {devices/lab_pin.sym} 143320 -15800 0 0 {name=p142613 lab=_64203_/B }
C {devices/lab_pin.sym} 143440 -15860 0 1 {name=p142614 lab=_64459_/Y }
C {sky130_stdcells/nor4_4.sym} 143380 -15860 0 0 {name=X_64459_ }
C {devices/lab_pin.sym} 143290 -15710 0 0 {name=p142615 lab=_83304_/CLK }
C {devices/lab_pin.sym} 143290 -15690 0 0 {name=p142616 lab=_83293_/D }
C {devices/lab_pin.sym} 143470 -15710 0 1 {name=p142617 lab=_83293_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -15700 0 0 {name=X_83293_ }
C {devices/lab_pin.sym} 143300 -15590 0 0 {name=p142618 lab=_56966_/X }
C {devices/lab_pin.sym} 143300 -15550 0 0 {name=p142619 lab=_57153_/A }
C {devices/lab_pin.sym} 143300 -15510 0 0 {name=p142620 lab=_56999_/Y }
C {devices/lab_pin.sym} 143460 -15550 0 1 {name=p142621 lab=_57001_/A }
C {sky130_stdcells/o21ai_4.sym} 143380 -15550 0 0 {name=X_57000_ }
C {devices/lab_pin.sym} 143300 -15430 0 0 {name=p142622 lab=_85483_/Q }
C {devices/lab_pin.sym} 143300 -15390 0 0 {name=p142623 lab=_54193_/X }
C {devices/lab_pin.sym} 143300 -15350 0 0 {name=p142624 lab=_54211_/Y }
C {devices/lab_pin.sym} 143460 -15390 0 1 {name=p142625 lab=_54212_/Y }
C {sky130_stdcells/o21ai_4.sym} 143380 -15390 0 0 {name=X_54212_ }
C {devices/lab_pin.sym} 143290 -15250 0 0 {name=p142626 lab=_83335_/CLK }
C {devices/lab_pin.sym} 143290 -15230 0 0 {name=p142627 lab=_57344_/Y }
C {devices/lab_pin.sym} 143470 -15250 0 1 {name=p142628 lab=_57340_/B }
C {sky130_stdcells/dfxtp_4.sym} 143380 -15240 0 0 {name=X_85032_ }
C {devices/lab_pin.sym} 143320 -15120 0 0 {name=p142629 lab=_51403_/X }
C {devices/lab_pin.sym} 143320 -15080 0 0 {name=p142630 lab=_52950_/B }
C {devices/lab_pin.sym} 143440 -15100 0 1 {name=p142631 lab=_51424_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -15100 0 0 {name=X_51424_ }
C {devices/lab_pin.sym} 143290 -14970 0 0 {name=p142632 lab=_82263_/CLK }
C {devices/lab_pin.sym} 143290 -14950 0 0 {name=p142633 lab=_82244_/D }
C {devices/lab_pin.sym} 143470 -14970 0 1 {name=p142634 lab=_82244_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -14960 0 0 {name=X_82244_ }
C {devices/lab_pin.sym} 143300 -14860 0 0 {name=p142635 lab=_87866_/Q }
C {devices/lab_pin.sym} 143300 -14820 0 0 {name=p142636 lab=_67176_/X }
C {devices/lab_pin.sym} 143300 -14780 0 0 {name=p142637 lab=_67153_/X }
C {devices/lab_pin.sym} 143300 -14740 0 0 {name=p142638 lab=_67177_/X }
C {devices/lab_pin.sym} 143460 -14800 0 1 {name=p142639 lab=_67178_/X }
C {sky130_stdcells/a211o_4.sym} 143380 -14800 0 0 {name=X_67178_ }
C {devices/lab_pin.sym} 143320 -14660 0 0 {name=p142640 lab=_55192_/A }
C {devices/lab_pin.sym} 143320 -14620 0 0 {name=p142641 lab=_85133_/Q }
C {devices/lab_pin.sym} 143440 -14640 0 1 {name=p142642 lab=_55192_/X }
C {sky130_stdcells/and2_4.sym} 143380 -14640 0 0 {name=X_55192_ }
C {devices/lab_pin.sym} 143300 -14530 0 0 {name=p142643 lab=_85496_/Q }
C {devices/lab_pin.sym} 143300 -14490 0 0 {name=p142644 lab=_54140_/X }
C {devices/lab_pin.sym} 143300 -14450 0 0 {name=p142645 lab=_54142_/Y }
C {devices/lab_pin.sym} 143460 -14490 0 1 {name=p142646 lab=_54143_/Y }
C {sky130_stdcells/o21ai_4.sym} 143380 -14490 0 0 {name=X_54143_ }
C {devices/lab_pin.sym} 143320 -14360 0 0 {name=p142647 lab=_66054_/X }
C {devices/lab_pin.sym} 143320 -14320 0 0 {name=p142648 lab=_73927_/B }
C {devices/lab_pin.sym} 143440 -14340 0 1 {name=p142649 lab=_66129_/X }
C {sky130_stdcells/and2_4.sym} 143380 -14340 0 0 {name=X_66129_ }
C {devices/lab_pin.sym} 143300 -14230 0 0 {name=p142650 lab=_86026_/Q }
C {devices/lab_pin.sym} 143300 -14190 0 0 {name=p142651 lab=_51332_/X }
C {devices/lab_pin.sym} 143300 -14150 0 0 {name=p142652 lab=_51354_/Y }
C {devices/lab_pin.sym} 143460 -14190 0 1 {name=p142653 lab=_51355_/Y }
C {sky130_stdcells/o21ai_4.sym} 143380 -14190 0 0 {name=X_51355_ }
C {devices/lab_pin.sym} 143290 -14050 0 0 {name=p142654 lab=_82575_/CLK }
C {devices/lab_pin.sym} 143290 -14030 0 0 {name=p142655 lab=_84167_/Q }
C {devices/lab_pin.sym} 143470 -14050 0 1 {name=p142656 lab=_78006_/B }
C {sky130_stdcells/dfxtp_4.sym} 143380 -14040 0 0 {name=X_82175_ }
C {devices/lab_pin.sym} 143320 -13920 0 0 {name=p142657 lab=_50240_/A }
C {devices/lab_pin.sym} 143320 -13880 0 0 {name=p142658 lab=_50306_/B }
C {devices/lab_pin.sym} 143440 -13900 0 1 {name=p142659 lab=_50306_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -13900 0 0 {name=X_50306_ }
C {devices/lab_pin.sym} 143290 -13770 0 0 {name=p142660 lab=_80835_/CLK }
C {devices/lab_pin.sym} 143290 -13750 0 0 {name=p142661 lab=_81126_/D }
C {devices/lab_pin.sym} 143470 -13770 0 1 {name=p142662 lab=_40737_/A }
C {sky130_stdcells/dfxtp_4.sym} 143380 -13760 0 0 {name=X_81126_ }
C {devices/lab_pin.sym} 143300 -13650 0 0 {name=p142663 lab=_58948_/Y }
C {devices/lab_pin.sym} 143300 -13610 0 0 {name=p142664 lab=_58950_/Y }
C {devices/lab_pin.sym} 143300 -13570 0 0 {name=p142665 lab=_58939_/X }
C {devices/lab_pin.sym} 143460 -13610 0 1 {name=p142666 lab=_58951_/X }
C {sky130_stdcells/a21o_4.sym} 143380 -13610 0 0 {name=X_58951_ }
C {devices/lab_pin.sym} 143300 -13490 0 0 {name=p142667 lab=_85510_/Q }
C {devices/lab_pin.sym} 143300 -13450 0 0 {name=p142668 lab=_54067_/X }
C {devices/lab_pin.sym} 143300 -13410 0 0 {name=p142669 lab=_54073_/Y }
C {devices/lab_pin.sym} 143460 -13450 0 1 {name=p142670 lab=_54074_/Y }
C {sky130_stdcells/o21ai_4.sym} 143380 -13450 0 0 {name=X_54074_ }
C {devices/lab_pin.sym} 143340 -13310 0 0 {name=p142671 lab=_51286_/A }
C {devices/lab_pin.sym} 143420 -13310 0 1 {name=p142672 lab=_51296_/A }
C {sky130_stdcells/buf_2.sym} 143380 -13310 0 0 {name=X_51286_ }
C {devices/lab_pin.sym} 143340 -13190 0 0 {name=p142673 lab=clkbuf_9_175_0_CLK/X }
C {devices/lab_pin.sym} 143420 -13190 0 1 {name=p142674 lab=_85748_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 143380 -13190 0 0 {name=Xclkbuf_10_351_0_CLK }
C {devices/lab_pin.sym} 143290 -13070 0 0 {name=p142675 lab=_86998_/CLK }
C {devices/lab_pin.sym} 143290 -13050 0 0 {name=p142676 lab=_44730_/Y }
C {devices/lab_pin.sym} 143470 -13070 0 1 {name=p142677 lab=_74119_/A }
C {sky130_stdcells/dfxtp_4.sym} 143380 -13060 0 0 {name=X_86983_ }
C {devices/lab_pin.sym} 143340 -12930 0 0 {name=p142678 lab=_58876_/A }
C {devices/lab_pin.sym} 143420 -12930 0 1 {name=p142679 lab=_58605_/A }
C {sky130_stdcells/buf_2.sym} 143380 -12930 0 0 {name=X_57902_ }
C {devices/lab_pin.sym} 143320 -12820 0 0 {name=p142680 lab=_53025_/A }
C {devices/lab_pin.sym} 143320 -12780 0 0 {name=p142681 lab=_53025_/B }
C {devices/lab_pin.sym} 143440 -12800 0 1 {name=p142682 lab=_53025_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -12800 0 0 {name=X_53025_ }
C {devices/lab_pin.sym} 143340 -12670 0 0 {name=p142683 lab=clkbuf_9_490_0_CLK/X }
C {devices/lab_pin.sym} 143420 -12670 0 1 {name=p142684 lab=_85555_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 143380 -12670 0 0 {name=Xclkbuf_10_981_0_CLK }
C {devices/lab_pin.sym} 143340 -12550 0 0 {name=p142685 lab=_50505_/A }
C {devices/lab_pin.sym} 143420 -12550 0 1 {name=p142686 lab=_50464_/A }
C {sky130_stdcells/buf_2.sym} 143380 -12550 0 0 {name=X_50237_ }
C {devices/lab_pin.sym} 143290 -12430 0 0 {name=p142687 lab=_86096_/CLK }
C {devices/lab_pin.sym} 143290 -12410 0 0 {name=p142688 lab=_51856_/Y }
C {devices/lab_pin.sym} 143470 -12430 0 1 {name=p142689 lab=_85934_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -12420 0 0 {name=X_85934_ }
C {devices/lab_pin.sym} 143290 -12290 0 0 {name=p142690 lab=_85335_/CLK }
C {devices/lab_pin.sym} 143290 -12270 0 0 {name=p142691 lab=_81057_/D }
C {devices/lab_pin.sym} 143470 -12290 0 1 {name=p142692 lab=_81057_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -12280 0 0 {name=X_81057_ }
C {devices/lab_pin.sym} 143340 -12150 0 0 {name=p142693 lab=_58882_/A }
C {devices/lab_pin.sym} 143420 -12150 0 1 {name=p142694 lab=_59053_/A }
C {sky130_stdcells/buf_2.sym} 143380 -12150 0 0 {name=X_58882_ }
C {devices/lab_pin.sym} 143320 -12040 0 0 {name=p142695 lab=_80004_/X }
C {devices/lab_pin.sym} 143320 -12000 0 0 {name=p142696 lab=_80007_/Y }
C {devices/lab_pin.sym} 143440 -12020 0 1 {name=p142697 lab=_80008_/X }
C {sky130_stdcells/xor2_4.sym} 143380 -12020 0 0 {name=X_80008_ }
C {devices/lab_pin.sym} 143320 -11900 0 0 {name=p142698 lab=_86650_/Q }
C {devices/lab_pin.sym} 143320 -11860 0 0 {name=p142699 lab=_57833_/B }
C {devices/lab_pin.sym} 143440 -11880 0 1 {name=p142700 lab=_57833_/Y }
C {sky130_stdcells/nor2_4.sym} 143380 -11880 0 0 {name=X_57833_ }
C {devices/lab_pin.sym} 143300 -11770 0 0 {name=p142701 lab=_81967_/D }
C {devices/lab_pin.sym} 143300 -11730 0 0 {name=p142702 lab=_69763_/X }
C {devices/lab_pin.sym} 143300 -11690 0 0 {name=p142703 lab=_69818_/X }
C {devices/lab_pin.sym} 143460 -11730 0 1 {name=p142704 lab=_83895_/D }
C {sky130_stdcells/a21bo_4.sym} 143380 -11730 0 0 {name=X_69819_ }
C {devices/lab_pin.sym} 143340 -11590 0 0 {name=p142705 lab=clkbuf_8_236_0_CLK/X }
C {devices/lab_pin.sym} 143420 -11590 0 1 {name=p142706 lab=clkbuf_9_472_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 143380 -11590 0 0 {name=Xclkbuf_9_472_0_CLK }
C {devices/lab_pin.sym} 143300 -11490 0 0 {name=p142707 lab=_50165_/Y }
C {devices/lab_pin.sym} 143300 -11450 0 0 {name=p142708 lab=_50166_/X }
C {devices/lab_pin.sym} 143300 -11410 0 0 {name=p142709 lab=_50167_/X }
C {devices/lab_pin.sym} 143460 -11450 0 1 {name=p142710 lab=_86251_/D }
C {sky130_stdcells/a21oi_4.sym} 143380 -11450 0 0 {name=X_50168_ }
C {devices/lab_pin.sym} 143290 -11310 0 0 {name=p142711 lab=_85865_/CLK }
C {devices/lab_pin.sym} 143290 -11290 0 0 {name=p142712 lab=_85865_/D }
C {devices/lab_pin.sym} 143470 -11310 0 1 {name=p142713 lab=_85865_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -11300 0 0 {name=X_85865_ }
C {devices/lab_pin.sym} 143290 -11170 0 0 {name=p142714 lab=_87348_/CLK }
C {devices/lab_pin.sym} 143290 -11150 0 0 {name=p142715 lab=_87604_/D }
C {devices/lab_pin.sym} 143470 -11170 0 1 {name=p142716 lab=_87604_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -11160 0 0 {name=X_87604_ }
C {devices/lab_pin.sym} 143340 -11030 0 0 {name=p142717 lab=_72829_/X }
C {devices/lab_pin.sym} 143420 -11030 0 1 {name=p142718 lab=_72830_/X }
C {sky130_stdcells/buf_2.sym} 143380 -11030 0 0 {name=X_72830_ }
C {devices/lab_pin.sym} 143290 -10910 0 0 {name=p142719 lab=_84815_/CLK }
C {devices/lab_pin.sym} 143290 -10890 0 0 {name=p142720 lab=_58584_/Y }
C {devices/lab_pin.sym} 143470 -10910 0 1 {name=p142721 lab=_84816_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -10900 0 0 {name=X_84816_ }
C {devices/lab_pin.sym} 143340 -10770 0 0 {name=p142722 lab=clkbuf_9_183_0_CLK/X }
C {devices/lab_pin.sym} 143420 -10770 0 1 {name=p142723 lab=_85990_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 143380 -10770 0 0 {name=Xclkbuf_10_366_0_CLK }
C {devices/lab_pin.sym} 143300 -10670 0 0 {name=p142724 lab=_57761_/X }
C {devices/lab_pin.sym} 143300 -10630 0 0 {name=p142725 lab=_85501_/Q }
C {devices/lab_pin.sym} 143300 -10590 0 0 {name=p142726 lab=_57763_/X }
C {devices/lab_pin.sym} 143460 -10630 0 1 {name=p142727 lab=_57764_/X }
C {sky130_stdcells/o21a_4.sym} 143380 -10630 0 0 {name=X_57764_ }
C {devices/lab_pin.sym} 143300 -10520 0 0 {name=p142728 lab=_40485_/X }
C {devices/lab_pin.sym} 143300 -10480 0 0 {name=p142729 lab=_42962_/X }
C {devices/lab_pin.sym} 143300 -10440 0 0 {name=p142730 lab=_87616_/Q }
C {devices/lab_pin.sym} 143300 -10400 0 0 {name=p142731 lab=_42963_/X }
C {devices/lab_pin.sym} 143460 -10460 0 1 {name=p142732 lab=_87616_/D }
C {sky130_stdcells/a2bb2o_4.sym} 143380 -10460 0 0 {name=X_42990_ }
C {devices/lab_pin.sym} 143320 -10320 0 0 {name=p142733 lab=_50103_/A }
C {devices/lab_pin.sym} 143320 -10280 0 0 {name=p142734 lab=_52307_/B }
C {devices/lab_pin.sym} 143440 -10300 0 1 {name=p142735 lab=_50099_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -10300 0 0 {name=X_50099_ }
C {devices/lab_pin.sym} 143320 -10180 0 0 {name=p142736 lab=_54985_/A }
C {devices/lab_pin.sym} 143320 -10140 0 0 {name=p142737 lab=_47552_/A }
C {devices/lab_pin.sym} 143440 -10160 0 1 {name=p142738 lab=_54976_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -10160 0 0 {name=X_54976_ }
C {devices/lab_pin.sym} 143290 -10030 0 0 {name=p142739 lab=_85507_/CLK }
C {devices/lab_pin.sym} 143290 -10010 0 0 {name=p142740 lab=_85796_/D }
C {devices/lab_pin.sym} 143470 -10030 0 1 {name=p142741 lab=_65360_/B }
C {sky130_stdcells/dfxtp_4.sym} 143380 -10020 0 0 {name=X_85796_ }
C {devices/lab_pin.sym} 143340 -9890 0 0 {name=p142742 lab=clkbuf_9_498_0_CLK/X }
C {devices/lab_pin.sym} 143420 -9890 0 1 {name=p142743 lab=_85596_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 143380 -9890 0 0 {name=Xclkbuf_10_996_0_CLK }
C {devices/lab_pin.sym} 143300 -9790 0 0 {name=p142744 lab=_46159_/X }
C {devices/lab_pin.sym} 143300 -9750 0 0 {name=p142745 lab=_59500_/Y }
C {devices/lab_pin.sym} 143300 -9710 0 0 {name=p142746 lab=_59502_/Y }
C {devices/lab_pin.sym} 143460 -9750 0 1 {name=p142747 lab=_59503_/Y }
C {sky130_stdcells/a21oi_4.sym} 143380 -9750 0 0 {name=X_59503_ }
C {devices/lab_pin.sym} 143300 -9630 0 0 {name=p142748 lab=_57270_/A }
C {devices/lab_pin.sym} 143300 -9590 0 0 {name=p142749 lab=_56713_/X }
C {devices/lab_pin.sym} 143300 -9550 0 0 {name=p142750 lab=_56714_/Y }
C {devices/lab_pin.sym} 143460 -9590 0 1 {name=p142751 lab=_56715_/Y }
C {sky130_stdcells/o21ai_4.sym} 143380 -9590 0 0 {name=X_56715_ }
C {devices/lab_pin.sym} 143290 -9450 0 0 {name=p142752 lab=_87544_/CLK }
C {devices/lab_pin.sym} 143290 -9430 0 0 {name=p142753 lab=_87535_/D }
C {devices/lab_pin.sym} 143470 -9450 0 1 {name=p142754 lab=_87535_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -9440 0 0 {name=X_87535_ }
C {devices/lab_pin.sym} 143340 -9310 0 0 {name=p142755 lab=_41941_/A }
C {devices/lab_pin.sym} 143420 -9310 0 1 {name=p142756 lab=_41941_/Y }
C {sky130_stdcells/inv_2.sym} 143380 -9310 0 0 {name=X_41941_ }
C {devices/lab_pin.sym} 143320 -9200 0 0 {name=p142757 lab=_53951_/A }
C {devices/lab_pin.sym} 143320 -9160 0 0 {name=p142758 lab=_49176_/A }
C {devices/lab_pin.sym} 143440 -9180 0 1 {name=p142759 lab=_53927_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -9180 0 0 {name=X_53927_ }
C {devices/lab_pin.sym} 143320 -9060 0 0 {name=p142760 lab=_72754_/X }
C {devices/lab_pin.sym} 143320 -9020 0 0 {name=p142761 lab=_72761_/B }
C {devices/lab_pin.sym} 143440 -9040 0 1 {name=p142762 lab=_72762_/B }
C {sky130_stdcells/nand2_4.sym} 143380 -9040 0 0 {name=X_72761_ }
C {devices/lab_pin.sym} 143290 -8910 0 0 {name=p142763 lab=_84760_/CLK }
C {devices/lab_pin.sym} 143290 -8890 0 0 {name=p142764 lab=_84747_/D }
C {devices/lab_pin.sym} 143470 -8910 0 1 {name=p142765 lab=_84747_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -8900 0 0 {name=X_84747_ }
C {devices/lab_pin.sym} 143340 -8770 0 0 {name=p142766 lab=_57694_/X }
C {devices/lab_pin.sym} 143420 -8770 0 1 {name=p142767 lab=_58805_/A }
C {sky130_stdcells/buf_2.sym} 143380 -8770 0 0 {name=X_57695_ }
C {devices/lab_pin.sym} 143290 -8650 0 0 {name=p142768 lab=_82339_/CLK }
C {devices/lab_pin.sym} 143290 -8630 0 0 {name=p142769 lab=_81959_/D }
C {devices/lab_pin.sym} 143470 -8650 0 1 {name=p142770 lab=_77919_/B }
C {sky130_stdcells/dfxtp_4.sym} 143380 -8640 0 0 {name=X_81959_ }
C {devices/lab_pin.sym} 143300 -8530 0 0 {name=p142771 lab=_83053_/Q }
C {devices/lab_pin.sym} 143300 -8490 0 0 {name=p142772 lab=_46250_/X }
C {devices/lab_pin.sym} 143300 -8450 0 0 {name=p142773 lab=_74499_/Y }
C {devices/lab_pin.sym} 143460 -8490 0 1 {name=p142774 lab=_74500_/Y }
C {sky130_stdcells/o21ai_4.sym} 143380 -8490 0 0 {name=X_74500_ }
C {devices/lab_pin.sym} 143340 -8350 0 0 {name=p142775 lab=clkbuf_9_486_0_CLK/A }
C {devices/lab_pin.sym} 143420 -8350 0 1 {name=p142776 lab=clkbuf_9_487_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 143380 -8350 0 0 {name=Xclkbuf_9_487_0_CLK }
C {devices/lab_pin.sym} 143340 -8230 0 0 {name=p142777 lab=_71711_/Y }
C {devices/lab_pin.sym} 143420 -8230 0 1 {name=p142778 lab=_71712_/Y }
C {sky130_stdcells/inv_2.sym} 143380 -8230 0 0 {name=X_71712_ }
C {devices/lab_pin.sym} 143320 -8120 0 0 {name=p142779 lab=_59433_/Y }
C {devices/lab_pin.sym} 143320 -8080 0 0 {name=p142780 lab=_59424_/B }
C {devices/lab_pin.sym} 143440 -8100 0 1 {name=p142781 lab=_59434_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -8100 0 0 {name=X_59434_ }
C {devices/lab_pin.sym} 143340 -7970 0 0 {name=p142782 lab=_44714_/A }
C {devices/lab_pin.sym} 143420 -7970 0 1 {name=p142783 lab=_44660_/X }
C {sky130_stdcells/buf_2.sym} 143380 -7970 0 0 {name=X_44660_ }
C {devices/lab_pin.sym} 143320 -7860 0 0 {name=p142784 lab=_45957_/A }
C {devices/lab_pin.sym} 143320 -7820 0 0 {name=p142785 lab=_56645_/Y }
C {devices/lab_pin.sym} 143440 -7840 0 1 {name=p142786 lab=_56646_/Y }
C {sky130_stdcells/nor2_4.sym} 143380 -7840 0 0 {name=X_56646_ }
C {devices/lab_pin.sym} 143340 -7710 0 0 {name=p142787 lab=_75479_/X }
C {devices/lab_pin.sym} 143420 -7710 0 1 {name=p142788 lab=_75480_/Y }
C {sky130_stdcells/inv_2.sym} 143380 -7710 0 0 {name=X_75480_ }
C {devices/lab_pin.sym} 143290 -7590 0 0 {name=p142789 lab=_87708_/CLK }
C {devices/lab_pin.sym} 143290 -7570 0 0 {name=p142790 lab=_87466_/D }
C {devices/lab_pin.sym} 143470 -7590 0 1 {name=p142791 lab=_87466_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -7580 0 0 {name=X_87466_ }
C {devices/lab_pin.sym} 143340 -7450 0 0 {name=p142792 lab=_41872_/A }
C {devices/lab_pin.sym} 143420 -7450 0 1 {name=p142793 lab=_41872_/X }
C {sky130_stdcells/buf_2.sym} 143380 -7450 0 0 {name=X_41872_ }
C {devices/lab_pin.sym} 143320 -7340 0 0 {name=p142794 lab=_53844_/A }
C {devices/lab_pin.sym} 143320 -7300 0 0 {name=p142795 lab=_53858_/B }
C {devices/lab_pin.sym} 143440 -7320 0 1 {name=p142796 lab=_53858_/Y }
C {sky130_stdcells/nand2_4.sym} 143380 -7320 0 0 {name=X_53858_ }
C {devices/lab_pin.sym} 143300 -7210 0 0 {name=p142797 lab=_83188_/Q }
C {devices/lab_pin.sym} 143300 -7170 0 0 {name=p142798 lab=_72686_/X }
C {devices/lab_pin.sym} 143300 -7130 0 0 {name=p142799 lab=_72691_/Y }
C {devices/lab_pin.sym} 143460 -7170 0 1 {name=p142800 lab=_72692_/X }
C {sky130_stdcells/a21bo_4.sym} 143380 -7170 0 0 {name=X_72692_ }
C {devices/lab_pin.sym} 143290 -7030 0 0 {name=p142801 lab=_84396_/CLK }
C {devices/lab_pin.sym} 143290 -7010 0 0 {name=p142802 lab=_84678_/D }
C {devices/lab_pin.sym} 143470 -7030 0 1 {name=p142803 lab=_80215_/A }
C {sky130_stdcells/dfxtp_4.sym} 143380 -7020 0 0 {name=X_84678_ }
C {devices/lab_pin.sym} 143340 -6890 0 0 {name=p142804 lab=_43611_/A }
C {devices/lab_pin.sym} 143420 -6890 0 1 {name=p142805 lab=_43611_/X }
C {sky130_stdcells/buf_2.sym} 143380 -6890 0 0 {name=X_43611_ }
C {devices/lab_pin.sym} 143320 -6790 0 0 {name=p142806 lab=_74431_/A }
C {devices/lab_pin.sym} 143320 -6750 0 0 {name=p142807 lab=_74420_/X }
C {devices/lab_pin.sym} 143320 -6710 0 0 {name=p142808 lab=_74425_/X }
C {devices/lab_pin.sym} 143440 -6750 0 1 {name=p142809 lab=_74431_/X }
C {sky130_stdcells/and3_4.sym} 143380 -6750 0 0 {name=X_74431_ }
C {devices/lab_pin.sym} 143290 -6610 0 0 {name=p142810 lab=_86422_/CLK }
C {devices/lab_pin.sym} 143290 -6590 0 0 {name=p142811 lab=_49290_/Y }
C {devices/lab_pin.sym} 143470 -6610 0 1 {name=p142812 lab=_65029_/B }
C {sky130_stdcells/dfxtp_4.sym} 143380 -6600 0 0 {name=X_86417_ }
C {devices/lab_pin.sym} 143340 -6470 0 0 {name=p142813 lab=_52783_/A }
C {devices/lab_pin.sym} 143420 -6470 0 1 {name=p142814 lab=_52809_/X }
C {sky130_stdcells/buf_2.sym} 143380 -6470 0 0 {name=X_52809_ }
C {devices/lab_pin.sym} 143300 -6380 0 0 {name=p142815 lab=_40820_/X }
C {devices/lab_pin.sym} 143300 -6340 0 0 {name=p142816 lab=_40821_/X }
C {devices/lab_pin.sym} 143300 -6300 0 0 {name=p142817 lab=_88328_/Q }
C {devices/lab_pin.sym} 143300 -6260 0 0 {name=p142818 lab=_40822_/X }
C {devices/lab_pin.sym} 143460 -6320 0 1 {name=p142819 lab=_40823_/X }
C {sky130_stdcells/a2bb2o_4.sym} 143380 -6320 0 0 {name=X_40823_ }
C {devices/lab_pin.sym} 143340 -6170 0 0 {name=p142820 lab=_59081_/A }
C {devices/lab_pin.sym} 143420 -6170 0 1 {name=p142821 lab=_59365_/X }
C {sky130_stdcells/buf_2.sym} 143380 -6170 0 0 {name=X_59365_ }
C {devices/lab_pin.sym} 143300 -6070 0 0 {name=p142822 lab=_59497_/Y }
C {devices/lab_pin.sym} 143300 -6030 0 0 {name=p142823 lab=_71628_/X }
C {devices/lab_pin.sym} 143300 -5990 0 0 {name=p142824 lab=_71642_/Y }
C {devices/lab_pin.sym} 143460 -6030 0 1 {name=p142825 lab=_71643_/Y }
C {sky130_stdcells/o21ai_4.sym} 143380 -6030 0 0 {name=X_71643_ }
C {devices/lab_pin.sym} 143290 -5890 0 0 {name=p142826 lab=_83630_/CLK }
C {devices/lab_pin.sym} 143290 -5870 0 0 {name=p142827 lab=_71034_/Y }
C {devices/lab_pin.sym} 143470 -5890 0 1 {name=p142828 lab=_83629_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -5880 0 0 {name=X_83629_ }
C {devices/lab_pin.sym} 143300 -5790 0 0 {name=p142829 lab=_44588_/X }
C {devices/lab_pin.sym} 143300 -5750 0 0 {name=p142830 lab=_44589_/X }
C {devices/lab_pin.sym} 143300 -5710 0 0 {name=p142831 lab=_40914_/X }
C {devices/lab_pin.sym} 143300 -5670 0 0 {name=p142832 lab=_87043_/Q }
C {devices/lab_pin.sym} 143300 -5630 0 0 {name=p142833 lab=_44590_/X }
C {devices/lab_pin.sym} 143460 -5710 0 1 {name=p142834 lab=_44591_/Y }
C {sky130_stdcells/o32ai_4.sym} 143380 -5710 0 0 {name=X_44591_ }
C {devices/lab_pin.sym} 143320 -5560 0 0 {name=p142835 lab=_72641_/C }
C {devices/lab_pin.sym} 143320 -5520 0 0 {name=p142836 lab=_56558_/X }
C {devices/lab_pin.sym} 143440 -5540 0 1 {name=p142837 lab=_56577_/Y }
C {sky130_stdcells/xnor2_4.sym} 143380 -5540 0 0 {name=X_56577_ }
C {devices/lab_pin.sym} 143290 -5410 0 0 {name=p142838 lab=_87397_/CLK }
C {devices/lab_pin.sym} 143290 -5390 0 0 {name=p142839 lab=_43488_/Y }
C {devices/lab_pin.sym} 143470 -5410 0 1 {name=p142840 lab=_87397_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -5400 0 0 {name=X_87397_ }
C {devices/lab_pin.sym} 143320 -5290 0 0 {name=p142841 lab=_48894_/A }
C {devices/lab_pin.sym} 143320 -5250 0 0 {name=p142842 lab=_53806_/B }
C {devices/lab_pin.sym} 143320 -5210 0 0 {name=p142843 lab=_53774_/C }
C {devices/lab_pin.sym} 143440 -5250 0 1 {name=p142844 lab=_53789_/X }
C {sky130_stdcells/and3_4.sym} 143380 -5250 0 0 {name=X_53789_ }
C {devices/lab_pin.sym} 143340 -5110 0 0 {name=p142845 lab=_46330_/A }
C {devices/lab_pin.sym} 143420 -5110 0 1 {name=p142846 lab=_52454_/B }
C {sky130_stdcells/buf_2.sym} 143380 -5110 0 0 {name=X_46330_ }
C {devices/lab_pin.sym} 143340 -4990 0 0 {name=p142847 lab=_84880_/Q }
C {devices/lab_pin.sym} 143420 -4990 0 1 {name=p142848 lab=_58317_/A }
C {sky130_stdcells/inv_2.sym} 143380 -4990 0 0 {name=X_58316_ }
C {devices/lab_pin.sym} 143300 -4890 0 0 {name=p142849 lab=_77146_/B }
C {devices/lab_pin.sym} 143300 -4850 0 0 {name=p142850 lab=_77154_/A }
C {devices/lab_pin.sym} 143300 -4810 0 0 {name=p142851 lab=_77149_/Y }
C {devices/lab_pin.sym} 143460 -4850 0 1 {name=p142852 lab=_77151_/B }
C {sky130_stdcells/a21boi_4.sym} 143380 -4850 0 0 {name=X_77150_ }
C {devices/lab_pin.sym} 143340 -4710 0 0 {name=p142853 lab=_40363_/X }
C {devices/lab_pin.sym} 143420 -4710 0 1 {name=p142854 lab=_43542_/X }
C {sky130_stdcells/buf_2.sym} 143380 -4710 0 0 {name=X_43542_ }
C {devices/lab_pin.sym} 143340 -4590 0 0 {name=p142855 lab=_55477_/A }
C {devices/lab_pin.sym} 143420 -4590 0 1 {name=p142856 lab=_55534_/A }
C {sky130_stdcells/buf_2.sym} 143380 -4590 0 0 {name=X_55528_ }
C {devices/lab_pin.sym} 143290 -4470 0 0 {name=p142857 lab=_86351_/CLK }
C {devices/lab_pin.sym} 143290 -4450 0 0 {name=p142858 lab=_86348_/D }
C {devices/lab_pin.sym} 143470 -4470 0 1 {name=p142859 lab=_59256_/B }
C {sky130_stdcells/dfxtp_4.sym} 143380 -4460 0 0 {name=X_86348_ }
C {devices/lab_pin.sym} 143300 -4350 0 0 {name=p142860 lab=_83082_/Q }
C {devices/lab_pin.sym} 143300 -4310 0 0 {name=p142861 lab=_72699_/X }
C {devices/lab_pin.sym} 143300 -4270 0 0 {name=p142862 lab=_74361_/Y }
C {devices/lab_pin.sym} 143460 -4310 0 1 {name=p142863 lab=_74362_/X }
C {sky130_stdcells/a21bo_4.sym} 143380 -4310 0 0 {name=X_74362_ }
C {devices/lab_pin.sym} 143340 -4170 0 0 {name=p142864 lab=_40793_/A }
C {devices/lab_pin.sym} 143420 -4170 0 1 {name=p142865 lab=_40754_/X }
C {sky130_stdcells/buf_2.sym} 143380 -4170 0 0 {name=X_40754_ }
C {devices/lab_pin.sym} 143340 -4050 0 0 {name=p142866 lab=clkbuf_9_411_0_CLK/A }
C {devices/lab_pin.sym} 143420 -4050 0 1 {name=p142867 lab=clkbuf_9_410_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 143380 -4050 0 0 {name=Xclkbuf_9_410_0_CLK }
C {devices/lab_pin.sym} 143300 -3950 0 0 {name=p142868 lab=_59208_/X }
C {devices/lab_pin.sym} 143300 -3910 0 0 {name=p142869 lab=_86057_/Q }
C {devices/lab_pin.sym} 143300 -3870 0 0 {name=p142870 lab=_59295_/X }
C {devices/lab_pin.sym} 143460 -3910 0 1 {name=p142871 lab=_59296_/Y }
C {sky130_stdcells/o21ai_4.sym} 143380 -3910 0 0 {name=X_59296_ }
C {devices/lab_pin.sym} 143320 -3790 0 0 {name=p142872 lab=_71865_/A }
C {devices/lab_pin.sym} 143320 -3750 0 0 {name=p142873 lab=_71583_/B }
C {devices/lab_pin.sym} 143320 -3710 0 0 {name=p142874 lab=_71574_/C }
C {devices/lab_pin.sym} 143440 -3750 0 1 {name=p142875 lab=_71574_/Y }
C {sky130_stdcells/nor3_4.sym} 143380 -3750 0 0 {name=X_71574_ }
C {devices/lab_pin.sym} 143320 -3620 0 0 {name=p142876 lab=_81723_/D }
C {devices/lab_pin.sym} 143320 -3580 0 0 {name=p142877 lab=_76109_/B }
C {devices/lab_pin.sym} 143440 -3600 0 1 {name=p142878 lab=_76103_/A }
C {sky130_stdcells/xor2_4.sym} 143380 -3600 0 0 {name=X_76101_ }
C {devices/lab_pin.sym} 143320 -3480 0 0 {name=p142879 lab=_48593_/A }
C {devices/lab_pin.sym} 143320 -3440 0 0 {name=p142880 lab=_73313_/B }
C {devices/lab_pin.sym} 143440 -3460 0 1 {name=p142881 lab=_73313_/X }
C {sky130_stdcells/xor2_4.sym} 143380 -3460 0 0 {name=X_73313_ }
C {devices/lab_pin.sym} 143340 -3330 0 0 {name=p142882 lab=_48631_/A }
C {devices/lab_pin.sym} 143420 -3330 0 1 {name=p142883 lab=_46348_/A }
C {sky130_stdcells/buf_2.sym} 143380 -3330 0 0 {name=X_46261_ }
C {devices/lab_pin.sym} 143300 -3230 0 0 {name=p142884 lab=_57678_/Y }
C {devices/lab_pin.sym} 143300 -3190 0 0 {name=p142885 lab=_70500_/Y }
C {devices/lab_pin.sym} 143300 -3150 0 0 {name=p142886 lab=_70524_/Y }
C {devices/lab_pin.sym} 143460 -3190 0 1 {name=p142887 lab=_83755_/D }
C {sky130_stdcells/o21ai_4.sym} 143380 -3190 0 0 {name=X_70525_ }
C {devices/lab_pin.sym} 143340 -3050 0 0 {name=p142888 lab=_84898_/Q }
C {devices/lab_pin.sym} 143420 -3050 0 1 {name=p142889 lab=_58248_/A }
C {sky130_stdcells/buf_2.sym} 143380 -3050 0 0 {name=X_58247_ }
C {devices/lab_pin.sym} 143320 -2940 0 0 {name=p142890 lab=_82093_/Q }
C {devices/lab_pin.sym} 143320 -2900 0 0 {name=p142891 lab=_77081_/B }
C {devices/lab_pin.sym} 143440 -2920 0 1 {name=p142892 lab=_77081_/X }
C {sky130_stdcells/xor2_4.sym} 143380 -2920 0 0 {name=X_77081_ }
C {devices/lab_pin.sym} 143340 -2790 0 0 {name=p142893 lab=clkbuf_9_152_0_CLK/X }
C {devices/lab_pin.sym} 143420 -2790 0 1 {name=p142894 lab=_83495_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 143380 -2790 0 0 {name=Xclkbuf_10_304_0_CLK }
C {devices/lab_pin.sym} 143300 -2710 0 0 {name=p142895 lab=_43472_/X }
C {devices/lab_pin.sym} 143300 -2670 0 0 {name=p142896 lab=_43452_/X }
C {devices/lab_pin.sym} 143300 -2630 0 0 {name=p142897 lab=_41667_/X }
C {devices/lab_pin.sym} 143300 -2590 0 0 {name=p142898 lab=_87404_/Q }
C {devices/lab_pin.sym} 143300 -2550 0 0 {name=p142899 lab=_43456_/X }
C {devices/lab_pin.sym} 143460 -2630 0 1 {name=p142900 lab=_43474_/A }
C {sky130_stdcells/o32ai_4.sym} 143380 -2630 0 0 {name=X_43473_ }
C {devices/lab_pin.sym} 143320 -2480 0 0 {name=p142901 lab=_55454_/X }
C {devices/lab_pin.sym} 143320 -2440 0 0 {name=p142902 lab=_45599_/Y }
C {devices/lab_pin.sym} 143440 -2460 0 1 {name=p142903 lab=_55459_/Y }
C {sky130_stdcells/nor2_4.sym} 143380 -2460 0 0 {name=X_55459_ }
C {devices/lab_pin.sym} 143320 -2350 0 0 {name=p142904 lab=_74297_/A }
C {devices/lab_pin.sym} 143320 -2310 0 0 {name=p142905 lab=_74297_/B }
C {devices/lab_pin.sym} 143320 -2270 0 0 {name=p142906 lab=_55966_/X }
C {devices/lab_pin.sym} 143440 -2310 0 1 {name=p142907 lab=_74293_/Y }
C {sky130_stdcells/nand3_4.sym} 143380 -2310 0 0 {name=X_74293_ }
C {devices/lab_pin.sym} 143290 -2170 0 0 {name=p142908 lab=_85959_/CLK }
C {devices/lab_pin.sym} 143290 -2150 0 0 {name=p142909 lab=_50026_/Y }
C {devices/lab_pin.sym} 143470 -2170 0 1 {name=p142910 lab=_72427_/B }
C {sky130_stdcells/dfxtp_4.sym} 143380 -2160 0 0 {name=X_86279_ }
C {devices/lab_pin.sym} 143340 -2030 0 0 {name=p142911 lab=_40685_/A }
C {devices/lab_pin.sym} 143420 -2030 0 1 {name=p142912 lab=_88354_/D }
C {sky130_stdcells/inv_2.sym} 143380 -2030 0 0 {name=X_40685_ }
C {devices/lab_pin.sym} 143340 -1910 0 0 {name=p142913 lab=_48755_/A }
C {devices/lab_pin.sym} 143420 -1910 0 1 {name=p142914 lab=_48731_/A }
C {sky130_stdcells/buf_2.sym} 143380 -1910 0 0 {name=X_48000_ }
C {devices/lab_pin.sym} 143340 -1790 0 0 {name=p142915 lab=_45212_/A }
C {devices/lab_pin.sym} 143420 -1790 0 1 {name=p142916 lab=_45212_/X }
C {sky130_stdcells/buf_2.sym} 143380 -1790 0 0 {name=X_45212_ }
C {devices/lab_pin.sym} 143320 -1680 0 0 {name=p142917 lab=_76032_/A }
C {devices/lab_pin.sym} 143320 -1640 0 0 {name=p142918 lab=_81745_/D }
C {devices/lab_pin.sym} 143440 -1660 0 1 {name=p142919 lab=_76032_/X }
C {sky130_stdcells/xor2_4.sym} 143380 -1660 0 0 {name=X_76032_ }
C {devices/lab_pin.sym} 143340 -1530 0 0 {name=p142920 lab=clkbuf_9_467_0_CLK/X }
C {devices/lab_pin.sym} 143420 -1530 0 1 {name=p142921 lab=_88086_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 143380 -1530 0 0 {name=Xclkbuf_10_934_0_CLK }
C {devices/lab_pin.sym} 143290 -1410 0 0 {name=p142922 lab=_87260_/CLK }
C {devices/lab_pin.sym} 143290 -1390 0 0 {name=p142923 lab=_88018_/D }
C {devices/lab_pin.sym} 143470 -1410 0 1 {name=p142924 lab=_88018_/Q }
C {sky130_stdcells/dfxtp_4.sym} 143380 -1400 0 0 {name=X_88018_ }
C {devices/lab_pin.sym} 143340 -1270 0 0 {name=p142925 lab=_42424_/A }
C {devices/lab_pin.sym} 143420 -1270 0 1 {name=p142926 lab=_87871_/D }
C {sky130_stdcells/inv_2.sym} 143380 -1270 0 0 {name=X_42424_ }
C {devices/lab_pin.sym} 143320 -1170 0 0 {name=p142927 lab=_73242_/X }
C {devices/lab_pin.sym} 143320 -1130 0 0 {name=p142928 lab=_73230_/X }
C {devices/lab_pin.sym} 143320 -1090 0 0 {name=p142929 lab=_73232_/Y }
C {devices/lab_pin.sym} 143440 -1130 0 1 {name=p142930 lab=_73244_/Y }
C {sky130_stdcells/nand3_4.sym} 143380 -1130 0 0 {name=X_73244_ }
C {devices/lab_pin.sym} 143320 -1010 0 0 {name=p142931 lab=_70694_/A }
C {devices/lab_pin.sym} 143320 -970 0 0 {name=p142932 lab=HASH_ADDR[4] }
C {devices/lab_pin.sym} 143320 -930 0 0 {name=p142933 lab=_70412_/X }
C {devices/lab_pin.sym} 143440 -970 0 1 {name=p142934 lab=_71462_/B }
C {sky130_stdcells/nor3_4.sym} 143380 -970 0 0 {name=X_70456_ }
C {devices/lab_pin.sym} 143320 -840 0 0 {name=p142935 lab=_46164_/A }
C {devices/lab_pin.sym} 143320 -800 0 0 {name=p142936 lab=_46092_/X }
C {devices/lab_pin.sym} 143440 -820 0 1 {name=p142937 lab=_46217_/C }
C {sky130_stdcells/nor2_4.sym} 143380 -820 0 0 {name=X_46192_ }
C {devices/lab_pin.sym} 143340 -690 0 0 {name=p142938 lab=_58177_/Y }
C {devices/lab_pin.sym} 143420 -690 0 1 {name=p142939 lab=_64292_/A }
C {sky130_stdcells/buf_2.sym} 143380 -690 0 0 {name=X_58178_ }
C {devices/lab_pin.sym} 144260 -42150 0 0 {name=p142940 lab=_64392_/B }
C {devices/lab_pin.sym} 144340 -42150 0 1 {name=p142941 lab=_61509_/B }
C {sky130_stdcells/buf_2.sym} 144300 -42150 0 0 {name=X_45143_ }
C {devices/lab_pin.sym} 144260 -42030 0 0 {name=p142942 lab=_57129_/A }
C {devices/lab_pin.sym} 144340 -42030 0 1 {name=p142943 lab=_57129_/Y }
C {sky130_stdcells/inv_2.sym} 144300 -42030 0 0 {name=X_57129_ }
C {devices/lab_pin.sym} 144260 -41910 0 0 {name=p142944 lab=clkbuf_9_424_0_CLK/A }
C {devices/lab_pin.sym} 144340 -41910 0 1 {name=p142945 lab=clkbuf_9_425_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 144300 -41910 0 0 {name=Xclkbuf_9_425_0_CLK }
C {devices/lab_pin.sym} 144220 -41820 0 0 {name=p142946 lab=_41727_/X }
C {devices/lab_pin.sym} 144220 -41780 0 0 {name=p142947 lab=_42342_/X }
C {devices/lab_pin.sym} 144220 -41740 0 0 {name=p142948 lab=_87905_/Q }
C {devices/lab_pin.sym} 144220 -41700 0 0 {name=p142949 lab=_42343_/X }
C {devices/lab_pin.sym} 144380 -41760 0 1 {name=p142950 lab=_87905_/D }
C {sky130_stdcells/a2bb2o_4.sym} 144300 -41760 0 0 {name=X_42355_ }
C {devices/lab_pin.sym} 144240 -41620 0 0 {name=p142951 lab=_73175_/A }
C {devices/lab_pin.sym} 144240 -41580 0 0 {name=p142952 lab=_44127_/X }
C {devices/lab_pin.sym} 144360 -41600 0 1 {name=p142953 lab=_73175_/Y }
C {sky130_stdcells/nor2_4.sym} 144300 -41600 0 0 {name=X_73175_ }
C {devices/lab_pin.sym} 144260 -41470 0 0 {name=p142954 lab=_70387_/A }
C {devices/lab_pin.sym} 144340 -41470 0 1 {name=p142955 lab=_70997_/A }
C {sky130_stdcells/buf_2.sym} 144300 -41470 0 0 {name=X_70387_ }
C {devices/lab_pin.sym} 144260 -41350 0 0 {name=p142956 lab=_41305_/Y }
C {devices/lab_pin.sym} 144340 -41350 0 1 {name=p142957 lab=_41306_/X }
C {sky130_stdcells/buf_2.sym} 144300 -41350 0 0 {name=X_41306_ }
C {devices/lab_pin.sym} 144220 -41270 0 0 {name=p142958 lab=_60078_/X }
C {devices/lab_pin.sym} 144220 -41230 0 0 {name=p142959 lab=_60063_/Y }
C {devices/lab_pin.sym} 144220 -41190 0 0 {name=p142960 lab=_60045_/Y }
C {devices/lab_pin.sym} 144220 -41150 0 0 {name=p142961 lab=_60138_/Y }
C {devices/lab_pin.sym} 144220 -41120 0 0 {name=p142962 lab=_60139_/Y }
C {devices/lab_pin.sym} 144380 -41190 0 1 {name=p142963 lab=_60140_/Y }
C {sky130_stdcells/a41oi_4.sym} 144300 -41190 0 0 {name=X_60140_ }
C {devices/lab_pin.sym} 144220 -41050 0 0 {name=p142964 lab=_72122_/Y }
C {devices/lab_pin.sym} 144220 -41010 0 0 {name=p142965 lab=_72125_/Y }
C {devices/lab_pin.sym} 144220 -40970 0 0 {name=p142966 lab=_59351_/X }
C {devices/lab_pin.sym} 144380 -41010 0 1 {name=p142967 lab=_72126_/X }
C {sky130_stdcells/a21o_4.sym} 144300 -41010 0 0 {name=X_72126_ }
C {devices/lab_pin.sym} 144260 -40870 0 0 {name=p142968 lab=clkbuf_9_159_0_CLK/X }
C {devices/lab_pin.sym} 144340 -40870 0 1 {name=p142969 lab=_85379_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 144300 -40870 0 0 {name=Xclkbuf_10_319_0_CLK }
C {devices/lab_pin.sym} 144260 -40750 0 0 {name=p142970 lab=_49924_/A }
C {devices/lab_pin.sym} 144340 -40750 0 1 {name=p142971 lab=_49951_/X }
C {sky130_stdcells/buf_2.sym} 144300 -40750 0 0 {name=X_49951_ }
C {devices/lab_pin.sym} 144220 -40650 0 0 {name=p142972 lab=_56317_/C }
C {devices/lab_pin.sym} 144220 -40610 0 0 {name=p142973 lab=_45056_/X }
C {devices/lab_pin.sym} 144220 -40570 0 0 {name=p142974 lab=_45012_/X }
C {devices/lab_pin.sym} 144380 -40610 0 1 {name=p142975 lab=_45074_/X }
C {sky130_stdcells/o21a_4.sym} 144300 -40610 0 0 {name=X_45074_ }
C {devices/lab_pin.sym} 144220 -40510 0 0 {name=p142976 lab=_42279_/X }
C {devices/lab_pin.sym} 144220 -40470 0 0 {name=p142977 lab=_42275_/X }
C {devices/lab_pin.sym} 144220 -40430 0 0 {name=p142978 lab=_41545_/X }
C {devices/lab_pin.sym} 144220 -40390 0 0 {name=p142979 lab=_87939_/Q }
C {devices/lab_pin.sym} 144220 -40350 0 0 {name=p142980 lab=_42276_/X }
C {devices/lab_pin.sym} 144380 -40430 0 1 {name=p142981 lab=_42287_/A }
C {sky130_stdcells/o32ai_4.sym} 144300 -40430 0 0 {name=X_42286_ }
C {devices/lab_pin.sym} 144240 -40290 0 0 {name=p142982 lab=_77983_/A }
C {devices/lab_pin.sym} 144240 -40250 0 0 {name=p142983 lab=_77983_/B }
C {devices/lab_pin.sym} 144240 -40210 0 0 {name=p142984 lab=_77983_/C }
C {devices/lab_pin.sym} 144360 -40250 0 1 {name=p142985 lab=_77983_/Y }
C {sky130_stdcells/nand3_4.sym} 144300 -40250 0 0 {name=X_77983_ }
C {devices/lab_pin.sym} 144260 -40110 0 0 {name=p142986 lab=clkbuf_9_474_0_CLK/X }
C {devices/lab_pin.sym} 144340 -40110 0 1 {name=p142987 lab=_86218_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 144300 -40110 0 0 {name=Xclkbuf_10_949_0_CLK }
C {devices/lab_pin.sym} 144220 -40010 0 0 {name=p142988 lab=_64658_/B }
C {devices/lab_pin.sym} 144220 -39970 0 0 {name=p142989 lab=_48896_/X }
C {devices/lab_pin.sym} 144220 -39930 0 0 {name=p142990 lab=_48901_/Y }
C {devices/lab_pin.sym} 144380 -39970 0 1 {name=p142991 lab=_48902_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -39970 0 0 {name=X_48902_ }
C {devices/lab_pin.sym} 144260 -39830 0 0 {name=p142992 lab=_44025_/A }
C {devices/lab_pin.sym} 144340 -39830 0 1 {name=p142993 lab=_44025_/X }
C {sky130_stdcells/buf_2.sym} 144300 -39830 0 0 {name=X_44025_ }
C {devices/lab_pin.sym} 144240 -39720 0 0 {name=p142994 lab=_79722_/A }
C {devices/lab_pin.sym} 144240 -39680 0 0 {name=p142995 lab=_79722_/B }
C {devices/lab_pin.sym} 144360 -39700 0 1 {name=p142996 lab=_79722_/X }
C {sky130_stdcells/xor2_4.sym} 144300 -39700 0 0 {name=X_79722_ }
C {devices/lab_pin.sym} 144220 -39610 0 0 {name=p142997 lab=_41205_/X }
C {devices/lab_pin.sym} 144220 -39570 0 0 {name=p142998 lab=_41206_/X }
C {devices/lab_pin.sym} 144220 -39530 0 0 {name=p142999 lab=_41234_/X }
C {devices/lab_pin.sym} 144220 -39490 0 0 {name=p143000 lab=_88252_/Q }
C {devices/lab_pin.sym} 144220 -39450 0 0 {name=p143001 lab=_41236_/X }
C {devices/lab_pin.sym} 144380 -39530 0 1 {name=p143002 lab=_41237_/Y }
C {sky130_stdcells/o32ai_4.sym} 144300 -39530 0 0 {name=X_41237_ }
C {devices/lab_pin.sym} 144260 -39370 0 0 {name=p143003 lab=_76934_/A }
C {devices/lab_pin.sym} 144340 -39370 0 1 {name=p143004 lab=_76934_/Y }
C {sky130_stdcells/inv_2.sym} 144300 -39370 0 0 {name=X_76934_ }
C {devices/lab_pin.sym} 144220 -39280 0 0 {name=p143005 lab=_60011_/X }
C {devices/lab_pin.sym} 144220 -39240 0 0 {name=p143006 lab=_59995_/X }
C {devices/lab_pin.sym} 144220 -39200 0 0 {name=p143007 lab=_61277_/C }
C {devices/lab_pin.sym} 144220 -39160 0 0 {name=p143008 lab=_60070_/Y }
C {devices/lab_pin.sym} 144380 -39220 0 1 {name=p143009 lab=_60071_/X }
C {sky130_stdcells/a211o_4.sym} 144300 -39220 0 0 {name=X_60071_ }
C {devices/lab_pin.sym} 144240 -39080 0 0 {name=p143010 lab=_72040_/A }
C {devices/lab_pin.sym} 144240 -39040 0 0 {name=p143011 lab=_49083_/A }
C {devices/lab_pin.sym} 144360 -39060 0 1 {name=p143012 lab=_72057_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -39060 0 0 {name=X_72057_ }
C {devices/lab_pin.sym} 144240 -38940 0 0 {name=p143013 lab=_49901_/A }
C {devices/lab_pin.sym} 144240 -38900 0 0 {name=p143014 lab=_53095_/B }
C {devices/lab_pin.sym} 144360 -38920 0 1 {name=p143015 lab=_49882_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -38920 0 0 {name=X_49882_ }
C {devices/lab_pin.sym} 144240 -38810 0 0 {name=p143016 lab=_71055_/A }
C {devices/lab_pin.sym} 144240 -38770 0 0 {name=p143017 lab=_71066_/B }
C {devices/lab_pin.sym} 144240 -38730 0 0 {name=p143018 lab=_71001_/C }
C {devices/lab_pin.sym} 144360 -38770 0 1 {name=p143019 lab=_71008_/Y }
C {sky130_stdcells/nand3_4.sym} 144300 -38770 0 0 {name=X_71008_ }
C {devices/lab_pin.sym} 144260 -38630 0 0 {name=p143020 lab=_48833_/A }
C {devices/lab_pin.sym} 144340 -38630 0 1 {name=p143021 lab=_48849_/B }
C {sky130_stdcells/buf_2.sym} 144300 -38630 0 0 {name=X_48833_ }
C {devices/lab_pin.sym} 144220 -38530 0 0 {name=p143022 lab=_79645_/B }
C {devices/lab_pin.sym} 144220 -38490 0 0 {name=p143023 lab=_79639_/X }
C {devices/lab_pin.sym} 144220 -38450 0 0 {name=p143024 lab=_79652_/X }
C {devices/lab_pin.sym} 144380 -38490 0 1 {name=p143025 lab=_79653_/Y }
C {sky130_stdcells/a21boi_4.sym} 144300 -38490 0 0 {name=X_79653_ }
C {devices/lab_pin.sym} 144220 -38370 0 0 {name=p143026 lab=_41143_/X }
C {devices/lab_pin.sym} 144220 -38330 0 0 {name=p143027 lab=_40648_/A }
C {devices/lab_pin.sym} 144220 -38290 0 0 {name=p143028 lab=_41167_/X }
C {devices/lab_pin.sym} 144380 -38330 0 1 {name=p143029 lab=_41168_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -38330 0 0 {name=X_41168_ }
C {devices/lab_pin.sym} 144240 -38200 0 0 {name=p143030 lab=_81498_/Q }
C {devices/lab_pin.sym} 144240 -38160 0 0 {name=p143031 lab=_81370_/D }
C {devices/lab_pin.sym} 144360 -38180 0 1 {name=p143032 lab=_76910_/A }
C {sky130_stdcells/xor2_4.sym} 144300 -38180 0 0 {name=X_76865_ }
C {devices/lab_pin.sym} 144220 -38070 0 0 {name=p143033 lab=_78591_/A }
C {devices/lab_pin.sym} 144220 -38030 0 0 {name=p143034 lab=_78602_/Y }
C {devices/lab_pin.sym} 144220 -37990 0 0 {name=p143035 lab=_78603_/Y }
C {devices/lab_pin.sym} 144380 -38030 0 1 {name=p143036 lab=_78604_/X }
C {sky130_stdcells/a21bo_4.sym} 144300 -38030 0 0 {name=X_78604_ }
C {devices/lab_pin.sym} 144260 -37890 0 0 {name=p143037 lab=_64184_/A }
C {devices/lab_pin.sym} 144340 -37890 0 1 {name=p143038 lab=_63831_/A }
C {sky130_stdcells/buf_2.sym} 144300 -37890 0 0 {name=X_63830_ }
C {devices/lab_pin.sym} 144260 -37770 0 0 {name=p143039 lab=_80925_/Q }
C {devices/lab_pin.sym} 144340 -37770 0 1 {name=p143040 lab=_75818_/A }
C {sky130_stdcells/inv_2.sym} 144300 -37770 0 0 {name=X_75816_ }
C {devices/lab_pin.sym} 144220 -37670 0 0 {name=p143041 lab=_73042_/B }
C {devices/lab_pin.sym} 144220 -37630 0 0 {name=p143042 lab=_48754_/X }
C {devices/lab_pin.sym} 144220 -37590 0 0 {name=p143043 lab=_48763_/Y }
C {devices/lab_pin.sym} 144380 -37630 0 1 {name=p143044 lab=_48764_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -37630 0 0 {name=X_48764_ }
C {devices/lab_pin.sym} 144260 -37490 0 0 {name=p143045 lab=_79584_/A }
C {devices/lab_pin.sym} 144340 -37490 0 1 {name=p143046 lab=_79586_/A }
C {sky130_stdcells/buf_2.sym} 144300 -37490 0 0 {name=X_79584_ }
C {devices/lab_pin.sym} 144260 -37370 0 0 {name=p143047 lab=_45975_/X }
C {devices/lab_pin.sym} 144340 -37370 0 1 {name=p143048 lab=_45976_/X }
C {sky130_stdcells/buf_2.sym} 144300 -37370 0 0 {name=X_45976_ }
C {devices/lab_pin.sym} 144220 -37280 0 0 {name=p143049 lab=_41098_/X }
C {devices/lab_pin.sym} 144220 -37240 0 0 {name=p143050 lab=_41065_/X }
C {devices/lab_pin.sym} 144220 -37200 0 0 {name=p143051 lab=_69536_/B }
C {devices/lab_pin.sym} 144220 -37160 0 0 {name=p143052 lab=_41066_/X }
C {devices/lab_pin.sym} 144380 -37220 0 1 {name=p143053 lab=_88278_/D }
C {sky130_stdcells/a2bb2o_4.sym} 144300 -37220 0 0 {name=X_41099_ }
C {devices/lab_pin.sym} 144260 -37070 0 0 {name=p143054 lab=_76785_/Y }
C {devices/lab_pin.sym} 144340 -37070 0 1 {name=p143055 lab=_81361_/D }
C {sky130_stdcells/inv_2.sym} 144300 -37070 0 0 {name=X_76796_ }
C {devices/lab_pin.sym} 144260 -36950 0 0 {name=p143056 lab=_47620_/X }
C {devices/lab_pin.sym} 144340 -36950 0 1 {name=p143057 lab=_47715_/X }
C {sky130_stdcells/buf_2.sym} 144300 -36950 0 0 {name=X_47715_ }
C {devices/lab_pin.sym} 144240 -36840 0 0 {name=p143058 lab=_78547_/A }
C {devices/lab_pin.sym} 144240 -36800 0 0 {name=p143059 lab=_82674_/D }
C {devices/lab_pin.sym} 144360 -36820 0 1 {name=p143060 lab=_78536_/B }
C {sky130_stdcells/xor2_4.sym} 144300 -36820 0 0 {name=X_78535_ }
C {devices/lab_pin.sym} 144220 -36710 0 0 {name=p143061 lab=_85247_/Q }
C {devices/lab_pin.sym} 144220 -36670 0 0 {name=p143062 lab=_44874_/X }
C {devices/lab_pin.sym} 144220 -36630 0 0 {name=p143063 lab=_44926_/X }
C {devices/lab_pin.sym} 144380 -36670 0 1 {name=p143064 lab=_44927_/X }
C {sky130_stdcells/o21a_4.sym} 144300 -36670 0 0 {name=X_44927_ }
C {devices/lab_pin.sym} 144260 -36530 0 0 {name=p143065 lab=_63761_/A }
C {devices/lab_pin.sym} 144340 -36530 0 1 {name=p143066 lab=_63761_/X }
C {sky130_stdcells/buf_2.sym} 144300 -36530 0 0 {name=X_63761_ }
C {devices/lab_pin.sym} 144240 -36420 0 0 {name=p143067 lab=_75747_/A }
C {devices/lab_pin.sym} 144240 -36380 0 0 {name=p143068 lab=_75747_/B }
C {devices/lab_pin.sym} 144360 -36400 0 1 {name=p143069 lab=_75748_/B }
C {sky130_stdcells/xor2_4.sym} 144300 -36400 0 0 {name=X_75747_ }
C {devices/lab_pin.sym} 144240 -36280 0 0 {name=p143070 lab=_48695_/A }
C {devices/lab_pin.sym} 144240 -36240 0 0 {name=p143071 lab=_48695_/B }
C {devices/lab_pin.sym} 144360 -36260 0 1 {name=p143072 lab=_48695_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -36260 0 0 {name=X_48695_ }
C {devices/lab_pin.sym} 144260 -36130 0 0 {name=p143073 lab=_60901_/B }
C {devices/lab_pin.sym} 144340 -36130 0 1 {name=p143074 lab=_61012_/C }
C {sky130_stdcells/buf_2.sym} 144300 -36130 0 0 {name=X_60973_ }
C {devices/lab_pin.sym} 144260 -36010 0 0 {name=p143075 lab=_73257_/A }
C {devices/lab_pin.sym} 144340 -36010 0 1 {name=p143076 lab=_72959_/X }
C {sky130_stdcells/buf_2.sym} 144300 -36010 0 0 {name=X_72959_ }
C {devices/lab_pin.sym} 144240 -35910 0 0 {name=p143077 lab=_64757_/X }
C {devices/lab_pin.sym} 144240 -35870 0 0 {name=p143078 lab=_65548_/B }
C {devices/lab_pin.sym} 144240 -35830 0 0 {name=p143079 lab=_64760_/X }
C {devices/lab_pin.sym} 144360 -35870 0 1 {name=p143080 lab=_65512_/A }
C {sky130_stdcells/nand3_4.sym} 144300 -35870 0 0 {name=X_65500_ }
C {devices/lab_pin.sym} 144220 -35770 0 0 {name=p143081 lab=_58237_/X }
C {devices/lab_pin.sym} 144220 -35730 0 0 {name=p143082 lab=_62689_/X }
C {devices/lab_pin.sym} 144220 -35690 0 0 {name=p143083 lab=_62708_/X }
C {devices/lab_pin.sym} 144220 -35650 0 0 {name=p143084 lab=_62699_/X }
C {devices/lab_pin.sym} 144220 -35620 0 0 {name=p143085 lab=_62711_/X }
C {devices/lab_pin.sym} 144380 -35690 0 1 {name=p143086 lab=_62712_/Y }
C {sky130_stdcells/a41oi_4.sym} 144300 -35690 0 0 {name=X_62712_ }
C {devices/lab_pin.sym} 144220 -35550 0 0 {name=p143087 lab=_47642_/Y }
C {devices/lab_pin.sym} 144220 -35510 0 0 {name=p143088 lab=_47602_/X }
C {devices/lab_pin.sym} 144220 -35470 0 0 {name=p143089 lab=_47645_/X }
C {devices/lab_pin.sym} 144380 -35510 0 1 {name=p143090 lab=_86613_/D }
C {sky130_stdcells/a21oi_4.sym} 144300 -35510 0 0 {name=X_47646_ }
C {devices/lab_pin.sym} 144220 -35390 0 0 {name=p143091 lab=_66477_/Y }
C {devices/lab_pin.sym} 144220 -35350 0 0 {name=p143092 lab=_66449_/X }
C {devices/lab_pin.sym} 144220 -35310 0 0 {name=p143093 lab=_66479_/Y }
C {devices/lab_pin.sym} 144380 -35350 0 1 {name=p143094 lab=_66480_/X }
C {sky130_stdcells/a21o_4.sym} 144300 -35350 0 0 {name=X_66480_ }
C {devices/lab_pin.sym} 144240 -35220 0 0 {name=p143095 lab=_78466_/A }
C {devices/lab_pin.sym} 144240 -35180 0 0 {name=p143096 lab=_78466_/B }
C {devices/lab_pin.sym} 144360 -35200 0 1 {name=p143097 lab=_78466_/X }
C {sky130_stdcells/or2_4.sym} 144300 -35200 0 0 {name=X_78466_ }
C {devices/lab_pin.sym} 144260 -35070 0 0 {name=p143098 lab=_43896_/X }
C {devices/lab_pin.sym} 144340 -35070 0 1 {name=p143099 lab=_44858_/X }
C {sky130_stdcells/buf_2.sym} 144300 -35070 0 0 {name=X_44858_ }
C {devices/lab_pin.sym} 144240 -34970 0 0 {name=p143100 lab=_63701_/A }
C {devices/lab_pin.sym} 144240 -34930 0 0 {name=p143101 lab=_63701_/B }
C {devices/lab_pin.sym} 144240 -34890 0 0 {name=p143102 lab=_80310_/B }
C {devices/lab_pin.sym} 144360 -34930 0 1 {name=p143103 lab=_63692_/Y }
C {sky130_stdcells/nor3_4.sym} 144300 -34930 0 0 {name=X_63692_ }
C {devices/lab_pin.sym} 144240 -34800 0 0 {name=p143104 lab=_75678_/A }
C {devices/lab_pin.sym} 144240 -34760 0 0 {name=p143105 lab=_75677_/Y }
C {devices/lab_pin.sym} 144360 -34780 0 1 {name=p143106 lab=_75685_/A }
C {sky130_stdcells/xor2_4.sym} 144300 -34780 0 0 {name=X_75678_ }
C {devices/lab_pin.sym} 144240 -34660 0 0 {name=p143107 lab=_65427_/X }
C {devices/lab_pin.sym} 144240 -34620 0 0 {name=p143108 lab=_65431_/B }
C {devices/lab_pin.sym} 144360 -34640 0 1 {name=p143109 lab=_65431_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -34640 0 0 {name=X_65431_ }
C {devices/lab_pin.sym} 144240 -34520 0 0 {name=p143110 lab=_77417_/A }
C {devices/lab_pin.sym} 144240 -34480 0 0 {name=p143111 lab=_77417_/B }
C {devices/lab_pin.sym} 144360 -34500 0 1 {name=p143112 lab=_77417_/X }
C {sky130_stdcells/xor2_4.sym} 144300 -34500 0 0 {name=X_77417_ }
C {devices/lab_pin.sym} 144260 -34370 0 0 {name=p143113 lab=_40554_/X }
C {devices/lab_pin.sym} 144340 -34370 0 1 {name=p143114 lab=_43810_/A }
C {sky130_stdcells/buf_2.sym} 144300 -34370 0 0 {name=X_43809_ }
C {devices/lab_pin.sym} 144260 -34250 0 0 {name=p143115 lab=_74675_/A }
C {devices/lab_pin.sym} 144340 -34250 0 1 {name=p143116 lab=_74694_/A }
C {sky130_stdcells/buf_2.sym} 144300 -34250 0 0 {name=X_74629_ }
C {devices/lab_pin.sym} 144260 -34130 0 0 {name=p143117 lab=_60239_/B }
C {devices/lab_pin.sym} 144340 -34130 0 1 {name=p143118 lab=_62924_/C }
C {sky130_stdcells/buf_2.sym} 144300 -34130 0 0 {name=X_62643_ }
C {devices/lab_pin.sym} 144260 -34010 0 0 {name=p143119 lab=_81244_/Q }
C {devices/lab_pin.sym} 144340 -34010 0 1 {name=p143120 lab=_47578_/A }
C {sky130_stdcells/inv_2.sym} 144300 -34010 0 0 {name=X_47577_ }
C {devices/lab_pin.sym} 144240 -33900 0 0 {name=p143121 lab=_78369_/A }
C {devices/lab_pin.sym} 144240 -33860 0 0 {name=p143122 lab=_78397_/B }
C {devices/lab_pin.sym} 144360 -33880 0 1 {name=p143123 lab=_78397_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -33880 0 0 {name=X_78397_ }
C {devices/lab_pin.sym} 144260 -33750 0 0 {name=p143124 lab=_44650_/A }
C {devices/lab_pin.sym} 144340 -33750 0 1 {name=p143125 lab=_44789_/X }
C {sky130_stdcells/buf_2.sym} 144300 -33750 0 0 {name=X_44789_ }
C {devices/lab_pin.sym} 144260 -33630 0 0 {name=p143126 lab=_49405_/A }
C {devices/lab_pin.sym} 144340 -33630 0 1 {name=p143127 lab=_49316_/X }
C {sky130_stdcells/buf_2.sym} 144300 -33630 0 0 {name=X_49316_ }
C {devices/lab_pin.sym} 144220 -33540 0 0 {name=p143128 lab=_68144_/X }
C {devices/lab_pin.sym} 144220 -33500 0 0 {name=p143129 lab=_66934_/Y }
C {devices/lab_pin.sym} 144220 -33460 0 0 {name=p143130 lab=_68148_/X }
C {devices/lab_pin.sym} 144220 -33420 0 0 {name=p143131 lab=_68149_/Y }
C {devices/lab_pin.sym} 144380 -33480 0 1 {name=p143132 lab=_68150_/X }
C {sky130_stdcells/a211o_4.sym} 144300 -33480 0 0 {name=X_68150_ }
C {devices/lab_pin.sym} 144240 -33340 0 0 {name=p143133 lab=_46528_/A }
C {devices/lab_pin.sym} 144240 -33300 0 0 {name=p143134 lab=_46527_/X }
C {devices/lab_pin.sym} 144360 -33320 0 1 {name=p143135 lab=_46528_/X }
C {sky130_stdcells/or2_4.sym} 144300 -33320 0 0 {name=X_46528_ }
C {devices/lab_pin.sym} 144260 -33190 0 0 {name=p143136 lab=_65859_/A }
C {devices/lab_pin.sym} 144340 -33190 0 1 {name=p143137 lab=_65362_/X }
C {sky130_stdcells/buf_2.sym} 144300 -33190 0 0 {name=X_65362_ }
C {devices/lab_pin.sym} 144220 -33090 0 0 {name=p143138 lab=_77316_/B }
C {devices/lab_pin.sym} 144220 -33050 0 0 {name=p143139 lab=_77334_/A }
C {devices/lab_pin.sym} 144220 -33010 0 0 {name=p143140 lab=_77333_/A }
C {devices/lab_pin.sym} 144380 -33050 0 1 {name=p143141 lab=_77348_/X }
C {sky130_stdcells/o21a_4.sym} 144300 -33050 0 0 {name=X_77348_ }
C {devices/lab_pin.sym} 144240 -32930 0 0 {name=p143142 lab=_62551_/X }
C {devices/lab_pin.sym} 144240 -32890 0 0 {name=p143143 lab=_62553_/X }
C {devices/lab_pin.sym} 144240 -32850 0 0 {name=p143144 lab=_84400_/Q }
C {devices/lab_pin.sym} 144360 -32890 0 1 {name=p143145 lab=_62574_/Y }
C {sky130_stdcells/nor3_4.sym} 144300 -32890 0 0 {name=X_62574_ }
C {devices/lab_pin.sym} 144220 -32780 0 0 {name=p143146 lab=_87113_/Q }
C {devices/lab_pin.sym} 144220 -32740 0 0 {name=p143147 lab=_67074_/X }
C {devices/lab_pin.sym} 144220 -32700 0 0 {name=p143148 lab=_67075_/X }
C {devices/lab_pin.sym} 144220 -32660 0 0 {name=p143149 lab=_67100_/X }
C {devices/lab_pin.sym} 144380 -32720 0 1 {name=p143150 lab=_67101_/X }
C {sky130_stdcells/a211o_4.sym} 144300 -32720 0 0 {name=X_67101_ }
C {devices/lab_pin.sym} 144220 -32590 0 0 {name=p143151 lab=_79797_/B }
C {devices/lab_pin.sym} 144220 -32550 0 0 {name=p143152 lab=_64255_/X }
C {devices/lab_pin.sym} 144220 -32510 0 0 {name=p143153 lab=_64312_/X }
C {devices/lab_pin.sym} 144380 -32550 0 1 {name=p143154 lab=_64313_/X }
C {sky130_stdcells/a21o_4.sym} 144300 -32550 0 0 {name=X_64313_ }
C {devices/lab_pin.sym} 144260 -32410 0 0 {name=p143155 lab=_49247_/A }
C {devices/lab_pin.sym} 144340 -32410 0 1 {name=p143156 lab=_49247_/X }
C {sky130_stdcells/buf_2.sym} 144300 -32410 0 0 {name=X_49247_ }
C {devices/lab_pin.sym} 144260 -32290 0 0 {name=p143157 lab=_61334_/A }
C {devices/lab_pin.sym} 144340 -32290 0 1 {name=p143158 lab=_61525_/X }
C {sky130_stdcells/buf_2.sym} 144300 -32290 0 0 {name=X_61525_ }
C {devices/lab_pin.sym} 144220 -32200 0 0 {name=p143159 lab=_87380_/Q }
C {devices/lab_pin.sym} 144220 -32160 0 0 {name=p143160 lab=_67987_/X }
C {devices/lab_pin.sym} 144220 -32120 0 0 {name=p143161 lab=_68053_/X }
C {devices/lab_pin.sym} 144220 -32080 0 0 {name=p143162 lab=_68080_/X }
C {devices/lab_pin.sym} 144380 -32140 0 1 {name=p143163 lab=_68081_/X }
C {sky130_stdcells/a211o_4.sym} 144300 -32140 0 0 {name=X_68081_ }
C {devices/lab_pin.sym} 144260 -31990 0 0 {name=p143164 lab=_64789_/A }
C {devices/lab_pin.sym} 144340 -31990 0 1 {name=p143165 lab=_65294_/B }
C {sky130_stdcells/buf_2.sym} 144300 -31990 0 0 {name=X_65293_ }
C {devices/lab_pin.sym} 144240 -31880 0 0 {name=p143166 lab=_46459_/A }
C {devices/lab_pin.sym} 144240 -31840 0 0 {name=p143167 lab=_46459_/B }
C {devices/lab_pin.sym} 144360 -31860 0 1 {name=p143168 lab=_46459_/X }
C {sky130_stdcells/or2_4.sym} 144300 -31860 0 0 {name=X_46459_ }
C {devices/lab_pin.sym} 144240 -31740 0 0 {name=p143169 lab=_77279_/A }
C {devices/lab_pin.sym} 144240 -31700 0 0 {name=p143170 lab=_82086_/D }
C {devices/lab_pin.sym} 144360 -31720 0 1 {name=p143171 lab=_77279_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -31720 0 0 {name=X_77279_ }
C {devices/lab_pin.sym} 144260 -31590 0 0 {name=p143172 lab=_66794_/A }
C {devices/lab_pin.sym} 144340 -31590 0 1 {name=p143173 lab=_67032_/X }
C {sky130_stdcells/buf_2.sym} 144300 -31590 0 0 {name=X_67032_ }
C {devices/lab_pin.sym} 144240 -31480 0 0 {name=p143174 lab=_79018_/A }
C {devices/lab_pin.sym} 144240 -31440 0 0 {name=p143175 lab=_79017_/Y }
C {devices/lab_pin.sym} 144360 -31460 0 1 {name=p143176 lab=_79019_/B }
C {sky130_stdcells/xnor2_4.sym} 144300 -31460 0 0 {name=X_79018_ }
C {devices/lab_pin.sym} 144260 -31330 0 0 {name=p143177 lab=_64303_/A }
C {devices/lab_pin.sym} 144340 -31330 0 1 {name=p143178 lab=_64273_/B }
C {sky130_stdcells/buf_2.sym} 144300 -31330 0 0 {name=X_64244_ }
C {devices/lab_pin.sym} 144220 -31230 0 0 {name=p143179 lab=_65357_/B }
C {devices/lab_pin.sym} 144220 -31190 0 0 {name=p143180 lab=_49153_/X }
C {devices/lab_pin.sym} 144220 -31150 0 0 {name=p143181 lab=_49177_/Y }
C {devices/lab_pin.sym} 144380 -31190 0 1 {name=p143182 lab=_49178_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -31190 0 0 {name=X_49178_ }
C {devices/lab_pin.sym} 144240 -31070 0 0 {name=p143183 lab=_61434_/A }
C {devices/lab_pin.sym} 144240 -31030 0 0 {name=p143184 lab=_61434_/B }
C {devices/lab_pin.sym} 144240 -30990 0 0 {name=p143185 lab=_84479_/Q }
C {devices/lab_pin.sym} 144360 -31030 0 1 {name=p143186 lab=_61456_/Y }
C {sky130_stdcells/nor3_4.sym} 144300 -31030 0 0 {name=X_61456_ }
C {devices/lab_pin.sym} 144240 -30900 0 0 {name=p143187 lab=_59354_/Y }
C {devices/lab_pin.sym} 144240 -30860 0 0 {name=p143188 lab=_66332_/C }
C {devices/lab_pin.sym} 144360 -30880 0 1 {name=p143189 lab=_80292_/A }
C {sky130_stdcells/nand2_4.sym} 144300 -30880 0 0 {name=X_80290_ }
C {devices/lab_pin.sym} 144260 -30750 0 0 {name=p143190 lab=clkbuf_4_9_1_CLK/X }
C {devices/lab_pin.sym} 144340 -30750 0 1 {name=p143191 lab=clkbuf_6_39_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 144300 -30750 0 0 {name=Xclkbuf_5_19_0_CLK }
C {devices/lab_pin.sym} 144220 -30650 0 0 {name=p143192 lab=_48125_/Y }
C {devices/lab_pin.sym} 144220 -30610 0 0 {name=p143193 lab=_48109_/X }
C {devices/lab_pin.sym} 144220 -30570 0 0 {name=p143194 lab=_48128_/X }
C {devices/lab_pin.sym} 144380 -30610 0 1 {name=p143195 lab=_86565_/D }
C {sky130_stdcells/a21oi_4.sym} 144300 -30610 0 0 {name=X_48129_ }
C {devices/lab_pin.sym} 144240 -30490 0 0 {name=p143196 lab=_60407_/A }
C {devices/lab_pin.sym} 144240 -30450 0 0 {name=p143197 lab=_61293_/B }
C {devices/lab_pin.sym} 144240 -30410 0 0 {name=p143198 lab=_60407_/C }
C {devices/lab_pin.sym} 144360 -30450 0 1 {name=p143199 lab=_60408_/C }
C {sky130_stdcells/and3_4.sym} 144300 -30450 0 0 {name=X_60407_ }
C {devices/lab_pin.sym} 144240 -30330 0 0 {name=p143200 lab=_64187_/A }
C {devices/lab_pin.sym} 144240 -30290 0 0 {name=p143201 lab=_64187_/B }
C {devices/lab_pin.sym} 144240 -30250 0 0 {name=p143202 lab=_79921_/A }
C {devices/lab_pin.sym} 144360 -30290 0 1 {name=p143203 lab=_64175_/Y }
C {sky130_stdcells/nor3_4.sym} 144300 -30290 0 0 {name=X_64175_ }
C {devices/lab_pin.sym} 144260 -30150 0 0 {name=p143204 lab=_84852_/Q }
C {devices/lab_pin.sym} 144340 -30150 0 1 {name=p143205 lab=_61387_/X }
C {sky130_stdcells/buf_2.sym} 144300 -30150 0 0 {name=X_61387_ }
C {devices/lab_pin.sym} 144220 -30050 0 0 {name=p143206 lab=_86066_/Q }
C {devices/lab_pin.sym} 144220 -30010 0 0 {name=p143207 lab=_51128_/X }
C {devices/lab_pin.sym} 144220 -29970 0 0 {name=p143208 lab=_51139_/Y }
C {devices/lab_pin.sym} 144380 -30010 0 1 {name=p143209 lab=_51140_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -30010 0 0 {name=X_51140_ }
C {devices/lab_pin.sym} 144220 -29910 0 0 {name=p143210 lab=_63119_/Y }
C {devices/lab_pin.sym} 144220 -29870 0 0 {name=p143211 lab=_63121_/X }
C {devices/lab_pin.sym} 144220 -29830 0 0 {name=p143212 lab=_63122_/X }
C {devices/lab_pin.sym} 144220 -29790 0 0 {name=p143213 lab=_63124_/X }
C {devices/lab_pin.sym} 144220 -29750 0 0 {name=p143214 lab=_63125_/X }
C {devices/lab_pin.sym} 144380 -29830 0 1 {name=p143215 lab=_63126_/Y }
C {sky130_stdcells/o41ai_4.sym} 144300 -29830 0 0 {name=X_63126_ }
C {devices/lab_pin.sym} 144220 -29700 0 0 {name=p143216 lab=_79671_/A }
C {devices/lab_pin.sym} 144220 -29660 0 0 {name=p143217 lab=_60323_/X }
C {devices/lab_pin.sym} 144220 -29620 0 0 {name=p143218 lab=_60334_/Y }
C {devices/lab_pin.sym} 144220 -29580 0 0 {name=p143219 lab=_60337_/Y }
C {devices/lab_pin.sym} 144380 -29640 0 1 {name=p143220 lab=_60338_/X }
C {sky130_stdcells/o22a_4.sym} 144300 -29640 0 0 {name=X_60338_ }
C {devices/lab_pin.sym} 144260 -29490 0 0 {name=p143221 lab=_69223_/A }
C {devices/lab_pin.sym} 144340 -29490 0 1 {name=p143222 lab=_69027_/A }
C {sky130_stdcells/buf_2.sym} 144300 -29490 0 0 {name=X_68983_ }
C {devices/lab_pin.sym} 144240 -29400 0 0 {name=p143223 lab=_51056_/A }
C {devices/lab_pin.sym} 144240 -29360 0 0 {name=p143224 lab=_51071_/B }
C {devices/lab_pin.sym} 144240 -29320 0 0 {name=p143225 lab=_51071_/C }
C {devices/lab_pin.sym} 144240 -29280 0 0 {name=p143226 lab=_52763_/D }
C {devices/lab_pin.sym} 144360 -29340 0 1 {name=p143227 lab=_51071_/X }
C {sky130_stdcells/and4_4.sym} 144300 -29340 0 0 {name=X_51071_ }
C {devices/lab_pin.sym} 144240 -29200 0 0 {name=p143228 lab=_67934_/A }
C {devices/lab_pin.sym} 144240 -29160 0 0 {name=p143229 lab=_67933_/X }
C {devices/lab_pin.sym} 144360 -29180 0 1 {name=p143230 lab=_67934_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -29180 0 0 {name=X_67934_ }
C {devices/lab_pin.sym} 144220 -29070 0 0 {name=p143231 lab=_63052_/Y }
C {devices/lab_pin.sym} 144220 -29030 0 0 {name=p143232 lab=_63054_/X }
C {devices/lab_pin.sym} 144220 -28990 0 0 {name=p143233 lab=_63056_/X }
C {devices/lab_pin.sym} 144380 -29030 0 1 {name=p143234 lab=_63057_/Y }
C {sky130_stdcells/a21oi_4.sym} 144300 -29030 0 0 {name=X_63057_ }
C {devices/lab_pin.sym} 144220 -28920 0 0 {name=p143235 lab=_60268_/Y }
C {devices/lab_pin.sym} 144220 -28880 0 0 {name=p143236 lab=_60259_/A }
C {devices/lab_pin.sym} 144220 -28840 0 0 {name=p143237 lab=_79817_/A }
C {devices/lab_pin.sym} 144220 -28800 0 0 {name=p143238 lab=_59868_/X }
C {devices/lab_pin.sym} 144380 -28860 0 1 {name=p143239 lab=_84643_/D }
C {sky130_stdcells/a2bb2o_4.sym} 144300 -28860 0 0 {name=X_60269_ }
C {devices/lab_pin.sym} 144210 -28710 0 0 {name=p143240 lab=_82629_/CLK }
C {devices/lab_pin.sym} 144210 -28690 0 0 {name=p143241 lab=_83980_/D }
C {devices/lab_pin.sym} 144390 -28710 0 1 {name=p143242 lab=_82628_/D }
C {sky130_stdcells/dfxtp_4.sym} 144300 -28700 0 0 {name=X_83980_ }
C {devices/lab_pin.sym} 144220 -28590 0 0 {name=p143243 lab=_50019_/Y }
C {devices/lab_pin.sym} 144220 -28550 0 0 {name=p143244 lab=_50003_/X }
C {devices/lab_pin.sym} 144220 -28510 0 0 {name=p143245 lab=_50021_/X }
C {devices/lab_pin.sym} 144380 -28550 0 1 {name=p143246 lab=_86280_/D }
C {sky130_stdcells/a21oi_4.sym} 144300 -28550 0 0 {name=X_50022_ }
C {devices/lab_pin.sym} 144260 -28410 0 0 {name=p143247 lab=_61856_/A }
C {devices/lab_pin.sym} 144340 -28410 0 1 {name=p143248 lab=_62008_/X }
C {sky130_stdcells/buf_2.sym} 144300 -28410 0 0 {name=X_62008_ }
C {devices/lab_pin.sym} 144210 -28290 0 0 {name=p143249 lab=_82931_/CLK }
C {devices/lab_pin.sym} 144210 -28270 0 0 {name=p143250 lab=_78257_/X }
C {devices/lab_pin.sym} 144390 -28290 0 1 {name=p143251 lab=_82931_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -28280 0 0 {name=X_82931_ }
C {devices/lab_pin.sym} 144260 -28150 0 0 {name=p143252 lab=_68651_/A }
C {devices/lab_pin.sym} 144340 -28150 0 1 {name=p143253 lab=_67865_/X }
C {sky130_stdcells/buf_2.sym} 144300 -28150 0 0 {name=X_67865_ }
C {devices/lab_pin.sym} 144260 -28030 0 0 {name=p143254 lab=_69733_/A }
C {devices/lab_pin.sym} 144340 -28030 0 1 {name=p143255 lab=_69604_/X }
C {sky130_stdcells/buf_2.sym} 144300 -28030 0 0 {name=X_69604_ }
C {devices/lab_pin.sym} 144260 -27910 0 0 {name=p143256 lab=_54882_/A }
C {devices/lab_pin.sym} 144340 -27910 0 1 {name=p143257 lab=_54830_/X }
C {sky130_stdcells/buf_2.sym} 144300 -27910 0 0 {name=X_54830_ }
C {devices/lab_pin.sym} 144260 -27790 0 0 {name=p143258 lab=_69582_/A }
C {devices/lab_pin.sym} 144340 -27790 0 1 {name=p143259 lab=_66816_/X }
C {sky130_stdcells/buf_2.sym} 144300 -27790 0 0 {name=X_66816_ }
C {devices/lab_pin.sym} 144210 -27670 0 0 {name=p143260 lab=_85651_/CLK }
C {devices/lab_pin.sym} 144210 -27650 0 0 {name=p143261 lab=_85650_/D }
C {devices/lab_pin.sym} 144390 -27670 0 1 {name=p143262 lab=_85650_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -27660 0 0 {name=X_85650_ }
C {devices/lab_pin.sym} 144210 -27530 0 0 {name=p143263 lab=_82859_/CLK }
C {devices/lab_pin.sym} 144210 -27510 0 0 {name=p143264 lab=_82862_/D }
C {devices/lab_pin.sym} 144390 -27530 0 1 {name=p143265 lab=_40864_/A }
C {sky130_stdcells/dfxtp_4.sym} 144300 -27520 0 0 {name=X_82862_ }
C {devices/lab_pin.sym} 144240 -27400 0 0 {name=p143266 lab=_67891_/A }
C {devices/lab_pin.sym} 144240 -27360 0 0 {name=p143267 lab=_87200_/Q }
C {devices/lab_pin.sym} 144360 -27380 0 1 {name=p143268 lab=_67796_/X }
C {sky130_stdcells/and2_4.sym} 144300 -27380 0 0 {name=X_67796_ }
C {devices/lab_pin.sym} 144210 -27250 0 0 {name=p143269 lab=_84333_/CLK }
C {devices/lab_pin.sym} 144210 -27230 0 0 {name=p143270 lab=_84601_/D }
C {devices/lab_pin.sym} 144390 -27250 0 1 {name=p143271 lab=_79141_/A }
C {sky130_stdcells/dfxtp_4.sym} 144300 -27240 0 0 {name=X_84601_ }
C {devices/lab_pin.sym} 144210 -27110 0 0 {name=p143272 lab=_81259_/CLK }
C {devices/lab_pin.sym} 144210 -27090 0 0 {name=p143273 lab=_81813_/D }
C {devices/lab_pin.sym} 144390 -27110 0 1 {name=p143274 lab=_81813_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -27100 0 0 {name=X_81813_ }
C {devices/lab_pin.sym} 144220 -26990 0 0 {name=p143275 lab=_69532_/X }
C {devices/lab_pin.sym} 144220 -26950 0 0 {name=p143276 lab=_69534_/X }
C {devices/lab_pin.sym} 144220 -26910 0 0 {name=p143277 lab=_69346_/X }
C {devices/lab_pin.sym} 144380 -26950 0 1 {name=p143278 lab=_69535_/X }
C {sky130_stdcells/a21o_4.sym} 144300 -26950 0 0 {name=X_69535_ }
C {devices/lab_pin.sym} 144240 -26840 0 0 {name=p143279 lab=_54775_/A }
C {devices/lab_pin.sym} 144240 -26800 0 0 {name=p143280 lab=_54755_/B }
C {devices/lab_pin.sym} 144240 -26760 0 0 {name=p143281 lab=_54775_/C }
C {devices/lab_pin.sym} 144240 -26720 0 0 {name=p143282 lab=_47474_/A }
C {devices/lab_pin.sym} 144360 -26780 0 1 {name=p143283 lab=_54761_/X }
C {sky130_stdcells/and4_4.sym} 144300 -26780 0 0 {name=X_54761_ }
C {devices/lab_pin.sym} 144260 -26630 0 0 {name=p143284 lab=_66628_/X }
C {devices/lab_pin.sym} 144340 -26630 0 1 {name=p143285 lab=_66747_/X }
C {sky130_stdcells/buf_2.sym} 144300 -26630 0 0 {name=X_66747_ }
C {devices/lab_pin.sym} 144210 -26510 0 0 {name=p143286 lab=_85581_/CLK }
C {devices/lab_pin.sym} 144210 -26490 0 0 {name=p143287 lab=_53721_/Y }
C {devices/lab_pin.sym} 144390 -26510 0 1 {name=p143288 lab=_85581_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -26500 0 0 {name=X_85581_ }
C {devices/lab_pin.sym} 144240 -26390 0 0 {name=p143289 lab=_50270_/A }
C {devices/lab_pin.sym} 144240 -26350 0 0 {name=p143290 lab=_51972_/X }
C {devices/lab_pin.sym} 144240 -26310 0 0 {name=p143291 lab=_51958_/C }
C {devices/lab_pin.sym} 144360 -26350 0 1 {name=p143292 lab=_51973_/X }
C {sky130_stdcells/and3_4.sym} 144300 -26350 0 0 {name=X_51973_ }
C {devices/lab_pin.sym} 144220 -26250 0 0 {name=p143293 lab=_63954_/X }
C {devices/lab_pin.sym} 144220 -26210 0 0 {name=p143294 lab=_63890_/X }
C {devices/lab_pin.sym} 144220 -26170 0 0 {name=p143295 lab=_63956_/Y }
C {devices/lab_pin.sym} 144220 -26130 0 0 {name=p143296 lab=_63957_/Y }
C {devices/lab_pin.sym} 144220 -26100 0 0 {name=p143297 lab=_63958_/X }
C {devices/lab_pin.sym} 144380 -26170 0 1 {name=p143298 lab=_63959_/X }
C {sky130_stdcells/a41o_4.sym} 144300 -26170 0 0 {name=X_63959_ }
C {devices/lab_pin.sym} 144210 -26010 0 0 {name=p143299 lab=_82792_/CLK }
C {devices/lab_pin.sym} 144210 -25990 0 0 {name=p143300 lab=_82825_/Q }
C {devices/lab_pin.sym} 144390 -26010 0 1 {name=p143301 lab=_78405_/A }
C {sky130_stdcells/dfxtp_4.sym} 144300 -26000 0 0 {name=X_82793_ }
C {devices/lab_pin.sym} 144260 -25870 0 0 {name=p143302 lab=_56525_/A }
C {devices/lab_pin.sym} 144340 -25870 0 1 {name=p143303 lab=_56510_/A }
C {sky130_stdcells/buf_2.sym} 144300 -25870 0 0 {name=X_56500_ }
C {devices/lab_pin.sym} 144210 -25750 0 0 {name=p143304 lab=_87577_/CLK }
C {devices/lab_pin.sym} 144210 -25730 0 0 {name=p143305 lab=_87320_/D }
C {devices/lab_pin.sym} 144390 -25750 0 1 {name=p143306 lab=_74186_/A }
C {sky130_stdcells/dfxtp_4.sym} 144300 -25740 0 0 {name=X_87320_ }
C {devices/lab_pin.sym} 144220 -25630 0 0 {name=p143307 lab=_53710_/Y }
C {devices/lab_pin.sym} 144220 -25590 0 0 {name=p143308 lab=_53680_/X }
C {devices/lab_pin.sym} 144220 -25550 0 0 {name=p143309 lab=_53711_/X }
C {devices/lab_pin.sym} 144380 -25590 0 1 {name=p143310 lab=_53712_/Y }
C {sky130_stdcells/a21oi_4.sym} 144300 -25590 0 0 {name=X_53712_ }
C {devices/lab_pin.sym} 144210 -25450 0 0 {name=p143311 lab=_84538_/CLK }
C {devices/lab_pin.sym} 144210 -25430 0 0 {name=p143312 lab=_84532_/D }
C {devices/lab_pin.sym} 144390 -25450 0 1 {name=p143313 lab=_76980_/A }
C {sky130_stdcells/dfxtp_4.sym} 144300 -25440 0 0 {name=X_84532_ }
C {devices/lab_pin.sym} 144240 -25340 0 0 {name=p143314 lab=_50941_/A }
C {devices/lab_pin.sym} 144240 -25300 0 0 {name=p143315 lab=_50919_/B }
C {devices/lab_pin.sym} 144240 -25260 0 0 {name=p143316 lab=_50948_/C }
C {devices/lab_pin.sym} 144240 -25220 0 0 {name=p143317 lab=_51787_/D }
C {devices/lab_pin.sym} 144360 -25280 0 1 {name=p143318 lab=_50924_/X }
C {sky130_stdcells/and4_4.sym} 144300 -25280 0 0 {name=X_50924_ }
C {devices/lab_pin.sym} 144220 -25150 0 0 {name=p143319 lab=_57484_/A }
C {devices/lab_pin.sym} 144220 -25110 0 0 {name=p143320 lab=_56903_/X }
C {devices/lab_pin.sym} 144220 -25070 0 0 {name=p143321 lab=_57479_/X }
C {devices/lab_pin.sym} 144380 -25110 0 1 {name=p143322 lab=_57481_/A }
C {sky130_stdcells/o21ai_4.sym} 144300 -25110 0 0 {name=X_57480_ }
C {devices/lab_pin.sym} 144210 -24970 0 0 {name=p143323 lab=_88175_/CLK }
C {devices/lab_pin.sym} 144210 -24950 0 0 {name=p143324 lab=_81744_/D }
C {devices/lab_pin.sym} 144390 -24970 0 1 {name=p143325 lab=_41374_/A }
C {sky130_stdcells/dfxtp_4.sym} 144300 -24960 0 0 {name=X_81744_ }
C {devices/lab_pin.sym} 144240 -24840 0 0 {name=p143326 lab=_69302_/A }
C {devices/lab_pin.sym} 144240 -24800 0 0 {name=p143327 lab=_69466_/B }
C {devices/lab_pin.sym} 144360 -24820 0 1 {name=p143328 lab=_69466_/X }
C {sky130_stdcells/and2_4.sym} 144300 -24820 0 0 {name=X_69466_ }
C {devices/lab_pin.sym} 144220 -24710 0 0 {name=p143329 lab=_85395_/Q }
C {devices/lab_pin.sym} 144220 -24670 0 0 {name=p143330 lab=_54676_/X }
C {devices/lab_pin.sym} 144220 -24630 0 0 {name=p143331 lab=_54691_/Y }
C {devices/lab_pin.sym} 144380 -24670 0 1 {name=p143332 lab=_54692_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -24670 0 0 {name=X_54692_ }
C {devices/lab_pin.sym} 144260 -24530 0 0 {name=p143333 lab=_69162_/A }
C {devices/lab_pin.sym} 144340 -24530 0 1 {name=p143334 lab=_66678_/X }
C {sky130_stdcells/buf_2.sym} 144300 -24530 0 0 {name=X_66678_ }
C {devices/lab_pin.sym} 144240 -24430 0 0 {name=p143335 lab=_56431_/A }
C {devices/lab_pin.sym} 144240 -24390 0 0 {name=p143336 lab=_56433_/B }
C {devices/lab_pin.sym} 144240 -24350 0 0 {name=p143337 lab=_85196_/Q }
C {devices/lab_pin.sym} 144360 -24390 0 1 {name=p143338 lab=_56431_/Y }
C {sky130_stdcells/nand3_4.sym} 144300 -24390 0 0 {name=X_56431_ }
C {devices/lab_pin.sym} 144220 -24280 0 0 {name=p143339 lab=_73595_/A }
C {devices/lab_pin.sym} 144220 -24240 0 0 {name=p143340 lab=_68414_/X }
C {devices/lab_pin.sym} 144220 -24200 0 0 {name=p143341 lab=_68379_/X }
C {devices/lab_pin.sym} 144220 -24160 0 0 {name=p143342 lab=_68416_/Y }
C {devices/lab_pin.sym} 144380 -24220 0 1 {name=p143343 lab=_68417_/X }
C {sky130_stdcells/a211o_4.sym} 144300 -24220 0 0 {name=X_68417_ }
C {devices/lab_pin.sym} 144210 -24070 0 0 {name=p143344 lab=_87776_/CLK }
C {devices/lab_pin.sym} 144210 -24050 0 0 {name=p143345 lab=_43821_/Y }
C {devices/lab_pin.sym} 144390 -24070 0 1 {name=p143346 lab=_87251_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -24060 0 0 {name=X_87251_ }
C {devices/lab_pin.sym} 144240 -23940 0 0 {name=p143347 lab=_53611_/X }
C {devices/lab_pin.sym} 144240 -23900 0 0 {name=p143348 lab=_74389_/B }
C {devices/lab_pin.sym} 144360 -23920 0 1 {name=p143349 lab=_53643_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -23920 0 0 {name=X_53643_ }
C {devices/lab_pin.sym} 144240 -23800 0 0 {name=p143350 lab=_65769_/A }
C {devices/lab_pin.sym} 144240 -23760 0 0 {name=p143351 lab=_86516_/Q }
C {devices/lab_pin.sym} 144360 -23780 0 1 {name=p143352 lab=_65629_/X }
C {sky130_stdcells/and2_4.sym} 144300 -23780 0 0 {name=X_65629_ }
C {devices/lab_pin.sym} 144210 -23650 0 0 {name=p143353 lab=_82452_/CLK }
C {devices/lab_pin.sym} 144210 -23630 0 0 {name=p143354 lab=_61647_/Y }
C {devices/lab_pin.sym} 144390 -23650 0 1 {name=p143355 lab=_79131_/B }
C {sky130_stdcells/dfxtp_4.sym} 144300 -23640 0 0 {name=X_84463_ }
C {devices/lab_pin.sym} 144220 -23530 0 0 {name=p143356 lab=_50853_/Y }
C {devices/lab_pin.sym} 144220 -23490 0 0 {name=p143357 lab=_50849_/X }
C {devices/lab_pin.sym} 144220 -23450 0 0 {name=p143358 lab=_50854_/Y }
C {devices/lab_pin.sym} 144380 -23490 0 1 {name=p143359 lab=_86120_/D }
C {sky130_stdcells/a21boi_4.sym} 144300 -23490 0 0 {name=X_50855_ }
C {devices/lab_pin.sym} 144210 -23350 0 0 {name=p143360 lab=_81275_/CLK }
C {devices/lab_pin.sym} 144210 -23330 0 0 {name=p143361 lab=_80023_/Y }
C {devices/lab_pin.sym} 144390 -23350 0 1 {name=p143362 lab=_76874_/A }
C {sky130_stdcells/dfxtp_4.sym} 144300 -23340 0 0 {name=X_81675_ }
C {devices/lab_pin.sym} 144240 -23220 0 0 {name=p143363 lab=_69288_/A }
C {devices/lab_pin.sym} 144240 -23180 0 0 {name=p143364 lab=_69397_/B }
C {devices/lab_pin.sym} 144360 -23200 0 1 {name=p143365 lab=_69397_/X }
C {sky130_stdcells/and2_4.sym} 144300 -23200 0 0 {name=X_69397_ }
C {devices/lab_pin.sym} 144210 -23070 0 0 {name=p143366 lab=_86490_/CLK }
C {devices/lab_pin.sym} 144210 -23050 0 0 {name=p143367 lab=_86202_/D }
C {devices/lab_pin.sym} 144390 -23070 0 1 {name=p143368 lab=_86202_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -23060 0 0 {name=X_86202_ }
C {devices/lab_pin.sym} 144220 -22950 0 0 {name=p143369 lab=_59085_/X }
C {devices/lab_pin.sym} 144220 -22910 0 0 {name=p143370 lab=_86069_/Q }
C {devices/lab_pin.sym} 144220 -22870 0 0 {name=p143371 lab=_59149_/X }
C {devices/lab_pin.sym} 144380 -22910 0 1 {name=p143372 lab=_59150_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -22910 0 0 {name=X_59150_ }
C {devices/lab_pin.sym} 144210 -22770 0 0 {name=p143373 lab=_83414_/CLK }
C {devices/lab_pin.sym} 144210 -22750 0 0 {name=p143374 lab=_83414_/D }
C {devices/lab_pin.sym} 144390 -22770 0 1 {name=p143375 lab=_58480_/A }
C {sky130_stdcells/dfxtp_4.sym} 144300 -22760 0 0 {name=X_83414_ }
C {devices/lab_pin.sym} 144260 -22630 0 0 {name=p143376 lab=_56351_/A }
C {devices/lab_pin.sym} 144340 -22630 0 1 {name=p143377 lab=_56363_/B }
C {sky130_stdcells/buf_2.sym} 144300 -22630 0 0 {name=X_56362_ }
C {devices/lab_pin.sym} 144240 -22520 0 0 {name=p143378 lab=_84777_/Q }
C {devices/lab_pin.sym} 144240 -22480 0 0 {name=p143379 lab=_65916_/C }
C {devices/lab_pin.sym} 144360 -22500 0 1 {name=p143380 lab=_80629_/A }
C {sky130_stdcells/xor2_4.sym} 144300 -22500 0 0 {name=X_80626_ }
C {devices/lab_pin.sym} 144260 -22370 0 0 {name=p143381 lab=_68517_/A }
C {devices/lab_pin.sym} 144340 -22370 0 1 {name=p143382 lab=_68348_/X }
C {sky130_stdcells/buf_2.sym} 144300 -22370 0 0 {name=X_68348_ }
C {devices/lab_pin.sym} 144210 -22250 0 0 {name=p143383 lab=_87183_/CLK }
C {devices/lab_pin.sym} 144210 -22230 0 0 {name=p143384 lab=_87182_/D }
C {devices/lab_pin.sym} 144390 -22250 0 1 {name=p143385 lab=_44053_/A }
C {sky130_stdcells/dfxtp_4.sym} 144300 -22240 0 0 {name=X_87182_ }
C {devices/lab_pin.sym} 144260 -22110 0 0 {name=p143386 lab=_53696_/A }
C {devices/lab_pin.sym} 144340 -22110 0 1 {name=p143387 lab=_53574_/X }
C {sky130_stdcells/buf_2.sym} 144300 -22110 0 0 {name=X_53574_ }
C {devices/lab_pin.sym} 144210 -21990 0 0 {name=p143388 lab=_84393_/CLK }
C {devices/lab_pin.sym} 144210 -21970 0 0 {name=p143389 lab=_84394_/D }
C {devices/lab_pin.sym} 144390 -21990 0 1 {name=p143390 lab=_62636_/C }
C {sky130_stdcells/dfxtp_4.sym} 144300 -21980 0 0 {name=X_84394_ }
C {devices/lab_pin.sym} 144220 -21870 0 0 {name=p143391 lab=_86133_/Q }
C {devices/lab_pin.sym} 144220 -21830 0 0 {name=p143392 lab=_50775_/X }
C {devices/lab_pin.sym} 144220 -21790 0 0 {name=p143393 lab=_50785_/Y }
C {devices/lab_pin.sym} 144380 -21830 0 1 {name=p143394 lab=_50786_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -21830 0 0 {name=X_50786_ }
C {devices/lab_pin.sym} 144220 -21710 0 0 {name=p143395 lab=_58100_/X }
C {devices/lab_pin.sym} 144220 -21670 0 0 {name=p143396 lab=_85477_/Q }
C {devices/lab_pin.sym} 144220 -21630 0 0 {name=p143397 lab=_58062_/X }
C {devices/lab_pin.sym} 144380 -21670 0 1 {name=p143398 lab=_58101_/X }
C {sky130_stdcells/o21a_4.sym} 144300 -21670 0 0 {name=X_58101_ }
C {devices/lab_pin.sym} 144260 -21530 0 0 {name=p143399 lab=_55317_/A }
C {devices/lab_pin.sym} 144340 -21530 0 1 {name=p143400 lab=_55323_/A }
C {sky130_stdcells/buf_2.sym} 144300 -21530 0 0 {name=X_55313_ }
C {devices/lab_pin.sym} 144210 -21410 0 0 {name=p143401 lab=_86424_/CLK }
C {devices/lab_pin.sym} 144210 -21390 0 0 {name=p143402 lab=_86133_/D }
C {devices/lab_pin.sym} 144390 -21410 0 1 {name=p143403 lab=_86133_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -21400 0 0 {name=X_86133_ }
C {devices/lab_pin.sym} 144220 -21290 0 0 {name=p143404 lab=_52523_/Y }
C {devices/lab_pin.sym} 144220 -21250 0 0 {name=p143405 lab=_52496_/X }
C {devices/lab_pin.sym} 144220 -21210 0 0 {name=p143406 lab=_52524_/X }
C {devices/lab_pin.sym} 144380 -21250 0 1 {name=p143407 lab=_52525_/Y }
C {sky130_stdcells/a21oi_4.sym} 144300 -21250 0 0 {name=X_52525_ }
C {devices/lab_pin.sym} 144260 -21110 0 0 {name=p143408 lab=_59081_/A }
C {devices/lab_pin.sym} 144340 -21110 0 1 {name=p143409 lab=_59081_/X }
C {sky130_stdcells/buf_2.sym} 144300 -21110 0 0 {name=X_59081_ }
C {devices/lab_pin.sym} 144210 -20990 0 0 {name=p143410 lab=_83338_/CLK }
C {devices/lab_pin.sym} 144210 -20970 0 0 {name=p143411 lab=_71875_/X }
C {devices/lab_pin.sym} 144390 -20990 0 1 {name=p143412 lab=_83345_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -20980 0 0 {name=X_83345_ }
C {devices/lab_pin.sym} 144220 -20870 0 0 {name=p143413 lab=_59078_/Y }
C {devices/lab_pin.sym} 144220 -20830 0 0 {name=p143414 lab=_66016_/Y }
C {devices/lab_pin.sym} 144220 -20790 0 0 {name=p143415 lab=_80556_/Y }
C {devices/lab_pin.sym} 144380 -20830 0 1 {name=p143416 lab=_80557_/X }
C {sky130_stdcells/o21a_4.sym} 144300 -20830 0 0 {name=X_80557_ }
C {devices/lab_pin.sym} 144240 -20710 0 0 {name=p143417 lab=_56368_/A }
C {devices/lab_pin.sym} 144240 -20670 0 0 {name=p143418 lab=_56270_/B }
C {devices/lab_pin.sym} 144240 -20630 0 0 {name=p143419 lab=_85247_/Q }
C {devices/lab_pin.sym} 144360 -20670 0 1 {name=p143420 lab=_56293_/Y }
C {sky130_stdcells/nand3_4.sym} 144300 -20670 0 0 {name=X_56293_ }
C {devices/lab_pin.sym} 144260 -20530 0 0 {name=p143421 lab=_68338_/A }
C {devices/lab_pin.sym} 144340 -20530 0 1 {name=p143422 lab=_68279_/X }
C {sky130_stdcells/buf_2.sym} 144300 -20530 0 0 {name=X_68279_ }
C {devices/lab_pin.sym} 144260 -20410 0 0 {name=p143423 lab=_70246_/A }
C {devices/lab_pin.sym} 144340 -20410 0 1 {name=p143424 lab=_70328_/A }
C {sky130_stdcells/buf_2.sym} 144300 -20410 0 0 {name=X_70310_ }
C {devices/lab_pin.sym} 144220 -20310 0 0 {name=p143425 lab=_58017_/X }
C {devices/lab_pin.sym} 144220 -20270 0 0 {name=p143426 lab=_85387_/Q }
C {devices/lab_pin.sym} 144220 -20230 0 0 {name=p143427 lab=_58031_/X }
C {devices/lab_pin.sym} 144380 -20270 0 1 {name=p143428 lab=_58032_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -20270 0 0 {name=X_58032_ }
C {devices/lab_pin.sym} 144260 -20130 0 0 {name=p143429 lab=_55244_/A }
C {devices/lab_pin.sym} 144340 -20130 0 1 {name=p143430 lab=_55272_/A }
C {sky130_stdcells/buf_2.sym} 144300 -20130 0 0 {name=X_55244_ }
C {devices/lab_pin.sym} 144210 -20010 0 0 {name=p143431 lab=_85748_/CLK }
C {devices/lab_pin.sym} 144210 -19990 0 0 {name=p143432 lab=_51155_/Y }
C {devices/lab_pin.sym} 144390 -20010 0 1 {name=p143433 lab=_86064_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -20000 0 0 {name=X_86064_ }
C {devices/lab_pin.sym} 144220 -19900 0 0 {name=p143434 lab=_40469_/X }
C {devices/lab_pin.sym} 144220 -19860 0 0 {name=p143435 lab=_40410_/X }
C {devices/lab_pin.sym} 144220 -19820 0 0 {name=p143436 lab=_88387_/Q }
C {devices/lab_pin.sym} 144220 -19780 0 0 {name=p143437 lab=_40411_/X }
C {devices/lab_pin.sym} 144380 -19840 0 1 {name=p143438 lab=_40470_/X }
C {sky130_stdcells/a2bb2o_4.sym} 144300 -19840 0 0 {name=X_40470_ }
C {devices/lab_pin.sym} 144240 -19700 0 0 {name=p143439 lab=_52466_/A }
C {devices/lab_pin.sym} 144240 -19660 0 0 {name=p143440 lab=_53976_/B }
C {devices/lab_pin.sym} 144360 -19680 0 1 {name=p143441 lab=_52456_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -19680 0 0 {name=X_52456_ }
C {devices/lab_pin.sym} 144260 -19550 0 0 {name=p143442 lab=_71289_/Y }
C {devices/lab_pin.sym} 144340 -19550 0 1 {name=p143443 lab=_71290_/X }
C {sky130_stdcells/buf_2.sym} 144300 -19550 0 0 {name=X_71290_ }
C {devices/lab_pin.sym} 144210 -19430 0 0 {name=p143444 lab=_83278_/CLK }
C {devices/lab_pin.sym} 144210 -19410 0 0 {name=p143445 lab=_83276_/D }
C {devices/lab_pin.sym} 144390 -19430 0 1 {name=p143446 lab=_83276_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -19420 0 0 {name=X_83276_ }
C {devices/lab_pin.sym} 144240 -19300 0 0 {name=p143447 lab=_80480_/A }
C {devices/lab_pin.sym} 144240 -19260 0 0 {name=p143448 lab=_80471_/A }
C {devices/lab_pin.sym} 144360 -19280 0 1 {name=p143449 lab=_80488_/X }
C {sky130_stdcells/and2_4.sym} 144300 -19280 0 0 {name=X_80488_ }
C {devices/lab_pin.sym} 144210 -19150 0 0 {name=p143450 lab=_85013_/CLK }
C {devices/lab_pin.sym} 144210 -19130 0 0 {name=p143451 lab=_85015_/D }
C {devices/lab_pin.sym} 144390 -19150 0 1 {name=p143452 lab=_57401_/B }
C {sky130_stdcells/dfxtp_4.sym} 144300 -19140 0 0 {name=X_85015_ }
C {devices/lab_pin.sym} 144220 -19030 0 0 {name=p143453 lab=_51405_/Y }
C {devices/lab_pin.sym} 144220 -18990 0 0 {name=p143454 lab=_51229_/X }
C {devices/lab_pin.sym} 144220 -18950 0 0 {name=p143455 lab=_51406_/X }
C {devices/lab_pin.sym} 144380 -18990 0 1 {name=p143456 lab=_86016_/D }
C {sky130_stdcells/a21oi_4.sym} 144300 -18990 0 0 {name=X_51407_ }
C {devices/lab_pin.sym} 144240 -18880 0 0 {name=p143457 lab=_70239_/A }
C {devices/lab_pin.sym} 144240 -18840 0 0 {name=p143458 lab=_70239_/B }
C {devices/lab_pin.sym} 144240 -18800 0 0 {name=p143459 lab=_70241_/C }
C {devices/lab_pin.sym} 144240 -18760 0 0 {name=p143460 lab=_70239_/D }
C {devices/lab_pin.sym} 144360 -18820 0 1 {name=p143461 lab=_70241_/X }
C {sky130_stdcells/and4_4.sym} 144300 -18820 0 0 {name=X_70241_ }
C {devices/lab_pin.sym} 144210 -18670 0 0 {name=p143462 lab=_81094_/CLK }
C {devices/lab_pin.sym} 144210 -18650 0 0 {name=p143463 lab=_82259_/Q }
C {devices/lab_pin.sym} 144390 -18670 0 1 {name=p143464 lab=_77473_/A }
C {sky130_stdcells/dfxtp_4.sym} 144300 -18660 0 0 {name=X_82227_ }
C {devices/lab_pin.sym} 144260 -18530 0 0 {name=p143465 lab=_55174_/X }
C {devices/lab_pin.sym} 144340 -18530 0 1 {name=p143466 lab=_55177_/A }
C {sky130_stdcells/buf_2.sym} 144300 -18530 0 0 {name=X_55175_ }
C {devices/lab_pin.sym} 144240 -18420 0 0 {name=p143467 lab=_52373_/X }
C {devices/lab_pin.sym} 144240 -18380 0 0 {name=p143468 lab=_49135_/X }
C {devices/lab_pin.sym} 144360 -18400 0 1 {name=p143469 lab=_52387_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -18400 0 0 {name=X_52387_ }
C {devices/lab_pin.sym} 144260 -18270 0 0 {name=p143470 lab=clkbuf_6_51_0_CLK/X }
C {devices/lab_pin.sym} 144340 -18270 0 1 {name=p143471 lab=clkbuf_8_205_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 144300 -18270 0 0 {name=Xclkbuf_7_102_0_CLK }
C {devices/lab_pin.sym} 144260 -18150 0 0 {name=p143472 lab=clkbuf_9_145_0_CLK/X }
C {devices/lab_pin.sym} 144340 -18150 0 1 {name=p143473 lab=_84921_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 144300 -18150 0 0 {name=Xclkbuf_10_290_0_CLK }
C {devices/lab_pin.sym} 144220 -18050 0 0 {name=p143474 lab=_85499_/Q }
C {devices/lab_pin.sym} 144220 -18010 0 0 {name=p143475 lab=_54113_/X }
C {devices/lab_pin.sym} 144220 -17970 0 0 {name=p143476 lab=_54125_/Y }
C {devices/lab_pin.sym} 144380 -18010 0 1 {name=p143477 lab=_54126_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -18010 0 0 {name=X_54126_ }
C {devices/lab_pin.sym} 144220 -17900 0 0 {name=p143478 lab=_41134_/X }
C {devices/lab_pin.sym} 144220 -17860 0 0 {name=p143479 lab=_42137_/X }
C {devices/lab_pin.sym} 144220 -17820 0 0 {name=p143480 lab=_88015_/Q }
C {devices/lab_pin.sym} 144220 -17780 0 0 {name=p143481 lab=_42138_/X }
C {devices/lab_pin.sym} 144380 -17840 0 1 {name=p143482 lab=_88015_/D }
C {sky130_stdcells/a2bb2o_4.sym} 144300 -17840 0 0 {name=X_42140_ }
C {devices/lab_pin.sym} 144260 -17690 0 0 {name=p143483 lab=_51822_/A }
C {devices/lab_pin.sym} 144340 -17690 0 1 {name=p143484 lab=_51793_/A }
C {sky130_stdcells/buf_2.sym} 144300 -17690 0 0 {name=X_51338_ }
C {devices/lab_pin.sym} 144210 -17570 0 0 {name=p143485 lab=_84197_/CLK }
C {devices/lab_pin.sym} 144210 -17550 0 0 {name=p143486 lab=_84150_/Q }
C {devices/lab_pin.sym} 144390 -17570 0 1 {name=p143487 lab=_82158_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -17560 0 0 {name=X_82158_ }
C {devices/lab_pin.sym} 144260 -17430 0 0 {name=p143488 lab=_70154_/X }
C {devices/lab_pin.sym} 144340 -17430 0 1 {name=p143489 lab=_70232_/A }
C {sky130_stdcells/buf_2.sym} 144300 -17430 0 0 {name=X_70172_ }
C {devices/lab_pin.sym} 144220 -17350 0 0 {name=p143490 lab=_59881_/X }
C {devices/lab_pin.sym} 144220 -17310 0 0 {name=p143491 lab=_59971_/X }
C {devices/lab_pin.sym} 144220 -17270 0 0 {name=p143492 lab=_59979_/Y }
C {devices/lab_pin.sym} 144220 -17230 0 0 {name=p143493 lab=_59981_/Y }
C {devices/lab_pin.sym} 144220 -17200 0 0 {name=p143494 lab=_59982_/Y }
C {devices/lab_pin.sym} 144380 -17270 0 1 {name=p143495 lab=_84679_/D }
C {sky130_stdcells/a41oi_4.sym} 144300 -17270 0 0 {name=X_59983_ }
C {devices/lab_pin.sym} 144260 -17110 0 0 {name=p143496 lab=clkbuf_9_36_0_CLK/X }
C {devices/lab_pin.sym} 144340 -17110 0 1 {name=p143497 lab=_83013_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 144300 -17110 0 0 {name=Xclkbuf_10_72_0_CLK }
C {devices/lab_pin.sym} 144210 -16990 0 0 {name=p143498 lab=_81104_/CLK }
C {devices/lab_pin.sym} 144210 -16970 0 0 {name=p143499 lab=_79760_/X }
C {devices/lab_pin.sym} 144390 -16990 0 1 {name=p143500 lab=_81109_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -16980 0 0 {name=X_81109_ }
C {devices/lab_pin.sym} 144260 -16850 0 0 {name=p143501 lab=_42071_/A }
C {devices/lab_pin.sym} 144340 -16850 0 1 {name=p143502 lab=_42071_/Y }
C {sky130_stdcells/inv_2.sym} 144300 -16850 0 0 {name=X_42071_ }
C {devices/lab_pin.sym} 144260 -16730 0 0 {name=p143503 lab=_58641_/A }
C {devices/lab_pin.sym} 144340 -16730 0 1 {name=p143504 lab=_58934_/X }
C {sky130_stdcells/buf_2.sym} 144300 -16730 0 0 {name=X_58934_ }
C {devices/lab_pin.sym} 144220 -16630 0 0 {name=p143505 lab=_54055_/Y }
C {devices/lab_pin.sym} 144220 -16590 0 0 {name=p143506 lab=_54006_/X }
C {devices/lab_pin.sym} 144220 -16550 0 0 {name=p143507 lab=_54056_/Y }
C {devices/lab_pin.sym} 144380 -16590 0 1 {name=p143508 lab=_85514_/D }
C {sky130_stdcells/a21boi_4.sym} 144300 -16590 0 0 {name=X_54057_ }
C {devices/lab_pin.sym} 144220 -16470 0 0 {name=p143509 lab=_64780_/B }
C {devices/lab_pin.sym} 144220 -16430 0 0 {name=p143510 lab=_51259_/X }
C {devices/lab_pin.sym} 144220 -16390 0 0 {name=p143511 lab=_51268_/Y }
C {devices/lab_pin.sym} 144380 -16430 0 1 {name=p143512 lab=_51269_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -16430 0 0 {name=X_51269_ }
C {devices/lab_pin.sym} 144240 -16300 0 0 {name=p143513 lab=_81141_/D }
C {devices/lab_pin.sym} 144240 -16260 0 0 {name=p143514 lab=_74980_/B }
C {devices/lab_pin.sym} 144360 -16280 0 1 {name=p143515 lab=_74987_/C }
C {sky130_stdcells/nand2_4.sym} 144300 -16280 0 0 {name=X_74980_ }
C {devices/lab_pin.sym} 144210 -16150 0 0 {name=p143516 lab=_87397_/CLK }
C {devices/lab_pin.sym} 144210 -16130 0 0 {name=p143517 lab=_86966_/D }
C {devices/lab_pin.sym} 144390 -16150 0 1 {name=p143518 lab=_86966_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -16140 0 0 {name=X_86966_ }
C {devices/lab_pin.sym} 144210 -16010 0 0 {name=p143519 lab=_82008_/CLK }
C {devices/lab_pin.sym} 144210 -15990 0 0 {name=p143520 lab=_82089_/D }
C {devices/lab_pin.sym} 144390 -16010 0 1 {name=p143521 lab=_82089_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -16000 0 0 {name=X_82089_ }
C {devices/lab_pin.sym} 144220 -15910 0 0 {name=p143522 lab=_40999_/X }
C {devices/lab_pin.sym} 144220 -15870 0 0 {name=p143523 lab=_41000_/X }
C {devices/lab_pin.sym} 144220 -15830 0 0 {name=p143524 lab=_41021_/X }
C {devices/lab_pin.sym} 144220 -15790 0 0 {name=p143525 lab=_88292_/Q }
C {devices/lab_pin.sym} 144220 -15750 0 0 {name=p143526 lab=_40995_/X }
C {devices/lab_pin.sym} 144380 -15830 0 1 {name=p143527 lab=_41022_/Y }
C {sky130_stdcells/o32ai_4.sym} 144300 -15830 0 0 {name=X_41022_ }
C {devices/lab_pin.sym} 144240 -15700 0 0 {name=p143528 lab=_53019_/A }
C {devices/lab_pin.sym} 144240 -15660 0 0 {name=p143529 lab=_52997_/B }
C {devices/lab_pin.sym} 144240 -15620 0 0 {name=p143530 lab=_53019_/C }
C {devices/lab_pin.sym} 144240 -15580 0 0 {name=p143531 lab=_53008_/D }
C {devices/lab_pin.sym} 144360 -15640 0 1 {name=p143532 lab=_53008_/X }
C {sky130_stdcells/and4_4.sym} 144300 -15640 0 0 {name=X_53008_ }
C {devices/lab_pin.sym} 144240 -15500 0 0 {name=p143533 lab=_72758_/X }
C {devices/lab_pin.sym} 144240 -15460 0 0 {name=p143534 lab=_86546_/Q }
C {devices/lab_pin.sym} 144360 -15480 0 1 {name=p143535 lab=_73931_/X }
C {sky130_stdcells/and2_4.sym} 144300 -15480 0 0 {name=X_73931_ }
C {devices/lab_pin.sym} 144210 -15350 0 0 {name=p143536 lab=_86558_/CLK }
C {devices/lab_pin.sym} 144210 -15330 0 0 {name=p143537 lab=_51959_/Y }
C {devices/lab_pin.sym} 144390 -15350 0 1 {name=p143538 lab=_85917_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -15340 0 0 {name=X_85917_ }
C {devices/lab_pin.sym} 144260 -15210 0 0 {name=p143539 lab=_58749_/A }
C {devices/lab_pin.sym} 144340 -15210 0 1 {name=p143540 lab=_58941_/A }
C {sky130_stdcells/buf_2.sym} 144300 -15210 0 0 {name=X_58865_ }
C {devices/lab_pin.sym} 144260 -15090 0 0 {name=p143541 lab=clkbuf_6_58_0_CLK/X }
C {devices/lab_pin.sym} 144340 -15090 0 1 {name=p143542 lab=clkbuf_8_235_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 144300 -15090 0 0 {name=Xclkbuf_7_117_0_CLK }
C {devices/lab_pin.sym} 144210 -14970 0 0 {name=p143543 lab=_80664_/CLK }
C {devices/lab_pin.sym} 144210 -14950 0 0 {name=p143544 lab=_45130_/Y }
C {devices/lab_pin.sym} 144390 -14970 0 1 {name=p143545 lab=_64378_/B }
C {sky130_stdcells/dfxtp_4.sym} 144300 -14960 0 0 {name=X_86897_ }
C {devices/lab_pin.sym} 144220 -14850 0 0 {name=p143546 lab=_55207_/A }
C {devices/lab_pin.sym} 144220 -14810 0 0 {name=p143547 lab=_45798_/X }
C {devices/lab_pin.sym} 144220 -14770 0 0 {name=p143548 lab=_44889_/A }
C {devices/lab_pin.sym} 144380 -14810 0 1 {name=p143549 lab=_45830_/X }
C {sky130_stdcells/o21a_4.sym} 144300 -14810 0 0 {name=X_45830_ }
C {devices/lab_pin.sym} 144220 -14690 0 0 {name=p143550 lab=_57726_/X }
C {devices/lab_pin.sym} 144220 -14650 0 0 {name=p143551 lab=_86012_/Q }
C {devices/lab_pin.sym} 144220 -14610 0 0 {name=p143552 lab=_57815_/X }
C {devices/lab_pin.sym} 144380 -14650 0 1 {name=p143553 lab=_57816_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -14650 0 0 {name=X_57816_ }
C {devices/lab_pin.sym} 144260 -14510 0 0 {name=p143554 lab=_81394_/Q }
C {devices/lab_pin.sym} 144340 -14510 0 1 {name=p143555 lab=_76650_/Y }
C {sky130_stdcells/inv_2.sym} 144300 -14510 0 0 {name=X_76650_ }
C {devices/lab_pin.sym} 144210 -14390 0 0 {name=p143556 lab=_85558_/CLK }
C {devices/lab_pin.sym} 144210 -14370 0 0 {name=p143557 lab=_85848_/D }
C {devices/lab_pin.sym} 144390 -14390 0 1 {name=p143558 lab=_64844_/B }
C {sky130_stdcells/dfxtp_4.sym} 144300 -14380 0 0 {name=X_85848_ }
C {devices/lab_pin.sym} 144220 -14280 0 0 {name=p143559 lab=_73786_/X }
C {devices/lab_pin.sym} 144220 -14240 0 0 {name=p143560 lab=_84981_/Q }
C {devices/lab_pin.sym} 144220 -14200 0 0 {name=p143561 lab=_73859_/X }
C {devices/lab_pin.sym} 144220 -14160 0 0 {name=p143562 lab=_73861_/X }
C {devices/lab_pin.sym} 144380 -14220 0 1 {name=p143563 lab=_73863_/B }
C {sky130_stdcells/a211o_4.sym} 144300 -14220 0 0 {name=X_73862_ }
C {devices/lab_pin.sym} 144260 -14070 0 0 {name=p143564 lab=_58796_/A }
C {devices/lab_pin.sym} 144340 -14070 0 1 {name=p143565 lab=_58796_/X }
C {sky130_stdcells/buf_2.sym} 144300 -14070 0 0 {name=X_58796_ }
C {devices/lab_pin.sym} 144260 -13950 0 0 {name=p143566 lab=clkbuf_9_43_0_CLK/X }
C {devices/lab_pin.sym} 144340 -13950 0 1 {name=p143567 lab=_83248_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 144300 -13950 0 0 {name=Xclkbuf_10_87_0_CLK }
C {devices/lab_pin.sym} 144260 -13830 0 0 {name=p143568 lab=_75594_/Y }
C {devices/lab_pin.sym} 144340 -13830 0 1 {name=p143569 lab=_75601_/Y }
C {sky130_stdcells/inv_2.sym} 144300 -13830 0 0 {name=X_75601_ }
C {devices/lab_pin.sym} 144220 -13730 0 0 {name=p143570 lab=_72808_/X }
C {devices/lab_pin.sym} 144220 -13690 0 0 {name=p143571 lab=_72810_/X }
C {devices/lab_pin.sym} 144220 -13650 0 0 {name=p143572 lab=_72812_/X }
C {devices/lab_pin.sym} 144380 -13690 0 1 {name=p143573 lab=_72813_/X }
C {sky130_stdcells/a21o_4.sym} 144300 -13690 0 0 {name=X_72813_ }
C {devices/lab_pin.sym} 144240 -13560 0 0 {name=p143574 lab=_45761_/A }
C {devices/lab_pin.sym} 144240 -13520 0 0 {name=p143575 lab=_45746_/B }
C {devices/lab_pin.sym} 144360 -13540 0 1 {name=p143576 lab=_45761_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -13540 0 0 {name=X_45761_ }
C {devices/lab_pin.sym} 144220 -13430 0 0 {name=p143577 lab=_57705_/X }
C {devices/lab_pin.sym} 144220 -13390 0 0 {name=p143578 lab=_85502_/Q }
C {devices/lab_pin.sym} 144220 -13350 0 0 {name=p143579 lab=_57736_/X }
C {devices/lab_pin.sym} 144380 -13390 0 1 {name=p143580 lab=_57747_/X }
C {sky130_stdcells/o21a_4.sym} 144300 -13390 0 0 {name=X_57747_ }
C {devices/lab_pin.sym} 144240 -13270 0 0 {name=p143581 lab=_76576_/X }
C {devices/lab_pin.sym} 144240 -13230 0 0 {name=p143582 lab=_76579_/Y }
C {devices/lab_pin.sym} 144240 -13190 0 0 {name=p143583 lab=_76577_/Y }
C {devices/lab_pin.sym} 144360 -13230 0 1 {name=p143584 lab=_76614_/C }
C {sky130_stdcells/nand3_4.sym} 144300 -13230 0 0 {name=X_76581_ }
C {devices/lab_pin.sym} 144260 -13090 0 0 {name=p143585 lab=_42972_/Y }
C {devices/lab_pin.sym} 144340 -13090 0 1 {name=p143586 lab=_87624_/D }
C {sky130_stdcells/inv_2.sym} 144300 -13090 0 0 {name=X_42973_ }
C {devices/lab_pin.sym} 144240 -13000 0 0 {name=p143587 lab=_54955_/A }
C {devices/lab_pin.sym} 144240 -12960 0 0 {name=p143588 lab=_54955_/B }
C {devices/lab_pin.sym} 144240 -12920 0 0 {name=p143589 lab=_54255_/C }
C {devices/lab_pin.sym} 144240 -12880 0 0 {name=p143590 lab=_47532_/A }
C {devices/lab_pin.sym} 144360 -12940 0 1 {name=p143591 lab=_54959_/X }
C {sky130_stdcells/and4_4.sym} 144300 -12940 0 0 {name=X_54959_ }
C {devices/lab_pin.sym} 144260 -12790 0 0 {name=p143592 lab=clkbuf_8_233_0_CLK/A }
C {devices/lab_pin.sym} 144340 -12790 0 1 {name=p143593 lab=clkbuf_9_467_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 144300 -12790 0 0 {name=Xclkbuf_8_233_0_CLK }
C {devices/lab_pin.sym} 144220 -12690 0 0 {name=p143594 lab=_73791_/X }
C {devices/lab_pin.sym} 144220 -12650 0 0 {name=p143595 lab=_73792_/Y }
C {devices/lab_pin.sym} 144220 -12610 0 0 {name=p143596 lab=_73720_/X }
C {devices/lab_pin.sym} 144380 -12650 0 1 {name=p143597 lab=_73793_/X }
C {sky130_stdcells/a21o_4.sym} 144300 -12650 0 0 {name=X_73793_ }
C {devices/lab_pin.sym} 144210 -12510 0 0 {name=p143598 lab=_82956_/CLK }
C {devices/lab_pin.sym} 144210 -12490 0 0 {name=p143599 lab=_85779_/D }
C {devices/lab_pin.sym} 144390 -12510 0 1 {name=p143600 lab=_85779_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -12500 0 0 {name=X_85779_ }
C {devices/lab_pin.sym} 144220 -12390 0 0 {name=p143601 lab=_86628_/Q }
C {devices/lab_pin.sym} 144220 -12350 0 0 {name=p143602 lab=_47478_/X }
C {devices/lab_pin.sym} 144220 -12310 0 0 {name=p143603 lab=_47499_/Y }
C {devices/lab_pin.sym} 144380 -12350 0 1 {name=p143604 lab=_47500_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -12350 0 0 {name=X_47500_ }
C {devices/lab_pin.sym} 144260 -12210 0 0 {name=p143605 lab=_78320_/A }
C {devices/lab_pin.sym} 144340 -12210 0 1 {name=p143606 lab=_78320_/Y }
C {sky130_stdcells/inv_2.sym} 144300 -12210 0 0 {name=X_78320_ }
C {devices/lab_pin.sym} 144260 -12090 0 0 {name=p143607 lab=_44528_/A }
C {devices/lab_pin.sym} 144340 -12090 0 1 {name=p143608 lab=_44712_/X }
C {sky130_stdcells/buf_2.sym} 144300 -12090 0 0 {name=X_44712_ }
C {devices/lab_pin.sym} 144220 -11990 0 0 {name=p143609 lab=_75530_/Y }
C {devices/lab_pin.sym} 144220 -11950 0 0 {name=p143610 lab=_75531_/Y }
C {devices/lab_pin.sym} 144220 -11910 0 0 {name=p143611 lab=_75533_/B }
C {devices/lab_pin.sym} 144380 -11950 0 1 {name=p143612 lab=_75535_/A }
C {sky130_stdcells/a21oi_4.sym} 144300 -11950 0 0 {name=X_75532_ }
C {devices/lab_pin.sym} 144210 -11810 0 0 {name=p143613 lab=_87520_/CLK }
C {devices/lab_pin.sym} 144210 -11790 0 0 {name=p143614 lab=_87518_/D }
C {devices/lab_pin.sym} 144390 -11810 0 1 {name=p143615 lab=_87518_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -11800 0 0 {name=X_87518_ }
C {devices/lab_pin.sym} 144220 -11710 0 0 {name=p143616 lab=_41894_/X }
C {devices/lab_pin.sym} 144220 -11670 0 0 {name=p143617 lab=_41879_/X }
C {devices/lab_pin.sym} 144220 -11630 0 0 {name=p143618 lab=_40656_/X }
C {devices/lab_pin.sym} 144220 -11590 0 0 {name=p143619 lab=_73842_/A }
C {devices/lab_pin.sym} 144220 -11550 0 0 {name=p143620 lab=_41882_/X }
C {devices/lab_pin.sym} 144380 -11630 0 1 {name=p143621 lab=_41925_/A }
C {sky130_stdcells/o32ai_4.sym} 144300 -11630 0 0 {name=X_41924_ }
C {devices/lab_pin.sym} 144260 -11470 0 0 {name=p143622 lab=_83582_/Q }
C {devices/lab_pin.sym} 144340 -11470 0 1 {name=p143623 lab=_73073_/A }
C {sky130_stdcells/inv_2.sym} 144300 -11470 0 0 {name=X_48480_ }
C {devices/lab_pin.sym} 144260 -11350 0 0 {name=p143624 lab=_73257_/A }
C {devices/lab_pin.sym} 144340 -11350 0 1 {name=p143625 lab=_72744_/X }
C {sky130_stdcells/buf_2.sym} 144300 -11350 0 0 {name=X_72744_ }
C {devices/lab_pin.sym} 144220 -11250 0 0 {name=p143626 lab=_55317_/B }
C {devices/lab_pin.sym} 144220 -11210 0 0 {name=p143627 lab=_45357_/X }
C {devices/lab_pin.sym} 144220 -11170 0 0 {name=p143628 lab=_45691_/X }
C {devices/lab_pin.sym} 144380 -11210 0 1 {name=p143629 lab=_45692_/X }
C {sky130_stdcells/o21a_4.sym} 144300 -11210 0 0 {name=X_45692_ }
C {devices/lab_pin.sym} 144260 -11070 0 0 {name=p143630 lab=_83755_/Q }
C {devices/lab_pin.sym} 144340 -11070 0 1 {name=p143631 lab=_57678_/Y }
C {sky130_stdcells/inv_2.sym} 144300 -11070 0 0 {name=X_57678_ }
C {devices/lab_pin.sym} 144260 -10950 0 0 {name=p143632 lab=clkbuf_9_5_0_CLK/X }
C {devices/lab_pin.sym} 144340 -10950 0 1 {name=p143633 lab=_85213_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 144300 -10950 0 0 {name=Xclkbuf_10_10_0_CLK }
C {devices/lab_pin.sym} 144260 -10830 0 0 {name=p143634 lab=_83731_/Q }
C {devices/lab_pin.sym} 144340 -10830 0 1 {name=p143635 lab=_47431_/Y }
C {sky130_stdcells/inv_2.sym} 144300 -10830 0 0 {name=X_47431_ }
C {devices/lab_pin.sym} 144260 -10710 0 0 {name=p143636 lab=_58982_/A }
C {devices/lab_pin.sym} 144340 -10710 0 1 {name=p143637 lab=_59417_/X }
C {sky130_stdcells/buf_2.sym} 144300 -10710 0 0 {name=X_59417_ }
C {devices/lab_pin.sym} 144240 -10600 0 0 {name=p143638 lab=_78251_/A }
C {devices/lab_pin.sym} 144240 -10560 0 0 {name=p143639 lab=_78250_/Y }
C {devices/lab_pin.sym} 144360 -10580 0 1 {name=p143640 lab=_78263_/B }
C {sky130_stdcells/nor2_4.sym} 144300 -10580 0 0 {name=X_78251_ }
C {devices/lab_pin.sym} 144220 -10490 0 0 {name=p143641 lab=_44638_/X }
C {devices/lab_pin.sym} 144220 -10450 0 0 {name=p143642 lab=_44639_/X }
C {devices/lab_pin.sym} 144220 -10410 0 0 {name=p143643 lab=_41045_/A }
C {devices/lab_pin.sym} 144220 -10370 0 0 {name=p143644 lab=_87020_/Q }
C {devices/lab_pin.sym} 144220 -10330 0 0 {name=p143645 lab=_44640_/X }
C {devices/lab_pin.sym} 144380 -10410 0 1 {name=p143646 lab=_44644_/A }
C {sky130_stdcells/o32ai_4.sym} 144300 -10410 0 0 {name=X_44643_ }
C {devices/lab_pin.sym} 144240 -10260 0 0 {name=p143647 lab=_72664_/C }
C {devices/lab_pin.sym} 144240 -10220 0 0 {name=p143648 lab=_56629_/B }
C {devices/lab_pin.sym} 144360 -10240 0 1 {name=p143649 lab=_56630_/A }
C {sky130_stdcells/xnor2_4.sym} 144300 -10240 0 0 {name=X_56629_ }
C {devices/lab_pin.sym} 144240 -10130 0 0 {name=p143650 lab=_75458_/X }
C {devices/lab_pin.sym} 144240 -10090 0 0 {name=p143651 lab=_75509_/A }
C {devices/lab_pin.sym} 144240 -10050 0 0 {name=p143652 lab=_75509_/C }
C {devices/lab_pin.sym} 144360 -10090 0 1 {name=p143653 lab=_75507_/A }
C {sky130_stdcells/nand3_4.sym} 144300 -10090 0 0 {name=X_75463_ }
C {devices/lab_pin.sym} 144220 -9990 0 0 {name=p143654 lab=_41839_/X }
C {devices/lab_pin.sym} 144220 -9950 0 0 {name=p143655 lab=_41841_/X }
C {devices/lab_pin.sym} 144220 -9910 0 0 {name=p143656 lab=_40532_/X }
C {devices/lab_pin.sym} 144220 -9870 0 0 {name=p143657 lab=_67245_/B }
C {devices/lab_pin.sym} 144220 -9830 0 0 {name=p143658 lab=_41835_/X }
C {devices/lab_pin.sym} 144380 -9910 0 1 {name=p143659 lab=_41856_/A }
C {sky130_stdcells/o32ai_4.sym} 144300 -9910 0 0 {name=X_41855_ }
C {devices/lab_pin.sym} 144210 -9750 0 0 {name=p143660 lab=_87221_/CLK }
C {devices/lab_pin.sym} 144210 -9730 0 0 {name=p143661 lab=_87449_/D }
C {devices/lab_pin.sym} 144390 -9750 0 1 {name=p143662 lab=_87449_/Q }
C {sky130_stdcells/dfxtp_4.sym} 144300 -9740 0 0 {name=X_87449_ }
C {devices/lab_pin.sym} 144240 -9630 0 0 {name=p143663 lab=_72683_/A }
C {devices/lab_pin.sym} 144240 -9590 0 0 {name=p143664 lab=_72683_/B }
C {devices/lab_pin.sym} 144240 -9550 0 0 {name=p143665 lab=_55491_/X }
C {devices/lab_pin.sym} 144360 -9590 0 1 {name=p143666 lab=_72675_/Y }
C {sky130_stdcells/nand3_4.sym} 144300 -9590 0 0 {name=X_72675_ }
C {devices/lab_pin.sym} 144240 -9470 0 0 {name=p143667 lab=_77202_/A }
C {devices/lab_pin.sym} 144240 -9430 0 0 {name=p143668 lab=_77202_/B }
C {devices/lab_pin.sym} 144240 -9390 0 0 {name=p143669 lab=_77202_/C }
C {devices/lab_pin.sym} 144360 -9430 0 1 {name=p143670 lab=_77203_/B }
C {sky130_stdcells/nand3_4.sym} 144300 -9430 0 0 {name=X_77202_ }
C {devices/lab_pin.sym} 144240 -9300 0 0 {name=p143671 lab=_74413_/X }
C {devices/lab_pin.sym} 144240 -9260 0 0 {name=p143672 lab=_74414_/B }
C {devices/lab_pin.sym} 144360 -9280 0 1 {name=p143673 lab=_74414_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -9280 0 0 {name=X_74414_ }
C {devices/lab_pin.sym} 144260 -9150 0 0 {name=p143674 lab=_40806_/A }
C {devices/lab_pin.sym} 144340 -9150 0 1 {name=p143675 lab=_40806_/X }
C {sky130_stdcells/buf_2.sym} 144300 -9150 0 0 {name=X_40806_ }
C {devices/lab_pin.sym} 144220 -9050 0 0 {name=p143676 lab=_86642_/Q }
C {devices/lab_pin.sym} 144220 -9010 0 0 {name=p143677 lab=_47332_/X }
C {devices/lab_pin.sym} 144220 -8970 0 0 {name=p143678 lab=_47361_/Y }
C {devices/lab_pin.sym} 144380 -9010 0 1 {name=p143679 lab=_47362_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -9010 0 0 {name=X_47362_ }
C {devices/lab_pin.sym} 144220 -8890 0 0 {name=p143680 lab=_59331_/X }
C {devices/lab_pin.sym} 144220 -8850 0 0 {name=p143681 lab=_85413_/Q }
C {devices/lab_pin.sym} 144220 -8810 0 0 {name=p143682 lab=_59347_/X }
C {devices/lab_pin.sym} 144380 -8850 0 1 {name=p143683 lab=_59348_/Y }
C {sky130_stdcells/o21ai_4.sym} 144300 -8850 0 0 {name=X_59348_ }
C {devices/lab_pin.sym} 144240 -8730 0 0 {name=p143684 lab=_71626_/A }
C {devices/lab_pin.sym} 144240 -8690 0 0 {name=p143685 lab=_71626_/B }
C {devices/lab_pin.sym} 144240 -8650 0 0 {name=p143686 lab=_71626_/C }
C {devices/lab_pin.sym} 144360 -8690 0 1 {name=p143687 lab=_71626_/Y }
C {sky130_stdcells/nor3_4.sym} 144300 -8690 0 0 {name=X_71626_ }
C {devices/lab_pin.sym} 144260 -8550 0 0 {name=p143688 lab=clkbuf_8_249_0_CLK/A }
C {devices/lab_pin.sym} 144340 -8550 0 1 {name=p143689 lab=clkbuf_9_497_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 144300 -8550 0 0 {name=Xclkbuf_8_248_0_CLK }
C {devices/lab_pin.sym} 144240 -8440 0 0 {name=p143690 lab=_78182_/A }
C {devices/lab_pin.sym} 144240 -8400 0 0 {name=p143691 lab=_78182_/B }
C {devices/lab_pin.sym} 144360 -8420 0 1 {name=p143692 lab=_78182_/X }
C {sky130_stdcells/xor2_4.sym} 144300 -8420 0 0 {name=X_78182_ }
C {devices/lab_pin.sym} 144220 -8330 0 0 {name=p143693 lab=_44554_/X }
C {devices/lab_pin.sym} 144220 -8290 0 0 {name=p143694 lab=_44555_/X }
C {devices/lab_pin.sym} 144220 -8250 0 0 {name=p143695 lab=_40881_/X }
C {devices/lab_pin.sym} 144220 -8210 0 0 {name=p143696 lab=_44573_/Y }
C {devices/lab_pin.sym} 144220 -8170 0 0 {name=p143697 lab=_44557_/X }
C {devices/lab_pin.sym} 144380 -8250 0 1 {name=p143698 lab=_44574_/Y }
C {sky130_stdcells/o32ai_4.sym} 144300 -8250 0 0 {name=X_44574_ }
C {devices/lab_pin.sym} 144240 -8100 0 0 {name=p143699 lab=_75393_/A }
C {devices/lab_pin.sym} 144240 -8060 0 0 {name=p143700 lab=_75393_/B }
C {devices/lab_pin.sym} 144360 -8080 0 1 {name=p143701 lab=_75394_/Y }
C {sky130_stdcells/nand2_4.sym} 144300 -8080 0 0 {name=X_75394_ }
C {devices/lab_pin.sym} 144260 -7950 0 0 {name=p143702 lab=clkbuf_9_121_0_CLK/X }
C {devices/lab_pin.sym} 144340 -7950 0 1 {name=p143703 lab=_84454_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 144300 -7950 0 0 {name=Xclkbuf_10_243_0_CLK }
C {devices/lab_pin.sym} 144260 -7830 0 0 {name=p143704 lab=_41785_/X }
C {devices/lab_pin.sym} 144340 -7830 0 1 {name=p143705 lab=_41786_/X }
C {sky130_stdcells/buf_2.sym} 144300 -7830 0 0 {name=X_41786_ }
C {devices/lab_pin.sym} 144260 -7710 0 0 {name=p143706 lab=_71959_/A }
C {devices/lab_pin.sym} 144340 -7710 0 1 {name=p143707 lab=_49113_/B }
C {sky130_stdcells/buf_2.sym} 144300 -7710 0 0 {name=X_49101_ }
C {devices/lab_pin.sym} 144260 -7590 0 0 {name=p143708 lab=_46313_/A }
C {devices/lab_pin.sym} 144340 -7590 0 1 {name=p143709 lab=_46313_/Y }
C {sky130_stdcells/inv_2.sym} 144300 -7590 0 0 {name=X_46313_ }
C {devices/lab_pin.sym} 144240 -7480 0 0 {name=p143710 lab=_77134_/A }
C {devices/lab_pin.sym} 144240 -7440 0 0 {name=p143711 lab=_82293_/D }
C {devices/lab_pin.sym} 144360 -7460 0 1 {name=p143712 lab=_77141_/B }
C {sky130_stdcells/or2_4.sym} 144300 -7460 0 0 {name=X_77133_ }
C {devices/lab_pin.sym} 144260 -7330 0 0 {name=p143713 lab=_43524_/Y }
C {devices/lab_pin.sym} 144340 -7330 0 1 {name=p143714 lab=_87377_/D }
C {sky130_stdcells/inv_2.sym} 144300 -7330 0 0 {name=X_43525_ }
C {devices/lab_pin.sym} 144260 -7210 0 0 {name=p143715 lab=clkbuf_9_436_0_CLK/X }
C {devices/lab_pin.sym} 144340 -7210 0 1 {name=p143716 lab=_84991_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 144300 -7210 0 0 {name=Xclkbuf_10_873_0_CLK }
C {devices/lab_pin.sym} 144240 -7110 0 0 {name=p143717 lab=_74351_/A }
C {devices/lab_pin.sym} 144240 -7070 0 0 {name=p143718 lab=_74342_/X }
C {devices/lab_pin.sym} 144240 -7030 0 0 {name=p143719 lab=_55801_/B }
C {devices/lab_pin.sym} 144360 -7070 0 1 {name=p143720 lab=_74345_/Y }
C {sky130_stdcells/nand3_4.sym} 144300 -7070 0 0 {name=X_74345_ }
C {devices/lab_pin.sym} 144240 -6940 0 0 {name=p143721 lab=_40737_/A }
C {devices/lab_pin.sym} 144240 -6900 0 0 {name=p143722 lab=_40765_/B }
C {devices/lab_pin.sym} 144360 -6920 0 1 {name=p143723 lab=_40737_/X }
C {sky130_stdcells/or2_4.sym} 144300 -6920 0 0 {name=X_40737_ }
C {devices/lab_pin.sym} 144260 -6790 0 0 {name=p143724 lab=_81818_/Q }
C {devices/lab_pin.sym} 144340 -6790 0 1 {name=p143725 lab=_47294_/A }
C {sky130_stdcells/inv_2.sym} 144300 -6790 0 0 {name=X_47293_ }
C {devices/lab_pin.sym} 144220 -6690 0 0 {name=p143726 lab=_59275_/Y }
C {devices/lab_pin.sym} 144220 -6650 0 0 {name=p143727 lab=_59277_/Y }
C {devices/lab_pin.sym} 144220 -6610 0 0 {name=p143728 lab=_59278_/X }
C {devices/lab_pin.sym} 144380 -6650 0 1 {name=p143729 lab=_59279_/X }
C {sky130_stdcells/a21o_4.sym} 144300 -6650 0 0 {name=X_59279_ }
C {devices/lab_pin.sym} 144260 -6510 0 0 {name=p143730 lab=_71556_/Y }
C {devices/lab_pin.sym} 144340 -6510 0 1 {name=p143731 lab=_71557_/X }
C {sky130_stdcells/buf_2.sym} 144300 -6510 0 0 {name=X_71557_ }
C {devices/lab_pin.sym} 144260 -6390 0 0 {name=p143732 lab=clkbuf_9_12_0_CLK/X }
C {devices/lab_pin.sym} 144340 -6390 0 1 {name=p143733 lab=_85186_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 144300 -6390 0 0 {name=Xclkbuf_10_25_0_CLK }
C {devices/lab_pin.sym} 144240 -6280 0 0 {name=p143734 lab=_49022_/A }
C {devices/lab_pin.sym} 144240 -6240 0 0 {name=p143735 lab=_53854_/B }
C {devices/lab_pin.sym} 144360 -6260 0 1 {name=p143736 lab=_49032_/X }
C {sky130_stdcells/and2_4.sym} 144300 -6260 0 0 {name=X_49032_ }
C {devices/lab_pin.sym} 144260 -6130 0 0 {name=p143737 lab=_61686_/A }
C {devices/lab_pin.sym} 144340 -6130 0 1 {name=p143738 lab=_72529_/C }
C {sky130_stdcells/buf_2.sym} 144300 -6130 0 0 {name=X_61310_ }
C {devices/lab_pin.sym} 144240 -6030 0 0 {name=p143739 lab=_44803_/A }
C {devices/lab_pin.sym} 144240 -5990 0 0 {name=p143740 lab=_46242_/Y }
C {devices/lab_pin.sym} 144240 -5950 0 0 {name=p143741 lab=_46623_/A }
C {devices/lab_pin.sym} 144360 -5990 0 1 {name=p143742 lab=_46244_/Y }
C {sky130_stdcells/nand3_4.sym} 144300 -5990 0 0 {name=X_46244_ }
C {sky130_stdcells/decap_3.sym} 144300 -5820 0 0 {name=XPHY_560 }
C {devices/lab_pin.sym} 144260 -5670 0 0 {name=p143743 lab=_70966_/A }
C {devices/lab_pin.sym} 144340 -5670 0 1 {name=p143744 lab=_70508_/X }
C {sky130_stdcells/buf_2.sym} 144300 -5670 0 0 {name=X_70508_ }
C {devices/lab_pin.sym} 144240 -5560 0 0 {name=p143745 lab=_77067_/B }
C {devices/lab_pin.sym} 144240 -5520 0 0 {name=p143746 lab=_77063_/Y }
C {devices/lab_pin.sym} 144360 -5540 0 1 {name=p143747 lab=_77065_/B }
C {sky130_stdcells/xnor2_4.sym} 144300 -5540 0 0 {name=X_77064_ }
C {devices/lab_pin.sym} 144260 -5410 0 0 {name=p143748 lab=_43528_/A }
C {devices/lab_pin.sym} 144340 -5410 0 1 {name=p143749 lab=_43456_/X }
C {sky130_stdcells/buf_2.sym} 144300 -5410 0 0 {name=X_43456_ }
C {devices/lab_pin.sym} 144260 -5290 0 0 {name=p143750 lab=clkbuf_9_365_0_CLK/A }
C {devices/lab_pin.sym} 144340 -5290 0 1 {name=p143751 lab=clkbuf_9_364_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 144300 -5290 0 0 {name=Xclkbuf_9_364_0_CLK }
C {devices/lab_pin.sym} 144220 -5190 0 0 {name=p143752 lab=_59931_/X }
C {devices/lab_pin.sym} 144220 -5150 0 0 {name=p143753 lab=_61811_/X }
C {devices/lab_pin.sym} 144220 -5110 0 0 {name=p143754 lab=_62289_/X }
C {devices/lab_pin.sym} 144380 -5150 0 1 {name=p143755 lab=_62290_/X }
C {sky130_stdcells/a21o_4.sym} 144300 -5150 0 0 {name=X_62290_ }
C {devices/lab_pin.sym} 144240 -5020 0 0 {name=p143756 lab=_74022_/X }
C {devices/lab_pin.sym} 144240 -4980 0 0 {name=p143757 lab=_86530_/Q }
C {devices/lab_pin.sym} 144360 -5000 0 1 {name=p143758 lab=_74276_/X }
C {sky130_stdcells/and2_4.sym} 144300 -5000 0 0 {name=X_74276_ }
C {sky130_stdcells/decap_3.sym} 144300 -4840 0 0 {name=XPHY_571 }
C {devices/lab_pin.sym} 144220 -4730 0 0 {name=p143759 lab=_40635_/X }
C {devices/lab_pin.sym} 144220 -4690 0 0 {name=p143760 lab=_40638_/X }
C {devices/lab_pin.sym} 144220 -4650 0 0 {name=p143761 lab=_40667_/X }
C {devices/lab_pin.sym} 144220 -4610 0 0 {name=p143762 lab=_68735_/B }
C {devices/lab_pin.sym} 144220 -4570 0 0 {name=p143763 lab=_40612_/X }
C {devices/lab_pin.sym} 144380 -4650 0 1 {name=p143764 lab=_40669_/A }
C {sky130_stdcells/o32ai_4.sym} 144300 -4650 0 0 {name=X_40668_ }
C {devices/lab_pin.sym} 144260 -4490 0 0 {name=p143765 lab=_71291_/Y }
C {devices/lab_pin.sym} 144340 -4490 0 1 {name=p143766 lab=_71488_/X }
C {sky130_stdcells/buf_2.sym} 144300 -4490 0 0 {name=X_71488_ }
C {sky130_stdcells/decap_3.sym} 144300 -4340 0 0 {name=XPHY_582 }
C {sky130_stdcells/decap_3.sym} 144300 -4160 0 0 {name=XPHY_593 }
C {devices/lab_pin.sym} 144240 -4020 0 0 {name=p143767 lab=_76015_/A }
C {devices/lab_pin.sym} 144240 -3980 0 0 {name=p143768 lab=_76015_/B }
C {devices/lab_pin.sym} 144360 -4000 0 1 {name=p143769 lab=_81743_/D }
C {sky130_stdcells/xnor2_4.sym} 144300 -4000 0 0 {name=X_76015_ }
C {devices/lab_pin.sym} 144260 -3870 0 0 {name=p143770 lab=_42407_/A }
C {devices/lab_pin.sym} 144340 -3870 0 1 {name=p143771 lab=_42407_/Y }
C {sky130_stdcells/inv_2.sym} 144300 -3870 0 0 {name=X_42407_ }
C {devices/lab_pin.sym} 144240 -3760 0 0 {name=p143772 lab=_61241_/A }
C {devices/lab_pin.sym} 144240 -3720 0 0 {name=p143773 lab=_61147_/Y }
C {devices/lab_pin.sym} 144360 -3740 0 1 {name=p143774 lab=_61241_/X }
C {sky130_stdcells/and2_4.sym} 144300 -3740 0 0 {name=X_61241_ }
C {devices/lab_pin.sym} 144260 -3610 0 0 {name=p143775 lab=_73227_/A }
C {devices/lab_pin.sym} 144340 -3610 0 1 {name=p143776 lab=_73228_/B }
C {sky130_stdcells/buf_2.sym} 144300 -3610 0 0 {name=X_73227_ }
C {devices/lab_pin.sym} 144260 -3490 0 0 {name=p143777 lab=clkbuf_9_129_0_CLK/X }
C {devices/lab_pin.sym} 144340 -3490 0 1 {name=p143778 lab=_84250_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 144300 -3490 0 0 {name=Xclkbuf_10_258_0_CLK }
C {devices/lab_pin.sym} 144220 -3390 0 0 {name=p143779 lab=_48236_/B }
C {devices/lab_pin.sym} 144220 -3350 0 0 {name=p143780 lab=_70422_/X }
C {devices/lab_pin.sym} 144220 -3310 0 0 {name=p143781 lab=_70438_/Y }
C {devices/lab_pin.sym} 144380 -3350 0 1 {name=p143782 lab=_83774_/D }
C {sky130_stdcells/o21ai_4.sym} 144300 -3350 0 0 {name=X_70439_ }
C {devices/lab_pin.sym} 144220 -3250 0 0 {name=p143783 lab=_46162_/X }
C {devices/lab_pin.sym} 144220 -3210 0 0 {name=p143784 lab=_46170_/C }
C {devices/lab_pin.sym} 144220 -3170 0 0 {name=p143785 lab=_46107_/A }
C {devices/lab_pin.sym} 144220 -3130 0 0 {name=p143786 lab=_46164_/A }
C {devices/lab_pin.sym} 144220 -3090 0 0 {name=p143787 lab=_46094_/X }
C {devices/lab_pin.sym} 144380 -3170 0 1 {name=p143788 lab=_46175_/Y }
C {sky130_stdcells/a2111oi_4.sym} 144300 -3170 0 0 {name=X_46175_ }
C {devices/lab_pin.sym} 144260 -3010 0 0 {name=p143789 lab=_43217_/A }
C {devices/lab_pin.sym} 144340 -3010 0 1 {name=p143790 lab=_43397_/A }
C {sky130_stdcells/buf_2.sym} 144300 -3010 0 0 {name=X_43387_ }
C {devices/lab_pin.sym} 144260 -2890 0 0 {name=p143791 lab=_40599_/A }
C {devices/lab_pin.sym} 144340 -2890 0 1 {name=p143792 lab=_40599_/X }
C {sky130_stdcells/buf_2.sym} 144300 -2890 0 0 {name=X_40599_ }
C {devices/lab_pin.sym} 144260 -2770 0 0 {name=p143793 lab=clkbuf_9_444_0_CLK/X }
C {devices/lab_pin.sym} 144340 -2770 0 1 {name=p143794 lab=_86246_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 144300 -2770 0 0 {name=Xclkbuf_10_888_0_CLK }
C {devices/lab_pin.sym} 144220 -2670 0 0 {name=p143795 lab=_45121_/X }
C {devices/lab_pin.sym} 144220 -2630 0 0 {name=p143796 lab=_45124_/Y }
C {devices/lab_pin.sym} 144220 -2590 0 0 {name=p143797 lab=_45125_/X }
C {devices/lab_pin.sym} 144380 -2630 0 1 {name=p143798 lab=_45126_/Y }
C {sky130_stdcells/a21oi_4.sym} 144300 -2630 0 0 {name=X_45126_ }
C {devices/lab_pin.sym} 144220 -2520 0 0 {name=p143799 lab=_41681_/X }
C {devices/lab_pin.sym} 144220 -2480 0 0 {name=p143800 lab=_42325_/X }
C {devices/lab_pin.sym} 144220 -2440 0 0 {name=p143801 lab=_87914_/Q }
C {devices/lab_pin.sym} 144220 -2400 0 0 {name=p143802 lab=_42326_/X }
C {devices/lab_pin.sym} 144380 -2460 0 1 {name=p143803 lab=_87914_/D }
C {sky130_stdcells/a2bb2o_4.sym} 144300 -2460 0 0 {name=X_42338_ }
C {devices/lab_pin.sym} 144240 -2340 0 0 {name=p143804 lab=_61172_/A }
C {devices/lab_pin.sym} 144240 -2300 0 0 {name=p143805 lab=_64211_/C }
C {devices/lab_pin.sym} 144240 -2260 0 0 {name=p143806 lab=_61112_/X }
C {devices/lab_pin.sym} 144240 -2220 0 0 {name=p143807 lab=_61205_/A }
C {devices/lab_pin.sym} 144360 -2280 0 1 {name=p143808 lab=_61173_/A }
C {sky130_stdcells/and4_4.sym} 144300 -2280 0 0 {name=X_61172_ }
C {devices/lab_pin.sym} 144240 -2140 0 0 {name=p143809 lab=_73495_/A }
C {devices/lab_pin.sym} 144240 -2100 0 0 {name=p143810 lab=_85874_/Q }
C {devices/lab_pin.sym} 144360 -2120 0 1 {name=p143811 lab=_73158_/X }
C {sky130_stdcells/and2_4.sym} 144300 -2120 0 0 {name=X_73158_ }
C {devices/lab_pin.sym} 144260 -1990 0 0 {name=p143812 lab=_60122_/Y }
C {devices/lab_pin.sym} 144340 -1990 0 1 {name=p143813 lab=_60123_/Y }
C {sky130_stdcells/inv_2.sym} 144300 -1990 0 0 {name=X_60123_ }
C {devices/lab_pin.sym} 144220 -1890 0 0 {name=p143814 lab=_72106_/Y }
C {devices/lab_pin.sym} 144220 -1850 0 0 {name=p143815 lab=_72107_/X }
C {devices/lab_pin.sym} 144220 -1810 0 0 {name=p143816 lab=_72108_/Y }
C {devices/lab_pin.sym} 144380 -1850 0 1 {name=p143817 lab=_83283_/D }
C {sky130_stdcells/a21boi_4.sym} 144300 -1850 0 0 {name=X_72109_ }
C {devices/lab_pin.sym} 144260 -1710 0 0 {name=p143818 lab=clkbuf_9_378_0_CLK/A }
C {devices/lab_pin.sym} 144340 -1710 0 1 {name=p143819 lab=clkbuf_9_379_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 144300 -1710 0 0 {name=Xclkbuf_9_379_0_CLK }
C {devices/lab_pin.sym} 144260 -1590 0 0 {name=p143820 lab=_49906_/A }
C {devices/lab_pin.sym} 144340 -1590 0 1 {name=p143821 lab=_49934_/X }
C {sky130_stdcells/buf_2.sym} 144300 -1590 0 0 {name=X_49934_ }
C {devices/lab_pin.sym} 144220 -1490 0 0 {name=p143822 lab=_85239_/Q }
C {devices/lab_pin.sym} 144220 -1450 0 0 {name=p143823 lab=_45056_/X }
C {devices/lab_pin.sym} 144220 -1410 0 0 {name=p143824 lab=_45012_/X }
C {devices/lab_pin.sym} 144380 -1450 0 1 {name=p143825 lab=_45057_/X }
C {sky130_stdcells/o21a_4.sym} 144300 -1450 0 0 {name=X_45057_ }
C {devices/lab_pin.sym} 144260 -1310 0 0 {name=p143826 lab=_42269_/A }
C {devices/lab_pin.sym} 144340 -1310 0 1 {name=p143827 lab=_42269_/Y }
C {sky130_stdcells/inv_2.sym} 144300 -1310 0 0 {name=X_42269_ }
C {devices/lab_pin.sym} 144260 -1190 0 0 {name=p143828 lab=_65673_/A }
C {devices/lab_pin.sym} 144340 -1190 0 1 {name=p143829 lab=_65980_/X }
C {sky130_stdcells/buf_2.sym} 144300 -1190 0 0 {name=X_65980_ }
C {devices/lab_pin.sym} 144220 -1090 0 0 {name=p143830 lab=_77960_/Y }
C {devices/lab_pin.sym} 144220 -1050 0 0 {name=p143831 lab=_77967_/C }
C {devices/lab_pin.sym} 144220 -1010 0 0 {name=p143832 lab=_77967_/B }
C {devices/lab_pin.sym} 144380 -1050 0 1 {name=p143833 lab=_77980_/A }
C {sky130_stdcells/a21o_4.sym} 144300 -1050 0 0 {name=X_77966_ }
C {devices/lab_pin.sym} 144220 -930 0 0 {name=p143834 lab=_87059_/Q }
C {devices/lab_pin.sym} 144220 -890 0 0 {name=p143835 lab=_45904_/X }
C {devices/lab_pin.sym} 144220 -850 0 0 {name=p143836 lab=_73088_/X }
C {devices/lab_pin.sym} 144380 -890 0 1 {name=p143837 lab=_73101_/C }
C {sky130_stdcells/o21ai_4.sym} 144300 -890 0 0 {name=X_73089_ }
C {devices/lab_pin.sym} 144260 -750 0 0 {name=p143838 lab=_44008_/A }
C {devices/lab_pin.sym} 144340 -750 0 1 {name=p143839 lab=_57686_/A }
C {sky130_stdcells/buf_2.sym} 144300 -750 0 0 {name=X_44008_ }
C {devices/lab_pin.sym} 145160 -42160 0 0 {name=p143840 lab=_79689_/Y }
C {devices/lab_pin.sym} 145160 -42120 0 0 {name=p143841 lab=_79692_/Y }
C {devices/lab_pin.sym} 145280 -42140 0 1 {name=p143842 lab=_79705_/X }
C {sky130_stdcells/or2_4.sym} 145220 -42140 0 0 {name=X_79705_ }
C {devices/lab_pin.sym} 145160 -42020 0 0 {name=p143843 lab=_64804_/A }
C {devices/lab_pin.sym} 145160 -41980 0 0 {name=p143844 lab=_64931_/B }
C {devices/lab_pin.sym} 145280 -42000 0 1 {name=p143845 lab=_64931_/X }
C {sky130_stdcells/and2_4.sym} 145220 -42000 0 0 {name=X_64931_ }
C {devices/lab_pin.sym} 145160 -41900 0 0 {name=p143846 lab=_62198_/B }
C {devices/lab_pin.sym} 145160 -41860 0 0 {name=p143847 lab=_59985_/A }
C {devices/lab_pin.sym} 145160 -41820 0 0 {name=p143848 lab=_59943_/X }
C {devices/lab_pin.sym} 145160 -41780 0 0 {name=p143849 lab=_59910_/X }
C {devices/lab_pin.sym} 145280 -41840 0 1 {name=p143850 lab=_60055_/A }
C {sky130_stdcells/and4_4.sym} 145220 -41840 0 0 {name=X_60054_ }
C {devices/lab_pin.sym} 145160 -41700 0 0 {name=p143851 lab=_76917_/A }
C {devices/lab_pin.sym} 145160 -41660 0 0 {name=p143852 lab=_76917_/B }
C {devices/lab_pin.sym} 145280 -41680 0 1 {name=p143853 lab=_76918_/B }
C {sky130_stdcells/xnor2_4.sym} 145220 -41680 0 0 {name=X_76917_ }
C {devices/lab_pin.sym} 145180 -41550 0 0 {name=p143854 lab=clkbuf_9_405_0_CLK/X }
C {devices/lab_pin.sym} 145260 -41550 0 1 {name=p143855 lab=_82558_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 145220 -41550 0 0 {name=Xclkbuf_10_811_0_CLK }
C {devices/lab_pin.sym} 145140 -41450 0 0 {name=p143856 lab=_58096_/B }
C {devices/lab_pin.sym} 145140 -41410 0 0 {name=p143857 lab=_49853_/X }
C {devices/lab_pin.sym} 145140 -41370 0 0 {name=p143858 lab=_49864_/Y }
C {devices/lab_pin.sym} 145300 -41410 0 1 {name=p143859 lab=_49865_/Y }
C {sky130_stdcells/o21ai_4.sym} 145220 -41410 0 0 {name=X_49865_ }
C {devices/lab_pin.sym} 145160 -41280 0 0 {name=p143860 lab=_77902_/A }
C {devices/lab_pin.sym} 145160 -41240 0 0 {name=p143861 lab=_77902_/B }
C {devices/lab_pin.sym} 145280 -41260 0 1 {name=p143862 lab=_82036_/D }
C {sky130_stdcells/xor2_4.sym} 145220 -41260 0 0 {name=X_77897_ }
C {devices/lab_pin.sym} 145160 -41140 0 0 {name=p143863 lab=_48831_/A }
C {devices/lab_pin.sym} 145160 -41100 0 0 {name=p143864 lab=_48816_/B }
C {devices/lab_pin.sym} 145280 -41120 0 1 {name=p143865 lab=_48816_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -41120 0 0 {name=X_48816_ }
C {devices/lab_pin.sym} 145180 -40990 0 0 {name=p143866 lab=_66560_/X }
C {devices/lab_pin.sym} 145260 -40990 0 1 {name=p143867 lab=_68402_/A }
C {sky130_stdcells/buf_2.sym} 145220 -40990 0 0 {name=X_67650_ }
C {devices/lab_pin.sym} 145160 -40880 0 0 {name=p143868 lab=_84210_/Q }
C {devices/lab_pin.sym} 145160 -40840 0 0 {name=p143869 lab=_72394_/A }
C {devices/lab_pin.sym} 145280 -40860 0 1 {name=p143870 lab=_79636_/X }
C {sky130_stdcells/xor2_4.sym} 145220 -40860 0 0 {name=X_79636_ }
C {devices/lab_pin.sym} 145140 -40750 0 0 {name=p143871 lab=_64857_/X }
C {devices/lab_pin.sym} 145140 -40710 0 0 {name=p143872 lab=_64861_/X }
C {devices/lab_pin.sym} 145140 -40670 0 0 {name=p143873 lab=_64807_/X }
C {devices/lab_pin.sym} 145300 -40710 0 1 {name=p143874 lab=_64862_/X }
C {sky130_stdcells/a21o_4.sym} 145220 -40710 0 0 {name=X_64862_ }
C {devices/lab_pin.sym} 145160 -40580 0 0 {name=p143875 lab=_76846_/Y }
C {devices/lab_pin.sym} 145160 -40540 0 0 {name=p143876 lab=_76847_/Y }
C {devices/lab_pin.sym} 145280 -40560 0 1 {name=p143877 lab=_76849_/A }
C {sky130_stdcells/xor2_4.sym} 145220 -40560 0 0 {name=X_76848_ }
C {devices/lab_pin.sym} 145180 -40430 0 0 {name=p143878 lab=clkbuf_9_303_0_CLK/A }
C {devices/lab_pin.sym} 145260 -40430 0 1 {name=p143879 lab=clkbuf_9_302_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 145220 -40430 0 0 {name=Xclkbuf_9_302_0_CLK }
C {devices/lab_pin.sym} 145160 -40340 0 0 {name=p143880 lab=_49807_/A }
C {devices/lab_pin.sym} 145160 -40300 0 0 {name=p143881 lab=_49802_/B }
C {devices/lab_pin.sym} 145160 -40260 0 0 {name=p143882 lab=_49795_/X }
C {devices/lab_pin.sym} 145160 -40220 0 0 {name=p143883 lab=_53008_/D }
C {devices/lab_pin.sym} 145280 -40280 0 1 {name=p143884 lab=_49796_/X }
C {sky130_stdcells/and4_4.sym} 145220 -40280 0 0 {name=X_49796_ }
C {devices/lab_pin.sym} 145180 -40130 0 0 {name=p143885 lab=_68721_/A }
C {devices/lab_pin.sym} 145260 -40130 0 1 {name=p143886 lab=_66602_/A }
C {sky130_stdcells/buf_2.sym} 145220 -40130 0 0 {name=X_66601_ }
C {devices/lab_pin.sym} 145180 -40010 0 0 {name=p143887 lab=_63972_/A }
C {devices/lab_pin.sym} 145260 -40010 0 1 {name=p143888 lab=_63814_/C }
C {sky130_stdcells/buf_2.sym} 145220 -40010 0 0 {name=X_63813_ }
C {devices/lab_pin.sym} 145140 -39910 0 0 {name=p143889 lab=_72960_/B }
C {devices/lab_pin.sym} 145140 -39870 0 0 {name=p143890 lab=_48730_/X }
C {devices/lab_pin.sym} 145140 -39830 0 0 {name=p143891 lab=_48746_/Y }
C {devices/lab_pin.sym} 145300 -39870 0 1 {name=p143892 lab=_48747_/Y }
C {sky130_stdcells/o21ai_4.sym} 145220 -39870 0 0 {name=X_48747_ }
C {devices/lab_pin.sym} 145180 -39730 0 0 {name=p143893 lab=_67226_/A }
C {devices/lab_pin.sym} 145260 -39730 0 1 {name=p143894 lab=_67581_/X }
C {sky130_stdcells/buf_2.sym} 145220 -39730 0 0 {name=X_67581_ }
C {devices/lab_pin.sym} 145180 -39610 0 0 {name=p143895 lab=_79566_/B }
C {devices/lab_pin.sym} 145260 -39610 0 1 {name=p143896 lab=_79567_/Y }
C {sky130_stdcells/inv_2.sym} 145220 -39610 0 0 {name=X_79567_ }
C {devices/lab_pin.sym} 145160 -39500 0 0 {name=p143897 lab=_44104_/Y }
C {devices/lab_pin.sym} 145160 -39460 0 0 {name=p143898 lab=_45927_/X }
C {devices/lab_pin.sym} 145280 -39480 0 1 {name=p143899 lab=_45959_/X }
C {sky130_stdcells/or2_4.sym} 145220 -39480 0 0 {name=X_45959_ }
C {devices/lab_pin.sym} 145140 -39380 0 0 {name=p143900 lab=_64666_/X }
C {devices/lab_pin.sym} 145140 -39340 0 0 {name=p143901 lab=_86138_/Q }
C {devices/lab_pin.sym} 145140 -39300 0 0 {name=p143902 lab=_64766_/X }
C {devices/lab_pin.sym} 145140 -39260 0 0 {name=p143903 lab=_64792_/X }
C {devices/lab_pin.sym} 145300 -39320 0 1 {name=p143904 lab=_64793_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -39320 0 0 {name=X_64793_ }
C {devices/lab_pin.sym} 145140 -39200 0 0 {name=p143905 lab=_76765_/Y }
C {devices/lab_pin.sym} 145140 -39160 0 0 {name=p143906 lab=_76766_/Y }
C {devices/lab_pin.sym} 145140 -39120 0 0 {name=p143907 lab=_81486_/Q }
C {devices/lab_pin.sym} 145140 -39080 0 0 {name=p143908 lab=_81358_/D }
C {devices/lab_pin.sym} 145300 -39140 0 1 {name=p143909 lab=_76779_/X }
C {sky130_stdcells/a2bb2o_4.sym} 145220 -39140 0 0 {name=X_76779_ }
C {devices/lab_pin.sym} 145140 -39010 0 0 {name=p143910 lab=_69317_/X }
C {devices/lab_pin.sym} 145140 -38970 0 0 {name=p143911 lab=_69319_/X }
C {devices/lab_pin.sym} 145140 -38930 0 0 {name=p143912 lab=_69251_/X }
C {devices/lab_pin.sym} 145300 -38970 0 1 {name=p143913 lab=_69320_/X }
C {sky130_stdcells/a21o_4.sym} 145220 -38970 0 0 {name=X_69320_ }
C {devices/lab_pin.sym} 145180 -38830 0 0 {name=p143914 lab=clkbuf_9_413_0_CLK/X }
C {devices/lab_pin.sym} 145260 -38830 0 1 {name=p143915 lab=_82942_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 145220 -38830 0 0 {name=Xclkbuf_10_826_0_CLK }
C {devices/lab_pin.sym} 145180 -38710 0 0 {name=p143916 lab=_44019_/A }
C {devices/lab_pin.sym} 145260 -38710 0 1 {name=p143917 lab=_66565_/A }
C {sky130_stdcells/buf_2.sym} 145220 -38710 0 0 {name=X_66532_ }
C {devices/lab_pin.sym} 145140 -38610 0 0 {name=p143918 lab=_78482_/B }
C {devices/lab_pin.sym} 145140 -38570 0 0 {name=p143919 lab=_78513_/Y }
C {devices/lab_pin.sym} 145140 -38530 0 0 {name=p143920 lab=_78517_/Y }
C {devices/lab_pin.sym} 145300 -38570 0 1 {name=p143921 lab=_78519_/B }
C {sky130_stdcells/a21oi_4.sym} 145220 -38570 0 0 {name=X_78518_ }
C {devices/lab_pin.sym} 145180 -38430 0 0 {name=p143922 lab=_63578_/A }
C {devices/lab_pin.sym} 145260 -38430 0 1 {name=p143923 lab=_63744_/X }
C {sky130_stdcells/buf_2.sym} 145220 -38430 0 0 {name=X_63744_ }
C {devices/lab_pin.sym} 145180 -38310 0 0 {name=p143924 lab=_74501_/A }
C {devices/lab_pin.sym} 145260 -38310 0 1 {name=p143925 lab=_48680_/A }
C {sky130_stdcells/buf_2.sym} 145220 -38310 0 0 {name=X_48678_ }
C {devices/lab_pin.sym} 145180 -38190 0 0 {name=p143926 lab=_63972_/A }
C {devices/lab_pin.sym} 145260 -38190 0 1 {name=p143927 lab=_63781_/C }
C {sky130_stdcells/buf_2.sym} 145220 -38190 0 0 {name=X_60956_ }
C {devices/lab_pin.sym} 145160 -38080 0 0 {name=p143928 lab=_79505_/B }
C {devices/lab_pin.sym} 145160 -38040 0 0 {name=p143929 lab=_79498_/B }
C {devices/lab_pin.sym} 145280 -38060 0 1 {name=p143930 lab=_82847_/D }
C {sky130_stdcells/xor2_4.sym} 145220 -38060 0 0 {name=X_79498_ }
C {devices/lab_pin.sym} 145180 -37930 0 0 {name=p143931 lab=_57716_/A }
C {devices/lab_pin.sym} 145260 -37930 0 1 {name=p143932 lab=_69251_/X }
C {sky130_stdcells/buf_2.sym} 145220 -37930 0 0 {name=X_69251_ }
C {devices/lab_pin.sym} 145160 -37840 0 0 {name=p143933 lab=_47655_/A }
C {devices/lab_pin.sym} 145160 -37800 0 0 {name=p143934 lab=_47645_/B }
C {devices/lab_pin.sym} 145160 -37760 0 0 {name=p143935 lab=_47614_/X }
C {devices/lab_pin.sym} 145160 -37720 0 0 {name=p143936 lab=_53155_/D }
C {devices/lab_pin.sym} 145280 -37780 0 1 {name=p143937 lab=_47629_/X }
C {sky130_stdcells/and4_4.sym} 145220 -37780 0 0 {name=X_47629_ }
C {devices/lab_pin.sym} 145180 -37630 0 0 {name=p143938 lab=clkbuf_8_158_0_CLK/X }
C {devices/lab_pin.sym} 145260 -37630 0 1 {name=p143939 lab=clkbuf_9_317_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 145220 -37630 0 0 {name=Xclkbuf_9_317_0_CLK }
C {devices/lab_pin.sym} 145140 -37530 0 0 {name=p143940 lab=_66411_/X }
C {devices/lab_pin.sym} 145140 -37490 0 0 {name=p143941 lab=_66189_/Y }
C {devices/lab_pin.sym} 145140 -37450 0 0 {name=p143942 lab=_66462_/Y }
C {devices/lab_pin.sym} 145300 -37490 0 1 {name=p143943 lab=_66463_/Y }
C {sky130_stdcells/o21ai_4.sym} 145220 -37490 0 0 {name=X_66463_ }
C {devices/lab_pin.sym} 145180 -37350 0 0 {name=p143944 lab=_78448_/X }
C {devices/lab_pin.sym} 145260 -37350 0 1 {name=p143945 lab=_78475_/B }
C {sky130_stdcells/inv_2.sym} 145220 -37350 0 0 {name=X_78449_ }
C {devices/lab_pin.sym} 145160 -37250 0 0 {name=p143946 lab=_63697_/A }
C {devices/lab_pin.sym} 145160 -37210 0 0 {name=p143947 lab=_84910_/Q }
C {devices/lab_pin.sym} 145160 -37170 0 0 {name=p143948 lab=_63537_/C }
C {devices/lab_pin.sym} 145280 -37210 0 1 {name=p143949 lab=_63675_/X }
C {sky130_stdcells/and3_4.sym} 145220 -37210 0 0 {name=X_63675_ }
C {devices/lab_pin.sym} 145160 -37100 0 0 {name=p143950 lab=_60882_/X }
C {devices/lab_pin.sym} 145160 -37060 0 0 {name=p143951 lab=_60984_/A }
C {devices/lab_pin.sym} 145160 -37020 0 0 {name=p143952 lab=_60901_/A }
C {devices/lab_pin.sym} 145160 -36980 0 0 {name=p143953 lab=_60901_/B }
C {devices/lab_pin.sym} 145280 -37040 0 1 {name=p143954 lab=_61036_/C }
C {sky130_stdcells/nor4_4.sym} 145220 -37040 0 0 {name=X_60887_ }
C {devices/lab_pin.sym} 145140 -36920 0 0 {name=p143955 lab=_68196_/X }
C {devices/lab_pin.sym} 145140 -36880 0 0 {name=p143956 lab=_67247_/Y }
C {devices/lab_pin.sym} 145140 -36840 0 0 {name=p143957 lab=_68189_/X }
C {devices/lab_pin.sym} 145140 -36800 0 0 {name=p143958 lab=_68201_/Y }
C {devices/lab_pin.sym} 145300 -36860 0 1 {name=p143959 lab=_68202_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -36860 0 0 {name=X_68202_ }
C {devices/lab_pin.sym} 145140 -36740 0 0 {name=p143960 lab=_65362_/X }
C {devices/lab_pin.sym} 145140 -36700 0 0 {name=p143961 lab=_85506_/Q }
C {devices/lab_pin.sym} 145140 -36660 0 0 {name=p143962 lab=_65363_/X }
C {devices/lab_pin.sym} 145140 -36620 0 0 {name=p143963 lab=_65413_/X }
C {devices/lab_pin.sym} 145300 -36680 0 1 {name=p143964 lab=_65414_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -36680 0 0 {name=X_65414_ }
C {devices/lab_pin.sym} 145160 -36540 0 0 {name=p143965 lab=_50640_/A }
C {devices/lab_pin.sym} 145160 -36500 0 0 {name=p143966 lab=_53858_/B }
C {devices/lab_pin.sym} 145280 -36520 0 1 {name=p143967 lab=_50640_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -36520 0 0 {name=X_50640_ }
C {devices/lab_pin.sym} 145160 -36410 0 0 {name=p143968 lab=_62653_/A }
C {devices/lab_pin.sym} 145160 -36370 0 0 {name=p143969 lab=_62653_/B }
C {devices/lab_pin.sym} 145160 -36330 0 0 {name=p143970 lab=_84395_/Q }
C {devices/lab_pin.sym} 145280 -36370 0 1 {name=p143971 lab=_62626_/Y }
C {sky130_stdcells/nor3_4.sym} 145220 -36370 0 0 {name=X_62626_ }
C {devices/lab_pin.sym} 145130 -36230 0 0 {name=p143972 lab=_81461_/CLK }
C {devices/lab_pin.sym} 145130 -36210 0 0 {name=p143973 lab=_76819_/B }
C {devices/lab_pin.sym} 145310 -36230 0 1 {name=p143974 lab=_81460_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -36220 0 0 {name=X_81460_ }
C {devices/lab_pin.sym} 145180 -36090 0 0 {name=p143975 lab=_69182_/A }
C {devices/lab_pin.sym} 145260 -36090 0 1 {name=p143976 lab=_69182_/X }
C {sky130_stdcells/buf_2.sym} 145220 -36090 0 0 {name=X_69182_ }
C {devices/lab_pin.sym} 145180 -35970 0 0 {name=p143977 lab=_84131_/Q }
C {devices/lab_pin.sym} 145260 -35970 0 1 {name=p143978 lab=_66395_/C }
C {sky130_stdcells/inv_2.sym} 145220 -35970 0 0 {name=X_66394_ }
C {devices/lab_pin.sym} 145140 -35870 0 0 {name=p143979 lab=_80401_/A }
C {devices/lab_pin.sym} 145140 -35830 0 0 {name=p143980 lab=_80400_/X }
C {devices/lab_pin.sym} 145140 -35790 0 0 {name=p143981 lab=_80410_/Y }
C {devices/lab_pin.sym} 145300 -35830 0 1 {name=p143982 lab=_80411_/Y }
C {sky130_stdcells/a21boi_4.sym} 145220 -35830 0 0 {name=X_80411_ }
C {devices/lab_pin.sym} 145180 -35690 0 0 {name=p143983 lab=clkbuf_5_2_0_CLK/A }
C {devices/lab_pin.sym} 145260 -35690 0 1 {name=p143984 lab=clkbuf_6_5_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 145220 -35690 0 0 {name=Xclkbuf_5_2_0_CLK }
C {devices/lab_pin.sym} 145180 -35570 0 0 {name=p143985 lab=_68106_/A }
C {devices/lab_pin.sym} 145260 -35570 0 1 {name=p143986 lab=_68133_/X }
C {sky130_stdcells/buf_2.sym} 145220 -35570 0 0 {name=X_68133_ }
C {devices/lab_pin.sym} 145160 -35470 0 0 {name=p143987 lab=_65339_/X }
C {devices/lab_pin.sym} 145160 -35430 0 0 {name=p143988 lab=_65340_/X }
C {devices/lab_pin.sym} 145160 -35390 0 0 {name=p143989 lab=_65344_/X }
C {devices/lab_pin.sym} 145280 -35430 0 1 {name=p143990 lab=_65345_/Y }
C {sky130_stdcells/nand3_4.sym} 145220 -35430 0 0 {name=X_65345_ }
C {devices/lab_pin.sym} 145140 -35310 0 0 {name=p143991 lab=_86175_/Q }
C {devices/lab_pin.sym} 145140 -35270 0 0 {name=p143992 lab=_50499_/X }
C {devices/lab_pin.sym} 145140 -35230 0 0 {name=p143993 lab=_50570_/Y }
C {devices/lab_pin.sym} 145300 -35270 0 1 {name=p143994 lab=_50571_/Y }
C {sky130_stdcells/o21ai_4.sym} 145220 -35270 0 0 {name=X_50571_ }
C {devices/lab_pin.sym} 145180 -35130 0 0 {name=p143995 lab=_62557_/A }
C {devices/lab_pin.sym} 145260 -35130 0 1 {name=p143996 lab=_62557_/Y }
C {sky130_stdcells/inv_2.sym} 145220 -35130 0 0 {name=X_62557_ }
C {devices/lab_pin.sym} 145130 -35010 0 0 {name=p143997 lab=_83926_/CLK }
C {devices/lab_pin.sym} 145130 -34990 0 0 {name=p143998 lab=_81391_/D }
C {devices/lab_pin.sym} 145310 -35010 0 1 {name=p143999 lab=_76917_/B }
C {sky130_stdcells/dfxtp_4.sym} 145220 -35000 0 0 {name=X_81391_ }
C {devices/lab_pin.sym} 145160 -34890 0 0 {name=p144000 lab=_48979_/A }
C {devices/lab_pin.sym} 145160 -34850 0 0 {name=p144001 lab=_52310_/B }
C {devices/lab_pin.sym} 145160 -34810 0 0 {name=p144002 lab=_52291_/C }
C {devices/lab_pin.sym} 145280 -34850 0 1 {name=p144003 lab=_52310_/X }
C {sky130_stdcells/and3_4.sym} 145220 -34850 0 0 {name=X_52310_ }
C {devices/lab_pin.sym} 145130 -34710 0 0 {name=p144004 lab=_83561_/CLK }
C {devices/lab_pin.sym} 145130 -34690 0 0 {name=p144005 lab=_83130_/D }
C {devices/lab_pin.sym} 145310 -34710 0 1 {name=p144006 lab=_83130_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -34700 0 0 {name=X_83130_ }
C {devices/lab_pin.sym} 145140 -34590 0 0 {name=p144007 lab=_61506_/X }
C {devices/lab_pin.sym} 145140 -34550 0 0 {name=p144008 lab=_61455_/X }
C {devices/lab_pin.sym} 145140 -34510 0 0 {name=p144009 lab=_61507_/Y }
C {devices/lab_pin.sym} 145300 -34550 0 1 {name=p144010 lab=_84475_/D }
C {sky130_stdcells/a21oi_4.sym} 145220 -34550 0 0 {name=X_61508_ }
C {devices/lab_pin.sym} 145180 -34410 0 0 {name=p144011 lab=_80341_/Y }
C {devices/lab_pin.sym} 145260 -34410 0 1 {name=p144012 lab=_80350_/A }
C {sky130_stdcells/inv_2.sym} 145220 -34410 0 0 {name=X_80342_ }
C {devices/lab_pin.sym} 145140 -34320 0 0 {name=p144013 lab=_67948_/X }
C {devices/lab_pin.sym} 145140 -34280 0 0 {name=p144014 lab=_68049_/Y }
C {devices/lab_pin.sym} 145140 -34240 0 0 {name=p144015 lab=_67983_/X }
C {devices/lab_pin.sym} 145140 -34200 0 0 {name=p144016 lab=_68063_/Y }
C {devices/lab_pin.sym} 145300 -34260 0 1 {name=p144017 lab=_68064_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -34260 0 0 {name=X_68064_ }
C {devices/lab_pin.sym} 145160 -34120 0 0 {name=p144018 lab=_53276_/A }
C {devices/lab_pin.sym} 145160 -34080 0 0 {name=p144019 lab=_54469_/B }
C {devices/lab_pin.sym} 145280 -34100 0 1 {name=p144020 lab=_53290_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -34100 0 0 {name=X_53290_ }
C {devices/lab_pin.sym} 145140 -34000 0 0 {name=p144021 lab=_65272_/X }
C {devices/lab_pin.sym} 145140 -33960 0 0 {name=p144022 lab=_85511_/Q }
C {devices/lab_pin.sym} 145140 -33920 0 0 {name=p144023 lab=_65146_/X }
C {devices/lab_pin.sym} 145140 -33880 0 0 {name=p144024 lab=_65275_/X }
C {devices/lab_pin.sym} 145300 -33940 0 1 {name=p144025 lab=_65276_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -33940 0 0 {name=X_65276_ }
C {devices/lab_pin.sym} 145160 -33820 0 0 {name=p144026 lab=_62487_/X }
C {devices/lab_pin.sym} 145160 -33780 0 0 {name=p144027 lab=_62022_/A }
C {devices/lab_pin.sym} 145160 -33740 0 0 {name=p144028 lab=_62628_/C }
C {devices/lab_pin.sym} 145160 -33700 0 0 {name=p144029 lab=_62219_/X }
C {devices/lab_pin.sym} 145280 -33760 0 1 {name=p144030 lab=_62488_/X }
C {sky130_stdcells/and4_4.sym} 145220 -33760 0 0 {name=X_62488_ }
C {devices/lab_pin.sym} 145180 -33610 0 0 {name=p144031 lab=_67014_/X }
C {devices/lab_pin.sym} 145260 -33610 0 1 {name=p144032 lab=_67015_/X }
C {sky130_stdcells/buf_2.sym} 145220 -33610 0 0 {name=X_67015_ }
C {devices/lab_pin.sym} 145160 -33500 0 0 {name=p144033 lab=_52250_/A }
C {devices/lab_pin.sym} 145160 -33460 0 0 {name=p144034 lab=_48673_/B }
C {devices/lab_pin.sym} 145280 -33480 0 1 {name=p144035 lab=_52241_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -33480 0 0 {name=X_52241_ }
C {devices/lab_pin.sym} 145160 -33370 0 0 {name=p144036 lab=_64250_/A }
C {devices/lab_pin.sym} 145160 -33330 0 0 {name=p144037 lab=_84856_/Q }
C {devices/lab_pin.sym} 145160 -33290 0 0 {name=p144038 lab=_64250_/C }
C {devices/lab_pin.sym} 145280 -33330 0 1 {name=p144039 lab=_64227_/Y }
C {sky130_stdcells/nand3_4.sym} 145220 -33330 0 0 {name=X_64227_ }
C {devices/lab_pin.sym} 145130 -33190 0 0 {name=p144040 lab=_85581_/CLK }
C {devices/lab_pin.sym} 145130 -33170 0 0 {name=p144041 lab=_83061_/D }
C {devices/lab_pin.sym} 145310 -33190 0 1 {name=p144042 lab=_83061_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -33180 0 0 {name=X_83061_ }
C {devices/lab_pin.sym} 145160 -33070 0 0 {name=p144043 lab=_61429_/A }
C {devices/lab_pin.sym} 145160 -33030 0 0 {name=p144044 lab=_61438_/X }
C {devices/lab_pin.sym} 145160 -32990 0 0 {name=p144045 lab=_61429_/C }
C {devices/lab_pin.sym} 145280 -33030 0 1 {name=p144046 lab=_61439_/Y }
C {sky130_stdcells/nand3_4.sym} 145220 -33030 0 0 {name=X_61439_ }
C {devices/lab_pin.sym} 145160 -32900 0 0 {name=p144047 lab=_59364_/Y }
C {devices/lab_pin.sym} 145160 -32860 0 0 {name=p144048 lab=_66345_/C }
C {devices/lab_pin.sym} 145280 -32880 0 1 {name=p144049 lab=_80273_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -32880 0 0 {name=X_80273_ }
C {devices/lab_pin.sym} 145130 -32750 0 0 {name=p144050 lab=_82139_/CLK }
C {devices/lab_pin.sym} 145130 -32730 0 0 {name=p144051 lab=_82044_/Q }
C {devices/lab_pin.sym} 145310 -32750 0 1 {name=p144052 lab=_82012_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -32740 0 0 {name=X_82012_ }
C {devices/lab_pin.sym} 145140 -32630 0 0 {name=p144053 lab=_52169_/Y }
C {devices/lab_pin.sym} 145140 -32590 0 0 {name=p144054 lab=_52170_/X }
C {devices/lab_pin.sym} 145140 -32550 0 0 {name=p144055 lab=_52171_/X }
C {devices/lab_pin.sym} 145300 -32590 0 1 {name=p144056 lab=_52172_/Y }
C {sky130_stdcells/a21oi_4.sym} 145220 -32590 0 0 {name=X_52172_ }
C {devices/lab_pin.sym} 145160 -32480 0 0 {name=p144057 lab=_58201_/X }
C {devices/lab_pin.sym} 145160 -32440 0 0 {name=p144058 lab=_64158_/B }
C {devices/lab_pin.sym} 145160 -32400 0 0 {name=p144059 lab=_64158_/C }
C {devices/lab_pin.sym} 145160 -32360 0 0 {name=p144060 lab=_64192_/D }
C {devices/lab_pin.sym} 145280 -32420 0 1 {name=p144061 lab=_64159_/D }
C {sky130_stdcells/nand4_4.sym} 145220 -32420 0 0 {name=X_64158_ }
C {devices/lab_pin.sym} 145160 -32280 0 0 {name=p144062 lab=_51112_/A }
C {devices/lab_pin.sym} 145160 -32240 0 0 {name=p144063 lab=_52813_/B }
C {devices/lab_pin.sym} 145280 -32260 0 1 {name=p144064 lab=_51123_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -32260 0 0 {name=X_51123_ }
C {devices/lab_pin.sym} 145160 -32160 0 0 {name=p144065 lab=_63088_/A }
C {devices/lab_pin.sym} 145160 -32120 0 0 {name=p144066 lab=_84832_/Q }
C {devices/lab_pin.sym} 145160 -32080 0 0 {name=p144067 lab=_63087_/X }
C {devices/lab_pin.sym} 145160 -32040 0 0 {name=p144068 lab=_63077_/D }
C {devices/lab_pin.sym} 145280 -32100 0 1 {name=p144069 lab=_63109_/X }
C {sky130_stdcells/and4_4.sym} 145220 -32100 0 0 {name=X_63109_ }
C {devices/lab_pin.sym} 145130 -31950 0 0 {name=p144070 lab=_87077_/CLK }
C {devices/lab_pin.sym} 145130 -31930 0 0 {name=p144071 lab=_86820_/D }
C {devices/lab_pin.sym} 145310 -31950 0 1 {name=p144072 lab=_86820_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -31940 0 0 {name=X_86820_ }
C {devices/lab_pin.sym} 145140 -31830 0 0 {name=p144073 lab=_56978_/Y }
C {devices/lab_pin.sym} 145140 -31790 0 0 {name=p144074 lab=_56979_/Y }
C {devices/lab_pin.sym} 145140 -31750 0 0 {name=p144075 lab=_56930_/X }
C {devices/lab_pin.sym} 145300 -31790 0 1 {name=p144076 lab=_56980_/Y }
C {sky130_stdcells/a21oi_4.sym} 145220 -31790 0 0 {name=X_56980_ }
C {devices/lab_pin.sym} 145140 -31680 0 0 {name=p144077 lab=_87995_/Q }
C {devices/lab_pin.sym} 145140 -31640 0 0 {name=p144078 lab=_68895_/X }
C {devices/lab_pin.sym} 145140 -31600 0 0 {name=p144079 lab=_68916_/X }
C {devices/lab_pin.sym} 145140 -31560 0 0 {name=p144080 lab=_68965_/X }
C {devices/lab_pin.sym} 145300 -31620 0 1 {name=p144081 lab=_68966_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -31620 0 0 {name=X_68966_ }
C {devices/lab_pin.sym} 145140 -31490 0 0 {name=p144082 lab=_64084_/Y }
C {devices/lab_pin.sym} 145140 -31450 0 0 {name=p144083 lab=_64073_/X }
C {devices/lab_pin.sym} 145140 -31410 0 0 {name=p144084 lab=_64088_/Y }
C {devices/lab_pin.sym} 145300 -31450 0 1 {name=p144085 lab=_84276_/D }
C {sky130_stdcells/a21oi_4.sym} 145220 -31450 0 0 {name=X_64089_ }
C {devices/lab_pin.sym} 145140 -31330 0 0 {name=p144086 lab=_86082_/Q }
C {devices/lab_pin.sym} 145140 -31290 0 0 {name=p144087 lab=_51047_/X }
C {devices/lab_pin.sym} 145140 -31250 0 0 {name=p144088 lab=_51053_/Y }
C {devices/lab_pin.sym} 145300 -31290 0 1 {name=p144089 lab=_51054_/Y }
C {sky130_stdcells/o21ai_4.sym} 145220 -31290 0 0 {name=X_51054_ }
C {devices/lab_pin.sym} 145180 -31150 0 0 {name=p144090 lab=_68429_/A }
C {devices/lab_pin.sym} 145260 -31150 0 1 {name=p144091 lab=_67917_/X }
C {sky130_stdcells/buf_2.sym} 145220 -31150 0 0 {name=X_67917_ }
C {devices/lab_pin.sym} 145160 -31040 0 0 {name=p144092 lab=_55947_/A }
C {devices/lab_pin.sym} 145160 -31000 0 0 {name=p144093 lab=_55931_/B }
C {devices/lab_pin.sym} 145280 -31020 0 1 {name=p144094 lab=_55931_/X }
C {sky130_stdcells/and2_4.sym} 145220 -31020 0 0 {name=X_55931_ }
C {devices/lab_pin.sym} 145130 -30890 0 0 {name=p144095 lab=_85535_/CLK }
C {devices/lab_pin.sym} 145130 -30870 0 0 {name=p144096 lab=_46278_/Y }
C {devices/lab_pin.sym} 145310 -30890 0 1 {name=p144097 lab=_86751_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -30880 0 0 {name=X_86751_ }
C {devices/lab_pin.sym} 145130 -30750 0 0 {name=p144098 lab=_80991_/CLK }
C {devices/lab_pin.sym} 145130 -30730 0 0 {name=p144099 lab=_83963_/D }
C {devices/lab_pin.sym} 145310 -30750 0 1 {name=p144100 lab=_83963_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -30740 0 0 {name=X_83963_ }
C {devices/lab_pin.sym} 145140 -30640 0 0 {name=p144101 lab=_87998_/Q }
C {devices/lab_pin.sym} 145140 -30600 0 0 {name=p144102 lab=_68895_/X }
C {devices/lab_pin.sym} 145140 -30560 0 0 {name=p144103 lab=_68800_/X }
C {devices/lab_pin.sym} 145140 -30520 0 0 {name=p144104 lab=_68896_/X }
C {devices/lab_pin.sym} 145300 -30580 0 1 {name=p144105 lab=_68897_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -30580 0 0 {name=X_68897_ }
C {devices/lab_pin.sym} 145160 -30460 0 0 {name=p144106 lab=_50025_/A }
C {devices/lab_pin.sym} 145160 -30420 0 0 {name=p144107 lab=_49994_/X }
C {devices/lab_pin.sym} 145160 -30380 0 0 {name=p144108 lab=_50005_/C }
C {devices/lab_pin.sym} 145160 -30340 0 0 {name=p144109 lab=_53217_/D }
C {devices/lab_pin.sym} 145280 -30400 0 1 {name=p144110 lab=_50005_/X }
C {sky130_stdcells/and4_4.sym} 145220 -30400 0 0 {name=X_50005_ }
C {devices/lab_pin.sym} 145130 -30250 0 0 {name=p144111 lab=_85700_/CLK }
C {devices/lab_pin.sym} 145130 -30230 0 0 {name=p144112 lab=_85702_/D }
C {devices/lab_pin.sym} 145310 -30250 0 1 {name=p144113 lab=_85702_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -30240 0 0 {name=X_85702_ }
C {devices/lab_pin.sym} 145180 -30110 0 0 {name=p144114 lab=_58007_/A }
C {devices/lab_pin.sym} 145260 -30110 0 1 {name=p144115 lab=_58650_/X }
C {sky130_stdcells/buf_2.sym} 145220 -30110 0 0 {name=X_58650_ }
C {devices/lab_pin.sym} 145130 -29990 0 0 {name=p144116 lab=_82925_/CLK }
C {devices/lab_pin.sym} 145130 -29970 0 0 {name=p144117 lab=_78128_/X }
C {devices/lab_pin.sym} 145310 -29990 0 1 {name=p144118 lab=_48157_/B }
C {sky130_stdcells/dfxtp_4.sym} 145220 -29980 0 0 {name=X_82914_ }
C {devices/lab_pin.sym} 145160 -29860 0 0 {name=p144119 lab=_55859_/X }
C {devices/lab_pin.sym} 145160 -29820 0 0 {name=p144120 lab=_55862_/B }
C {devices/lab_pin.sym} 145280 -29840 0 1 {name=p144121 lab=_55862_/X }
C {sky130_stdcells/and2_4.sym} 145220 -29840 0 0 {name=X_55862_ }
C {devices/lab_pin.sym} 145160 -29720 0 0 {name=p144122 lab=_67873_/A }
C {devices/lab_pin.sym} 145160 -29680 0 0 {name=p144123 lab=_67848_/B }
C {devices/lab_pin.sym} 145280 -29700 0 1 {name=p144124 lab=_67848_/X }
C {sky130_stdcells/and2_4.sym} 145220 -29700 0 0 {name=X_67848_ }
C {devices/lab_pin.sym} 145130 -29570 0 0 {name=p144125 lab=_86361_/CLK }
C {devices/lab_pin.sym} 145130 -29550 0 0 {name=p144126 lab=_86682_/D }
C {devices/lab_pin.sym} 145310 -29570 0 1 {name=p144127 lab=_59090_/A }
C {sky130_stdcells/dfxtp_4.sym} 145220 -29560 0 0 {name=X_86682_ }
C {devices/lab_pin.sym} 145130 -29430 0 0 {name=p144128 lab=_82558_/CLK }
C {devices/lab_pin.sym} 145130 -29410 0 0 {name=p144129 lab=_69830_/X }
C {devices/lab_pin.sym} 145310 -29430 0 1 {name=p144130 lab=_81966_/D }
C {sky130_stdcells/dfxtp_4.sym} 145220 -29420 0 0 {name=X_83894_ }
C {devices/lab_pin.sym} 145160 -29310 0 0 {name=p144131 lab=_48067_/A }
C {devices/lab_pin.sym} 145160 -29270 0 0 {name=p144132 lab=_57619_/B }
C {devices/lab_pin.sym} 145160 -29230 0 0 {name=p144133 lab=_71960_/C }
C {devices/lab_pin.sym} 145280 -29270 0 1 {name=p144134 lab=_57601_/X }
C {sky130_stdcells/and3_4.sym} 145220 -29270 0 0 {name=X_57601_ }
C {devices/lab_pin.sym} 145180 -29130 0 0 {name=p144135 lab=_54758_/A }
C {devices/lab_pin.sym} 145260 -29130 0 1 {name=p144136 lab=_54823_/A }
C {sky130_stdcells/buf_2.sym} 145220 -29130 0 0 {name=X_54813_ }
C {devices/lab_pin.sym} 145130 -29010 0 0 {name=p144137 lab=_83161_/CLK }
C {devices/lab_pin.sym} 145130 -28990 0 0 {name=p144138 lab=_85633_/D }
C {devices/lab_pin.sym} 145310 -29010 0 1 {name=p144139 lab=_85633_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -29000 0 0 {name=X_85633_ }
C {devices/lab_pin.sym} 145140 -28890 0 0 {name=p144140 lab=_58571_/X }
C {devices/lab_pin.sym} 145140 -28850 0 0 {name=p144141 lab=_85792_/Q }
C {devices/lab_pin.sym} 145140 -28810 0 0 {name=p144142 lab=_58089_/X }
C {devices/lab_pin.sym} 145300 -28850 0 1 {name=p144143 lab=_58581_/X }
C {sky130_stdcells/o21a_4.sym} 145220 -28850 0 0 {name=X_58581_ }
C {devices/lab_pin.sym} 145130 -28710 0 0 {name=p144144 lab=_82975_/CLK }
C {devices/lab_pin.sym} 145130 -28690 0 0 {name=p144145 lab=_82845_/D }
C {devices/lab_pin.sym} 145310 -28710 0 1 {name=p144146 lab=_82845_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -28700 0 0 {name=X_82845_ }
C {devices/lab_pin.sym} 145140 -28590 0 0 {name=p144147 lab=_67775_/X }
C {devices/lab_pin.sym} 145140 -28550 0 0 {name=p144148 lab=_67778_/X }
C {devices/lab_pin.sym} 145140 -28510 0 0 {name=p144149 lab=_67637_/X }
C {devices/lab_pin.sym} 145300 -28550 0 1 {name=p144150 lab=_67779_/Y }
C {sky130_stdcells/a21oi_4.sym} 145220 -28550 0 0 {name=X_67779_ }
C {devices/lab_pin.sym} 145140 -28440 0 0 {name=p144151 lab=_85260_/Q }
C {devices/lab_pin.sym} 145140 -28400 0 0 {name=p144152 lab=_55177_/A }
C {devices/lab_pin.sym} 145140 -28360 0 0 {name=p144153 lab=_44045_/X }
C {devices/lab_pin.sym} 145140 -28320 0 0 {name=p144154 lab=_55792_/X }
C {devices/lab_pin.sym} 145300 -28380 0 1 {name=p144155 lab=_55793_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -28380 0 0 {name=X_55793_ }
C {devices/lab_pin.sym} 145140 -28250 0 0 {name=p144156 lab=_57530_/Y }
C {devices/lab_pin.sym} 145140 -28210 0 0 {name=p144157 lab=_57515_/X }
C {devices/lab_pin.sym} 145140 -28170 0 0 {name=p144158 lab=_57531_/Y }
C {devices/lab_pin.sym} 145300 -28210 0 1 {name=p144159 lab=_84985_/D }
C {sky130_stdcells/a21boi_4.sym} 145220 -28210 0 0 {name=X_57532_ }
C {devices/lab_pin.sym} 145140 -28100 0 0 {name=p144160 lab=_69505_/X }
C {devices/lab_pin.sym} 145140 -28060 0 0 {name=p144161 lab=_69515_/Y }
C {devices/lab_pin.sym} 145140 -28020 0 0 {name=p144162 lab=_69516_/X }
C {devices/lab_pin.sym} 145140 -27980 0 0 {name=p144163 lab=_69517_/Y }
C {devices/lab_pin.sym} 145300 -28040 0 1 {name=p144164 lab=_69518_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -28040 0 0 {name=X_69518_ }
C {devices/lab_pin.sym} 145130 -27890 0 0 {name=p144165 lab=_88363_/CLK }
C {devices/lab_pin.sym} 145130 -27870 0 0 {name=p144166 lab=_40697_/X }
C {devices/lab_pin.sym} 145310 -27890 0 1 {name=p144167 lab=_88352_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -27880 0 0 {name=X_88352_ }
C {devices/lab_pin.sym} 145140 -27770 0 0 {name=p144168 lab=_54742_/Y }
C {devices/lab_pin.sym} 145140 -27730 0 0 {name=p144169 lab=_54720_/X }
C {devices/lab_pin.sym} 145140 -27690 0 0 {name=p144170 lab=_54743_/X }
C {devices/lab_pin.sym} 145300 -27730 0 1 {name=p144171 lab=_54744_/Y }
C {sky130_stdcells/a21oi_4.sym} 145220 -27730 0 0 {name=X_54744_ }
C {devices/lab_pin.sym} 145130 -27590 0 0 {name=p144172 lab=_85561_/CLK }
C {devices/lab_pin.sym} 145130 -27570 0 0 {name=p144173 lab=_53811_/Y }
C {devices/lab_pin.sym} 145310 -27590 0 1 {name=p144174 lab=_85564_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -27580 0 0 {name=X_85564_ }
C {devices/lab_pin.sym} 145180 -27450 0 0 {name=p144175 lab=_50537_/A }
C {devices/lab_pin.sym} 145260 -27450 0 1 {name=p144176 lab=_51956_/X }
C {sky130_stdcells/buf_2.sym} 145220 -27450 0 0 {name=X_51956_ }
C {devices/lab_pin.sym} 145180 -27330 0 0 {name=p144177 lab=_70790_/A }
C {devices/lab_pin.sym} 145260 -27330 0 1 {name=p144178 lab=_70903_/A }
C {sky130_stdcells/buf_2.sym} 145220 -27330 0 0 {name=X_70790_ }
C {devices/lab_pin.sym} 145130 -27210 0 0 {name=p144179 lab=_82774_/CLK }
C {devices/lab_pin.sym} 145130 -27190 0 0 {name=p144180 lab=_82776_/D }
C {devices/lab_pin.sym} 145310 -27210 0 1 {name=p144181 lab=_82968_/D }
C {sky130_stdcells/dfxtp_4.sym} 145220 -27200 0 0 {name=X_82776_ }
C {devices/lab_pin.sym} 145130 -27070 0 0 {name=p144182 lab=_87813_/CLK }
C {devices/lab_pin.sym} 145130 -27050 0 0 {name=p144183 lab=_87303_/D }
C {devices/lab_pin.sym} 145310 -27070 0 1 {name=p144184 lab=_87303_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -27060 0 0 {name=X_87303_ }
C {devices/lab_pin.sym} 145130 -26930 0 0 {name=p144185 lab=_84503_/CLK }
C {devices/lab_pin.sym} 145130 -26910 0 0 {name=p144186 lab=_84515_/D }
C {devices/lab_pin.sym} 145310 -26930 0 1 {name=p144187 lab=_84515_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -26920 0 0 {name=X_84515_ }
C {devices/lab_pin.sym} 145140 -26810 0 0 {name=p144188 lab=_86109_/Q }
C {devices/lab_pin.sym} 145140 -26770 0 0 {name=p144189 lab=_50882_/X }
C {devices/lab_pin.sym} 145140 -26730 0 0 {name=p144190 lab=_50906_/Y }
C {devices/lab_pin.sym} 145300 -26770 0 1 {name=p144191 lab=_50907_/Y }
C {sky130_stdcells/o21ai_4.sym} 145220 -26770 0 0 {name=X_50907_ }
C {devices/lab_pin.sym} 145160 -26640 0 0 {name=p144192 lab=_84999_/Q }
C {devices/lab_pin.sym} 145160 -26600 0 0 {name=p144193 lab=_57463_/B }
C {devices/lab_pin.sym} 145280 -26620 0 1 {name=p144194 lab=_57463_/X }
C {sky130_stdcells/or2_4.sym} 145220 -26620 0 0 {name=X_57463_ }
C {devices/lab_pin.sym} 145130 -26490 0 0 {name=p144195 lab=_84014_/CLK }
C {devices/lab_pin.sym} 145130 -26470 0 0 {name=p144196 lab=_81727_/D }
C {devices/lab_pin.sym} 145310 -26490 0 1 {name=p144197 lab=_81727_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -26480 0 0 {name=X_81727_ }
C {devices/lab_pin.sym} 145140 -26370 0 0 {name=p144198 lab=_68923_/X }
C {devices/lab_pin.sym} 145140 -26330 0 0 {name=p144199 lab=_68925_/X }
C {devices/lab_pin.sym} 145140 -26290 0 0 {name=p144200 lab=_69418_/X }
C {devices/lab_pin.sym} 145300 -26330 0 1 {name=p144201 lab=_69449_/Y }
C {sky130_stdcells/a21oi_4.sym} 145220 -26330 0 0 {name=X_69449_ }
C {devices/lab_pin.sym} 145130 -26190 0 0 {name=p144202 lab=_88283_/CLK }
C {devices/lab_pin.sym} 145130 -26170 0 0 {name=p144203 lab=_41071_/X }
C {devices/lab_pin.sym} 145310 -26190 0 1 {name=p144204 lab=_69472_/B }
C {sky130_stdcells/dfxtp_4.sym} 145220 -26180 0 0 {name=X_88283_ }
C {devices/lab_pin.sym} 145140 -26070 0 0 {name=p144205 lab=_54670_/Y }
C {devices/lab_pin.sym} 145140 -26030 0 0 {name=p144206 lab=_54666_/X }
C {devices/lab_pin.sym} 145140 -25990 0 0 {name=p144207 lab=_54674_/X }
C {devices/lab_pin.sym} 145300 -26030 0 1 {name=p144208 lab=_85399_/D }
C {sky130_stdcells/a21oi_4.sym} 145220 -26030 0 0 {name=X_54675_ }
C {devices/lab_pin.sym} 145130 -25890 0 0 {name=p144209 lab=_85492_/CLK }
C {devices/lab_pin.sym} 145130 -25870 0 0 {name=p144210 lab=_85495_/D }
C {devices/lab_pin.sym} 145310 -25890 0 1 {name=p144211 lab=_85495_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -25880 0 0 {name=X_85495_ }
C {devices/lab_pin.sym} 145160 -25780 0 0 {name=p144212 lab=_51887_/A }
C {devices/lab_pin.sym} 145160 -25740 0 0 {name=p144213 lab=_51870_/B }
C {devices/lab_pin.sym} 145160 -25700 0 0 {name=p144214 lab=_51870_/C }
C {devices/lab_pin.sym} 145160 -25660 0 0 {name=p144215 lab=_52716_/D }
C {devices/lab_pin.sym} 145280 -25720 0 1 {name=p144216 lab=_51887_/X }
C {sky130_stdcells/and4_4.sym} 145220 -25720 0 0 {name=X_51887_ }
C {devices/lab_pin.sym} 145140 -25590 0 0 {name=p144217 lab=_59198_/Y }
C {devices/lab_pin.sym} 145140 -25550 0 0 {name=p144218 lab=_59201_/Y }
C {devices/lab_pin.sym} 145140 -25510 0 0 {name=p144219 lab=_59140_/X }
C {devices/lab_pin.sym} 145300 -25550 0 1 {name=p144220 lab=_59202_/X }
C {sky130_stdcells/a21o_4.sym} 145220 -25550 0 0 {name=X_59202_ }
C {devices/lab_pin.sym} 145160 -25430 0 0 {name=p144221 lab=_56418_/A }
C {devices/lab_pin.sym} 145160 -25390 0 0 {name=p144222 lab=_56418_/B }
C {devices/lab_pin.sym} 145160 -25350 0 0 {name=p144223 lab=_56414_/C }
C {devices/lab_pin.sym} 145280 -25390 0 1 {name=p144224 lab=_56414_/Y }
C {sky130_stdcells/nand3_4.sym} 145220 -25390 0 0 {name=X_56414_ }
C {devices/lab_pin.sym} 145130 -25250 0 0 {name=p144225 lab=_87235_/CLK }
C {devices/lab_pin.sym} 145130 -25230 0 0 {name=p144226 lab=_87234_/D }
C {devices/lab_pin.sym} 145310 -25250 0 1 {name=p144227 lab=_68793_/B }
C {sky130_stdcells/dfxtp_4.sym} 145220 -25240 0 0 {name=X_87234_ }
C {devices/lab_pin.sym} 145180 -25110 0 0 {name=p144228 lab=_53687_/A }
C {devices/lab_pin.sym} 145260 -25110 0 1 {name=p144229 lab=_53626_/X }
C {sky130_stdcells/buf_2.sym} 145220 -25110 0 0 {name=X_53626_ }
C {devices/lab_pin.sym} 145140 -25020 0 0 {name=p144230 lab=_41636_/X }
C {devices/lab_pin.sym} 145140 -24980 0 0 {name=p144231 lab=_41638_/X }
C {devices/lab_pin.sym} 145140 -24940 0 0 {name=p144232 lab=_67365_/B }
C {devices/lab_pin.sym} 145140 -24900 0 0 {name=p144233 lab=_41639_/X }
C {devices/lab_pin.sym} 145300 -24960 0 1 {name=p144234 lab=_88178_/D }
C {sky130_stdcells/a2bb2o_4.sym} 145220 -24960 0 0 {name=X_41640_ }
C {devices/lab_pin.sym} 145140 -24830 0 0 {name=p144235 lab=_72457_/Y }
C {devices/lab_pin.sym} 145140 -24790 0 0 {name=p144236 lab=_72459_/Y }
C {devices/lab_pin.sym} 145140 -24750 0 0 {name=p144237 lab=_57718_/A }
C {devices/lab_pin.sym} 145300 -24790 0 1 {name=p144238 lab=_72460_/X }
C {sky130_stdcells/a21o_4.sym} 145220 -24790 0 0 {name=X_72460_ }
C {devices/lab_pin.sym} 145130 -24650 0 0 {name=p144239 lab=_84452_/CLK }
C {devices/lab_pin.sym} 145130 -24630 0 0 {name=p144240 lab=_61914_/Y }
C {devices/lab_pin.sym} 145310 -24650 0 1 {name=p144241 lab=_78069_/B }
C {sky130_stdcells/dfxtp_4.sym} 145220 -24640 0 0 {name=X_84446_ }
C {devices/lab_pin.sym} 145180 -24510 0 0 {name=p144242 lab=_51010_/A }
C {devices/lab_pin.sym} 145260 -24510 0 1 {name=p144243 lab=_50957_/A }
C {sky130_stdcells/buf_2.sym} 145220 -24510 0 0 {name=X_50838_ }
C {devices/lab_pin.sym} 145130 -24390 0 0 {name=p144244 lab=_81680_/CLK }
C {devices/lab_pin.sym} 145130 -24370 0 0 {name=p144245 lab=_81690_/Q }
C {devices/lab_pin.sym} 145310 -24390 0 1 {name=p144246 lab=_81658_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -24380 0 0 {name=X_81658_ }
C {devices/lab_pin.sym} 145180 -24250 0 0 {name=p144247 lab=_57465_/A }
C {devices/lab_pin.sym} 145260 -24250 0 1 {name=p144248 lab=_57394_/X }
C {sky130_stdcells/buf_2.sym} 145220 -24250 0 0 {name=X_57394_ }
C {devices/lab_pin.sym} 145180 -24130 0 0 {name=p144249 lab=_59133_/A }
C {devices/lab_pin.sym} 145260 -24130 0 1 {name=p144250 lab=_59133_/X }
C {sky130_stdcells/buf_2.sym} 145220 -24130 0 0 {name=X_59133_ }
C {devices/lab_pin.sym} 145160 -24030 0 0 {name=p144251 lab=_71411_/A }
C {devices/lab_pin.sym} 145160 -23990 0 0 {name=p144252 lab=_71411_/B }
C {devices/lab_pin.sym} 145160 -23950 0 0 {name=p144253 lab=_71411_/C }
C {devices/lab_pin.sym} 145280 -23990 0 1 {name=p144254 lab=_71411_/Y }
C {sky130_stdcells/nor3_4.sym} 145220 -23990 0 0 {name=X_71411_ }
C {devices/lab_pin.sym} 145140 -23870 0 0 {name=p144255 lab=_80601_/A }
C {devices/lab_pin.sym} 145140 -23830 0 0 {name=p144256 lab=_80600_/Y }
C {devices/lab_pin.sym} 145140 -23790 0 0 {name=p144257 lab=_80608_/X }
C {devices/lab_pin.sym} 145300 -23830 0 1 {name=p144258 lab=_80610_/B }
C {sky130_stdcells/o21ai_4.sym} 145220 -23830 0 0 {name=X_80609_ }
C {devices/lab_pin.sym} 145160 -23710 0 0 {name=p144259 lab=_56345_/A }
C {devices/lab_pin.sym} 145160 -23670 0 0 {name=p144260 lab=_56345_/B }
C {devices/lab_pin.sym} 145160 -23630 0 0 {name=p144261 lab=_55783_/B }
C {devices/lab_pin.sym} 145280 -23670 0 1 {name=p144262 lab=_56345_/Y }
C {sky130_stdcells/nand3_4.sym} 145220 -23670 0 0 {name=X_56345_ }
C {devices/lab_pin.sym} 145140 -23560 0 0 {name=p144263 lab=_41570_/X }
C {devices/lab_pin.sym} 145140 -23520 0 0 {name=p144264 lab=_41530_/X }
C {devices/lab_pin.sym} 145140 -23480 0 0 {name=p144265 lab=_67087_/B }
C {devices/lab_pin.sym} 145140 -23440 0 0 {name=p144266 lab=_41531_/X }
C {devices/lab_pin.sym} 145300 -23500 0 1 {name=p144267 lab=_88190_/D }
C {sky130_stdcells/a2bb2o_4.sym} 145220 -23500 0 0 {name=X_41571_ }
C {devices/lab_pin.sym} 145130 -23350 0 0 {name=p144268 lab=_86941_/CLK }
C {devices/lab_pin.sym} 145130 -23330 0 0 {name=p144269 lab=_87165_/D }
C {devices/lab_pin.sym} 145310 -23350 0 1 {name=p144270 lab=_87165_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -23340 0 0 {name=X_87165_ }
C {devices/lab_pin.sym} 145180 -23210 0 0 {name=p144271 lab=_54067_/A }
C {devices/lab_pin.sym} 145260 -23210 0 1 {name=p144272 lab=_53622_/A }
C {sky130_stdcells/buf_2.sym} 145220 -23210 0 0 {name=X_53557_ }
C {devices/lab_pin.sym} 145140 -23110 0 0 {name=p144273 lab=_72352_/X }
C {devices/lab_pin.sym} 145140 -23070 0 0 {name=p144274 lab=_85963_/Q }
C {devices/lab_pin.sym} 145140 -23030 0 0 {name=p144275 lab=_72390_/X }
C {devices/lab_pin.sym} 145300 -23070 0 1 {name=p144276 lab=_72391_/Y }
C {sky130_stdcells/o21ai_4.sym} 145220 -23070 0 0 {name=X_72391_ }
C {devices/lab_pin.sym} 145130 -22930 0 0 {name=p144277 lab=_84507_/CLK }
C {devices/lab_pin.sym} 145130 -22910 0 0 {name=p144278 lab=_62854_/Y }
C {devices/lab_pin.sym} 145310 -22930 0 1 {name=p144279 lab=_75907_/B }
C {sky130_stdcells/dfxtp_4.sym} 145220 -22920 0 0 {name=X_84377_ }
C {devices/lab_pin.sym} 145160 -22800 0 0 {name=p144280 lab=_50764_/A }
C {devices/lab_pin.sym} 145160 -22760 0 0 {name=p144281 lab=_53983_/B }
C {devices/lab_pin.sym} 145280 -22780 0 1 {name=p144282 lab=_50769_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -22780 0 0 {name=X_50769_ }
C {devices/lab_pin.sym} 145130 -22650 0 0 {name=p144283 lab=_81351_/CLK }
C {devices/lab_pin.sym} 145130 -22630 0 0 {name=p144284 lab=_84189_/Q }
C {devices/lab_pin.sym} 145310 -22650 0 1 {name=p144285 lab=_81589_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -22640 0 0 {name=X_81589_ }
C {devices/lab_pin.sym} 145180 -22510 0 0 {name=p144286 lab=_43309_/Y }
C {devices/lab_pin.sym} 145260 -22510 0 1 {name=p144287 lab=_87488_/D }
C {sky130_stdcells/inv_2.sym} 145220 -22510 0 0 {name=X_43310_ }
C {devices/lab_pin.sym} 145180 -22390 0 0 {name=p144288 lab=clkbuf_7_95_0_CLK/A }
C {devices/lab_pin.sym} 145260 -22390 0 1 {name=p144289 lab=clkbuf_7_94_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 145220 -22390 0 0 {name=Xclkbuf_7_94_0_CLK }
C {devices/lab_pin.sym} 145140 -22300 0 0 {name=p144290 lab=_74106_/X }
C {devices/lab_pin.sym} 145140 -22260 0 0 {name=p144291 lab=_85609_/Q }
C {devices/lab_pin.sym} 145140 -22220 0 0 {name=p144292 lab=_74107_/X }
C {devices/lab_pin.sym} 145140 -22180 0 0 {name=p144293 lab=_74129_/X }
C {devices/lab_pin.sym} 145300 -22240 0 1 {name=p144294 lab=_74130_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -22240 0 0 {name=X_74130_ }
C {devices/lab_pin.sym} 145130 -22090 0 0 {name=p144295 lab=_85507_/CLK }
C {devices/lab_pin.sym} 145130 -22070 0 0 {name=p144296 lab=_50873_/Y }
C {devices/lab_pin.sym} 145310 -22090 0 1 {name=p144297 lab=_86116_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -22080 0 0 {name=X_86116_ }
C {devices/lab_pin.sym} 145160 -21960 0 0 {name=p144298 lab=_82311_/Q }
C {devices/lab_pin.sym} 145160 -21920 0 0 {name=p144299 lab=_40467_/B }
C {devices/lab_pin.sym} 145280 -21940 0 1 {name=p144300 lab=_40522_/X }
C {sky130_stdcells/or2_4.sym} 145220 -21940 0 0 {name=X_40522_ }
C {devices/lab_pin.sym} 145180 -21810 0 0 {name=p144301 lab=_52309_/A }
C {devices/lab_pin.sym} 145260 -21810 0 1 {name=p144302 lab=_52509_/B }
C {sky130_stdcells/buf_2.sym} 145220 -21810 0 0 {name=X_52508_ }
C {devices/lab_pin.sym} 145140 -21710 0 0 {name=p144303 lab=_59060_/Y }
C {devices/lab_pin.sym} 145140 -21670 0 0 {name=p144304 lab=_59063_/Y }
C {devices/lab_pin.sym} 145140 -21630 0 0 {name=p144305 lab=_59053_/X }
C {devices/lab_pin.sym} 145300 -21670 0 1 {name=p144306 lab=_59064_/X }
C {sky130_stdcells/a21o_4.sym} 145220 -21670 0 0 {name=X_59064_ }
C {devices/lab_pin.sym} 145160 -21540 0 0 {name=p144307 lab=_71137_/B }
C {devices/lab_pin.sym} 145160 -21500 0 0 {name=p144308 lab=_71342_/B }
C {devices/lab_pin.sym} 145280 -21520 0 1 {name=p144309 lab=_71343_/A }
C {sky130_stdcells/nor2_4.sym} 145220 -21520 0 0 {name=X_71342_ }
C {devices/lab_pin.sym} 145130 -21390 0 0 {name=p144310 lab=_83337_/CLK }
C {devices/lab_pin.sym} 145130 -21370 0 0 {name=p144311 lab=_83328_/D }
C {devices/lab_pin.sym} 145310 -21390 0 1 {name=p144312 lab=_83328_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -21380 0 0 {name=X_83328_ }
C {devices/lab_pin.sym} 145160 -21270 0 0 {name=p144313 lab=_56171_/A }
C {devices/lab_pin.sym} 145160 -21230 0 0 {name=p144314 lab=_56275_/X }
C {devices/lab_pin.sym} 145160 -21190 0 0 {name=p144315 lab=_56171_/C }
C {devices/lab_pin.sym} 145280 -21230 0 1 {name=p144316 lab=_56277_/A }
C {sky130_stdcells/nand3_4.sym} 145220 -21230 0 0 {name=X_56276_ }
C {devices/lab_pin.sym} 145180 -21090 0 0 {name=p144317 lab=_44228_/X }
C {devices/lab_pin.sym} 145260 -21090 0 1 {name=p144318 lab=_44290_/X }
C {sky130_stdcells/buf_2.sym} 145220 -21090 0 0 {name=X_44290_ }
C {devices/lab_pin.sym} 145130 -20970 0 0 {name=p144319 lab=_88268_/CLK }
C {devices/lab_pin.sym} 145130 -20950 0 0 {name=p144320 lab=_87096_/D }
C {devices/lab_pin.sym} 145310 -20970 0 1 {name=p144321 lab=_87096_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -20960 0 0 {name=X_87096_ }
C {devices/lab_pin.sym} 145160 -20840 0 0 {name=p144322 lab=_53458_/A }
C {devices/lab_pin.sym} 145160 -20800 0 0 {name=p144323 lab=_53488_/B }
C {devices/lab_pin.sym} 145280 -20820 0 1 {name=p144324 lab=_53488_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -20820 0 0 {name=X_53488_ }
C {devices/lab_pin.sym} 145180 -20690 0 0 {name=p144325 lab=_58701_/A }
C {devices/lab_pin.sym} 145260 -20690 0 1 {name=p144326 lab=_58015_/X }
C {sky130_stdcells/buf_2.sym} 145220 -20690 0 0 {name=X_58015_ }
C {devices/lab_pin.sym} 145180 -20570 0 0 {name=p144327 lab=_43162_/A }
C {devices/lab_pin.sym} 145260 -20570 0 1 {name=p144328 lab=_43241_/X }
C {sky130_stdcells/buf_2.sym} 145220 -20570 0 0 {name=X_43241_ }
C {devices/lab_pin.sym} 145140 -20480 0 0 {name=p144329 lab=_74016_/X }
C {devices/lab_pin.sym} 145140 -20440 0 0 {name=p144330 lab=_85612_/Q }
C {devices/lab_pin.sym} 145140 -20400 0 0 {name=p144331 lab=_56933_/X }
C {devices/lab_pin.sym} 145140 -20360 0 0 {name=p144332 lab=_74060_/X }
C {devices/lab_pin.sym} 145300 -20420 0 1 {name=p144333 lab=_74061_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -20420 0 0 {name=X_74061_ }
C {devices/lab_pin.sym} 145160 -20290 0 0 {name=p144334 lab=_55227_/A }
C {devices/lab_pin.sym} 145160 -20250 0 0 {name=p144335 lab=_83315_/Q }
C {devices/lab_pin.sym} 145160 -20210 0 0 {name=p144336 lab=_55225_/X }
C {devices/lab_pin.sym} 145280 -20250 0 1 {name=p144337 lab=_55227_/Y }
C {sky130_stdcells/nand3_4.sym} 145220 -20250 0 0 {name=X_55227_ }
C {devices/lab_pin.sym} 145130 -20110 0 0 {name=p144338 lab=_85535_/CLK }
C {devices/lab_pin.sym} 145130 -20090 0 0 {name=p144339 lab=_51248_/Y }
C {devices/lab_pin.sym} 145310 -20110 0 1 {name=p144340 lab=_64643_/B }
C {sky130_stdcells/dfxtp_4.sym} 145220 -20100 0 0 {name=X_86047_ }
C {devices/lab_pin.sym} 145140 -20010 0 0 {name=p144341 lab=_40437_/X }
C {devices/lab_pin.sym} 145140 -19970 0 0 {name=p144342 lab=_40443_/X }
C {devices/lab_pin.sym} 145140 -19930 0 0 {name=p144343 lab=_40452_/X }
C {devices/lab_pin.sym} 145140 -19890 0 0 {name=p144344 lab=_88389_/Q }
C {devices/lab_pin.sym} 145140 -19850 0 0 {name=p144345 lab=_40447_/X }
C {devices/lab_pin.sym} 145300 -19930 0 1 {name=p144346 lab=_40454_/A }
C {sky130_stdcells/o32ai_4.sym} 145220 -19930 0 0 {name=X_40453_ }
C {devices/lab_pin.sym} 145180 -19770 0 0 {name=p144347 lab=_52185_/A }
C {devices/lab_pin.sym} 145260 -19770 0 1 {name=p144348 lab=_52466_/A }
C {sky130_stdcells/buf_2.sym} 145220 -19770 0 0 {name=X_52439_ }
C {devices/lab_pin.sym} 145130 -19650 0 0 {name=p144349 lab=_86282_/CLK }
C {devices/lab_pin.sym} 145130 -19630 0 0 {name=p144350 lab=_83259_/D }
C {devices/lab_pin.sym} 145310 -19650 0 1 {name=p144351 lab=_83259_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -19640 0 0 {name=X_83259_ }
C {devices/lab_pin.sym} 145180 -19510 0 0 {name=p144352 lab=_70638_/A }
C {devices/lab_pin.sym} 145260 -19510 0 1 {name=p144353 lab=_71276_/D }
C {sky130_stdcells/buf_2.sym} 145220 -19510 0 0 {name=X_71273_ }
C {devices/lab_pin.sym} 145160 -19400 0 0 {name=p144354 lab=_73093_/A }
C {devices/lab_pin.sym} 145160 -19360 0 0 {name=p144355 lab=_73012_/B }
C {devices/lab_pin.sym} 145280 -19380 0 1 {name=p144356 lab=_73012_/X }
C {sky130_stdcells/and2_4.sym} 145220 -19380 0 0 {name=X_73012_ }
C {devices/lab_pin.sym} 145180 -19250 0 0 {name=p144357 lab=_70238_/A }
C {devices/lab_pin.sym} 145260 -19250 0 1 {name=p144358 lab=_70224_/X }
C {sky130_stdcells/buf_2.sym} 145220 -19250 0 0 {name=X_70224_ }
C {devices/lab_pin.sym} 145180 -19130 0 0 {name=p144359 lab=_43121_/A }
C {devices/lab_pin.sym} 145260 -19130 0 1 {name=p144360 lab=_43172_/X }
C {sky130_stdcells/buf_2.sym} 145220 -19130 0 0 {name=X_43172_ }
C {devices/lab_pin.sym} 145180 -19010 0 0 {name=p144361 lab=_55158_/A }
C {devices/lab_pin.sym} 145260 -19010 0 1 {name=p144362 lab=_55172_/A }
C {sky130_stdcells/buf_2.sym} 145220 -19010 0 0 {name=X_55158_ }
C {devices/lab_pin.sym} 145180 -18890 0 0 {name=p144363 lab=_46317_/A }
C {devices/lab_pin.sym} 145260 -18890 0 1 {name=p144364 lab=_40385_/B }
C {sky130_stdcells/buf_2.sym} 145220 -18890 0 0 {name=X_40384_ }
C {devices/lab_pin.sym} 145140 -18810 0 0 {name=p144365 lab=_42120_/X }
C {devices/lab_pin.sym} 145140 -18770 0 0 {name=p144366 lab=_42116_/X }
C {devices/lab_pin.sym} 145140 -18730 0 0 {name=p144367 lab=_41087_/X }
C {devices/lab_pin.sym} 145140 -18690 0 0 {name=p144368 lab=_88024_/Q }
C {devices/lab_pin.sym} 145140 -18650 0 0 {name=p144369 lab=_42117_/X }
C {devices/lab_pin.sym} 145300 -18730 0 1 {name=p144370 lab=_42124_/A }
C {sky130_stdcells/o32ai_4.sym} 145220 -18730 0 0 {name=X_42123_ }
C {devices/lab_pin.sym} 145180 -18570 0 0 {name=p144371 lab=_54245_/A }
C {devices/lab_pin.sym} 145260 -18570 0 1 {name=p144372 lab=_54217_/A }
C {sky130_stdcells/buf_2.sym} 145220 -18570 0 0 {name=X_54109_ }
C {devices/lab_pin.sym} 145140 -18480 0 0 {name=p144373 lab=_77806_/Y }
C {devices/lab_pin.sym} 145140 -18440 0 0 {name=p144374 lab=_77807_/Y }
C {devices/lab_pin.sym} 145140 -18400 0 0 {name=p144375 lab=_82058_/Q }
C {devices/lab_pin.sym} 145140 -18360 0 0 {name=p144376 lab=_77819_/Y }
C {devices/lab_pin.sym} 145300 -18420 0 1 {name=p144377 lab=_77820_/X }
C {sky130_stdcells/a2bb2o_4.sym} 145220 -18420 0 0 {name=X_77820_ }
C {devices/lab_pin.sym} 145160 -18290 0 0 {name=p144378 lab=_70127_/X }
C {devices/lab_pin.sym} 145160 -18250 0 0 {name=p144379 lab=_70134_/X }
C {devices/lab_pin.sym} 145160 -18210 0 0 {name=p144380 lab=_70154_/X }
C {devices/lab_pin.sym} 145280 -18250 0 1 {name=p144381 lab=_70155_/X }
C {sky130_stdcells/and3_4.sym} 145220 -18250 0 0 {name=X_70155_ }
C {devices/lab_pin.sym} 145140 -18130 0 0 {name=p144382 lab=_73904_/B }
C {devices/lab_pin.sym} 145140 -18090 0 0 {name=p144383 lab=_47948_/X }
C {devices/lab_pin.sym} 145140 -18050 0 0 {name=p144384 lab=_47979_/Y }
C {devices/lab_pin.sym} 145300 -18090 0 1 {name=p144385 lab=_47980_/Y }
C {sky130_stdcells/o21ai_4.sym} 145220 -18090 0 0 {name=X_47980_ }
C {devices/lab_pin.sym} 145160 -17960 0 0 {name=p144386 lab=_55093_/A }
C {devices/lab_pin.sym} 145160 -17920 0 0 {name=p144387 lab=_47762_/Y }
C {devices/lab_pin.sym} 145280 -17940 0 1 {name=p144388 lab=_55089_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -17940 0 0 {name=X_55089_ }
C {devices/lab_pin.sym} 145160 -17820 0 0 {name=p144389 lab=_59917_/X }
C {devices/lab_pin.sym} 145160 -17780 0 0 {name=p144390 lab=_59909_/Y }
C {devices/lab_pin.sym} 145280 -17800 0 1 {name=p144391 lab=_59966_/Y }
C {sky130_stdcells/nor2_4.sym} 145220 -17800 0 0 {name=X_59966_ }
C {devices/lab_pin.sym} 145130 -17670 0 0 {name=p144392 lab=_87748_/CLK }
C {devices/lab_pin.sym} 145130 -17650 0 0 {name=p144393 lab=_42175_/Y }
C {devices/lab_pin.sym} 145310 -17670 0 1 {name=p144394 lab=_87998_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -17660 0 0 {name=X_87998_ }
C {devices/lab_pin.sym} 145140 -17550 0 0 {name=p144395 lab=_86688_/Q }
C {devices/lab_pin.sym} 145140 -17510 0 0 {name=p144396 lab=_46908_/X }
C {devices/lab_pin.sym} 145140 -17470 0 0 {name=p144397 lab=_46930_/Y }
C {devices/lab_pin.sym} 145300 -17510 0 1 {name=p144398 lab=_46931_/Y }
C {sky130_stdcells/o21ai_4.sym} 145220 -17510 0 0 {name=X_46931_ }
C {devices/lab_pin.sym} 145180 -17370 0 0 {name=p144399 lab=_42053_/Y }
C {devices/lab_pin.sym} 145260 -17370 0 1 {name=p144400 lab=_42054_/Y }
C {sky130_stdcells/inv_2.sym} 145220 -17370 0 0 {name=X_42054_ }
C {devices/lab_pin.sym} 145140 -17280 0 0 {name=p144401 lab=_84790_/Q }
C {devices/lab_pin.sym} 145140 -17240 0 0 {name=p144402 lab=_58871_/X }
C {devices/lab_pin.sym} 145140 -17200 0 0 {name=p144403 lab=_58911_/X }
C {devices/lab_pin.sym} 145140 -17160 0 0 {name=p144404 lab=_58916_/X }
C {devices/lab_pin.sym} 145300 -17220 0 1 {name=p144405 lab=_84790_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 145220 -17220 0 0 {name=X_58917_ }
C {devices/lab_pin.sym} 145160 -17090 0 0 {name=p144406 lab=_77747_/X }
C {devices/lab_pin.sym} 145160 -17050 0 0 {name=p144407 lab=_77751_/B }
C {devices/lab_pin.sym} 145160 -17010 0 0 {name=p144408 lab=_77751_/C }
C {devices/lab_pin.sym} 145280 -17050 0 1 {name=p144409 lab=_77758_/A }
C {sky130_stdcells/nand3_4.sym} 145220 -17050 0 0 {name=X_77751_ }
C {devices/lab_pin.sym} 145160 -16920 0 0 {name=p144410 lab=_74971_/A }
C {devices/lab_pin.sym} 145160 -16880 0 0 {name=p144411 lab=_74963_/B }
C {devices/lab_pin.sym} 145280 -16900 0 1 {name=p144412 lab=_74964_/B }
C {sky130_stdcells/xor2_4.sym} 145220 -16900 0 0 {name=X_74963_ }
C {devices/lab_pin.sym} 145140 -16790 0 0 {name=p144413 lab=_69057_/X }
C {devices/lab_pin.sym} 145140 -16750 0 0 {name=p144414 lab=_69060_/X }
C {devices/lab_pin.sym} 145140 -16710 0 0 {name=p144415 lab=_69156_/X }
C {devices/lab_pin.sym} 145300 -16750 0 1 {name=p144416 lab=_70086_/Y }
C {sky130_stdcells/a21oi_4.sym} 145220 -16750 0 0 {name=X_70086_ }
C {devices/lab_pin.sym} 145130 -16610 0 0 {name=p144417 lab=_88215_/CLK }
C {devices/lab_pin.sym} 145130 -16590 0 0 {name=p144418 lab=_86949_/D }
C {devices/lab_pin.sym} 145310 -16610 0 1 {name=p144419 lab=_86949_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -16600 0 0 {name=X_86949_ }
C {devices/lab_pin.sym} 145180 -16470 0 0 {name=p144420 lab=_59896_/X }
C {devices/lab_pin.sym} 145260 -16470 0 1 {name=p144421 lab=_59898_/A }
C {sky130_stdcells/buf_2.sym} 145220 -16470 0 0 {name=X_59897_ }
C {devices/lab_pin.sym} 145140 -16390 0 0 {name=p144422 lab=_40999_/X }
C {devices/lab_pin.sym} 145140 -16350 0 0 {name=p144423 lab=_41000_/X }
C {devices/lab_pin.sym} 145140 -16310 0 0 {name=p144424 lab=_41004_/X }
C {devices/lab_pin.sym} 145140 -16270 0 0 {name=p144425 lab=_88295_/Q }
C {devices/lab_pin.sym} 145140 -16230 0 0 {name=p144426 lab=_40995_/X }
C {devices/lab_pin.sym} 145300 -16310 0 1 {name=p144427 lab=_41005_/Y }
C {sky130_stdcells/o32ai_4.sym} 145220 -16310 0 0 {name=X_41005_ }
C {devices/lab_pin.sym} 145180 -16150 0 0 {name=p144428 lab=clkbuf_6_16_0_CLK/X }
C {devices/lab_pin.sym} 145260 -16150 0 1 {name=p144429 lab=clkbuf_8_65_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 145220 -16150 0 0 {name=Xclkbuf_7_32_0_CLK }
C {devices/lab_pin.sym} 145140 -16050 0 0 {name=p144430 lab=_76699_/X }
C {devices/lab_pin.sym} 145140 -16010 0 0 {name=p144431 lab=_76700_/Y }
C {devices/lab_pin.sym} 145140 -15970 0 0 {name=p144432 lab=_76701_/X }
C {devices/lab_pin.sym} 145300 -16010 0 1 {name=p144433 lab=_76703_/A }
C {sky130_stdcells/a21oi_4.sym} 145220 -16010 0 0 {name=X_76702_ }
C {devices/lab_pin.sym} 145180 -15870 0 0 {name=p144434 lab=_49570_/A }
C {devices/lab_pin.sym} 145260 -15870 0 1 {name=p144435 lab=_49650_/X }
C {sky130_stdcells/buf_2.sym} 145220 -15870 0 0 {name=X_49650_ }
C {devices/lab_pin.sym} 145140 -15770 0 0 {name=p144436 lab=_73912_/X }
C {devices/lab_pin.sym} 145140 -15730 0 0 {name=p144437 lab=_73913_/Y }
C {devices/lab_pin.sym} 145140 -15690 0 0 {name=p144438 lab=_73839_/X }
C {devices/lab_pin.sym} 145300 -15730 0 1 {name=p144439 lab=_73914_/X }
C {sky130_stdcells/a21o_4.sym} 145220 -15730 0 0 {name=X_73914_ }
C {devices/lab_pin.sym} 145180 -15590 0 0 {name=p144440 lab=_52718_/B }
C {devices/lab_pin.sym} 145260 -15590 0 1 {name=p144441 lab=_51026_/B }
C {sky130_stdcells/buf_2.sym} 145220 -15590 0 0 {name=X_46862_ }
C {devices/lab_pin.sym} 145140 -15490 0 0 {name=p144442 lab=_58846_/X }
C {devices/lab_pin.sym} 145140 -15450 0 0 {name=p144443 lab=_85771_/Q }
C {devices/lab_pin.sym} 145140 -15410 0 0 {name=p144444 lab=_58847_/X }
C {devices/lab_pin.sym} 145300 -15450 0 1 {name=p144445 lab=_58848_/X }
C {sky130_stdcells/o21a_4.sym} 145220 -15450 0 0 {name=X_58848_ }
C {devices/lab_pin.sym} 145160 -15320 0 0 {name=p144446 lab=_77680_/X }
C {devices/lab_pin.sym} 145160 -15280 0 0 {name=p144447 lab=_77693_/D }
C {devices/lab_pin.sym} 145280 -15300 0 1 {name=p144448 lab=_77687_/B }
C {sky130_stdcells/and2_4.sym} 145220 -15300 0 0 {name=X_77682_ }
C {devices/lab_pin.sym} 145160 -15180 0 0 {name=p144449 lab=_74894_/A }
C {devices/lab_pin.sym} 145160 -15140 0 0 {name=p144450 lab=_74893_/Y }
C {devices/lab_pin.sym} 145280 -15160 0 1 {name=p144451 lab=_74895_/B }
C {sky130_stdcells/xor2_4.sym} 145220 -15160 0 0 {name=X_74894_ }
C {devices/lab_pin.sym} 145180 -15030 0 0 {name=p144452 lab=clkbuf_7_86_0_CLK/X }
C {devices/lab_pin.sym} 145260 -15030 0 1 {name=p144453 lab=clkbuf_9_345_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 145220 -15030 0 0 {name=Xclkbuf_8_172_0_CLK }
C {devices/lab_pin.sym} 145140 -14930 0 0 {name=p144454 lab=_48595_/Y }
C {devices/lab_pin.sym} 145140 -14890 0 0 {name=p144455 lab=_48403_/X }
C {devices/lab_pin.sym} 145140 -14850 0 0 {name=p144456 lab=_48600_/Y }
C {devices/lab_pin.sym} 145300 -14890 0 1 {name=p144457 lab=_86508_/D }
C {sky130_stdcells/a21boi_4.sym} 145220 -14890 0 0 {name=X_48601_ }
C {devices/lab_pin.sym} 145140 -14770 0 0 {name=p144458 lab=_79408_/X }
C {devices/lab_pin.sym} 145140 -14730 0 0 {name=p144459 lab=_79419_/X }
C {devices/lab_pin.sym} 145140 -14690 0 0 {name=p144460 lab=_79420_/X }
C {devices/lab_pin.sym} 145300 -14730 0 1 {name=p144461 lab=_79421_/Y }
C {sky130_stdcells/a21oi_4.sym} 145220 -14730 0 0 {name=X_79421_ }
C {devices/lab_pin.sym} 145140 -14620 0 0 {name=p144462 lab=_45811_/Y }
C {devices/lab_pin.sym} 145140 -14580 0 0 {name=p144463 lab=_45632_/X }
C {devices/lab_pin.sym} 145140 -14540 0 0 {name=p144464 lab=_45616_/X }
C {devices/lab_pin.sym} 145140 -14500 0 0 {name=p144465 lab=_45812_/Y }
C {devices/lab_pin.sym} 145300 -14560 0 1 {name=p144466 lab=_45813_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -14560 0 0 {name=X_45813_ }
C {devices/lab_pin.sym} 145180 -14410 0 0 {name=p144467 lab=_76633_/A }
C {devices/lab_pin.sym} 145260 -14410 0 1 {name=p144468 lab=_76633_/Y }
C {sky130_stdcells/inv_2.sym} 145220 -14410 0 0 {name=X_76633_ }
C {devices/lab_pin.sym} 145160 -14300 0 0 {name=p144469 lab=_49580_/X }
C {devices/lab_pin.sym} 145160 -14260 0 0 {name=p144470 lab=_52794_/B }
C {devices/lab_pin.sym} 145280 -14280 0 1 {name=p144471 lab=_49581_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -14280 0 0 {name=X_49581_ }
C {devices/lab_pin.sym} 145160 -14160 0 0 {name=p144472 lab=_73845_/A }
C {devices/lab_pin.sym} 145160 -14120 0 0 {name=p144473 lab=_73873_/B }
C {devices/lab_pin.sym} 145280 -14140 0 1 {name=p144474 lab=_73845_/Y }
C {sky130_stdcells/nor2_4.sym} 145220 -14140 0 0 {name=X_73845_ }
C {devices/lab_pin.sym} 145140 -14030 0 0 {name=p144475 lab=_46789_/Y }
C {devices/lab_pin.sym} 145140 -13990 0 0 {name=p144476 lab=_46751_/X }
C {devices/lab_pin.sym} 145140 -13950 0 0 {name=p144477 lab=_46792_/X }
C {devices/lab_pin.sym} 145300 -13990 0 1 {name=p144478 lab=_86703_/D }
C {sky130_stdcells/a21oi_4.sym} 145220 -13990 0 0 {name=X_46793_ }
C {devices/lab_pin.sym} 145160 -13860 0 0 {name=p144479 lab=_58699_/A }
C {devices/lab_pin.sym} 145160 -13820 0 0 {name=p144480 lab=_86384_/Q }
C {devices/lab_pin.sym} 145280 -13840 0 1 {name=p144481 lab=_58779_/Y }
C {sky130_stdcells/nor2_4.sym} 145220 -13840 0 0 {name=X_58779_ }
C {devices/lab_pin.sym} 145180 -13710 0 0 {name=p144482 lab=_52175_/A }
C {devices/lab_pin.sym} 145260 -13710 0 1 {name=p144483 lab=_48533_/A }
C {sky130_stdcells/buf_2.sym} 145220 -13710 0 0 {name=X_48532_ }
C {devices/lab_pin.sym} 145160 -13610 0 0 {name=p144484 lab=_60792_/A }
C {devices/lab_pin.sym} 145160 -13570 0 0 {name=p144485 lab=_60810_/B }
C {devices/lab_pin.sym} 145160 -13530 0 0 {name=p144486 lab=_60810_/C }
C {devices/lab_pin.sym} 145280 -13570 0 1 {name=p144487 lab=_60810_/Y }
C {sky130_stdcells/nor3_4.sym} 145220 -13570 0 0 {name=X_60810_ }
C {devices/lab_pin.sym} 145160 -13440 0 0 {name=p144488 lab=_84346_/Q }
C {devices/lab_pin.sym} 145160 -13400 0 0 {name=p144489 lab=_79352_/B }
C {devices/lab_pin.sym} 145280 -13420 0 1 {name=p144490 lab=_79360_/B }
C {sky130_stdcells/xor2_4.sym} 145220 -13420 0 0 {name=X_79352_ }
C {devices/lab_pin.sym} 145140 -13310 0 0 {name=p144491 lab=_85131_/Q }
C {devices/lab_pin.sym} 145140 -13270 0 0 {name=p144492 lab=_45709_/X }
C {devices/lab_pin.sym} 145140 -13230 0 0 {name=p144493 lab=_45743_/X }
C {devices/lab_pin.sym} 145300 -13270 0 1 {name=p144494 lab=_45744_/X }
C {sky130_stdcells/o21a_4.sym} 145220 -13270 0 0 {name=X_45744_ }
C {devices/lab_pin.sym} 145160 -13140 0 0 {name=p144495 lab=_76562_/Y }
C {devices/lab_pin.sym} 145160 -13100 0 0 {name=p144496 lab=_76563_/X }
C {devices/lab_pin.sym} 145280 -13120 0 1 {name=p144497 lab=_76564_/X }
C {sky130_stdcells/xor2_4.sym} 145220 -13120 0 0 {name=X_76564_ }
C {devices/lab_pin.sym} 145180 -12990 0 0 {name=p144498 lab=_42955_/Y }
C {devices/lab_pin.sym} 145260 -12990 0 1 {name=p144499 lab=_87633_/D }
C {sky130_stdcells/inv_2.sym} 145220 -12990 0 0 {name=X_42956_ }
C {devices/lab_pin.sym} 145180 -12870 0 0 {name=p144500 lab=_61948_/A }
C {devices/lab_pin.sym} 145260 -12870 0 1 {name=p144501 lab=_61790_/X }
C {sky130_stdcells/buf_2.sym} 145220 -12870 0 0 {name=X_61790_ }
C {devices/lab_pin.sym} 145180 -12750 0 0 {name=p144502 lab=_72973_/B }
C {devices/lab_pin.sym} 145260 -12750 0 1 {name=p144503 lab=_73776_/X }
C {sky130_stdcells/buf_2.sym} 145220 -12750 0 0 {name=X_73776_ }
C {devices/lab_pin.sym} 145140 -12650 0 0 {name=p144504 lab=_51316_/B }
C {devices/lab_pin.sym} 145140 -12610 0 0 {name=p144505 lab=_70983_/X }
C {devices/lab_pin.sym} 145140 -12570 0 0 {name=p144506 lab=_70987_/Y }
C {devices/lab_pin.sym} 145300 -12610 0 1 {name=p144507 lab=_70988_/Y }
C {sky130_stdcells/o21ai_4.sym} 145220 -12610 0 0 {name=X_70988_ }
C {devices/lab_pin.sym} 145180 -12470 0 0 {name=p144508 lab=clkbuf_7_47_0_CLK/A }
C {devices/lab_pin.sym} 145260 -12470 0 1 {name=p144509 lab=clkbuf_8_95_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 145220 -12470 0 0 {name=Xclkbuf_7_47_0_CLK }
C {devices/lab_pin.sym} 145160 -12360 0 0 {name=p144510 lab=_82593_/Q }
C {devices/lab_pin.sym} 145160 -12320 0 0 {name=p144511 lab=_78303_/B }
C {devices/lab_pin.sym} 145280 -12340 0 1 {name=p144512 lab=_78306_/C }
C {sky130_stdcells/xnor2_4.sym} 145220 -12340 0 0 {name=X_78303_ }
C {devices/lab_pin.sym} 145180 -12210 0 0 {name=p144513 lab=_81087_/Q }
C {devices/lab_pin.sym} 145260 -12210 0 1 {name=p144514 lab=_75519_/A }
C {sky130_stdcells/inv_2.sym} 145220 -12210 0 0 {name=X_75515_ }
C {devices/lab_pin.sym} 145180 -12090 0 0 {name=p144515 lab=_51719_/A }
C {devices/lab_pin.sym} 145260 -12090 0 1 {name=p144516 lab=_41907_/X }
C {sky130_stdcells/buf_2.sym} 145220 -12090 0 0 {name=X_41907_ }
C {devices/lab_pin.sym} 145140 -11990 0 0 {name=p144517 lab=_48372_/X }
C {devices/lab_pin.sym} 145140 -11950 0 0 {name=p144518 lab=_82360_/Q }
C {devices/lab_pin.sym} 145140 -11910 0 0 {name=p144519 lab=_48462_/Y }
C {devices/lab_pin.sym} 145300 -11950 0 1 {name=p144520 lab=_48464_/A }
C {sky130_stdcells/o21ai_4.sym} 145220 -11950 0 0 {name=X_48463_ }
C {devices/lab_pin.sym} 145180 -11810 0 0 {name=p144521 lab=_63436_/A }
C {devices/lab_pin.sym} 145260 -11810 0 1 {name=p144522 lab=_63370_/A }
C {sky130_stdcells/buf_2.sym} 145220 -11810 0 0 {name=X_60741_ }
C {devices/lab_pin.sym} 145180 -11690 0 0 {name=p144523 lab=_72795_/A }
C {devices/lab_pin.sym} 145260 -11690 0 1 {name=p144524 lab=_72769_/B }
C {sky130_stdcells/buf_2.sym} 145220 -11690 0 0 {name=X_72727_ }
C {devices/lab_pin.sym} 145140 -11590 0 0 {name=p144525 lab=_79275_/B }
C {devices/lab_pin.sym} 145140 -11550 0 0 {name=p144526 lab=_79292_/B }
C {devices/lab_pin.sym} 145140 -11510 0 0 {name=p144527 lab=_79282_/X }
C {devices/lab_pin.sym} 145300 -11550 0 1 {name=p144528 lab=_79283_/Y }
C {sky130_stdcells/a21boi_4.sym} 145220 -11550 0 0 {name=X_79283_ }
C {devices/lab_pin.sym} 145180 -11410 0 0 {name=p144529 lab=_45252_/A }
C {devices/lab_pin.sym} 145260 -11410 0 1 {name=p144530 lab=_45675_/X }
C {sky130_stdcells/buf_2.sym} 145220 -11410 0 0 {name=X_45675_ }
C {devices/lab_pin.sym} 145180 -11290 0 0 {name=p144531 lab=clkbuf_7_93_0_CLK/X }
C {devices/lab_pin.sym} 145260 -11290 0 1 {name=p144532 lab=clkbuf_9_375_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 145220 -11290 0 0 {name=Xclkbuf_8_187_0_CLK }
C {devices/lab_pin.sym} 145140 -11190 0 0 {name=p144533 lab=_76491_/X }
C {devices/lab_pin.sym} 145140 -11150 0 0 {name=p144534 lab=_76492_/Y }
C {devices/lab_pin.sym} 145140 -11110 0 0 {name=p144535 lab=_76494_/Y }
C {devices/lab_pin.sym} 145300 -11150 0 1 {name=p144536 lab=_76513_/B }
C {sky130_stdcells/a21o_4.sym} 145220 -11150 0 0 {name=X_76495_ }
C {devices/lab_pin.sym} 145180 -11010 0 0 {name=p144537 lab=_42832_/A }
C {devices/lab_pin.sym} 145260 -11010 0 1 {name=p144538 lab=_42887_/X }
C {sky130_stdcells/buf_2.sym} 145220 -11010 0 0 {name=X_42887_ }
C {devices/lab_pin.sym} 145180 -10890 0 0 {name=p144539 lab=clkbuf_9_91_0_CLK/X }
C {devices/lab_pin.sym} 145260 -10890 0 1 {name=p144540 lab=_83325_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 145220 -10890 0 0 {name=Xclkbuf_10_182_0_CLK }
C {devices/lab_pin.sym} 145180 -10770 0 0 {name=p144541 lab=_47414_/A }
C {devices/lab_pin.sym} 145260 -10770 0 1 {name=p144542 lab=_47414_/X }
C {sky130_stdcells/buf_2.sym} 145220 -10770 0 0 {name=X_47414_ }
C {devices/lab_pin.sym} 145160 -10660 0 0 {name=p144543 lab=_78234_/A }
C {devices/lab_pin.sym} 145160 -10620 0 0 {name=p144544 lab=_78233_/X }
C {devices/lab_pin.sym} 145280 -10640 0 1 {name=p144545 lab=_78234_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -10640 0 0 {name=X_78234_ }
C {devices/lab_pin.sym} 145140 -10550 0 0 {name=p144546 lab=_44622_/X }
C {devices/lab_pin.sym} 145140 -10510 0 0 {name=p144547 lab=_44623_/X }
C {devices/lab_pin.sym} 145140 -10470 0 0 {name=p144548 lab=_40994_/A }
C {devices/lab_pin.sym} 145140 -10430 0 0 {name=p144549 lab=_87028_/Q }
C {devices/lab_pin.sym} 145140 -10390 0 0 {name=p144550 lab=_44625_/X }
C {devices/lab_pin.sym} 145300 -10470 0 1 {name=p144551 lab=_44627_/A }
C {sky130_stdcells/o32ai_4.sym} 145220 -10470 0 0 {name=X_44626_ }
C {devices/lab_pin.sym} 145160 -10330 0 0 {name=p144552 lab=_75442_/Y }
C {devices/lab_pin.sym} 145160 -10290 0 0 {name=p144553 lab=_75443_/Y }
C {devices/lab_pin.sym} 145160 -10250 0 0 {name=p144554 lab=_75445_/Y }
C {devices/lab_pin.sym} 145280 -10290 0 1 {name=p144555 lab=_75446_/X }
C {sky130_stdcells/or3_4.sym} 145220 -10290 0 0 {name=X_75446_ }
C {devices/lab_pin.sym} 145140 -10180 0 0 {name=p144556 lab=_58535_/Y }
C {devices/lab_pin.sym} 145140 -10140 0 0 {name=p144557 lab=_63436_/X }
C {devices/lab_pin.sym} 145140 -10100 0 0 {name=p144558 lab=_61430_/A }
C {devices/lab_pin.sym} 145140 -10060 0 0 {name=p144559 lab=_63437_/X }
C {devices/lab_pin.sym} 145300 -10120 0 1 {name=p144560 lab=_63460_/X }
C {sky130_stdcells/a2bb2o_4.sym} 145220 -10120 0 0 {name=X_63460_ }
C {devices/lab_pin.sym} 145140 -10000 0 0 {name=p144561 lab=_40485_/X }
C {devices/lab_pin.sym} 145140 -9960 0 0 {name=p144562 lab=_41813_/X }
C {devices/lab_pin.sym} 145140 -9920 0 0 {name=p144563 lab=_67028_/B }
C {devices/lab_pin.sym} 145140 -9880 0 0 {name=p144564 lab=_41814_/X }
C {devices/lab_pin.sym} 145300 -9940 0 1 {name=p144565 lab=_41838_/X }
C {sky130_stdcells/a2bb2o_4.sym} 145220 -9940 0 0 {name=X_41838_ }
C {devices/lab_pin.sym} 145160 -9800 0 0 {name=p144566 lab=_48044_/A }
C {devices/lab_pin.sym} 145160 -9760 0 0 {name=p144567 lab=_47869_/A }
C {devices/lab_pin.sym} 145280 -9780 0 1 {name=p144568 lab=_48394_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -9780 0 0 {name=X_48394_ }
C {devices/lab_pin.sym} 145140 -9680 0 0 {name=p144569 lab=_78080_/A }
C {devices/lab_pin.sym} 145140 -9640 0 0 {name=p144570 lab=_60323_/X }
C {devices/lab_pin.sym} 145140 -9600 0 0 {name=p144571 lab=_60647_/Y }
C {devices/lab_pin.sym} 145140 -9560 0 0 {name=p144572 lab=_60671_/Y }
C {devices/lab_pin.sym} 145300 -9620 0 1 {name=p144573 lab=_84585_/D }
C {sky130_stdcells/o22a_4.sym} 145220 -9620 0 0 {name=X_60672_ }
C {devices/lab_pin.sym} 145180 -9470 0 0 {name=p144574 lab=_72630_/X }
C {devices/lab_pin.sym} 145260 -9470 0 1 {name=p144575 lab=_72658_/X }
C {sky130_stdcells/buf_2.sym} 145220 -9470 0 0 {name=X_72658_ }
C {devices/lab_pin.sym} 145180 -9350 0 0 {name=p144576 lab=_62120_/A }
C {devices/lab_pin.sym} 145260 -9350 0 1 {name=p144577 lab=_62411_/X }
C {sky130_stdcells/buf_2.sym} 145220 -9350 0 0 {name=X_62411_ }
C {devices/lab_pin.sym} 145160 -9240 0 0 {name=p144578 lab=_47333_/X }
C {devices/lab_pin.sym} 145160 -9200 0 0 {name=p144579 lab=_52995_/B }
C {devices/lab_pin.sym} 145280 -9220 0 1 {name=p144580 lab=_47345_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -9220 0 0 {name=X_47345_ }
C {devices/lab_pin.sym} 145160 -9120 0 0 {name=p144581 lab=_70543_/Y }
C {devices/lab_pin.sym} 145160 -9080 0 0 {name=p144582 lab=_70573_/B }
C {devices/lab_pin.sym} 145160 -9040 0 0 {name=p144583 lab=_70568_/D }
C {devices/lab_pin.sym} 145160 -9000 0 0 {name=p144584 lab=_71606_/X }
C {devices/lab_pin.sym} 145280 -9060 0 1 {name=p144585 lab=_71609_/Y }
C {sky130_stdcells/nor4_4.sym} 145220 -9060 0 0 {name=X_71609_ }
C {devices/lab_pin.sym} 145160 -8920 0 0 {name=p144586 lab=_78165_/A }
C {devices/lab_pin.sym} 145160 -8880 0 0 {name=p144587 lab=_78162_/C }
C {devices/lab_pin.sym} 145280 -8900 0 1 {name=p144588 lab=_78165_/X }
C {sky130_stdcells/and2_4.sym} 145220 -8900 0 0 {name=X_78165_ }
C {devices/lab_pin.sym} 145180 -8770 0 0 {name=p144589 lab=_44533_/A }
C {devices/lab_pin.sym} 145260 -8770 0 1 {name=p144590 lab=_44557_/X }
C {sky130_stdcells/buf_2.sym} 145220 -8770 0 0 {name=X_44557_ }
C {devices/lab_pin.sym} 145180 -8650 0 0 {name=p144591 lab=_63516_/A }
C {devices/lab_pin.sym} 145260 -8650 0 1 {name=p144592 lab=_63391_/X }
C {sky130_stdcells/buf_2.sym} 145220 -8650 0 0 {name=X_63391_ }
C {devices/lab_pin.sym} 145180 -8530 0 0 {name=p144593 lab=_75376_/Y }
C {devices/lab_pin.sym} 145260 -8530 0 1 {name=p144594 lab=_75377_/Y }
C {sky130_stdcells/inv_2.sym} 145220 -8530 0 0 {name=X_75377_ }
C {devices/lab_pin.sym} 145140 -8440 0 0 {name=p144595 lab=_41768_/X }
C {devices/lab_pin.sym} 145140 -8400 0 0 {name=p144596 lab=_41750_/X }
C {devices/lab_pin.sym} 145140 -8360 0 0 {name=p144597 lab=_88153_/Q }
C {devices/lab_pin.sym} 145140 -8320 0 0 {name=p144598 lab=_41751_/X }
C {devices/lab_pin.sym} 145300 -8380 0 1 {name=p144599 lab=_88153_/D }
C {sky130_stdcells/a2bb2o_4.sym} 145220 -8380 0 0 {name=X_41769_ }
C {devices/lab_pin.sym} 145140 -8260 0 0 {name=p144600 lab=_79352_/B }
C {devices/lab_pin.sym} 145140 -8220 0 0 {name=p144601 lab=_72445_/X }
C {devices/lab_pin.sym} 145140 -8180 0 0 {name=p144602 lab=_72587_/Y }
C {devices/lab_pin.sym} 145140 -8140 0 0 {name=p144603 lab=_72588_/Y }
C {devices/lab_pin.sym} 145300 -8200 0 1 {name=p144604 lab=_83226_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 145220 -8200 0 0 {name=X_72589_ }
C {devices/lab_pin.sym} 145180 -8050 0 0 {name=p144605 lab=_83248_/CLK }
C {devices/lab_pin.sym} 145260 -8050 0 1 {name=p144606 lab=_84838_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 145220 -8050 0 0 {name=Xclkbuf_opt_6_CLK }
C {devices/lab_pin.sym} 145180 -7930 0 0 {name=p144607 lab=clkbuf_7_55_0_CLK/X }
C {devices/lab_pin.sym} 145260 -7930 0 1 {name=p144608 lab=clkbuf_9_220_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 145220 -7930 0 0 {name=Xclkbuf_8_110_0_CLK }
C {devices/lab_pin.sym} 145160 -7820 0 0 {name=p144609 lab=_65155_/A }
C {devices/lab_pin.sym} 145160 -7780 0 0 {name=p144610 lab=_65130_/B }
C {devices/lab_pin.sym} 145280 -7800 0 1 {name=p144611 lab=_65130_/X }
C {sky130_stdcells/and2_4.sym} 145220 -7800 0 0 {name=X_65130_ }
C {devices/lab_pin.sym} 145160 -7680 0 0 {name=p144612 lab=_77113_/Y }
C {devices/lab_pin.sym} 145160 -7640 0 0 {name=p144613 lab=_77115_/X }
C {devices/lab_pin.sym} 145280 -7660 0 1 {name=p144614 lab=_77126_/A }
C {sky130_stdcells/nand2_4.sym} 145220 -7660 0 0 {name=X_77116_ }
C {devices/lab_pin.sym} 145180 -7530 0 0 {name=p144615 lab=_43507_/Y }
C {devices/lab_pin.sym} 145260 -7530 0 1 {name=p144616 lab=_87386_/D }
C {sky130_stdcells/inv_2.sym} 145220 -7530 0 0 {name=X_43508_ }
C {devices/lab_pin.sym} 145160 -7430 0 0 {name=p144617 lab=_62342_/A }
C {devices/lab_pin.sym} 145160 -7390 0 0 {name=p144618 lab=_62341_/X }
C {devices/lab_pin.sym} 145160 -7350 0 0 {name=p144619 lab=_76993_/B }
C {devices/lab_pin.sym} 145280 -7390 0 1 {name=p144620 lab=_62342_/Y }
C {sky130_stdcells/nor3_4.sym} 145220 -7390 0 0 {name=X_62342_ }
C {devices/lab_pin.sym} 145180 -7250 0 0 {name=p144621 lab=_72704_/A }
C {devices/lab_pin.sym} 145260 -7250 0 1 {name=p144622 lab=_74338_/A }
C {sky130_stdcells/buf_2.sym} 145220 -7250 0 0 {name=X_74328_ }
C {devices/lab_pin.sym} 145140 -7150 0 0 {name=p144623 lab=_47270_/Y }
C {devices/lab_pin.sym} 145140 -7110 0 0 {name=p144624 lab=_47271_/X }
C {devices/lab_pin.sym} 145140 -7070 0 0 {name=p144625 lab=_47275_/X }
C {devices/lab_pin.sym} 145300 -7110 0 1 {name=p144626 lab=_47276_/Y }
C {sky130_stdcells/a21oi_4.sym} 145220 -7110 0 0 {name=X_47276_ }
C {devices/lab_pin.sym} 145160 -6980 0 0 {name=p144627 lab=_82660_/Q }
C {devices/lab_pin.sym} 145160 -6940 0 0 {name=p144628 lab=_78096_/B }
C {devices/lab_pin.sym} 145280 -6960 0 1 {name=p144629 lab=_78096_/Y }
C {sky130_stdcells/xnor2_4.sym} 145220 -6960 0 0 {name=X_78096_ }
C {devices/lab_pin.sym} 145180 -6830 0 0 {name=p144630 lab=clkbuf_9_98_0_CLK/X }
C {devices/lab_pin.sym} 145260 -6830 0 1 {name=p144631 lab=_84660_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 145220 -6830 0 0 {name=Xclkbuf_10_197_0_CLK }
C {devices/lab_pin.sym} 145180 -6710 0 0 {name=p144632 lab=_44488_/A }
C {devices/lab_pin.sym} 145260 -6710 0 1 {name=p144633 lab=_44488_/Y }
C {sky130_stdcells/inv_2.sym} 145220 -6710 0 0 {name=X_44488_ }
C {devices/lab_pin.sym} 145180 -6590 0 0 {name=p144634 lab=_53848_/B }
C {devices/lab_pin.sym} 145260 -6590 0 1 {name=p144635 lab=_49015_/X }
C {sky130_stdcells/buf_2.sym} 145220 -6590 0 0 {name=X_49015_ }
C {devices/lab_pin.sym} 145180 -6470 0 0 {name=p144636 lab=_46227_/A }
C {devices/lab_pin.sym} 145260 -6470 0 1 {name=p144637 lab=_46227_/Y }
C {sky130_stdcells/inv_2.sym} 145220 -6470 0 0 {name=X_46227_ }
C {devices/lab_pin.sym} 145160 -6360 0 0 {name=p144638 lab=_65012_/A }
C {devices/lab_pin.sym} 145160 -6320 0 0 {name=p144639 lab=_65061_/B }
C {devices/lab_pin.sym} 145280 -6340 0 1 {name=p144640 lab=_65061_/X }
C {sky130_stdcells/and2_4.sym} 145220 -6340 0 0 {name=X_65061_ }
C {sky130_stdcells/decap_3.sym} 145220 -6180 0 0 {name=XPHY_390 }
C {devices/lab_pin.sym} 145160 -6040 0 0 {name=p144641 lab=_77047_/A }
C {devices/lab_pin.sym} 145160 -6000 0 0 {name=p144642 lab=_77047_/B }
C {devices/lab_pin.sym} 145280 -6020 0 1 {name=p144643 lab=_77048_/B }
C {sky130_stdcells/nand2_4.sym} 145220 -6020 0 0 {name=X_77047_ }
C {devices/lab_pin.sym} 145180 -5890 0 0 {name=p144644 lab=_43439_/A }
C {devices/lab_pin.sym} 145260 -5890 0 1 {name=p144645 lab=_43439_/Y }
C {sky130_stdcells/inv_2.sym} 145220 -5890 0 0 {name=X_43439_ }
C {devices/lab_pin.sym} 145160 -5790 0 0 {name=p144646 lab=_62632_/A }
C {devices/lab_pin.sym} 145160 -5750 0 0 {name=p144647 lab=_63410_/B }
C {devices/lab_pin.sym} 145160 -5710 0 0 {name=p144648 lab=_62319_/C }
C {devices/lab_pin.sym} 145280 -5750 0 1 {name=p144649 lab=_62273_/Y }
C {sky130_stdcells/nand3_4.sym} 145220 -5750 0 0 {name=X_62273_ }
C {devices/lab_pin.sym} 145160 -5620 0 0 {name=p144650 lab=_48141_/A }
C {devices/lab_pin.sym} 145160 -5580 0 0 {name=p144651 lab=_74259_/B }
C {devices/lab_pin.sym} 145280 -5600 0 1 {name=p144652 lab=_74259_/X }
C {sky130_stdcells/xor2_4.sym} 145220 -5600 0 0 {name=X_74259_ }
C {devices/lab_pin.sym} 145180 -5470 0 0 {name=p144653 lab=_64012_/A }
C {devices/lab_pin.sym} 145260 -5470 0 1 {name=p144654 lab=_64091_/C }
C {sky130_stdcells/buf_2.sym} 145220 -5470 0 0 {name=X_64012_ }
C {devices/lab_pin.sym} 145140 -5390 0 0 {name=p144655 lab=_61220_/Y }
C {devices/lab_pin.sym} 145140 -5350 0 0 {name=p144656 lab=_61149_/X }
C {devices/lab_pin.sym} 145140 -5310 0 0 {name=p144657 lab=_61221_/Y }
C {devices/lab_pin.sym} 145140 -5270 0 0 {name=p144658 lab=_61190_/X }
C {devices/lab_pin.sym} 145140 -5240 0 0 {name=p144659 lab=_61223_/Y }
C {devices/lab_pin.sym} 145300 -5310 0 1 {name=p144660 lab=_84504_/D }
C {sky130_stdcells/a41oi_4.sym} 145220 -5310 0 0 {name=X_61224_ }
C {devices/lab_pin.sym} 145160 -5170 0 0 {name=p144661 lab=_46158_/A }
C {devices/lab_pin.sym} 145160 -5130 0 0 {name=p144662 lab=_46158_/B }
C {devices/lab_pin.sym} 145160 -5090 0 0 {name=p144663 lab=_46158_/C }
C {devices/lab_pin.sym} 145280 -5130 0 1 {name=p144664 lab=_46158_/Y }
C {sky130_stdcells/nand3_4.sym} 145220 -5130 0 0 {name=X_46158_ }
C {devices/lab_pin.sym} 145180 -4990 0 0 {name=p144665 lab=clkbuf_7_62_0_CLK/X }
C {devices/lab_pin.sym} 145260 -4990 0 1 {name=p144666 lab=clkbuf_9_251_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 145220 -4990 0 0 {name=Xclkbuf_8_125_0_CLK }
C {devices/lab_pin.sym} 145180 -4870 0 0 {name=p144667 lab=clkbuf_9_60_0_CLK/X }
C {devices/lab_pin.sym} 145260 -4870 0 1 {name=p144668 lab=_84292_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 145220 -4870 0 0 {name=Xclkbuf_10_120_0_CLK }
C {devices/lab_pin.sym} 145140 -4770 0 0 {name=p144669 lab=_45106_/X }
C {devices/lab_pin.sym} 145140 -4730 0 0 {name=p144670 lab=_45108_/Y }
C {devices/lab_pin.sym} 145140 -4690 0 0 {name=p144671 lab=_45049_/X }
C {devices/lab_pin.sym} 145300 -4730 0 1 {name=p144672 lab=_45109_/Y }
C {sky130_stdcells/a21oi_4.sym} 145220 -4730 0 0 {name=X_45109_ }
C {devices/lab_pin.sym} 145160 -4600 0 0 {name=p144673 lab=_68938_/A }
C {devices/lab_pin.sym} 145160 -4560 0 0 {name=p144674 lab=_68820_/B }
C {devices/lab_pin.sym} 145280 -4580 0 1 {name=p144675 lab=_68820_/X }
C {sky130_stdcells/and2_4.sym} 145220 -4580 0 0 {name=X_68820_ }
C {devices/lab_pin.sym} 145180 -4450 0 0 {name=p144676 lab=_61140_/X }
C {devices/lab_pin.sym} 145260 -4450 0 1 {name=p144677 lab=_61271_/A }
C {sky130_stdcells/buf_2.sym} 145220 -4450 0 0 {name=X_61155_ }
C {devices/lab_pin.sym} 145160 -4360 0 0 {name=p144678 lab=_46089_/A }
C {devices/lab_pin.sym} 145160 -4320 0 0 {name=p144679 lab=_46151_/B }
C {devices/lab_pin.sym} 145160 -4280 0 0 {name=p144680 lab=_46089_/C }
C {devices/lab_pin.sym} 145160 -4240 0 0 {name=p144681 lab=_46143_/A }
C {devices/lab_pin.sym} 145280 -4300 0 1 {name=p144682 lab=_46112_/A }
C {sky130_stdcells/nand4_4.sym} 145220 -4300 0 0 {name=X_46089_ }
C {devices/lab_pin.sym} 145180 -4150 0 0 {name=p144683 lab=clkbuf_9_375_0_CLK/X }
C {devices/lab_pin.sym} 145260 -4150 0 1 {name=p144684 lab=_87748_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 145220 -4150 0 0 {name=Xclkbuf_10_750_0_CLK }
C {devices/lab_pin.sym} 145160 -4040 0 0 {name=p144685 lab=_78998_/A }
C {devices/lab_pin.sym} 145160 -4000 0 0 {name=p144686 lab=_78998_/B }
C {devices/lab_pin.sym} 145280 -4020 0 1 {name=p144687 lab=_78998_/Y }
C {sky130_stdcells/nor2_4.sym} 145220 -4020 0 0 {name=X_78998_ }
C {devices/lab_pin.sym} 145180 -3890 0 0 {name=p144688 lab=_60105_/X }
C {devices/lab_pin.sym} 145260 -3890 0 1 {name=p144689 lab=_60125_/A }
C {sky130_stdcells/buf_2.sym} 145220 -3890 0 0 {name=X_60106_ }
C {devices/lab_pin.sym} 145140 -3790 0 0 {name=p144690 lab=_49913_/Y }
C {devices/lab_pin.sym} 145140 -3750 0 0 {name=p144691 lab=_49897_/X }
C {devices/lab_pin.sym} 145140 -3710 0 0 {name=p144692 lab=_49916_/X }
C {devices/lab_pin.sym} 145300 -3750 0 1 {name=p144693 lab=_49917_/Y }
C {sky130_stdcells/a21oi_4.sym} 145220 -3750 0 0 {name=X_49917_ }
C {devices/lab_pin.sym} 145140 -3640 0 0 {name=p144694 lab=_44705_/A }
C {devices/lab_pin.sym} 145140 -3600 0 0 {name=p144695 lab=_68394_/X }
C {devices/lab_pin.sym} 145140 -3560 0 0 {name=p144696 lab=_68421_/X }
C {devices/lab_pin.sym} 145140 -3520 0 0 {name=p144697 lab=_68750_/X }
C {devices/lab_pin.sym} 145300 -3580 0 1 {name=p144698 lab=_68751_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -3580 0 0 {name=X_68751_ }
C {devices/lab_pin.sym} 145180 -3430 0 0 {name=p144699 lab=_58602_/A }
C {devices/lab_pin.sym} 145260 -3430 0 1 {name=p144700 lab=_66391_/A }
C {sky130_stdcells/buf_2.sym} 145220 -3430 0 0 {name=X_65963_ }
C {devices/lab_pin.sym} 145180 -3310 0 0 {name=p144701 lab=_61085_/X }
C {devices/lab_pin.sym} 145260 -3310 0 1 {name=p144702 lab=_61086_/X }
C {sky130_stdcells/buf_2.sym} 145220 -3310 0 0 {name=X_61086_ }
C {devices/lab_pin.sym} 145140 -3210 0 0 {name=p144703 lab=_77945_/Y }
C {devices/lab_pin.sym} 145140 -3170 0 0 {name=p144704 lab=_77933_/B }
C {devices/lab_pin.sym} 145140 -3130 0 0 {name=p144705 lab=_77948_/Y }
C {devices/lab_pin.sym} 145300 -3170 0 1 {name=p144706 lab=_77950_/B }
C {sky130_stdcells/o21ai_4.sym} 145220 -3170 0 0 {name=X_77949_ }
C {devices/lab_pin.sym} 145180 -3030 0 0 {name=p144707 lab=clkbuf_8_120_0_CLK/X }
C {devices/lab_pin.sym} 145260 -3030 0 1 {name=p144708 lab=clkbuf_9_241_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 145220 -3030 0 0 {name=Xclkbuf_9_241_0_CLK }
C {devices/lab_pin.sym} 145180 -2910 0 0 {name=p144709 lab=_67226_/A }
C {devices/lab_pin.sym} 145260 -2910 0 1 {name=p144710 lab=_67702_/X }
C {sky130_stdcells/buf_2.sym} 145220 -2910 0 0 {name=X_67702_ }
C {devices/lab_pin.sym} 145140 -2810 0 0 {name=p144711 lab=_64912_/Y }
C {devices/lab_pin.sym} 145140 -2770 0 0 {name=p144712 lab=_64814_/X }
C {devices/lab_pin.sym} 145140 -2730 0 0 {name=p144713 lab=_64913_/X }
C {devices/lab_pin.sym} 145300 -2770 0 1 {name=p144714 lab=_84222_/D }
C {sky130_stdcells/a21o_4.sym} 145220 -2770 0 0 {name=X_64914_ }
C {devices/lab_pin.sym} 145180 -2630 0 0 {name=p144715 lab=_72564_/A }
C {devices/lab_pin.sym} 145260 -2630 0 1 {name=p144716 lab=_72604_/B }
C {sky130_stdcells/buf_2.sym} 145220 -2630 0 0 {name=X_60037_ }
C {devices/lab_pin.sym} 145160 -2520 0 0 {name=p144717 lab=_49827_/X }
C {devices/lab_pin.sym} 145160 -2480 0 0 {name=p144718 lab=_53060_/B }
C {devices/lab_pin.sym} 145280 -2500 0 1 {name=p144719 lab=_49848_/Y }
C {sky130_stdcells/nand2_4.sym} 145220 -2500 0 0 {name=X_49848_ }
C {devices/lab_pin.sym} 145140 -2400 0 0 {name=p144720 lab=_87495_/Q }
C {devices/lab_pin.sym} 145140 -2360 0 0 {name=p144721 lab=_68626_/X }
C {devices/lab_pin.sym} 145140 -2320 0 0 {name=p144722 lab=_68601_/X }
C {devices/lab_pin.sym} 145140 -2280 0 0 {name=p144723 lab=_68681_/X }
C {devices/lab_pin.sym} 145300 -2340 0 1 {name=p144724 lab=_68682_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -2340 0 0 {name=X_68682_ }
C {devices/lab_pin.sym} 145130 -2190 0 0 {name=p144725 lab=_81996_/CLK }
C {devices/lab_pin.sym} 145130 -2170 0 0 {name=p144726 lab=_75554_/B }
C {devices/lab_pin.sym} 145310 -2190 0 1 {name=p144727 lab=_80960_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -2180 0 0 {name=X_80960_ }
C {devices/lab_pin.sym} 145140 -2070 0 0 {name=p144728 lab=_65891_/X }
C {devices/lab_pin.sym} 145140 -2030 0 0 {name=p144729 lab=_65893_/X }
C {devices/lab_pin.sym} 145140 -1990 0 0 {name=p144730 lab=_65809_/X }
C {devices/lab_pin.sym} 145300 -2030 0 1 {name=p144731 lab=_65894_/X }
C {sky130_stdcells/a21o_4.sym} 145220 -2030 0 0 {name=X_65894_ }
C {devices/lab_pin.sym} 145180 -1890 0 0 {name=p144732 lab=clkbuf_9_67_0_CLK/X }
C {devices/lab_pin.sym} 145260 -1890 0 1 {name=p144733 lab=_83787_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 145220 -1890 0 0 {name=Xclkbuf_10_135_0_CLK }
C {devices/lab_pin.sym} 145180 -1770 0 0 {name=p144734 lab=_68370_/A }
C {devices/lab_pin.sym} 145260 -1770 0 1 {name=p144735 lab=_67633_/X }
C {sky130_stdcells/buf_2.sym} 145220 -1770 0 0 {name=X_67633_ }
C {devices/lab_pin.sym} 145160 -1660 0 0 {name=p144736 lab=_79619_/A }
C {devices/lab_pin.sym} 145160 -1620 0 0 {name=p144737 lab=_79619_/B }
C {devices/lab_pin.sym} 145280 -1640 0 1 {name=p144738 lab=_79620_/A }
C {sky130_stdcells/and2_4.sym} 145220 -1640 0 0 {name=X_79619_ }
C {devices/lab_pin.sym} 145180 -1510 0 0 {name=p144739 lab=clkbuf_9_382_0_CLK/X }
C {devices/lab_pin.sym} 145260 -1510 0 1 {name=p144740 lab=_88056_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 145220 -1510 0 0 {name=Xclkbuf_10_765_0_CLK }
C {devices/lab_pin.sym} 145140 -1420 0 0 {name=p144741 lab=_64666_/X }
C {devices/lab_pin.sym} 145140 -1380 0 0 {name=p144742 lab=_86168_/Q }
C {devices/lab_pin.sym} 145140 -1340 0 0 {name=p144743 lab=_64766_/X }
C {devices/lab_pin.sym} 145140 -1300 0 0 {name=p144744 lab=_64844_/X }
C {devices/lab_pin.sym} 145300 -1360 0 1 {name=p144745 lab=_64845_/X }
C {sky130_stdcells/a211o_4.sym} 145220 -1360 0 0 {name=X_64845_ }
C {devices/lab_pin.sym} 145160 -1240 0 0 {name=p144746 lab=_49779_/A }
C {devices/lab_pin.sym} 145160 -1200 0 0 {name=p144747 lab=_49802_/B }
C {devices/lab_pin.sym} 145160 -1160 0 0 {name=p144748 lab=_49789_/C }
C {devices/lab_pin.sym} 145160 -1120 0 0 {name=p144749 lab=_52993_/D }
C {devices/lab_pin.sym} 145280 -1180 0 1 {name=p144750 lab=_49779_/X }
C {sky130_stdcells/and4_4.sym} 145220 -1180 0 0 {name=X_49779_ }
C {devices/lab_pin.sym} 145130 -1030 0 0 {name=p144751 lab=_80991_/CLK }
C {devices/lab_pin.sym} 145130 -1010 0 0 {name=p144752 lab=_80891_/D }
C {devices/lab_pin.sym} 145310 -1030 0 1 {name=p144753 lab=_80891_/Q }
C {sky130_stdcells/dfxtp_4.sym} 145220 -1020 0 0 {name=X_80891_ }
C {devices/lab_pin.sym} 145160 -920 0 0 {name=p144754 lab=_51805_/A }
C {devices/lab_pin.sym} 145160 -880 0 0 {name=p144755 lab=_51794_/B }
C {devices/lab_pin.sym} 145160 -840 0 0 {name=p144756 lab=_51810_/C }
C {devices/lab_pin.sym} 145160 -800 0 0 {name=p144757 lab=_46728_/X }
C {devices/lab_pin.sym} 145280 -860 0 1 {name=p144758 lab=_51810_/X }
C {sky130_stdcells/and4_4.sym} 145220 -860 0 0 {name=X_51810_ }
C {devices/lab_pin.sym} 145130 -710 0 0 {name=p144759 lab=_82629_/CLK }
C {devices/lab_pin.sym} 145130 -690 0 0 {name=p144760 lab=_83982_/Q }
C {devices/lab_pin.sym} 145310 -710 0 1 {name=p144761 lab=_78840_/A }
C {sky130_stdcells/dfxtp_4.sym} 145220 -700 0 0 {name=X_82630_ }
C {devices/lab_pin.sym} 146060 -42180 0 0 {name=p144762 lab=_87158_/Q }
C {devices/lab_pin.sym} 146060 -42140 0 0 {name=p144763 lab=_67467_/X }
C {devices/lab_pin.sym} 146060 -42100 0 0 {name=p144764 lab=_67516_/X }
C {devices/lab_pin.sym} 146060 -42060 0 0 {name=p144765 lab=_67563_/X }
C {devices/lab_pin.sym} 146220 -42120 0 1 {name=p144766 lab=_67564_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -42120 0 0 {name=X_67564_ }
C {devices/lab_pin.sym} 146100 -41970 0 0 {name=p144767 lab=clkbuf_8_128_0_CLK/X }
C {devices/lab_pin.sym} 146180 -41970 0 1 {name=p144768 lab=clkbuf_9_256_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 146140 -41970 0 0 {name=Xclkbuf_9_256_0_CLK }
C {devices/lab_pin.sym} 146080 -41880 0 0 {name=p144769 lab=_52784_/X }
C {devices/lab_pin.sym} 146080 -41840 0 0 {name=p144770 lab=_52775_/B }
C {devices/lab_pin.sym} 146080 -41800 0 0 {name=p144771 lab=_52789_/X }
C {devices/lab_pin.sym} 146080 -41760 0 0 {name=p144772 lab=_52790_/D }
C {devices/lab_pin.sym} 146200 -41820 0 1 {name=p144773 lab=_52790_/X }
C {sky130_stdcells/and4_4.sym} 146140 -41820 0 0 {name=X_52790_ }
C {devices/lab_pin.sym} 146100 -41670 0 0 {name=p144774 lab=_64776_/A }
C {devices/lab_pin.sym} 146180 -41670 0 1 {name=p144775 lab=_64776_/X }
C {sky130_stdcells/buf_2.sym} 146140 -41670 0 0 {name=X_64776_ }
C {devices/lab_pin.sym} 146060 -41590 0 0 {name=p144776 lab=_61979_/X }
C {devices/lab_pin.sym} 146060 -41550 0 0 {name=p144777 lab=_61982_/X }
C {devices/lab_pin.sym} 146060 -41510 0 0 {name=p144778 lab=_61987_/Y }
C {devices/lab_pin.sym} 146060 -41470 0 0 {name=p144779 lab=_84849_/Q }
C {devices/lab_pin.sym} 146060 -41430 0 0 {name=p144780 lab=_61973_/X }
C {devices/lab_pin.sym} 146220 -41510 0 1 {name=p144781 lab=_61988_/Y }
C {sky130_stdcells/o32ai_4.sym} 146140 -41510 0 0 {name=X_61988_ }
C {devices/lab_pin.sym} 146060 -41380 0 0 {name=p144782 lab=_88039_/Q }
C {devices/lab_pin.sym} 146060 -41340 0 0 {name=p144783 lab=_69162_/X }
C {devices/lab_pin.sym} 146060 -41300 0 0 {name=p144784 lab=_69202_/X }
C {devices/lab_pin.sym} 146060 -41260 0 0 {name=p144785 lab=_69302_/X }
C {devices/lab_pin.sym} 146220 -41320 0 1 {name=p144786 lab=_69303_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -41320 0 0 {name=X_69303_ }
C {devices/lab_pin.sym} 146060 -41190 0 0 {name=p144787 lab=_66512_/Y }
C {devices/lab_pin.sym} 146060 -41150 0 0 {name=p144788 lab=_59756_/X }
C {devices/lab_pin.sym} 146060 -41110 0 0 {name=p144789 lab=_66514_/Y }
C {devices/lab_pin.sym} 146220 -41150 0 1 {name=p144790 lab=_84108_/D }
C {sky130_stdcells/a21o_4.sym} 146140 -41150 0 0 {name=X_66515_ }
C {devices/lab_pin.sym} 146100 -41010 0 0 {name=p144791 lab=_54317_/A }
C {devices/lab_pin.sym} 146180 -41010 0 1 {name=p144792 lab=_54286_/C }
C {sky130_stdcells/buf_2.sym} 146140 -41010 0 0 {name=X_51741_ }
C {devices/lab_pin.sym} 146100 -40890 0 0 {name=p144793 lab=_60879_/D }
C {devices/lab_pin.sym} 146180 -40890 0 1 {name=p144794 lab=_64012_/A }
C {sky130_stdcells/buf_2.sym} 146140 -40890 0 0 {name=X_63727_ }
C {devices/lab_pin.sym} 146050 -40770 0 0 {name=p144795 lab=_82558_/CLK }
C {devices/lab_pin.sym} 146050 -40750 0 0 {name=p144796 lab=_83881_/Q }
C {devices/lab_pin.sym} 146230 -40770 0 1 {name=p144797 lab=_82561_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -40760 0 0 {name=X_82561_ }
C {devices/lab_pin.sym} 146100 -40630 0 0 {name=p144798 lab=_64180_/C }
C {devices/lab_pin.sym} 146180 -40630 0 1 {name=p144799 lab=_60957_/B }
C {sky130_stdcells/inv_2.sym} 146140 -40630 0 0 {name=X_60939_ }
C {devices/lab_pin.sym} 146100 -40510 0 0 {name=p144800 lab=_60109_/A }
C {devices/lab_pin.sym} 146180 -40510 0 1 {name=p144801 lab=_67495_/X }
C {sky130_stdcells/buf_2.sym} 146140 -40510 0 0 {name=X_67495_ }
C {devices/lab_pin.sym} 146050 -40390 0 0 {name=p144802 lab=_84299_/CLK }
C {devices/lab_pin.sym} 146050 -40370 0 0 {name=p144803 lab=_63702_/Y }
C {devices/lab_pin.sym} 146230 -40390 0 1 {name=p144804 lab=_80293_/A }
C {sky130_stdcells/dfxtp_4.sym} 146140 -40380 0 0 {name=X_84300_ }
C {devices/lab_pin.sym} 146050 -40250 0 0 {name=p144805 lab=_84020_/CLK }
C {devices/lab_pin.sym} 146050 -40230 0 0 {name=p144806 lab=_81512_/D }
C {devices/lab_pin.sym} 146230 -40250 0 1 {name=p144807 lab=_81512_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -40240 0 0 {name=X_81512_ }
C {sky130_stdcells/decap_3.sym} 146140 -40080 0 0 {name=XPHY_16 }
C {devices/lab_pin.sym} 146080 -39940 0 0 {name=p144808 lab=_69234_/A }
C {devices/lab_pin.sym} 146080 -39900 0 0 {name=p144809 lab=_87788_/Q }
C {devices/lab_pin.sym} 146200 -39920 0 1 {name=p144810 lab=_69234_/X }
C {sky130_stdcells/and2_4.sym} 146140 -39920 0 0 {name=X_69234_ }
C {devices/lab_pin.sym} 146080 -39800 0 0 {name=p144811 lab=_54478_/A }
C {devices/lab_pin.sym} 146080 -39760 0 0 {name=p144812 lab=_54460_/B }
C {devices/lab_pin.sym} 146200 -39780 0 1 {name=p144813 lab=_54460_/Y }
C {sky130_stdcells/nand2_4.sym} 146140 -39780 0 0 {name=X_54460_ }
C {devices/lab_pin.sym} 146060 -39670 0 0 {name=p144814 lab=_66442_/Y }
C {devices/lab_pin.sym} 146060 -39630 0 0 {name=p144815 lab=_66414_/X }
C {devices/lab_pin.sym} 146060 -39590 0 0 {name=p144816 lab=_66445_/Y }
C {devices/lab_pin.sym} 146220 -39630 0 1 {name=p144817 lab=_66446_/X }
C {sky130_stdcells/a21o_4.sym} 146140 -39630 0 0 {name=X_66446_ }
C {devices/lab_pin.sym} 146050 -39490 0 0 {name=p144818 lab=_85184_/CLK }
C {devices/lab_pin.sym} 146050 -39470 0 0 {name=p144819 lab=_56197_/Y }
C {devices/lab_pin.sym} 146230 -39490 0 1 {name=p144820 lab=_56196_/C }
C {sky130_stdcells/dfxtp_4.sym} 146140 -39480 0 0 {name=X_85280_ }
C {devices/lab_pin.sym} 146060 -39370 0 0 {name=p144821 lab=_85967_/Q }
C {devices/lab_pin.sym} 146060 -39330 0 0 {name=p144822 lab=_51647_/X }
C {devices/lab_pin.sym} 146060 -39290 0 0 {name=p144823 lab=_51671_/Y }
C {devices/lab_pin.sym} 146220 -39330 0 1 {name=p144824 lab=_51672_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -39330 0 0 {name=X_51672_ }
C {sky130_stdcells/decap_3.sym} 146140 -39160 0 0 {name=XPHY_27 }
C {devices/lab_pin.sym} 146100 -39010 0 0 {name=p144825 lab=_63375_/A }
C {devices/lab_pin.sym} 146180 -39010 0 1 {name=p144826 lab=_63697_/A }
C {sky130_stdcells/buf_2.sym} 146140 -39010 0 0 {name=X_63658_ }
C {devices/lab_pin.sym} 146050 -38890 0 0 {name=p144827 lab=_82491_/CLK }
C {devices/lab_pin.sym} 146050 -38870 0 0 {name=p144828 lab=_82492_/D }
C {devices/lab_pin.sym} 146230 -38890 0 1 {name=p144829 lab=_82492_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -38880 0 0 {name=X_82492_ }
C {sky130_stdcells/decap_3.sym} 146140 -38720 0 0 {name=XPHY_38 }
C {sky130_stdcells/decap_3.sym} 146140 -38540 0 0 {name=XPHY_49 }
C {devices/lab_pin.sym} 146060 -38410 0 0 {name=p144830 lab=_53407_/Y }
C {devices/lab_pin.sym} 146060 -38370 0 0 {name=p144831 lab=_53408_/X }
C {devices/lab_pin.sym} 146060 -38330 0 0 {name=p144832 lab=_53410_/X }
C {devices/lab_pin.sym} 146220 -38370 0 1 {name=p144833 lab=_53411_/Y }
C {sky130_stdcells/a21oi_4.sym} 146140 -38370 0 0 {name=X_53411_ }
C {devices/lab_pin.sym} 146050 -38230 0 0 {name=p144834 lab=_84231_/CLK }
C {devices/lab_pin.sym} 146050 -38210 0 0 {name=p144835 lab=_84231_/D }
C {devices/lab_pin.sym} 146230 -38230 0 1 {name=p144836 lab=_64663_/C }
C {sky130_stdcells/dfxtp_4.sym} 146140 -38220 0 0 {name=X_84231_ }
C {devices/lab_pin.sym} 146060 -38110 0 0 {name=p144837 lab=_86165_/Q }
C {devices/lab_pin.sym} 146060 -38070 0 0 {name=p144838 lab=_50594_/X }
C {devices/lab_pin.sym} 146060 -38030 0 0 {name=p144839 lab=_50622_/Y }
C {devices/lab_pin.sym} 146220 -38070 0 1 {name=p144840 lab=_50623_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -38070 0 0 {name=X_50623_ }
C {devices/lab_pin.sym} 146080 -37960 0 0 {name=p144841 lab=_62288_/X }
C {devices/lab_pin.sym} 146080 -37920 0 0 {name=p144842 lab=_62285_/X }
C {devices/lab_pin.sym} 146080 -37880 0 0 {name=p144843 lab=_64535_/B }
C {devices/lab_pin.sym} 146080 -37840 0 0 {name=p144844 lab=_62609_/D }
C {devices/lab_pin.sym} 146200 -37900 0 1 {name=p144845 lab=_62609_/X }
C {sky130_stdcells/and4_4.sym} 146140 -37900 0 0 {name=X_62609_ }
C {devices/lab_pin.sym} 146050 -37750 0 0 {name=p144846 lab=_84079_/CLK }
C {devices/lab_pin.sym} 146050 -37730 0 0 {name=p144847 lab=_81443_/D }
C {devices/lab_pin.sym} 146230 -37750 0 1 {name=p144848 lab=_81443_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -37740 0 0 {name=X_81443_ }
C {devices/lab_pin.sym} 146080 -37620 0 0 {name=p144849 lab=_69755_/A }
C {devices/lab_pin.sym} 146080 -37580 0 0 {name=p144850 lab=_69165_/B }
C {devices/lab_pin.sym} 146200 -37600 0 1 {name=p144851 lab=_69165_/X }
C {sky130_stdcells/and2_4.sym} 146140 -37600 0 0 {name=X_69165_ }
C {devices/lab_pin.sym} 146060 -37490 0 0 {name=p144852 lab=_54389_/Y }
C {devices/lab_pin.sym} 146060 -37450 0 0 {name=p144853 lab=_54366_/X }
C {devices/lab_pin.sym} 146060 -37410 0 0 {name=p144854 lab=_54390_/X }
C {devices/lab_pin.sym} 146220 -37450 0 1 {name=p144855 lab=_85451_/D }
C {sky130_stdcells/a21oi_4.sym} 146140 -37450 0 0 {name=X_54391_ }
C {devices/lab_pin.sym} 146100 -37310 0 0 {name=p144856 lab=_66377_/A }
C {devices/lab_pin.sym} 146180 -37310 0 1 {name=p144857 lab=_66377_/X }
C {sky130_stdcells/buf_2.sym} 146140 -37310 0 0 {name=X_66377_ }
C {devices/lab_pin.sym} 146060 -37230 0 0 {name=p144858 lab=_63556_/X }
C {devices/lab_pin.sym} 146060 -37190 0 0 {name=p144859 lab=_63582_/X }
C {devices/lab_pin.sym} 146060 -37150 0 0 {name=p144860 lab=_63583_/X }
C {devices/lab_pin.sym} 146060 -37110 0 0 {name=p144861 lab=_63587_/X }
C {devices/lab_pin.sym} 146060 -37070 0 0 {name=p144862 lab=_63588_/Y }
C {devices/lab_pin.sym} 146220 -37150 0 1 {name=p144863 lab=_63589_/Y }
C {sky130_stdcells/o41ai_4.sym} 146140 -37150 0 0 {name=X_63589_ }
C {devices/lab_pin.sym} 146100 -36990 0 0 {name=p144864 lab=_56130_/A }
C {devices/lab_pin.sym} 146180 -36990 0 1 {name=p144865 lab=_56130_/X }
C {sky130_stdcells/buf_2.sym} 146140 -36990 0 0 {name=X_56130_ }
C {devices/lab_pin.sym} 146060 -36890 0 0 {name=p144866 lab=_84035_/Q }
C {devices/lab_pin.sym} 146060 -36850 0 0 {name=p144867 lab=_68101_/X }
C {devices/lab_pin.sym} 146060 -36810 0 0 {name=p144868 lab=_68115_/X }
C {devices/lab_pin.sym} 146220 -36850 0 1 {name=p144869 lab=_68116_/X }
C {sky130_stdcells/a21bo_4.sym} 146140 -36850 0 0 {name=X_68116_ }
C {devices/lab_pin.sym} 146060 -36730 0 0 {name=p144870 lab=_85651_/Q }
C {devices/lab_pin.sym} 146060 -36690 0 0 {name=p144871 lab=_53324_/X }
C {devices/lab_pin.sym} 146060 -36650 0 0 {name=p144872 lab=_53341_/Y }
C {devices/lab_pin.sym} 146220 -36690 0 1 {name=p144873 lab=_53342_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -36690 0 0 {name=X_53342_ }
C {devices/lab_pin.sym} 146060 -36580 0 0 {name=p144874 lab=_65272_/X }
C {devices/lab_pin.sym} 146060 -36540 0 0 {name=p144875 lab=_85541_/Q }
C {devices/lab_pin.sym} 146060 -36500 0 0 {name=p144876 lab=_65326_/X }
C {devices/lab_pin.sym} 146060 -36460 0 0 {name=p144877 lab=_65327_/X }
C {devices/lab_pin.sym} 146220 -36520 0 1 {name=p144878 lab=_65328_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -36520 0 0 {name=X_65328_ }
C {devices/lab_pin.sym} 146050 -36370 0 0 {name=p144879 lab=_84161_/CLK }
C {devices/lab_pin.sym} 146050 -36350 0 0 {name=p144880 lab=_84162_/D }
C {devices/lab_pin.sym} 146230 -36370 0 1 {name=p144881 lab=_84162_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -36360 0 0 {name=X_84162_ }
C {devices/lab_pin.sym} 146080 -36240 0 0 {name=p144882 lab=_50575_/A }
C {devices/lab_pin.sym} 146080 -36200 0 0 {name=p144883 lab=_48872_/B }
C {devices/lab_pin.sym} 146200 -36220 0 1 {name=p144884 lab=_50554_/Y }
C {sky130_stdcells/nand2_4.sym} 146140 -36220 0 0 {name=X_50554_ }
C {devices/lab_pin.sym} 146100 -36090 0 0 {name=p144885 lab=clkbuf_9_351_0_CLK/X }
C {devices/lab_pin.sym} 146180 -36090 0 1 {name=p144886 lab=_87950_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 146140 -36090 0 0 {name=Xclkbuf_10_703_0_CLK }
C {devices/lab_pin.sym} 146050 -35970 0 0 {name=p144887 lab=_83926_/CLK }
C {devices/lab_pin.sym} 146050 -35950 0 0 {name=p144888 lab=_76934_/Y }
C {devices/lab_pin.sym} 146230 -35970 0 1 {name=p144889 lab=_81374_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -35960 0 0 {name=X_81374_ }
C {devices/lab_pin.sym} 146080 -35840 0 0 {name=p144890 lab=_69134_/A }
C {devices/lab_pin.sym} 146080 -35800 0 0 {name=p144891 lab=_87733_/Q }
C {devices/lab_pin.sym} 146200 -35820 0 1 {name=p144892 lab=_69096_/X }
C {sky130_stdcells/and2_4.sym} 146140 -35820 0 0 {name=X_69096_ }
C {devices/lab_pin.sym} 146050 -35690 0 0 {name=p144893 lab=_83846_/CLK }
C {devices/lab_pin.sym} 146050 -35670 0 0 {name=p144894 lab=_74285_/X }
C {devices/lab_pin.sym} 146230 -35690 0 1 {name=p144895 lab=_70267_/C }
C {sky130_stdcells/dfxtp_4.sym} 146140 -35680 0 0 {name=X_83113_ }
C {devices/lab_pin.sym} 146080 -35570 0 0 {name=p144896 lab=_56052_/A }
C {devices/lab_pin.sym} 146080 -35530 0 0 {name=p144897 lab=_56052_/B }
C {devices/lab_pin.sym} 146080 -35490 0 0 {name=p144898 lab=_55900_/B }
C {devices/lab_pin.sym} 146200 -35530 0 1 {name=p144899 lab=_56061_/Y }
C {sky130_stdcells/nand3_4.sym} 146140 -35530 0 0 {name=X_56061_ }
C {devices/lab_pin.sym} 146080 -35400 0 0 {name=p144900 lab=_84750_/Q }
C {devices/lab_pin.sym} 146080 -35360 0 0 {name=p144901 lab=_84142_/Q }
C {devices/lab_pin.sym} 146200 -35380 0 1 {name=p144902 lab=_80325_/X }
C {sky130_stdcells/or2_4.sym} 146140 -35380 0 0 {name=X_80325_ }
C {devices/lab_pin.sym} 146080 -35260 0 0 {name=p144903 lab=_68025_/A }
C {devices/lab_pin.sym} 146080 -35220 0 0 {name=p144904 lab=_68047_/B }
C {devices/lab_pin.sym} 146200 -35240 0 1 {name=p144905 lab=_68047_/X }
C {sky130_stdcells/and2_4.sym} 146140 -35240 0 0 {name=X_68047_ }
C {devices/lab_pin.sym} 146100 -35110 0 0 {name=p144906 lab=_53302_/A }
C {devices/lab_pin.sym} 146180 -35110 0 1 {name=p144907 lab=_53293_/C }
C {sky130_stdcells/buf_2.sym} 146140 -35110 0 0 {name=X_53273_ }
C {devices/lab_pin.sym} 146060 -35020 0 0 {name=p144908 lab=_65172_/X }
C {devices/lab_pin.sym} 146060 -34980 0 0 {name=p144909 lab=_86120_/Q }
C {devices/lab_pin.sym} 146060 -34940 0 0 {name=p144910 lab=_65256_/X }
C {devices/lab_pin.sym} 146060 -34900 0 0 {name=p144911 lab=_65258_/X }
C {devices/lab_pin.sym} 146220 -34960 0 1 {name=p144912 lab=_65259_/X }
C {sky130_stdcells/a211o_4.sym} 146140 -34960 0 0 {name=X_65259_ }
C {devices/lab_pin.sym} 146050 -34810 0 0 {name=p144913 lab=_81507_/CLK }
C {devices/lab_pin.sym} 146050 -34790 0 0 {name=p144914 lab=_84093_/D }
C {devices/lab_pin.sym} 146230 -34810 0 1 {name=p144915 lab=_80917_/D }
C {sky130_stdcells/dfxtp_4.sym} 146140 -34800 0 0 {name=X_84093_ }
C {devices/lab_pin.sym} 146080 -34680 0 0 {name=p144916 lab=_50465_/X }
C {devices/lab_pin.sym} 146080 -34640 0 0 {name=p144917 lab=_48561_/B }
C {devices/lab_pin.sym} 146200 -34660 0 1 {name=p144918 lab=_50485_/Y }
C {sky130_stdcells/nand2_4.sym} 146140 -34660 0 0 {name=X_50485_ }
C {devices/lab_pin.sym} 146060 -34550 0 0 {name=p144919 lab=_85335_/Q }
C {devices/lab_pin.sym} 146060 -34510 0 0 {name=p144920 lab=_54994_/X }
C {devices/lab_pin.sym} 146060 -34470 0 0 {name=p144921 lab=_55011_/Y }
C {devices/lab_pin.sym} 146220 -34510 0 1 {name=p144922 lab=_55012_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -34510 0 0 {name=X_55012_ }
C {devices/lab_pin.sym} 146060 -34390 0 0 {name=p144923 lab=_52221_/Y }
C {devices/lab_pin.sym} 146060 -34350 0 0 {name=p144924 lab=_52203_/X }
C {devices/lab_pin.sym} 146060 -34310 0 0 {name=p144925 lab=_52223_/X }
C {devices/lab_pin.sym} 146220 -34350 0 1 {name=p144926 lab=_85865_/D }
C {sky130_stdcells/a21oi_4.sym} 146140 -34350 0 0 {name=X_52224_ }
C {devices/lab_pin.sym} 146050 -34210 0 0 {name=p144927 lab=_83046_/CLK }
C {devices/lab_pin.sym} 146050 -34190 0 0 {name=p144928 lab=_74530_/Y }
C {devices/lab_pin.sym} 146230 -34210 0 1 {name=p144929 lab=_83044_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -34200 0 0 {name=X_83044_ }
C {devices/lab_pin.sym} 146050 -34070 0 0 {name=p144930 lab=_87922_/CLK }
C {devices/lab_pin.sym} 146050 -34050 0 0 {name=p144931 lab=_87921_/D }
C {devices/lab_pin.sym} 146230 -34070 0 1 {name=p144932 lab=_87921_/Q }
C {sky130_stdcells/dfxtp_4.sym} 146140 -34060 0 0 {name=X_87921_ }
C {devices/lab_pin.sym} 146080 -33940 0 0 {name=p144933 lab=_80253_/X }
C {devices/lab_pin.sym} 146080 -33900 0 0 {name=p144934 lab=_80256_/B }
C {devices/lab_pin.sym} 146200 -33920 0 1 {name=p144935 lab=_80256_/X }
C {sky130_stdcells/xor2_4.sym} 146140 -33920 0 0 {name=X_80256_ }
C {devices/lab_pin.sym} 146100 -33790 0 0 {name=p144936 lab=clkbuf_9_359_0_CLK/X }
C {devices/lab_pin.sym} 146180 -33790 0 1 {name=p144937 lab=_88006_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 146140 -33790 0 0 {name=Xclkbuf_10_718_0_CLK }
C {devices/lab_pin.sym} 146060 -33690 0 0 {name=p144938 lab=_59743_/B }
C {devices/lab_pin.sym} 146060 -33650 0 0 {name=p144939 lab=_59680_/A }
C {devices/lab_pin.sym} 146060 -33610 0 0 {name=p144940 lab=_72381_/A }
C {devices/lab_pin.sym} 146220 -33650 0 1 {name=p144941 lab=_59820_/Y }
C {sky130_stdcells/o21ai_4.sym} 146140 -33650 0 0 {name=X_59820_ }
C {devices/lab_pin.sym} 146060 -33530 0 0 {name=p144942 lab=_85878_/Q }
C {devices/lab_pin.sym} 146060 -33490 0 0 {name=p144943 lab=_52152_/X }
C {devices/lab_pin.sym} 146060 -33450 0 0 {name=p144944 lab=_52154_/Y }
