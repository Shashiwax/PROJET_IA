C {devices/lab_pin.sym} 149780 -6090 0 0 {name=p149272 lab=_46210_/A }
C {devices/lab_pin.sym} 149860 -6090 0 1 {name=p149273 lab=_68370_/A }
C {sky130_stdcells/buf_2.sym} 149820 -6090 0 0 {name=X_67632_ }
C {devices/lab_pin.sym} 149760 -5990 0 0 {name=p149274 lab=_79616_/Y }
C {devices/lab_pin.sym} 149760 -5950 0 0 {name=p149275 lab=_79603_/Y }
C {devices/lab_pin.sym} 149760 -5910 0 0 {name=p149276 lab=_79609_/A }
C {devices/lab_pin.sym} 149880 -5950 0 1 {name=p149277 lab=_79619_/B }
C {sky130_stdcells/nand3_4.sym} 149820 -5950 0 0 {name=X_79618_ }
C {devices/lab_pin.sym} 149760 -5820 0 0 {name=p149278 lab=_64767_/A }
C {devices/lab_pin.sym} 149760 -5780 0 0 {name=p149279 lab=_64844_/B }
C {devices/lab_pin.sym} 149880 -5800 0 1 {name=p149280 lab=_64844_/X }
C {sky130_stdcells/and2_4.sym} 149820 -5800 0 0 {name=X_64844_ }
C {devices/lab_pin.sym} 149780 -5670 0 0 {name=p149281 lab=_49861_/A }
C {devices/lab_pin.sym} 149860 -5670 0 1 {name=p149282 lab=_49802_/B }
C {sky130_stdcells/buf_2.sym} 149820 -5670 0 0 {name=X_49778_ }
C {devices/lab_pin.sym} 149730 -5550 0 0 {name=p149283 lab=_80740_/CLK }
C {devices/lab_pin.sym} 149730 -5530 0 0 {name=p149284 lab=_80890_/D }
C {devices/lab_pin.sym} 149910 -5550 0 1 {name=p149285 lab=_80890_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -5540 0 0 {name=X_80890_ }
C {devices/lab_pin.sym} 149740 -5430 0 0 {name=p149286 lab=_48726_/Y }
C {devices/lab_pin.sym} 149740 -5390 0 0 {name=p149287 lab=_48156_/X }
C {devices/lab_pin.sym} 149740 -5350 0 0 {name=p149288 lab=_48728_/X }
C {devices/lab_pin.sym} 149900 -5390 0 1 {name=p149289 lab=_86494_/D }
C {sky130_stdcells/a21oi_4.sym} 149820 -5390 0 0 {name=X_48729_ }
C {devices/lab_pin.sym} 149760 -5260 0 0 {name=p149290 lab=_65373_/C }
C {devices/lab_pin.sym} 149760 -5220 0 0 {name=p149291 lab=_79549_/B }
C {devices/lab_pin.sym} 149880 -5240 0 1 {name=p149292 lab=_79549_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -5240 0 0 {name=X_79549_ }
C {devices/lab_pin.sym} 149760 -5120 0 0 {name=p149293 lab=_67539_/X }
C {devices/lab_pin.sym} 149760 -5080 0 0 {name=p149294 lab=_67563_/B }
C {devices/lab_pin.sym} 149880 -5100 0 1 {name=p149295 lab=_67563_/X }
C {sky130_stdcells/and2_4.sym} 149820 -5100 0 0 {name=X_67563_ }
C {devices/lab_pin.sym} 149760 -4980 0 0 {name=p149296 lab=_64775_/A }
C {devices/lab_pin.sym} 149760 -4940 0 0 {name=p149297 lab=_64775_/B }
C {devices/lab_pin.sym} 149880 -4960 0 1 {name=p149298 lab=_64775_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -4960 0 0 {name=X_64775_ }
C {devices/lab_pin.sym} 149760 -4860 0 0 {name=p149299 lab=_61957_/A }
C {devices/lab_pin.sym} 149760 -4820 0 0 {name=p149300 lab=_61983_/Y }
C {devices/lab_pin.sym} 149760 -4780 0 0 {name=p149301 lab=_61984_/Y }
C {devices/lab_pin.sym} 149760 -4740 0 0 {name=p149302 lab=_61986_/Y }
C {devices/lab_pin.sym} 149880 -4800 0 1 {name=p149303 lab=_61987_/Y }
C {sky130_stdcells/nand4_4.sym} 149820 -4800 0 0 {name=X_61987_ }
C {devices/lab_pin.sym} 149760 -4660 0 0 {name=p149304 lab=_69302_/A }
C {devices/lab_pin.sym} 149760 -4620 0 0 {name=p149305 lab=_87783_/Q }
C {devices/lab_pin.sym} 149880 -4640 0 1 {name=p149306 lab=_69302_/X }
C {sky130_stdcells/and2_4.sym} 149820 -4640 0 0 {name=X_69302_ }
C {devices/lab_pin.sym} 149760 -4530 0 0 {name=p149307 lab=_66445_/A }
C {devices/lab_pin.sym} 149760 -4490 0 0 {name=p149308 lab=_66514_/B }
C {devices/lab_pin.sym} 149760 -4450 0 0 {name=p149309 lab=_66514_/C }
C {devices/lab_pin.sym} 149880 -4490 0 1 {name=p149310 lab=_66514_/Y }
C {sky130_stdcells/nor3_4.sym} 149820 -4490 0 0 {name=X_66514_ }
C {devices/lab_pin.sym} 149780 -4350 0 0 {name=p149311 lab=clkbuf_6_50_0_CLK/X }
C {devices/lab_pin.sym} 149860 -4350 0 1 {name=p149312 lab=clkbuf_8_203_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 149820 -4350 0 0 {name=Xclkbuf_7_101_0_CLK }
C {devices/lab_pin.sym} 149780 -4230 0 0 {name=p149313 lab=_54400_/A }
C {devices/lab_pin.sym} 149860 -4230 0 1 {name=p149314 lab=_54317_/A }
C {sky130_stdcells/buf_2.sym} 149820 -4230 0 0 {name=X_51740_ }
C {devices/lab_pin.sym} 149760 -4140 0 0 {name=p149315 lab=_61301_/X }
C {devices/lab_pin.sym} 149760 -4100 0 0 {name=p149316 lab=_64192_/B }
C {devices/lab_pin.sym} 149760 -4060 0 0 {name=p149317 lab=_64192_/C }
C {devices/lab_pin.sym} 149760 -4020 0 0 {name=p149318 lab=_64189_/D }
C {devices/lab_pin.sym} 149880 -4080 0 1 {name=p149319 lab=_63726_/Y }
C {sky130_stdcells/nand4_4.sym} 149820 -4080 0 0 {name=X_63726_ }
C {devices/lab_pin.sym} 149730 -3930 0 0 {name=p149320 lab=_86988_/CLK }
C {devices/lab_pin.sym} 149730 -3910 0 0 {name=p149321 lab=_82560_/D }
C {devices/lab_pin.sym} 149910 -3930 0 1 {name=p149322 lab=_82560_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -3920 0 0 {name=X_82560_ }
C {devices/lab_pin.sym} 149780 -3790 0 0 {name=p149323 lab=_60938_/A }
C {devices/lab_pin.sym} 149860 -3790 0 1 {name=p149324 lab=_60938_/Y }
C {sky130_stdcells/inv_2.sym} 149820 -3790 0 0 {name=X_60938_ }
C {devices/lab_pin.sym} 149740 -3690 0 0 {name=p149325 lab=_81499_/D }
C {devices/lab_pin.sym} 149740 -3650 0 0 {name=p149326 lab=_67449_/X }
C {devices/lab_pin.sym} 149740 -3610 0 0 {name=p149327 lab=_67493_/X }
C {devices/lab_pin.sym} 149900 -3650 0 1 {name=p149328 lab=_84067_/D }
C {sky130_stdcells/a21bo_4.sym} 149820 -3650 0 0 {name=X_67494_ }
C {devices/lab_pin.sym} 149730 -3510 0 0 {name=p149329 lab=_84020_/CLK }
C {devices/lab_pin.sym} 149730 -3490 0 0 {name=p149330 lab=_81511_/D }
C {devices/lab_pin.sym} 149910 -3510 0 1 {name=p149331 lab=_81511_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -3500 0 0 {name=X_81511_ }
C {devices/lab_pin.sym} 149780 -3370 0 0 {name=p149332 lab=_69233_/A }
C {devices/lab_pin.sym} 149860 -3370 0 1 {name=p149333 lab=_69234_/A }
C {sky130_stdcells/buf_2.sym} 149820 -3370 0 0 {name=X_69233_ }
C {devices/lab_pin.sym} 149760 -3270 0 0 {name=p149334 lab=_66445_/A }
C {devices/lab_pin.sym} 149760 -3230 0 0 {name=p149335 lab=_66402_/B }
C {devices/lab_pin.sym} 149760 -3190 0 0 {name=p149336 lab=_66445_/C }
C {devices/lab_pin.sym} 149880 -3230 0 1 {name=p149337 lab=_66445_/Y }
C {sky130_stdcells/nor3_4.sym} 149820 -3230 0 0 {name=X_66445_ }
C {sky130_stdcells/decap_3.sym} 149820 -3060 0 0 {name=XPHY_17 }
C {devices/lab_pin.sym} 149760 -2920 0 0 {name=p149338 lab=_51671_/A }
C {devices/lab_pin.sym} 149760 -2880 0 0 {name=p149339 lab=_53193_/B }
C {devices/lab_pin.sym} 149880 -2900 0 1 {name=p149340 lab=_51671_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -2900 0 0 {name=X_51671_ }
C {devices/lab_pin.sym} 149780 -2770 0 0 {name=p149341 lab=clkbuf_9_35_0_CLK/X }
C {devices/lab_pin.sym} 149860 -2770 0 1 {name=p149342 lab=_80664_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 149820 -2770 0 0 {name=Xclkbuf_10_71_0_CLK }
C {devices/lab_pin.sym} 149760 -2660 0 0 {name=p149343 lab=_63657_/A }
C {devices/lab_pin.sym} 149760 -2620 0 0 {name=p149344 lab=_62113_/X }
C {devices/lab_pin.sym} 149880 -2640 0 1 {name=p149345 lab=_63657_/X }
C {sky130_stdcells/and2_4.sym} 149820 -2640 0 0 {name=X_63657_ }
C {devices/lab_pin.sym} 149730 -2510 0 0 {name=p149346 lab=_82491_/CLK }
C {devices/lab_pin.sym} 149730 -2490 0 0 {name=p149347 lab=_82491_/D }
C {devices/lab_pin.sym} 149910 -2510 0 1 {name=p149348 lab=_82491_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -2500 0 0 {name=X_82491_ }
C {sky130_stdcells/decap_3.sym} 149820 -2340 0 0 {name=XPHY_28 }
C {devices/lab_pin.sym} 149780 -2190 0 0 {name=p149349 lab=_60930_/A }
C {devices/lab_pin.sym} 149860 -2190 0 1 {name=p149350 lab=_64191_/B }
C {sky130_stdcells/buf_2.sym} 149820 -2190 0 0 {name=X_60869_ }
C {sky130_stdcells/decap_3.sym} 149820 -2040 0 0 {name=XPHY_39 }
C {devices/lab_pin.sym} 149760 -1920 0 0 {name=p149351 lab=_53397_/A }
C {devices/lab_pin.sym} 149760 -1880 0 0 {name=p149352 lab=_53402_/B }
C {devices/lab_pin.sym} 149760 -1840 0 0 {name=p149353 lab=_53410_/C }
C {devices/lab_pin.sym} 149760 -1800 0 0 {name=p149354 lab=_52895_/D }
C {devices/lab_pin.sym} 149880 -1860 0 1 {name=p149355 lab=_53410_/X }
C {sky130_stdcells/and4_4.sym} 149820 -1860 0 0 {name=X_53410_ }
C {devices/lab_pin.sym} 149730 -1710 0 0 {name=p149356 lab=_84150_/CLK }
C {devices/lab_pin.sym} 149730 -1690 0 0 {name=p149357 lab=_64690_/X }
C {devices/lab_pin.sym} 149910 -1710 0 1 {name=p149358 lab=_84230_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -1700 0 0 {name=X_84230_ }
C {devices/lab_pin.sym} 149760 -1580 0 0 {name=p149359 lab=_50597_/A }
C {devices/lab_pin.sym} 149760 -1540 0 0 {name=p149360 lab=_49006_/X }
C {devices/lab_pin.sym} 149880 -1560 0 1 {name=p149361 lab=_50622_/Y }
C {sky130_stdcells/nand2_4.sym} 149820 -1560 0 0 {name=X_50622_ }
C {devices/lab_pin.sym} 149730 -1430 0 0 {name=p149362 lab=_84079_/CLK }
C {devices/lab_pin.sym} 149730 -1410 0 0 {name=p149363 lab=_76649_/B }
C {devices/lab_pin.sym} 149910 -1430 0 1 {name=p149364 lab=_81442_/Q }
C {sky130_stdcells/dfxtp_4.sym} 149820 -1420 0 0 {name=X_81442_ }
C {devices/lab_pin.sym} 149760 -1320 0 0 {name=p149365 lab=_62269_/X }
C {devices/lab_pin.sym} 149760 -1280 0 0 {name=p149366 lab=_58207_/A }
C {devices/lab_pin.sym} 149760 -1240 0 0 {name=p149367 lab=_62618_/C }
C {devices/lab_pin.sym} 149760 -1200 0 0 {name=p149368 lab=_62608_/D }
C {devices/lab_pin.sym} 149880 -1260 0 1 {name=p149369 lab=_62608_/X }
C {sky130_stdcells/and4_4.sym} 149820 -1260 0 0 {name=X_62608_ }
C {devices/lab_pin.sym} 149740 -1140 0 0 {name=p149370 lab=_88049_/Q }
C {devices/lab_pin.sym} 149740 -1100 0 0 {name=p149371 lab=_69162_/X }
C {devices/lab_pin.sym} 149740 -1060 0 0 {name=p149372 lab=_68884_/X }
C {devices/lab_pin.sym} 149740 -1020 0 0 {name=p149373 lab=_69163_/X }
C {devices/lab_pin.sym} 149900 -1080 0 1 {name=p149374 lab=_69164_/X }
C {sky130_stdcells/a211o_4.sym} 149820 -1080 0 0 {name=X_69164_ }
C {devices/lab_pin.sym} 149760 -960 0 0 {name=p149375 lab=_54395_/A }
C {devices/lab_pin.sym} 149760 -920 0 0 {name=p149376 lab=_54395_/B }
C {devices/lab_pin.sym} 149760 -880 0 0 {name=p149377 lab=_54395_/C }
C {devices/lab_pin.sym} 149760 -840 0 0 {name=p149378 lab=_46828_/Y }
C {devices/lab_pin.sym} 149880 -900 0 1 {name=p149379 lab=_54390_/X }
C {sky130_stdcells/and4_4.sym} 149820 -900 0 0 {name=X_54390_ }
C {devices/lab_pin.sym} 149740 -770 0 0 {name=p149380 lab=_66366_/X }
C {devices/lab_pin.sym} 149740 -730 0 0 {name=p149381 lab=_64675_/Y }
C {devices/lab_pin.sym} 149740 -690 0 0 {name=p149382 lab=_66375_/Y }
C {devices/lab_pin.sym} 149900 -730 0 1 {name=p149383 lab=_66376_/Y }
C {sky130_stdcells/o21ai_4.sym} 149820 -730 0 0 {name=X_66376_ }
C {devices/lab_pin.sym} 150680 -42180 0 0 {name=p149384 lab=_58442_/A }
C {devices/lab_pin.sym} 150680 -42140 0 0 {name=p149385 lab=_63541_/B }
C {devices/lab_pin.sym} 150680 -42100 0 0 {name=p149386 lab=_63575_/C }
C {devices/lab_pin.sym} 150680 -42060 0 0 {name=p149387 lab=_63541_/D }
C {devices/lab_pin.sym} 150800 -42120 0 1 {name=p149388 lab=_63588_/Y }
C {sky130_stdcells/nand4_4.sym} 150740 -42120 0 0 {name=X_63588_ }
C {devices/lab_pin.sym} 150700 -41970 0 0 {name=p149389 lab=clkbuf_6_58_0_CLK/X }
C {devices/lab_pin.sym} 150780 -41970 0 1 {name=p149390 lab=clkbuf_8_233_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 150740 -41970 0 0 {name=Xclkbuf_7_116_0_CLK }
C {devices/lab_pin.sym} 150660 -41880 0 0 {name=p149391 lab=_68088_/X }
C {devices/lab_pin.sym} 150660 -41840 0 0 {name=p149392 lab=_66720_/Y }
C {devices/lab_pin.sym} 150660 -41800 0 0 {name=p149393 lab=_68110_/X }
C {devices/lab_pin.sym} 150660 -41760 0 0 {name=p149394 lab=_68114_/Y }
C {devices/lab_pin.sym} 150820 -41820 0 1 {name=p149395 lab=_68115_/X }
C {sky130_stdcells/a211o_4.sym} 150740 -41820 0 0 {name=X_68115_ }
C {devices/lab_pin.sym} 150680 -41680 0 0 {name=p149396 lab=_53332_/A }
C {devices/lab_pin.sym} 150680 -41640 0 0 {name=p149397 lab=_47053_/A }
C {devices/lab_pin.sym} 150800 -41660 0 1 {name=p149398 lab=_53341_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -41660 0 0 {name=X_53341_ }
C {devices/lab_pin.sym} 150680 -41540 0 0 {name=p149399 lab=_65403_/A }
C {devices/lab_pin.sym} 150680 -41500 0 0 {name=p149400 lab=_65327_/B }
C {devices/lab_pin.sym} 150800 -41520 0 1 {name=p149401 lab=_65327_/X }
C {sky130_stdcells/and2_4.sym} 150740 -41520 0 0 {name=X_65327_ }
C {devices/lab_pin.sym} 150650 -41390 0 0 {name=p149402 lab=_84161_/CLK }
C {devices/lab_pin.sym} 150650 -41370 0 0 {name=p149403 lab=_84161_/D }
C {devices/lab_pin.sym} 150830 -41390 0 1 {name=p149404 lab=_84161_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -41380 0 0 {name=X_84161_ }
C {devices/lab_pin.sym} 150660 -41270 0 0 {name=p149405 lab=_50550_/Y }
C {devices/lab_pin.sym} 150660 -41230 0 0 {name=p149406 lab=_50551_/X }
C {devices/lab_pin.sym} 150660 -41190 0 0 {name=p149407 lab=_50552_/X }
C {devices/lab_pin.sym} 150820 -41230 0 1 {name=p149408 lab=_50553_/Y }
C {sky130_stdcells/a21oi_4.sym} 150740 -41230 0 0 {name=X_50553_ }
C {devices/lab_pin.sym} 150660 -41130 0 0 {name=p149409 lab=_62529_/X }
C {devices/lab_pin.sym} 150660 -41090 0 0 {name=p149410 lab=_62536_/Y }
C {devices/lab_pin.sym} 150660 -41050 0 0 {name=p149411 lab=_62538_/X }
C {devices/lab_pin.sym} 150660 -41010 0 0 {name=p149412 lab=_84843_/Q }
C {devices/lab_pin.sym} 150660 -40970 0 0 {name=p149413 lab=_62511_/X }
C {devices/lab_pin.sym} 150820 -41050 0 1 {name=p149414 lab=_62539_/Y }
C {sky130_stdcells/o32ai_4.sym} 150740 -41050 0 0 {name=X_62539_ }
C {devices/lab_pin.sym} 150650 -40890 0 0 {name=p149415 lab=_81265_/CLK }
C {devices/lab_pin.sym} 150650 -40870 0 0 {name=p149416 lab=_81373_/D }
C {devices/lab_pin.sym} 150830 -40890 0 1 {name=p149417 lab=_81373_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -40880 0 0 {name=X_81373_ }
C {devices/lab_pin.sym} 150700 -40750 0 0 {name=p149418 lab=_68649_/A }
C {devices/lab_pin.sym} 150780 -40750 0 1 {name=p149419 lab=_69095_/X }
C {sky130_stdcells/buf_2.sym} 150740 -40750 0 0 {name=X_69095_ }
C {devices/lab_pin.sym} 150650 -40630 0 0 {name=p149420 lab=_83846_/CLK }
C {devices/lab_pin.sym} 150650 -40610 0 0 {name=p149421 lab=_83112_/D }
C {devices/lab_pin.sym} 150830 -40630 0 1 {name=p149422 lab=_83112_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -40620 0 0 {name=X_83112_ }
C {devices/lab_pin.sym} 150700 -40490 0 0 {name=p149423 lab=_80324_/A }
C {devices/lab_pin.sym} 150780 -40490 0 1 {name=p149424 lab=_80324_/Y }
C {sky130_stdcells/inv_2.sym} 150740 -40490 0 0 {name=X_80324_ }
C {devices/lab_pin.sym} 150660 -40390 0 0 {name=p149425 lab=_68043_/X }
C {devices/lab_pin.sym} 150660 -40350 0 0 {name=p149426 lab=_68045_/X }
C {devices/lab_pin.sym} 150660 -40310 0 0 {name=p149427 lab=_67977_/X }
C {devices/lab_pin.sym} 150820 -40350 0 1 {name=p149428 lab=_68049_/A }
C {sky130_stdcells/a21o_4.sym} 150740 -40350 0 0 {name=X_68046_ }
C {devices/lab_pin.sym} 150700 -40210 0 0 {name=p149429 lab=_56059_/Y }
C {devices/lab_pin.sym} 150780 -40210 0 1 {name=p149430 lab=_56060_/X }
C {sky130_stdcells/buf_2.sym} 150740 -40210 0 0 {name=X_56060_ }
C {devices/lab_pin.sym} 150700 -40090 0 0 {name=p149431 lab=clkbuf_9_43_0_CLK/X }
C {devices/lab_pin.sym} 150780 -40090 0 1 {name=p149432 lab=_84892_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 150740 -40090 0 0 {name=Xclkbuf_10_86_0_CLK }
C {devices/lab_pin.sym} 150700 -39970 0 0 {name=p149433 lab=_51823_/A }
C {devices/lab_pin.sym} 150780 -39970 0 1 {name=p149434 lab=_53272_/X }
C {sky130_stdcells/buf_2.sym} 150740 -39970 0 0 {name=X_53272_ }
C {devices/lab_pin.sym} 150680 -39860 0 0 {name=p149435 lab=_65258_/A }
C {devices/lab_pin.sym} 150680 -39820 0 0 {name=p149436 lab=_85800_/Q }
C {devices/lab_pin.sym} 150800 -39840 0 1 {name=p149437 lab=_65258_/X }
C {sky130_stdcells/and2_4.sym} 150740 -39840 0 0 {name=X_65258_ }
C {devices/lab_pin.sym} 150650 -39710 0 0 {name=p149438 lab=_81507_/CLK }
C {devices/lab_pin.sym} 150650 -39690 0 0 {name=p149439 lab=_84092_/D }
C {devices/lab_pin.sym} 150830 -39710 0 1 {name=p149440 lab=_80916_/D }
C {sky130_stdcells/dfxtp_4.sym} 150740 -39700 0 0 {name=X_84092_ }
C {devices/lab_pin.sym} 150660 -39590 0 0 {name=p149441 lab=_50482_/Y }
C {devices/lab_pin.sym} 150660 -39550 0 0 {name=p149442 lab=_50474_/X }
C {devices/lab_pin.sym} 150660 -39510 0 0 {name=p149443 lab=_50483_/Y }
C {devices/lab_pin.sym} 150820 -39550 0 1 {name=p149444 lab=_50484_/Y }
C {sky130_stdcells/a21boi_4.sym} 150740 -39550 0 0 {name=X_50484_ }
C {devices/lab_pin.sym} 150680 -39420 0 0 {name=p149445 lab=_55011_/A }
C {devices/lab_pin.sym} 150680 -39380 0 0 {name=p149446 lab=_47623_/A }
C {devices/lab_pin.sym} 150800 -39400 0 1 {name=p149447 lab=_55011_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -39400 0 0 {name=X_55011_ }
C {devices/lab_pin.sym} 150700 -39270 0 0 {name=p149448 lab=clkbuf_8_233_0_CLK/A }
C {devices/lab_pin.sym} 150780 -39270 0 1 {name=p149449 lab=clkbuf_8_232_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 150740 -39270 0 0 {name=Xclkbuf_8_232_0_CLK }
C {devices/lab_pin.sym} 150680 -39170 0 0 {name=p149450 lab=_48841_/A }
C {devices/lab_pin.sym} 150680 -39130 0 0 {name=p149451 lab=_52198_/X }
C {devices/lab_pin.sym} 150680 -39090 0 0 {name=p149452 lab=_52223_/C }
C {devices/lab_pin.sym} 150800 -39130 0 1 {name=p149453 lab=_52223_/X }
C {sky130_stdcells/and3_4.sym} 150740 -39130 0 0 {name=X_52223_ }
C {devices/lab_pin.sym} 150650 -38990 0 0 {name=p149454 lab=_87473_/CLK }
C {devices/lab_pin.sym} 150650 -38970 0 0 {name=p149455 lab=_87920_/D }
C {devices/lab_pin.sym} 150830 -38990 0 1 {name=p149456 lab=_87920_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -38980 0 0 {name=X_87920_ }
C {devices/lab_pin.sym} 150680 -38870 0 0 {name=p149457 lab=_61117_/X }
C {devices/lab_pin.sym} 150680 -38830 0 0 {name=p149458 lab=_61169_/X }
C {devices/lab_pin.sym} 150680 -38790 0 0 {name=p149459 lab=_59477_/A }
C {devices/lab_pin.sym} 150800 -38830 0 1 {name=p149460 lab=_64209_/Y }
C {sky130_stdcells/nand3_4.sym} 150740 -38830 0 0 {name=X_64209_ }
C {devices/lab_pin.sym} 150650 -38690 0 0 {name=p149461 lab=_85428_/CLK }
C {devices/lab_pin.sym} 150650 -38670 0 0 {name=p149462 lab=_74532_/Y }
C {devices/lab_pin.sym} 150830 -38690 0 1 {name=p149463 lab=_47052_/A }
C {sky130_stdcells/dfxtp_4.sym} 150740 -38680 0 0 {name=X_83043_ }
C {devices/lab_pin.sym} 150660 -38570 0 0 {name=p149464 lab=_80242_/A }
C {devices/lab_pin.sym} 150660 -38530 0 0 {name=p149465 lab=_80241_/X }
C {devices/lab_pin.sym} 150660 -38490 0 0 {name=p149466 lab=_80254_/Y }
C {devices/lab_pin.sym} 150820 -38530 0 1 {name=p149467 lab=_80256_/B }
C {sky130_stdcells/a21boi_4.sym} 150740 -38530 0 0 {name=X_80255_ }
C {devices/lab_pin.sym} 150700 -38390 0 0 {name=p149468 lab=_64602_/A }
C {devices/lab_pin.sym} 150780 -38390 0 1 {name=p149469 lab=_65753_/A }
C {sky130_stdcells/buf_2.sym} 150740 -38390 0 0 {name=X_65189_ }
C {devices/lab_pin.sym} 150680 -38280 0 0 {name=p149470 lab=_52168_/A }
C {devices/lab_pin.sym} 150680 -38240 0 0 {name=p149471 lab=_48482_/B }
C {devices/lab_pin.sym} 150800 -38260 0 1 {name=p149472 lab=_52154_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -38260 0 0 {name=X_52154_ }
C {devices/lab_pin.sym} 150650 -38130 0 0 {name=p149473 lab=_87851_/CLK }
C {devices/lab_pin.sym} 150650 -38110 0 0 {name=p149474 lab=_42479_/Y }
C {devices/lab_pin.sym} 150830 -38130 0 1 {name=p149475 lab=_73750_/A }
C {sky130_stdcells/dfxtp_4.sym} 150740 -38120 0 0 {name=X_87851_ }
C {devices/lab_pin.sym} 150680 -38000 0 0 {name=p149476 lab=_80186_/A }
C {devices/lab_pin.sym} 150680 -37960 0 0 {name=p149477 lab=_84291_/Q }
C {devices/lab_pin.sym} 150800 -37980 0 1 {name=p149478 lab=_80186_/X }
C {sky130_stdcells/xor2_4.sym} 150740 -37980 0 0 {name=X_80186_ }
C {devices/lab_pin.sym} 150660 -37870 0 0 {name=p149479 lab=_82557_/D }
C {devices/lab_pin.sym} 150660 -37830 0 0 {name=p149480 lab=_69988_/X }
C {devices/lab_pin.sym} 150660 -37790 0 0 {name=p149481 lab=_69996_/Y }
C {devices/lab_pin.sym} 150820 -37830 0 1 {name=p149482 lab=_69997_/X }
C {sky130_stdcells/a21bo_4.sym} 150740 -37830 0 0 {name=X_69997_ }
C {devices/lab_pin.sym} 150680 -37720 0 0 {name=p149483 lab=_51084_/A }
C {devices/lab_pin.sym} 150680 -37680 0 0 {name=p149484 lab=_51115_/B }
C {devices/lab_pin.sym} 150680 -37640 0 0 {name=p149485 lab=_51110_/C }
C {devices/lab_pin.sym} 150680 -37600 0 0 {name=p149486 lab=_52797_/D }
C {devices/lab_pin.sym} 150800 -37660 0 1 {name=p149487 lab=_51105_/X }
C {sky130_stdcells/and4_4.sym} 150740 -37660 0 0 {name=X_51105_ }
C {devices/lab_pin.sym} 150650 -37510 0 0 {name=p149488 lab=_87484_/CLK }
C {devices/lab_pin.sym} 150650 -37490 0 0 {name=p149489 lab=_46035_/X }
C {devices/lab_pin.sym} 150830 -37510 0 1 {name=p149490 lab=_86802_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -37500 0 0 {name=X_86802_ }
C {devices/lab_pin.sym} 150700 -37370 0 0 {name=p149491 lab=_59755_/A }
C {devices/lab_pin.sym} 150780 -37370 0 1 {name=p149492 lab=_72584_/C }
C {sky130_stdcells/buf_2.sym} 150740 -37370 0 0 {name=X_59750_ }
C {devices/lab_pin.sym} 150680 -37260 0 0 {name=p149493 lab=_52121_/A }
C {devices/lab_pin.sym} 150680 -37220 0 0 {name=p149494 lab=_50383_/B }
C {devices/lab_pin.sym} 150800 -37240 0 1 {name=p149495 lab=_52085_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -37240 0 0 {name=X_52085_ }
C {devices/lab_pin.sym} 150660 -37130 0 0 {name=p149496 lab=_56626_/X }
C {devices/lab_pin.sym} 150660 -37090 0 0 {name=p149497 lab=_56952_/A }
C {devices/lab_pin.sym} 150660 -37050 0 0 {name=p149498 lab=_56961_/Y }
C {devices/lab_pin.sym} 150820 -37090 0 1 {name=p149499 lab=_85111_/D }
C {sky130_stdcells/a21oi_4.sym} 150740 -37090 0 0 {name=X_56962_ }
C {devices/lab_pin.sym} 150700 -36950 0 0 {name=p149500 lab=_69485_/A }
C {devices/lab_pin.sym} 150780 -36950 0 1 {name=p149501 lab=_68948_/X }
C {sky130_stdcells/buf_2.sym} 150740 -36950 0 0 {name=X_68948_ }
C {devices/lab_pin.sym} 150650 -36830 0 0 {name=p149502 lab=_87782_/CLK }
C {devices/lab_pin.sym} 150650 -36810 0 0 {name=p149503 lab=_42662_/Y }
C {devices/lab_pin.sym} 150830 -36830 0 1 {name=p149504 lab=_87782_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -36820 0 0 {name=X_87782_ }
C {devices/lab_pin.sym} 150650 -36690 0 0 {name=p149505 lab=_85100_/CLK }
C {devices/lab_pin.sym} 150650 -36670 0 0 {name=p149506 lab=_84994_/D }
C {devices/lab_pin.sym} 150830 -36690 0 1 {name=p149507 lab=_84994_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -36680 0 0 {name=X_84994_ }
C {devices/lab_pin.sym} 150700 -36550 0 0 {name=p149508 lab=clkbuf_8_247_0_CLK/A }
C {devices/lab_pin.sym} 150780 -36550 0 1 {name=p149509 lab=clkbuf_9_495_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 150740 -36550 0 0 {name=Xclkbuf_8_247_0_CLK }
C {devices/lab_pin.sym} 150700 -36430 0 0 {name=p149510 lab=clkbuf_9_121_0_CLK/X }
C {devices/lab_pin.sym} 150780 -36430 0 1 {name=p149511 lab=_84452_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 150740 -36430 0 0 {name=Xclkbuf_10_242_0_CLK }
C {devices/lab_pin.sym} 150700 -36310 0 0 {name=p149512 lab=_58701_/A }
C {devices/lab_pin.sym} 150780 -36310 0 1 {name=p149513 lab=_58701_/X }
C {sky130_stdcells/buf_2.sym} 150740 -36310 0 0 {name=X_58701_ }
C {devices/lab_pin.sym} 150660 -36210 0 0 {name=p149514 lab=_51032_/Y }
C {devices/lab_pin.sym} 150660 -36170 0 0 {name=p149515 lab=_51011_/X }
C {devices/lab_pin.sym} 150660 -36130 0 0 {name=p149516 lab=_51035_/X }
C {devices/lab_pin.sym} 150820 -36170 0 1 {name=p149517 lab=_86086_/D }
C {sky130_stdcells/a21oi_4.sym} 150740 -36170 0 0 {name=X_51036_ }
C {devices/lab_pin.sym} 150680 -36040 0 0 {name=p149518 lab=_55620_/A }
C {devices/lab_pin.sym} 150680 -36000 0 0 {name=p149519 lab=_55913_/B }
C {devices/lab_pin.sym} 150800 -36020 0 1 {name=p149520 lab=_55913_/X }
C {sky130_stdcells/and2_4.sym} 150740 -36020 0 0 {name=X_55913_ }
C {devices/lab_pin.sym} 150650 -35890 0 0 {name=p149521 lab=_86733_/CLK }
C {devices/lab_pin.sym} 150650 -35870 0 0 {name=p149522 lab=_46488_/Y }
C {devices/lab_pin.sym} 150830 -35890 0 1 {name=p149523 lab=_86733_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -35880 0 0 {name=X_86733_ }
C {devices/lab_pin.sym} 150700 -35750 0 0 {name=p149524 lab=_59681_/A }
C {devices/lab_pin.sym} 150780 -35750 0 1 {name=p149525 lab=_59836_/D }
C {sky130_stdcells/buf_2.sym} 150740 -35750 0 0 {name=X_59681_ }
C {devices/lab_pin.sym} 150650 -35630 0 0 {name=p149526 lab=_83973_/CLK }
C {devices/lab_pin.sym} 150650 -35610 0 0 {name=p149527 lab=_83945_/D }
C {devices/lab_pin.sym} 150830 -35630 0 1 {name=p149528 lab=_83945_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -35620 0 0 {name=X_83945_ }
C {devices/lab_pin.sym} 150680 -35500 0 0 {name=p149529 lab=_56859_/X }
C {devices/lab_pin.sym} 150680 -35460 0 0 {name=p149530 lab=_56893_/B }
C {devices/lab_pin.sym} 150800 -35480 0 1 {name=p149531 lab=_56893_/Y }
C {sky130_stdcells/nor2_4.sym} 150740 -35480 0 0 {name=X_56893_ }
C {devices/lab_pin.sym} 150660 -35370 0 0 {name=p149532 lab=_68874_/X }
C {devices/lab_pin.sym} 150660 -35330 0 0 {name=p149533 lab=_68877_/X }
C {devices/lab_pin.sym} 150660 -35290 0 0 {name=p149534 lab=_68878_/X }
C {devices/lab_pin.sym} 150820 -35330 0 1 {name=p149535 lab=_68879_/Y }
C {sky130_stdcells/a21oi_4.sym} 150740 -35330 0 0 {name=X_68879_ }
C {devices/lab_pin.sym} 150700 -35190 0 0 {name=p149536 lab=clkbuf_9_436_0_CLK/X }
C {devices/lab_pin.sym} 150780 -35190 0 1 {name=p149537 lab=_86587_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 150740 -35190 0 0 {name=Xclkbuf_10_872_0_CLK }
C {devices/lab_pin.sym} 150700 -35070 0 0 {name=p149538 lab=_70866_/A }
C {devices/lab_pin.sym} 150780 -35070 0 1 {name=p149539 lab=_70914_/B }
C {sky130_stdcells/buf_2.sym} 150740 -35070 0 0 {name=X_70910_ }
C {devices/lab_pin.sym} 150700 -34950 0 0 {name=p149540 lab=_58749_/A }
C {devices/lab_pin.sym} 150780 -34950 0 1 {name=p149541 lab=_58659_/A }
C {sky130_stdcells/buf_2.sym} 150740 -34950 0 0 {name=X_58632_ }
C {devices/lab_pin.sym} 150700 -34830 0 0 {name=p149542 lab=clkbuf_9_12_0_CLK/X }
C {devices/lab_pin.sym} 150780 -34830 0 1 {name=p149543 lab=_85249_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 150740 -34830 0 0 {name=Xclkbuf_10_24_0_CLK }
C {devices/lab_pin.sym} 150660 -34740 0 0 {name=p149544 lab=_45168_/A }
C {devices/lab_pin.sym} 150660 -34700 0 0 {name=p149545 lab=_55572_/X }
C {devices/lab_pin.sym} 150660 -34660 0 0 {name=p149546 lab=_44098_/X }
C {devices/lab_pin.sym} 150660 -34620 0 0 {name=p149547 lab=_55843_/X }
C {devices/lab_pin.sym} 150820 -34680 0 1 {name=p149548 lab=_55844_/X }
C {sky130_stdcells/a211o_4.sym} 150740 -34680 0 0 {name=X_55844_ }
C {devices/lab_pin.sym} 150650 -34530 0 0 {name=p149549 lab=_86665_/CLK }
C {devices/lab_pin.sym} 150650 -34510 0 0 {name=p149550 lab=_47164_/Y }
C {devices/lab_pin.sym} 150830 -34530 0 1 {name=p149551 lab=_86664_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -34520 0 0 {name=X_86664_ }
C {devices/lab_pin.sym} 150660 -34410 0 0 {name=p149552 lab=_71870_/Y }
C {devices/lab_pin.sym} 150660 -34370 0 0 {name=p149553 lab=_83338_/Q }
C {devices/lab_pin.sym} 150660 -34330 0 0 {name=p149554 lab=_71889_/Y }
C {devices/lab_pin.sym} 150820 -34370 0 1 {name=p149555 lab=_83338_/D }
C {sky130_stdcells/a21o_4.sym} 150740 -34370 0 0 {name=X_71890_ }
C {devices/lab_pin.sym} 150650 -34230 0 0 {name=p149556 lab=_82557_/CLK }
C {devices/lab_pin.sym} 150650 -34210 0 0 {name=p149557 lab=_83876_/D }
C {devices/lab_pin.sym} 150830 -34230 0 1 {name=p149558 lab=_82556_/D }
C {sky130_stdcells/dfxtp_4.sym} 150740 -34220 0 0 {name=X_83876_ }
C {devices/lab_pin.sym} 150700 -34090 0 0 {name=p149559 lab=clkbuf_9_363_0_CLK/A }
C {devices/lab_pin.sym} 150780 -34090 0 1 {name=p149560 lab=clkbuf_9_363_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 150740 -34090 0 0 {name=Xclkbuf_9_363_0_CLK }
C {devices/lab_pin.sym} 150650 -33970 0 0 {name=p149561 lab=_87373_/CLK }
C {devices/lab_pin.sym} 150650 -33950 0 0 {name=p149562 lab=_88403_/D }
C {devices/lab_pin.sym} 150830 -33970 0 1 {name=p149563 lab=_88403_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -33960 0 0 {name=X_88403_ }
C {devices/lab_pin.sym} 150650 -33830 0 0 {name=p149564 lab=_83544_/CLK }
C {devices/lab_pin.sym} 150650 -33810 0 0 {name=p149565 lab=_85615_/D }
C {devices/lab_pin.sym} 150830 -33830 0 1 {name=p149566 lab=_85615_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -33820 0 0 {name=X_85615_ }
C {devices/lab_pin.sym} 150680 -33720 0 0 {name=p149567 lab=_70869_/A }
C {devices/lab_pin.sym} 150680 -33680 0 0 {name=p149568 lab=_70846_/B }
C {devices/lab_pin.sym} 150680 -33640 0 0 {name=p149569 lab=_70849_/C }
C {devices/lab_pin.sym} 150680 -33600 0 0 {name=p149570 lab=_70841_/D }
C {devices/lab_pin.sym} 150800 -33660 0 1 {name=p149571 lab=_70841_/Y }
C {sky130_stdcells/nand4_4.sym} 150740 -33660 0 0 {name=X_70841_ }
C {devices/lab_pin.sym} 150660 -33530 0 0 {name=p149572 lab=_58559_/X }
C {devices/lab_pin.sym} 150660 -33490 0 0 {name=p149573 lab=_83354_/Q }
C {devices/lab_pin.sym} 150660 -33450 0 0 {name=p149574 lab=_58562_/Y }
C {devices/lab_pin.sym} 150820 -33490 0 1 {name=p149575 lab=_84818_/D }
C {sky130_stdcells/o21a_4.sym} 150740 -33490 0 0 {name=X_58563_ }
C {devices/lab_pin.sym} 150650 -33350 0 0 {name=p149576 lab=_82462_/CLK }
C {devices/lab_pin.sym} 150650 -33330 0 0 {name=p149577 lab=_82827_/D }
C {devices/lab_pin.sym} 150830 -33350 0 1 {name=p149578 lab=_82827_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -33340 0 0 {name=X_82827_ }
C {devices/lab_pin.sym} 150660 -33240 0 0 {name=p149579 lab=_56253_/C }
C {devices/lab_pin.sym} 150660 -33200 0 0 {name=p149580 lab=_55747_/X }
C {devices/lab_pin.sym} 150660 -33160 0 0 {name=p149581 lab=_55165_/X }
C {devices/lab_pin.sym} 150660 -33120 0 0 {name=p149582 lab=_55774_/X }
C {devices/lab_pin.sym} 150820 -33180 0 1 {name=p149583 lab=_55775_/X }
C {sky130_stdcells/a211o_4.sym} 150740 -33180 0 0 {name=X_55775_ }
C {devices/lab_pin.sym} 150650 -33030 0 0 {name=p149584 lab=_85955_/CLK }
C {devices/lab_pin.sym} 150650 -33010 0 0 {name=p149585 lab=_86595_/D }
C {devices/lab_pin.sym} 150830 -33030 0 1 {name=p149586 lab=_86595_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -33020 0 0 {name=X_86595_ }
C {devices/lab_pin.sym} 150660 -32910 0 0 {name=p149587 lab=_85718_/Q }
C {devices/lab_pin.sym} 150660 -32870 0 0 {name=p149588 lab=_52984_/X }
C {devices/lab_pin.sym} 150660 -32830 0 0 {name=p149589 lab=_52986_/Y }
C {devices/lab_pin.sym} 150820 -32870 0 1 {name=p149590 lab=_52987_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -32870 0 0 {name=X_52987_ }
C {devices/lab_pin.sym} 150700 -32730 0 0 {name=p149591 lab=clkbuf_9_128_0_CLK/X }
C {devices/lab_pin.sym} 150780 -32730 0 1 {name=p149592 lab=_84849_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 150740 -32730 0 0 {name=Xclkbuf_10_257_0_CLK }
C {devices/lab_pin.sym} 150660 -32630 0 0 {name=p149593 lab=_84988_/Q }
C {devices/lab_pin.sym} 150660 -32590 0 0 {name=p149594 lab=_57493_/X }
C {devices/lab_pin.sym} 150660 -32550 0 0 {name=p149595 lab=_57513_/Y }
C {devices/lab_pin.sym} 150820 -32590 0 1 {name=p149596 lab=_57514_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -32590 0 0 {name=X_57514_ }
C {devices/lab_pin.sym} 150650 -32450 0 0 {name=p149597 lab=_84970_/CLK }
C {devices/lab_pin.sym} 150650 -32430 0 0 {name=p149598 lab=_88334_/D }
C {devices/lab_pin.sym} 150830 -32450 0 1 {name=p149599 lab=_88334_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -32440 0 0 {name=X_88334_ }
C {devices/lab_pin.sym} 150700 -32310 0 0 {name=p149600 lab=_42723_/A }
C {devices/lab_pin.sym} 150780 -32310 0 1 {name=p149601 lab=_42740_/X }
C {sky130_stdcells/buf_2.sym} 150740 -32310 0 0 {name=X_42740_ }
C {devices/lab_pin.sym} 150700 -32190 0 0 {name=p149602 lab=_54672_/X }
C {devices/lab_pin.sym} 150780 -32190 0 1 {name=p149603 lab=_54748_/C }
C {sky130_stdcells/buf_2.sym} 150740 -32190 0 0 {name=X_54726_ }
C {devices/lab_pin.sym} 150700 -32070 0 0 {name=p149604 lab=_72757_/A }
C {devices/lab_pin.sym} 150780 -32070 0 1 {name=p149605 lab=_73583_/A }
C {sky130_stdcells/buf_2.sym} 150740 -32070 0 0 {name=X_73560_ }
C {devices/lab_pin.sym} 150650 -31950 0 0 {name=p149606 lab=_86145_/CLK }
C {devices/lab_pin.sym} 150650 -31930 0 0 {name=p149607 lab=_85546_/D }
C {devices/lab_pin.sym} 150830 -31950 0 1 {name=p149608 lab=_85546_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -31940 0 0 {name=X_85546_ }
C {devices/lab_pin.sym} 150660 -31830 0 0 {name=p149609 lab=_51933_/Y }
C {devices/lab_pin.sym} 150660 -31790 0 0 {name=p149610 lab=_51934_/X }
C {devices/lab_pin.sym} 150660 -31750 0 0 {name=p149611 lab=_51937_/Y }
C {devices/lab_pin.sym} 150820 -31790 0 1 {name=p149612 lab=_85920_/D }
C {sky130_stdcells/a21boi_4.sym} 150740 -31790 0 0 {name=X_51938_ }
C {devices/lab_pin.sym} 150700 -31650 0 0 {name=p149613 lab=_70772_/A }
C {devices/lab_pin.sym} 150780 -31650 0 1 {name=p149614 lab=_70791_/C }
C {sky130_stdcells/buf_2.sym} 150740 -31650 0 0 {name=X_70772_ }
C {devices/lab_pin.sym} 150700 -31530 0 0 {name=p149615 lab=_64467_/C }
C {devices/lab_pin.sym} 150780 -31530 0 1 {name=p149616 lab=_58495_/A }
C {sky130_stdcells/buf_2.sym} 150740 -31530 0 0 {name=X_58494_ }
C {devices/lab_pin.sym} 150650 -31410 0 0 {name=p149617 lab=_82774_/CLK }
C {devices/lab_pin.sym} 150650 -31390 0 0 {name=p149618 lab=_82758_/D }
C {devices/lab_pin.sym} 150830 -31410 0 1 {name=p149619 lab=_82758_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -31400 0 0 {name=X_82758_ }
C {devices/lab_pin.sym} 150700 -31270 0 0 {name=p149620 lab=clkbuf_9_443_0_CLK/X }
C {devices/lab_pin.sym} 150780 -31270 0 1 {name=p149621 lab=_85818_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 150740 -31270 0 0 {name=Xclkbuf_10_887_0_CLK }
C {devices/lab_pin.sym} 150700 -31150 0 0 {name=p149622 lab=clkbuf_9_19_0_CLK/X }
C {devices/lab_pin.sym} 150780 -31150 0 1 {name=p149623 lab=_85089_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 150740 -31150 0 0 {name=Xclkbuf_10_39_0_CLK }
C {devices/lab_pin.sym} 150680 -31050 0 0 {name=p149624 lab=_72592_/A }
C {devices/lab_pin.sym} 150680 -31010 0 0 {name=p149625 lab=_61414_/A }
C {devices/lab_pin.sym} 150680 -30970 0 0 {name=p149626 lab=_79513_/B }
C {devices/lab_pin.sym} 150800 -31010 0 1 {name=p149627 lab=_72511_/Y }
C {sky130_stdcells/nor3_4.sym} 150740 -31010 0 0 {name=X_72511_ }
C {devices/lab_pin.sym} 150650 -30870 0 0 {name=p149628 lab=_81755_/CLK }
C {devices/lab_pin.sym} 150650 -30850 0 0 {name=p149629 lab=_81333_/Q }
C {devices/lab_pin.sym} 150830 -30870 0 1 {name=p149630 lab=_81709_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -30860 0 0 {name=X_81709_ }
C {devices/lab_pin.sym} 150680 -30750 0 0 {name=p149631 lab=_57029_/A }
C {devices/lab_pin.sym} 150680 -30710 0 0 {name=p149632 lab=_57445_/B }
C {devices/lab_pin.sym} 150680 -30670 0 0 {name=p149633 lab=_56812_/X }
C {devices/lab_pin.sym} 150800 -30710 0 1 {name=p149634 lab=_57445_/Y }
C {sky130_stdcells/nand3_4.sym} 150740 -30710 0 0 {name=X_57445_ }
C {devices/lab_pin.sym} 150650 -30570 0 0 {name=p149635 lab=_88268_/CLK }
C {devices/lab_pin.sym} 150650 -30550 0 0 {name=p149636 lab=_88265_/D }
C {devices/lab_pin.sym} 150830 -30570 0 1 {name=p149637 lab=_68631_/B }
C {sky130_stdcells/dfxtp_4.sym} 150740 -30560 0 0 {name=X_88265_ }
C {devices/lab_pin.sym} 150660 -30470 0 0 {name=p149638 lab=_42665_/X }
C {devices/lab_pin.sym} 150660 -30430 0 0 {name=p149639 lab=_42666_/X }
C {devices/lab_pin.sym} 150660 -30390 0 0 {name=p149640 lab=_41036_/X }
C {devices/lab_pin.sym} 150660 -30350 0 0 {name=p149641 lab=_69381_/B }
C {devices/lab_pin.sym} 150660 -30310 0 0 {name=p149642 lab=_42658_/X }
C {devices/lab_pin.sym} 150820 -30390 0 1 {name=p149643 lab=_42672_/A }
C {sky130_stdcells/o32ai_4.sym} 150740 -30390 0 0 {name=X_42671_ }
C {devices/lab_pin.sym} 150700 -30230 0 0 {name=p149644 lab=_54656_/X }
C {devices/lab_pin.sym} 150780 -30230 0 1 {name=p149645 lab=_54674_/B }
C {sky130_stdcells/buf_2.sym} 150740 -30230 0 0 {name=X_54657_ }
C {devices/lab_pin.sym} 150650 -30110 0 0 {name=p149646 lab=_84926_/CLK }
C {devices/lab_pin.sym} 150650 -30090 0 0 {name=p149647 lab=_54248_/Y }
C {devices/lab_pin.sym} 150830 -30110 0 1 {name=p149648 lab=_85477_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -30100 0 0 {name=X_85477_ }
C {devices/lab_pin.sym} 150700 -29970 0 0 {name=p149649 lab=_72899_/A }
C {devices/lab_pin.sym} 150780 -29970 0 1 {name=p149650 lab=_73491_/X }
C {sky130_stdcells/buf_2.sym} 150740 -29970 0 0 {name=X_73491_ }
C {devices/lab_pin.sym} 150700 -29850 0 0 {name=p149651 lab=_51843_/A }
C {devices/lab_pin.sym} 150780 -29850 0 1 {name=p149652 lab=_51870_/B }
C {sky130_stdcells/buf_2.sym} 150740 -29850 0 0 {name=X_51869_ }
C {devices/lab_pin.sym} 150650 -29730 0 0 {name=p149653 lab=_81216_/CLK }
C {devices/lab_pin.sym} 150650 -29710 0 0 {name=p149654 lab=_78793_/A }
C {devices/lab_pin.sym} 150830 -29730 0 1 {name=p149655 lab=_78309_/B }
C {sky130_stdcells/dfxtp_4.sym} 150740 -29720 0 0 {name=X_82689_ }
C {devices/lab_pin.sym} 150700 -29590 0 0 {name=p149656 lab=clkbuf_9_378_0_CLK/A }
C {devices/lab_pin.sym} 150780 -29590 0 1 {name=p149657 lab=clkbuf_9_378_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 150740 -29590 0 0 {name=Xclkbuf_9_378_0_CLK }
C {devices/lab_pin.sym} 150700 -29470 0 0 {name=p149658 lab=_44410_/A }
C {devices/lab_pin.sym} 150780 -29470 0 1 {name=p149659 lab=_87123_/D }
C {sky130_stdcells/inv_2.sym} 150740 -29470 0 0 {name=X_44410_ }
C {devices/lab_pin.sym} 150650 -29350 0 0 {name=p149660 lab=_87408_/CLK }
C {devices/lab_pin.sym} 150650 -29330 0 0 {name=p149661 lab=_87216_/D }
C {devices/lab_pin.sym} 150830 -29350 0 1 {name=p149662 lab=_87216_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -29340 0 0 {name=X_87216_ }
C {devices/lab_pin.sym} 150680 -29220 0 0 {name=p149663 lab=_75228_/X }
C {devices/lab_pin.sym} 150680 -29180 0 0 {name=p149664 lab=_75230_/B }
C {devices/lab_pin.sym} 150800 -29200 0 1 {name=p149665 lab=_75230_/X }
C {sky130_stdcells/and2_4.sym} 150740 -29200 0 0 {name=X_75230_ }
C {devices/lab_pin.sym} 150660 -29110 0 0 {name=p149666 lab=_41611_/X }
C {devices/lab_pin.sym} 150660 -29070 0 0 {name=p149667 lab=_41613_/X }
C {devices/lab_pin.sym} 150660 -29030 0 0 {name=p149668 lab=_41621_/X }
C {devices/lab_pin.sym} 150660 -28990 0 0 {name=p149669 lab=_88181_/Q }
C {devices/lab_pin.sym} 150660 -28950 0 0 {name=p149670 lab=_41608_/X }
C {devices/lab_pin.sym} 150820 -29030 0 1 {name=p149671 lab=_41623_/A }
C {sky130_stdcells/o32ai_4.sym} 150740 -29030 0 0 {name=X_41622_ }
C {devices/lab_pin.sym} 150680 -28880 0 0 {name=p149672 lab=_53604_/A }
C {devices/lab_pin.sym} 150680 -28840 0 0 {name=p149673 lab=_50385_/B }
C {devices/lab_pin.sym} 150800 -28860 0 1 {name=p149674 lab=_53608_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -28860 0 0 {name=X_53608_ }
C {devices/lab_pin.sym} 150660 -28750 0 0 {name=p149675 lab=_57697_/X }
C {devices/lab_pin.sym} 150660 -28710 0 0 {name=p149676 lab=_85958_/Q }
C {devices/lab_pin.sym} 150660 -28670 0 0 {name=p149677 lab=_72441_/X }
C {devices/lab_pin.sym} 150820 -28710 0 1 {name=p149678 lab=_72442_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -28710 0 0 {name=X_72442_ }
C {devices/lab_pin.sym} 150650 -28570 0 0 {name=p149679 lab=_84426_/CLK }
C {devices/lab_pin.sym} 150650 -28550 0 0 {name=p149680 lab=_84428_/D }
C {devices/lab_pin.sym} 150830 -28570 0 1 {name=p149681 lab=_78051_/B }
C {sky130_stdcells/dfxtp_4.sym} 150740 -28560 0 0 {name=X_84428_ }
C {devices/lab_pin.sym} 150700 -28430 0 0 {name=p149682 lab=_45389_/X }
C {devices/lab_pin.sym} 150780 -28430 0 1 {name=p149683 lab=_45390_/X }
C {sky130_stdcells/buf_2.sym} 150740 -28430 0 0 {name=X_45390_ }
C {devices/lab_pin.sym} 150700 -28310 0 0 {name=p149684 lab=_73476_/A }
C {devices/lab_pin.sym} 150780 -28310 0 1 {name=p149685 lab=_57376_/X }
C {sky130_stdcells/buf_2.sym} 150740 -28310 0 0 {name=X_57376_ }
C {devices/lab_pin.sym} 150650 -28190 0 0 {name=p149686 lab=_88133_/CLK }
C {devices/lab_pin.sym} 150650 -28170 0 0 {name=p149687 lab=_41539_/Y }
C {devices/lab_pin.sym} 150830 -28190 0 1 {name=p149688 lab=_66932_/B }
C {sky130_stdcells/dfxtp_4.sym} 150740 -28180 0 0 {name=X_88196_ }
C {devices/lab_pin.sym} 150660 -28070 0 0 {name=p149689 lab=_85414_/Q }
C {devices/lab_pin.sym} 150660 -28030 0 0 {name=p149690 lab=_54567_/X }
C {devices/lab_pin.sym} 150660 -27990 0 0 {name=p149691 lab=_54587_/Y }
C {devices/lab_pin.sym} 150820 -28030 0 1 {name=p149692 lab=_54588_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -28030 0 0 {name=X_54588_ }
C {devices/lab_pin.sym} 150700 -27890 0 0 {name=p149693 lab=clkbuf_9_405_0_CLK/X }
C {devices/lab_pin.sym} 150780 -27890 0 1 {name=p149694 lab=_82299_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 150740 -27890 0 0 {name=Xclkbuf_10_810_0_CLK }
C {devices/lab_pin.sym} 150700 -27770 0 0 {name=p149695 lab=_58918_/A }
C {devices/lab_pin.sym} 150780 -27770 0 1 {name=p149696 lab=_59115_/X }
C {sky130_stdcells/buf_2.sym} 150740 -27770 0 0 {name=X_59115_ }
C {devices/lab_pin.sym} 150660 -27690 0 0 {name=p149697 lab=_44330_/X }
C {devices/lab_pin.sym} 150660 -27650 0 0 {name=p149698 lab=_44331_/X }
C {devices/lab_pin.sym} 150660 -27610 0 0 {name=p149699 lab=_41688_/X }
C {devices/lab_pin.sym} 150660 -27570 0 0 {name=p149700 lab=_87157_/Q }
C {devices/lab_pin.sym} 150660 -27530 0 0 {name=p149701 lab=_44332_/X }
C {devices/lab_pin.sym} 150820 -27610 0 1 {name=p149702 lab=_44341_/Y }
C {sky130_stdcells/o32ai_4.sym} 150740 -27610 0 0 {name=X_44341_ }
C {devices/lab_pin.sym} 150660 -27470 0 0 {name=p149703 lab=_56079_/X }
C {devices/lab_pin.sym} 150660 -27430 0 0 {name=p149704 lab=_56321_/X }
C {devices/lab_pin.sym} 150660 -27390 0 0 {name=p149705 lab=_56326_/Y }
C {devices/lab_pin.sym} 150820 -27430 0 1 {name=p149706 lab=_85235_/D }
C {sky130_stdcells/o21ai_4.sym} 150740 -27430 0 0 {name=X_56327_ }
C {devices/lab_pin.sym} 150680 -27310 0 0 {name=p149707 lab=_75155_/Y }
C {devices/lab_pin.sym} 150680 -27270 0 0 {name=p149708 lab=_75161_/B }
C {devices/lab_pin.sym} 150680 -27230 0 0 {name=p149709 lab=_75159_/Y }
C {devices/lab_pin.sym} 150800 -27270 0 1 {name=p149710 lab=_75162_/B }
C {sky130_stdcells/nand3_4.sym} 150740 -27270 0 0 {name=X_75161_ }
C {devices/lab_pin.sym} 150650 -27130 0 0 {name=p149711 lab=_88164_/CLK }
C {devices/lab_pin.sym} 150650 -27110 0 0 {name=p149712 lab=_44361_/Y }
C {devices/lab_pin.sym} 150830 -27130 0 1 {name=p149713 lab=_87147_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -27120 0 0 {name=X_87147_ }
C {devices/lab_pin.sym} 150660 -27020 0 0 {name=p149714 lab=_41552_/X }
C {devices/lab_pin.sym} 150660 -26980 0 0 {name=p149715 lab=_41530_/X }
C {devices/lab_pin.sym} 150660 -26940 0 0 {name=p149716 lab=_88194_/Q }
C {devices/lab_pin.sym} 150660 -26900 0 0 {name=p149717 lab=_41531_/X }
C {devices/lab_pin.sym} 150820 -26960 0 1 {name=p149718 lab=_88194_/D }
C {sky130_stdcells/a2bb2o_4.sym} 150740 -26960 0 0 {name=X_41553_ }
C {devices/lab_pin.sym} 150660 -26830 0 0 {name=p149719 lab=_53536_/Y }
C {devices/lab_pin.sym} 150660 -26790 0 0 {name=p149720 lab=_53537_/X }
C {devices/lab_pin.sym} 150660 -26750 0 0 {name=p149721 lab=_53538_/X }
C {devices/lab_pin.sym} 150820 -26790 0 1 {name=p149722 lab=_85617_/D }
C {sky130_stdcells/a21oi_4.sym} 150740 -26790 0 0 {name=X_53539_ }
C {devices/lab_pin.sym} 150660 -26670 0 0 {name=p149723 lab=_57709_/X }
C {devices/lab_pin.sym} 150660 -26630 0 0 {name=p149724 lab=_85356_/Q }
C {devices/lab_pin.sym} 150660 -26590 0 0 {name=p149725 lab=_72372_/X }
C {devices/lab_pin.sym} 150820 -26630 0 1 {name=p149726 lab=_72373_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -26630 0 0 {name=X_72373_ }
C {devices/lab_pin.sym} 150650 -26490 0 0 {name=p149727 lab=_84360_/CLK }
C {devices/lab_pin.sym} 150650 -26470 0 0 {name=p149728 lab=_63035_/X }
C {devices/lab_pin.sym} 150830 -26490 0 1 {name=p149729 lab=_79493_/A }
C {sky130_stdcells/dfxtp_4.sym} 150740 -26480 0 0 {name=X_84359_ }
C {devices/lab_pin.sym} 150700 -26350 0 0 {name=p149730 lab=clkbuf_8_150_0_CLK/X }
C {devices/lab_pin.sym} 150780 -26350 0 1 {name=p149731 lab=clkbuf_9_301_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 150740 -26350 0 0 {name=Xclkbuf_9_301_0_CLK }
C {devices/lab_pin.sym} 150680 -26240 0 0 {name=p149732 lab=_73588_/A }
C {devices/lab_pin.sym} 150680 -26200 0 0 {name=p149733 lab=_66242_/B }
C {devices/lab_pin.sym} 150800 -26220 0 1 {name=p149734 lab=_74112_/X }
C {sky130_stdcells/and2_4.sym} 150740 -26220 0 0 {name=X_74112_ }
C {devices/lab_pin.sym} 150700 -26090 0 0 {name=p149735 lab=_40324_/X }
C {devices/lab_pin.sym} 150780 -26090 0 1 {name=p149736 lab=_40504_/X }
C {sky130_stdcells/buf_2.sym} 150740 -26090 0 0 {name=X_40504_ }
C {devices/lab_pin.sym} 150660 -25990 0 0 {name=p149737 lab=_47055_/Y }
C {devices/lab_pin.sym} 150660 -25950 0 0 {name=p149738 lab=_47035_/X }
C {devices/lab_pin.sym} 150660 -25910 0 0 {name=p149739 lab=_47059_/X }
C {devices/lab_pin.sym} 150820 -25950 0 1 {name=p149740 lab=_86675_/D }
C {sky130_stdcells/a21oi_4.sym} 150740 -25950 0 0 {name=X_47060_ }
C {devices/lab_pin.sym} 150660 -25830 0 0 {name=p149741 lab=_50358_/B }
C {devices/lab_pin.sym} 150660 -25790 0 0 {name=p149742 lab=_71320_/X }
C {devices/lab_pin.sym} 150660 -25750 0 0 {name=p149743 lab=_71323_/Y }
C {devices/lab_pin.sym} 150820 -25790 0 1 {name=p149744 lab=_71324_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -25790 0 0 {name=X_71324_ }
C {devices/lab_pin.sym} 150700 -25650 0 0 {name=p149745 lab=_58603_/A }
C {devices/lab_pin.sym} 150780 -25650 0 1 {name=p149746 lab=_59046_/X }
C {sky130_stdcells/buf_2.sym} 150740 -25650 0 0 {name=X_59046_ }
C {devices/lab_pin.sym} 150700 -25530 0 0 {name=p149747 lab=_72838_/A }
C {devices/lab_pin.sym} 150780 -25530 0 1 {name=p149748 lab=_44272_/X }
C {sky130_stdcells/buf_2.sym} 150740 -25530 0 0 {name=X_44272_ }
C {devices/lab_pin.sym} 150700 -25410 0 0 {name=p149749 lab=_56245_/A }
C {devices/lab_pin.sym} 150780 -25410 0 1 {name=p149750 lab=_56263_/B }
C {sky130_stdcells/buf_2.sym} 150740 -25410 0 0 {name=X_56258_ }
C {devices/lab_pin.sym} 150650 -25290 0 0 {name=p149751 lab=_88267_/CLK }
C {devices/lab_pin.sym} 150650 -25270 0 0 {name=p149752 lab=_87078_/D }
C {devices/lab_pin.sym} 150830 -25290 0 1 {name=p149753 lab=_87078_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -25280 0 0 {name=X_87078_ }
C {devices/lab_pin.sym} 150680 -25160 0 0 {name=p149754 lab=_75090_/X }
C {devices/lab_pin.sym} 150680 -25120 0 0 {name=p149755 lab=_75107_/A }
C {devices/lab_pin.sym} 150800 -25140 0 1 {name=p149756 lab=_75092_/X }
C {sky130_stdcells/and2_4.sym} 150740 -25140 0 0 {name=X_75092_ }
C {devices/lab_pin.sym} 150660 -25030 0 0 {name=p149757 lab=_41481_/X }
C {devices/lab_pin.sym} 150660 -24990 0 0 {name=p149758 lab=_82332_/Q }
C {devices/lab_pin.sym} 150660 -24950 0 0 {name=p149759 lab=_41483_/X }
C {devices/lab_pin.sym} 150820 -24990 0 1 {name=p149760 lab=_41484_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -24990 0 0 {name=X_41484_ }
C {devices/lab_pin.sym} 150700 -24850 0 0 {name=p149761 lab=_46011_/A }
C {devices/lab_pin.sym} 150780 -24850 0 1 {name=p149762 lab=_46011_/Y }
C {sky130_stdcells/inv_2.sym} 150740 -24850 0 0 {name=X_46011_ }
C {devices/lab_pin.sym} 150700 -24730 0 0 {name=p149763 lab=_43223_/A }
C {devices/lab_pin.sym} 150780 -24730 0 1 {name=p149764 lab=_87531_/D }
C {sky130_stdcells/inv_2.sym} 150740 -24730 0 0 {name=X_43223_ }
C {devices/lab_pin.sym} 150660 -24640 0 0 {name=p149765 lab=_82981_/Q }
C {devices/lab_pin.sym} 150660 -24600 0 0 {name=p149766 lab=_55190_/X }
C {devices/lab_pin.sym} 150660 -24560 0 0 {name=p149767 lab=_55172_/X }
C {devices/lab_pin.sym} 150660 -24520 0 0 {name=p149768 lab=_55208_/Y }
C {devices/lab_pin.sym} 150820 -24580 0 1 {name=p149769 lab=_55209_/X }
C {sky130_stdcells/a211o_4.sym} 150740 -24580 0 0 {name=X_55209_ }
C {devices/lab_pin.sym} 150680 -24440 0 0 {name=p149770 lab=_74022_/X }
C {devices/lab_pin.sym} 150680 -24400 0 0 {name=p149771 lab=_86541_/Q }
C {devices/lab_pin.sym} 150800 -24420 0 1 {name=p149772 lab=_74043_/X }
C {sky130_stdcells/and2_4.sym} 150740 -24420 0 0 {name=X_74043_ }
C {devices/lab_pin.sym} 150680 -24300 0 0 {name=p149773 lab=_82734_/Q }
C {devices/lab_pin.sym} 150680 -24260 0 0 {name=p149774 lab=_78920_/B }
C {devices/lab_pin.sym} 150800 -24280 0 1 {name=p149775 lab=_78920_/X }
C {sky130_stdcells/xor2_4.sym} 150740 -24280 0 0 {name=X_78920_ }
C {devices/lab_pin.sym} 150650 -24150 0 0 {name=p149776 lab=_86029_/CLK }
C {devices/lab_pin.sym} 150650 -24130 0 0 {name=p149777 lab=_86029_/D }
C {devices/lab_pin.sym} 150830 -24150 0 1 {name=p149778 lab=_65120_/B }
C {sky130_stdcells/dfxtp_4.sym} 150740 -24140 0 0 {name=X_86029_ }
C {devices/lab_pin.sym} 150700 -24010 0 0 {name=p149779 lab=_40435_/A }
C {devices/lab_pin.sym} 150780 -24010 0 1 {name=p149780 lab=_40686_/A }
C {sky130_stdcells/buf_2.sym} 150740 -24010 0 0 {name=X_40435_ }
C {devices/lab_pin.sym} 150700 -23890 0 0 {name=p149781 lab=_70819_/A }
C {devices/lab_pin.sym} 150780 -23890 0 1 {name=p149782 lab=_71256_/B }
C {sky130_stdcells/buf_2.sym} 150740 -23890 0 0 {name=X_71255_ }
C {devices/lab_pin.sym} 150700 -23770 0 0 {name=p149783 lab=_56186_/Y }
C {devices/lab_pin.sym} 150780 -23770 0 1 {name=p149784 lab=_56252_/A }
C {sky130_stdcells/buf_2.sym} 150740 -23770 0 0 {name=X_56189_ }
C {devices/lab_pin.sym} 150700 -23650 0 0 {name=p149785 lab=clkbuf_9_412_0_CLK/X }
C {devices/lab_pin.sym} 150780 -23650 0 1 {name=p149786 lab=_82368_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 150740 -23650 0 0 {name=Xclkbuf_10_825_0_CLK }
C {devices/lab_pin.sym} 150660 -23550 0 0 {name=p149787 lab=_70195_/X }
C {devices/lab_pin.sym} 150660 -23510 0 0 {name=p149788 lab=_83838_/Q }
C {devices/lab_pin.sym} 150660 -23470 0 0 {name=p149789 lab=_70205_/X }
C {devices/lab_pin.sym} 150820 -23510 0 1 {name=p149790 lab=_70206_/X }
C {sky130_stdcells/a21o_4.sym} 150740 -23510 0 0 {name=X_70206_ }
C {devices/lab_pin.sym} 150700 -23370 0 0 {name=p149791 lab=_43121_/A }
C {devices/lab_pin.sym} 150780 -23370 0 1 {name=p149792 lab=_43154_/X }
C {sky130_stdcells/buf_2.sym} 150740 -23370 0 0 {name=X_43154_ }
C {devices/lab_pin.sym} 150680 -23260 0 0 {name=p149793 lab=_82727_/Q }
C {devices/lab_pin.sym} 150680 -23220 0 0 {name=p149794 lab=_78851_/B }
C {devices/lab_pin.sym} 150800 -23240 0 1 {name=p149795 lab=_78851_/X }
C {sky130_stdcells/xor2_4.sym} 150740 -23240 0 0 {name=X_78851_ }
C {devices/lab_pin.sym} 150700 -23110 0 0 {name=p149796 lab=_40365_/X }
C {devices/lab_pin.sym} 150780 -23110 0 1 {name=p149797 lab=_41061_/A }
C {sky130_stdcells/buf_2.sym} 150740 -23110 0 0 {name=X_40366_ }
C {devices/lab_pin.sym} 150660 -23010 0 0 {name=p149798 lab=_48788_/B }
C {devices/lab_pin.sym} 150660 -22970 0 0 {name=p149799 lab=_71164_/Y }
C {devices/lab_pin.sym} 150660 -22930 0 0 {name=p149800 lab=_71185_/Y }
C {devices/lab_pin.sym} 150820 -22970 0 1 {name=p149801 lab=_71186_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -22970 0 0 {name=X_71186_ }
C {devices/lab_pin.sym} 150700 -22830 0 0 {name=p149802 lab=clkbuf_8_158_0_CLK/X }
C {devices/lab_pin.sym} 150780 -22830 0 1 {name=p149803 lab=clkbuf_9_316_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 150740 -22830 0 0 {name=Xclkbuf_9_316_0_CLK }
C {devices/lab_pin.sym} 150660 -22740 0 0 {name=p149804 lab=_41032_/X }
C {devices/lab_pin.sym} 150660 -22700 0 0 {name=p149805 lab=_42103_/X }
C {devices/lab_pin.sym} 150660 -22660 0 0 {name=p149806 lab=_88034_/Q }
C {devices/lab_pin.sym} 150660 -22620 0 0 {name=p149807 lab=_42104_/X }
C {devices/lab_pin.sym} 150820 -22680 0 1 {name=p149808 lab=_88034_/D }
C {sky130_stdcells/a2bb2o_4.sym} 150740 -22680 0 0 {name=X_42105_ }
C {devices/lab_pin.sym} 150660 -22550 0 0 {name=p149809 lab=_77782_/Y }
C {devices/lab_pin.sym} 150660 -22510 0 0 {name=p149810 lab=_77796_/Y }
C {devices/lab_pin.sym} 150660 -22470 0 0 {name=p149811 lab=_77801_/X }
C {devices/lab_pin.sym} 150820 -22510 0 1 {name=p149812 lab=_77802_/Y }
C {sky130_stdcells/a21oi_4.sym} 150740 -22510 0 0 {name=X_77802_ }
C {devices/lab_pin.sym} 150660 -22400 0 0 {name=p149813 lab=_83521_/Q }
C {devices/lab_pin.sym} 150660 -22360 0 0 {name=p149814 lab=_83169_/Q }
C {devices/lab_pin.sym} 150660 -22320 0 0 {name=p149815 lab=_83504_/Q }
C {devices/lab_pin.sym} 150660 -22280 0 0 {name=p149816 lab=_83152_/Q }
C {devices/lab_pin.sym} 150820 -22340 0 1 {name=p149817 lab=_70139_/C }
C {sky130_stdcells/a22oi_4.sym} 150740 -22340 0 0 {name=X_70137_ }
C {devices/lab_pin.sym} 150660 -22210 0 0 {name=p149818 lab=_66084_/B }
C {devices/lab_pin.sym} 150660 -22170 0 0 {name=p149819 lab=_47948_/X }
C {devices/lab_pin.sym} 150660 -22130 0 0 {name=p149820 lab=_47961_/Y }
C {devices/lab_pin.sym} 150820 -22170 0 1 {name=p149821 lab=_47962_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -22170 0 0 {name=X_47962_ }
C {devices/lab_pin.sym} 150700 -22030 0 0 {name=p149822 lab=_43129_/A }
C {devices/lab_pin.sym} 150780 -22030 0 1 {name=p149823 lab=_43085_/X }
C {sky130_stdcells/buf_2.sym} 150740 -22030 0 0 {name=X_43085_ }
C {devices/lab_pin.sym} 150700 -21910 0 0 {name=p149824 lab=_62198_/B }
C {devices/lab_pin.sym} 150780 -21910 0 1 {name=p149825 lab=_59950_/B }
C {sky130_stdcells/buf_2.sym} 150740 -21910 0 0 {name=X_59948_ }
C {devices/lab_pin.sym} 150680 -21800 0 0 {name=p149826 lab=_78782_/A }
C {devices/lab_pin.sym} 150680 -21760 0 0 {name=p149827 lab=_78778_/X }
C {devices/lab_pin.sym} 150800 -21780 0 1 {name=p149828 lab=_78782_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -21780 0 0 {name=X_78782_ }
C {devices/lab_pin.sym} 150680 -21660 0 0 {name=p149829 lab=_75990_/Y }
C {devices/lab_pin.sym} 150680 -21620 0 0 {name=p149830 lab=_75993_/X }
C {devices/lab_pin.sym} 150800 -21640 0 1 {name=p149831 lab=_75994_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -21640 0 0 {name=X_75994_ }
C {devices/lab_pin.sym} 150680 -21540 0 0 {name=p149832 lab=_49685_/A }
C {devices/lab_pin.sym} 150680 -21500 0 0 {name=p149833 lab=_49697_/B }
C {devices/lab_pin.sym} 150680 -21460 0 0 {name=p149834 lab=_49685_/C }
C {devices/lab_pin.sym} 150680 -21420 0 0 {name=p149835 lab=_51225_/D }
C {devices/lab_pin.sym} 150800 -21480 0 1 {name=p149836 lab=_49701_/X }
C {sky130_stdcells/and4_4.sym} 150740 -21480 0 0 {name=X_49701_ }
C {devices/lab_pin.sym} 150680 -21340 0 0 {name=p149837 lab=_46948_/A }
C {devices/lab_pin.sym} 150680 -21300 0 0 {name=p149838 lab=_46912_/X }
C {devices/lab_pin.sym} 150800 -21320 0 1 {name=p149839 lab=_46913_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -21320 0 0 {name=X_46913_ }
C {devices/lab_pin.sym} 150700 -21190 0 0 {name=p149840 lab=_42036_/A }
C {devices/lab_pin.sym} 150780 -21190 0 1 {name=p149841 lab=_42036_/Y }
C {sky130_stdcells/inv_2.sym} 150740 -21190 0 0 {name=X_42036_ }
C {devices/lab_pin.sym} 150660 -21090 0 0 {name=p149842 lab=_77730_/Y }
C {devices/lab_pin.sym} 150660 -21050 0 0 {name=p149843 lab=_77732_/Y }
C {devices/lab_pin.sym} 150660 -21010 0 0 {name=p149844 lab=_77725_/Y }
C {devices/lab_pin.sym} 150820 -21050 0 1 {name=p149845 lab=_77743_/A }
C {sky130_stdcells/a21oi_4.sym} 150740 -21050 0 0 {name=X_77733_ }
C {devices/lab_pin.sym} 150680 -20920 0 0 {name=p149846 lab=_81135_/D }
C {devices/lab_pin.sym} 150680 -20880 0 0 {name=p149847 lab=_74945_/B }
C {devices/lab_pin.sym} 150800 -20900 0 1 {name=p149848 lab=_74945_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -20900 0 0 {name=X_74945_ }
C {devices/lab_pin.sym} 150660 -20790 0 0 {name=p149849 lab=_69876_/X }
C {devices/lab_pin.sym} 150660 -20750 0 0 {name=p149850 lab=_69878_/X }
C {devices/lab_pin.sym} 150660 -20710 0 0 {name=p149851 lab=_68400_/X }
C {devices/lab_pin.sym} 150820 -20750 0 1 {name=p149852 lab=_70068_/Y }
C {sky130_stdcells/a21oi_4.sym} 150740 -20750 0 0 {name=X_70068_ }
C {devices/lab_pin.sym} 150680 -20620 0 0 {name=p149853 lab=_47893_/A }
C {devices/lab_pin.sym} 150680 -20580 0 0 {name=p149854 lab=_46579_/X }
C {devices/lab_pin.sym} 150800 -20600 0 1 {name=p149855 lab=_47893_/X }
C {sky130_stdcells/or2_4.sym} 150740 -20600 0 0 {name=X_47893_ }
C {devices/lab_pin.sym} 150700 -20470 0 0 {name=p149856 lab=clkbuf_4_0_1_CLK/X }
C {devices/lab_pin.sym} 150780 -20470 0 1 {name=p149857 lab=clkbuf_6_3_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 150740 -20470 0 0 {name=Xclkbuf_5_1_0_CLK }
C {devices/lab_pin.sym} 150680 -20360 0 0 {name=p149858 lab=_59579_/A }
C {devices/lab_pin.sym} 150680 -20320 0 0 {name=p149859 lab=_59585_/A }
C {devices/lab_pin.sym} 150800 -20340 0 1 {name=p149860 lab=_60174_/D }
C {sky130_stdcells/nor2_4.sym} 150740 -20340 0 0 {name=X_59879_ }
C {devices/lab_pin.sym} 150680 -20240 0 0 {name=p149861 lab=_61909_/X }
C {devices/lab_pin.sym} 150680 -20200 0 0 {name=p149862 lab=_61846_/B }
C {devices/lab_pin.sym} 150680 -20160 0 0 {name=p149863 lab=_61878_/C }
C {devices/lab_pin.sym} 150680 -20120 0 0 {name=p149864 lab=_61910_/D }
C {devices/lab_pin.sym} 150800 -20180 0 1 {name=p149865 lab=_61910_/Y }
C {sky130_stdcells/nand4_4.sym} 150740 -20180 0 0 {name=X_61910_ }
C {devices/lab_pin.sym} 150700 -20030 0 0 {name=p149866 lab=_49632_/A }
C {devices/lab_pin.sym} 150780 -20030 0 1 {name=p149867 lab=_49632_/X }
C {sky130_stdcells/buf_2.sym} 150740 -20030 0 0 {name=X_49632_ }
C {devices/lab_pin.sym} 150700 -19910 0 0 {name=p149868 lab=_46751_/A }
C {devices/lab_pin.sym} 150780 -19910 0 1 {name=p149869 lab=_46844_/X }
C {sky130_stdcells/buf_2.sym} 150740 -19910 0 0 {name=X_46844_ }
C {devices/lab_pin.sym} 150680 -19820 0 0 {name=p149870 lab=_77666_/A }
C {devices/lab_pin.sym} 150680 -19780 0 0 {name=p149871 lab=_77638_/Y }
C {devices/lab_pin.sym} 150680 -19740 0 0 {name=p149872 lab=_77664_/C }
C {devices/lab_pin.sym} 150680 -19700 0 0 {name=p149873 lab=_77639_/Y }
C {devices/lab_pin.sym} 150800 -19760 0 1 {name=p149874 lab=_77665_/A }
C {sky130_stdcells/nand4_4.sym} 150740 -19760 0 0 {name=X_77664_ }
C {devices/lab_pin.sym} 150700 -19610 0 0 {name=p149875 lab=_62717_/A }
C {devices/lab_pin.sym} 150780 -19610 0 1 {name=p149876 lab=_62967_/D }
C {sky130_stdcells/buf_2.sym} 150740 -19610 0 0 {name=X_62890_ }
C {devices/lab_pin.sym} 150680 -19500 0 0 {name=p149877 lab=_81126_/D }
C {devices/lab_pin.sym} 150680 -19460 0 0 {name=p149878 lab=_74869_/B }
C {devices/lab_pin.sym} 150800 -19480 0 1 {name=p149879 lab=_74876_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -19480 0 0 {name=X_74876_ }
C {devices/lab_pin.sym} 150660 -19370 0 0 {name=p149880 lab=_79395_/A }
C {devices/lab_pin.sym} 150660 -19330 0 0 {name=p149881 lab=_79395_/B }
C {devices/lab_pin.sym} 150660 -19290 0 0 {name=p149882 lab=_79402_/Y }
C {devices/lab_pin.sym} 150820 -19330 0 1 {name=p149883 lab=_79419_/A }
C {sky130_stdcells/a21boi_4.sym} 150740 -19330 0 0 {name=X_79403_ }
C {devices/lab_pin.sym} 150700 -19190 0 0 {name=p149884 lab=_76614_/X }
C {devices/lab_pin.sym} 150780 -19190 0 1 {name=p149885 lab=_76615_/Y }
C {sky130_stdcells/inv_2.sym} 150740 -19190 0 0 {name=X_76615_ }
C {devices/lab_pin.sym} 150680 -19080 0 0 {name=p149886 lab=_49558_/A }
C {devices/lab_pin.sym} 150680 -19040 0 0 {name=p149887 lab=_52777_/B }
C {devices/lab_pin.sym} 150800 -19060 0 1 {name=p149888 lab=_49563_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -19060 0 0 {name=X_49563_ }
C {devices/lab_pin.sym} 150680 -18960 0 0 {name=p149889 lab=_61419_/X }
C {devices/lab_pin.sym} 150680 -18920 0 0 {name=p149890 lab=_61794_/B }
C {devices/lab_pin.sym} 150680 -18880 0 0 {name=p149891 lab=_61809_/C }
C {devices/lab_pin.sym} 150680 -18840 0 0 {name=p149892 lab=_61776_/D }
C {devices/lab_pin.sym} 150800 -18900 0 1 {name=p149893 lab=_61847_/B }
C {sky130_stdcells/nand4_4.sym} 150740 -18900 0 0 {name=X_61841_ }
C {devices/lab_pin.sym} 150680 -18760 0 0 {name=p149894 lab=_73733_/A }
C {devices/lab_pin.sym} 150680 -18720 0 0 {name=p149895 lab=_73827_/B }
C {devices/lab_pin.sym} 150800 -18740 0 1 {name=p149896 lab=_73827_/X }
C {sky130_stdcells/and2_4.sym} 150740 -18740 0 0 {name=X_73827_ }
C {devices/lab_pin.sym} 150700 -18610 0 0 {name=p149897 lab=_46774_/Y }
C {devices/lab_pin.sym} 150780 -18610 0 1 {name=p149898 lab=_46775_/X }
C {sky130_stdcells/buf_2.sym} 150740 -18610 0 0 {name=X_46775_ }
C {devices/lab_pin.sym} 150660 -18510 0 0 {name=p149899 lab=_77593_/Y }
C {devices/lab_pin.sym} 150660 -18470 0 0 {name=p149900 lab=_77564_/B }
C {devices/lab_pin.sym} 150660 -18430 0 0 {name=p149901 lab=_77594_/X }
C {devices/lab_pin.sym} 150820 -18470 0 1 {name=p149902 lab=_77596_/B }
C {sky130_stdcells/o21ai_4.sym} 150740 -18470 0 0 {name=X_77595_ }
C {devices/lab_pin.sym} 150680 -18340 0 0 {name=p149903 lab=_43987_/A }
C {devices/lab_pin.sym} 150680 -18300 0 0 {name=p149904 lab=_43987_/B }
C {devices/lab_pin.sym} 150800 -18320 0 1 {name=p149905 lab=_43987_/Y }
C {sky130_stdcells/nor2_4.sym} 150740 -18320 0 0 {name=X_43987_ }
C {devices/lab_pin.sym} 150700 -18190 0 0 {name=p149906 lab=_48514_/A }
C {devices/lab_pin.sym} 150780 -18190 0 1 {name=p149907 lab=_50466_/B }
C {sky130_stdcells/buf_2.sym} 150740 -18190 0 0 {name=X_48514_ }
C {devices/lab_pin.sym} 150680 -18080 0 0 {name=p149908 lab=_79334_/A }
C {devices/lab_pin.sym} 150680 -18040 0 0 {name=p149909 lab=_79334_/B }
C {devices/lab_pin.sym} 150800 -18060 0 1 {name=p149910 lab=_79334_/X }
C {sky130_stdcells/and2_4.sym} 150740 -18060 0 0 {name=X_79334_ }
C {devices/lab_pin.sym} 150660 -17950 0 0 {name=p149911 lab=_85132_/Q }
C {devices/lab_pin.sym} 150660 -17910 0 0 {name=p149912 lab=_45709_/X }
C {devices/lab_pin.sym} 150660 -17870 0 0 {name=p149913 lab=_45651_/X }
C {devices/lab_pin.sym} 150820 -17910 0 1 {name=p149914 lab=_45726_/X }
C {sky130_stdcells/o21a_4.sym} 150740 -17910 0 0 {name=X_45726_ }
C {devices/lab_pin.sym} 150660 -17790 0 0 {name=p149915 lab=_64558_/Y }
C {devices/lab_pin.sym} 150660 -17750 0 0 {name=p149916 lab=_59655_/X }
C {devices/lab_pin.sym} 150660 -17710 0 0 {name=p149917 lab=_64559_/Y }
C {devices/lab_pin.sym} 150820 -17750 0 1 {name=p149918 lab=_64560_/Y }
C {sky130_stdcells/a21oi_4.sym} 150740 -17750 0 0 {name=X_64560_ }
C {devices/lab_pin.sym} 150660 -17630 0 0 {name=p149919 lab=_76519_/X }
C {devices/lab_pin.sym} 150660 -17590 0 0 {name=p149920 lab=_76544_/Y }
C {devices/lab_pin.sym} 150660 -17550 0 0 {name=p149921 lab=_76545_/Y }
C {devices/lab_pin.sym} 150820 -17590 0 1 {name=p149922 lab=_76546_/X }
C {sky130_stdcells/a21bo_4.sym} 150740 -17590 0 0 {name=X_76546_ }
C {devices/lab_pin.sym} 150700 -17450 0 0 {name=p149923 lab=_42937_/Y }
C {devices/lab_pin.sym} 150780 -17450 0 1 {name=p149924 lab=_87642_/D }
C {sky130_stdcells/inv_2.sym} 150740 -17450 0 0 {name=X_42938_ }
C {devices/lab_pin.sym} 150680 -17360 0 0 {name=p149925 lab=_61839_/A }
C {devices/lab_pin.sym} 150680 -17320 0 0 {name=p149926 lab=_61791_/B }
C {devices/lab_pin.sym} 150680 -17280 0 0 {name=p149927 lab=_61732_/X }
C {devices/lab_pin.sym} 150680 -17240 0 0 {name=p149928 lab=_63041_/B }
C {devices/lab_pin.sym} 150800 -17300 0 1 {name=p149929 lab=_61772_/X }
C {sky130_stdcells/and4_4.sym} 150740 -17300 0 0 {name=X_61772_ }
C {devices/lab_pin.sym} 150680 -17180 0 0 {name=p149930 lab=_49500_/A }
C {devices/lab_pin.sym} 150680 -17140 0 0 {name=p149931 lab=_49500_/B }
C {devices/lab_pin.sym} 150680 -17100 0 0 {name=p149932 lab=_49493_/X }
C {devices/lab_pin.sym} 150680 -17060 0 0 {name=p149933 lab=_52709_/D }
C {devices/lab_pin.sym} 150800 -17120 0 1 {name=p149934 lab=_49494_/X }
C {sky130_stdcells/and4_4.sym} 150740 -17120 0 0 {name=X_49494_ }
C {devices/lab_pin.sym} 150660 -17000 0 0 {name=p149935 lab=_73731_/X }
C {devices/lab_pin.sym} 150660 -16960 0 0 {name=p149936 lab=_86233_/Q }
C {devices/lab_pin.sym} 150660 -16920 0 0 {name=p149937 lab=_73683_/X }
C {devices/lab_pin.sym} 150660 -16880 0 0 {name=p149938 lab=_73757_/X }
C {devices/lab_pin.sym} 150820 -16940 0 1 {name=p149939 lab=_73758_/X }
C {sky130_stdcells/a211o_4.sym} 150740 -16940 0 0 {name=X_73758_ }
C {devices/lab_pin.sym} 150680 -16800 0 0 {name=p149940 lab=_63488_/A }
C {devices/lab_pin.sym} 150680 -16760 0 0 {name=p149941 lab=_61922_/X }
C {devices/lab_pin.sym} 150800 -16780 0 1 {name=p149942 lab=_63511_/X }
C {sky130_stdcells/and2_4.sym} 150740 -16780 0 0 {name=X_63511_ }
C {devices/lab_pin.sym} 150700 -16650 0 0 {name=p149943 lab=_74403_/B }
C {devices/lab_pin.sym} 150780 -16650 0 1 {name=p149944 lab=_52137_/B }
C {sky130_stdcells/buf_2.sym} 150740 -16650 0 0 {name=X_48445_ }
C {devices/lab_pin.sym} 150700 -16530 0 0 {name=p149945 lab=_72943_/A }
C {devices/lab_pin.sym} 150780 -16530 0 1 {name=p149946 lab=_72709_/X }
C {sky130_stdcells/buf_2.sym} 150740 -16530 0 0 {name=X_72709_ }
C {devices/lab_pin.sym} 150680 -16430 0 0 {name=p149947 lab=_60722_/Y }
C {devices/lab_pin.sym} 150680 -16390 0 0 {name=p149948 lab=_59755_/A }
C {devices/lab_pin.sym} 150680 -16350 0 0 {name=p149949 lab=_60696_/Y }
C {devices/lab_pin.sym} 150800 -16390 0 1 {name=p149950 lab=_60723_/X }
C {sky130_stdcells/and3_4.sym} 150740 -16390 0 0 {name=X_60723_ }
C {devices/lab_pin.sym} 150660 -16270 0 0 {name=p149951 lab=_79258_/X }
C {devices/lab_pin.sym} 150660 -16230 0 0 {name=p149952 lab=_79260_/B }
C {devices/lab_pin.sym} 150660 -16190 0 0 {name=p149953 lab=_79264_/Y }
C {devices/lab_pin.sym} 150820 -16230 0 1 {name=p149954 lab=_79282_/A }
C {sky130_stdcells/a21boi_4.sym} 150740 -16230 0 0 {name=X_79265_ }
C {devices/lab_pin.sym} 150660 -16110 0 0 {name=p149955 lab=_45591_/X }
C {devices/lab_pin.sym} 150660 -16070 0 0 {name=p149956 lab=_61528_/A }
C {devices/lab_pin.sym} 150660 -16030 0 0 {name=p149957 lab=_45608_/X }
C {devices/lab_pin.sym} 150820 -16070 0 1 {name=p149958 lab=_45657_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -16070 0 0 {name=X_45657_ }
C {devices/lab_pin.sym} 150660 -15950 0 0 {name=p149959 lab=_64489_/Y }
C {devices/lab_pin.sym} 150660 -15910 0 0 {name=p149960 lab=_59655_/X }
C {devices/lab_pin.sym} 150660 -15870 0 0 {name=p149961 lab=_64490_/Y }
C {devices/lab_pin.sym} 150820 -15910 0 1 {name=p149962 lab=_84241_/D }
C {sky130_stdcells/a21oi_4.sym} 150740 -15910 0 0 {name=X_64491_ }
C {devices/lab_pin.sym} 150700 -15770 0 0 {name=p149963 lab=_76477_/A }
C {devices/lab_pin.sym} 150780 -15770 0 1 {name=p149964 lab=_76479_/B }
C {sky130_stdcells/inv_2.sym} 150740 -15770 0 0 {name=X_76477_ }
C {devices/lab_pin.sym} 150660 -15690 0 0 {name=p149965 lab=_42847_/X }
C {devices/lab_pin.sym} 150660 -15650 0 0 {name=p149966 lab=_42849_/X }
C {devices/lab_pin.sym} 150660 -15610 0 0 {name=p149967 lab=_41574_/X }
C {devices/lab_pin.sym} 150660 -15570 0 0 {name=p149968 lab=_67095_/B }
C {devices/lab_pin.sym} 150660 -15530 0 0 {name=p149969 lab=_42858_/X }
C {devices/lab_pin.sym} 150820 -15610 0 1 {name=p149970 lab=_42870_/A }
C {sky130_stdcells/o32ai_4.sym} 150740 -15610 0 0 {name=X_42869_ }
C {devices/lab_pin.sym} 150680 -15460 0 0 {name=p149971 lab=_73641_/A }
C {devices/lab_pin.sym} 150680 -15420 0 0 {name=p149972 lab=_73689_/B }
C {devices/lab_pin.sym} 150800 -15440 0 1 {name=p149973 lab=_73689_/X }
C {sky130_stdcells/and2_4.sym} 150740 -15440 0 0 {name=X_73689_ }
C {devices/lab_pin.sym} 150660 -15330 0 0 {name=p149974 lab=_66179_/X }
C {devices/lab_pin.sym} 150660 -15290 0 0 {name=p149975 lab=_66228_/Y }
C {devices/lab_pin.sym} 150660 -15250 0 0 {name=p149976 lab=_66229_/Y }
C {devices/lab_pin.sym} 150820 -15290 0 1 {name=p149977 lab=_66230_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -15290 0 0 {name=X_66230_ }
C {devices/lab_pin.sym} 150660 -15170 0 0 {name=p149978 lab=_78203_/A }
C {devices/lab_pin.sym} 150660 -15130 0 0 {name=p149979 lab=_82492_/Q }
C {devices/lab_pin.sym} 150660 -15090 0 0 {name=p149980 lab=_78215_/Y }
C {devices/lab_pin.sym} 150820 -15130 0 1 {name=p149981 lab=_78217_/B }
C {sky130_stdcells/a21oi_4.sym} 150740 -15130 0 0 {name=X_78216_ }
C {devices/lab_pin.sym} 150660 -15020 0 0 {name=p149982 lab=_40954_/Y }
C {devices/lab_pin.sym} 150660 -14980 0 0 {name=p149983 lab=_44602_/X }
C {devices/lab_pin.sym} 150660 -14940 0 0 {name=p149984 lab=_87036_/Q }
C {devices/lab_pin.sym} 150660 -14900 0 0 {name=p149985 lab=_44603_/X }
C {devices/lab_pin.sym} 150820 -14960 0 1 {name=p149986 lab=_44608_/X }
C {sky130_stdcells/a2bb2o_4.sym} 150740 -14960 0 0 {name=X_44608_ }
C {devices/lab_pin.sym} 150660 -14840 0 0 {name=p149987 lab=_61398_/B }
C {devices/lab_pin.sym} 150660 -14800 0 0 {name=p149988 lab=_63426_/X }
C {devices/lab_pin.sym} 150660 -14760 0 0 {name=p149989 lab=_63439_/X }
C {devices/lab_pin.sym} 150660 -14720 0 0 {name=p149990 lab=_63441_/X }
C {devices/lab_pin.sym} 150820 -14780 0 1 {name=p149991 lab=_63442_/X }
C {sky130_stdcells/a211o_4.sym} 150740 -14780 0 0 {name=X_63442_ }
C {devices/lab_pin.sym} 150660 -14650 0 0 {name=p149992 lab=_75427_/B }
C {devices/lab_pin.sym} 150660 -14610 0 0 {name=p149993 lab=_75427_/C }
C {devices/lab_pin.sym} 150660 -14570 0 0 {name=p149994 lab=_75423_/Y }
C {devices/lab_pin.sym} 150820 -14610 0 1 {name=p149995 lab=_75432_/C }
C {sky130_stdcells/o21ai_4.sym} 150740 -14610 0 0 {name=X_75428_ }
C {devices/lab_pin.sym} 150700 -14470 0 0 {name=p149996 lab=_74371_/A }
C {devices/lab_pin.sym} 150780 -14470 0 1 {name=p149997 lab=_52103_/A }
C {sky130_stdcells/buf_2.sym} 150740 -14470 0 0 {name=X_48376_ }
C {devices/lab_pin.sym} 150700 -14350 0 0 {name=p149998 lab=_63471_/A }
C {devices/lab_pin.sym} 150780 -14350 0 1 {name=p149999 lab=_60654_/X }
C {sky130_stdcells/buf_2.sym} 150740 -14350 0 0 {name=X_60654_ }
C {devices/lab_pin.sym} 150700 -14230 0 0 {name=p150000 lab=_79198_/B }
C {devices/lab_pin.sym} 150780 -14230 0 1 {name=p150001 lab=_79196_/Y }
C {sky130_stdcells/inv_2.sym} 150740 -14230 0 0 {name=X_79196_ }
C {devices/lab_pin.sym} 150660 -14130 0 0 {name=p150002 lab=_55499_/B }
C {devices/lab_pin.sym} 150660 -14090 0 0 {name=p150003 lab=_45507_/X }
C {devices/lab_pin.sym} 150660 -14050 0 0 {name=p150004 lab=_45429_/X }
C {devices/lab_pin.sym} 150820 -14090 0 1 {name=p150005 lab=_45588_/X }
C {sky130_stdcells/o21a_4.sym} 150740 -14090 0 0 {name=X_45588_ }
C {devices/lab_pin.sym} 150700 -13950 0 0 {name=p150006 lab=_47140_/A }
C {devices/lab_pin.sym} 150780 -13950 0 1 {name=p150007 lab=_47370_/C }
C {sky130_stdcells/buf_2.sym} 150740 -13950 0 0 {name=X_47327_ }
C {devices/lab_pin.sym} 150680 -13850 0 0 {name=p150008 lab=_66453_/A }
C {devices/lab_pin.sym} 150680 -13810 0 0 {name=p150009 lab=_66385_/B }
C {devices/lab_pin.sym} 150680 -13770 0 0 {name=p150010 lab=_66160_/X }
C {devices/lab_pin.sym} 150800 -13810 0 1 {name=p150011 lab=_66161_/Y }
C {sky130_stdcells/nand3_4.sym} 150740 -13810 0 0 {name=X_66161_ }
C {devices/lab_pin.sym} 150680 -13680 0 0 {name=p150012 lab=_78137_/Y }
C {devices/lab_pin.sym} 150680 -13640 0 0 {name=p150013 lab=_78146_/X }
C {devices/lab_pin.sym} 150800 -13660 0 1 {name=p150014 lab=_78147_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -13660 0 0 {name=X_78147_ }
C {devices/lab_pin.sym} 150660 -13560 0 0 {name=p150015 lab=_58409_/A }
C {devices/lab_pin.sym} 150660 -13520 0 0 {name=p150016 lab=_63370_/X }
C {devices/lab_pin.sym} 150660 -13480 0 0 {name=p150017 lab=_61338_/A }
C {devices/lab_pin.sym} 150660 -13440 0 0 {name=p150018 lab=_63372_/X }
C {devices/lab_pin.sym} 150820 -13500 0 1 {name=p150019 lab=_63373_/X }
C {sky130_stdcells/a2bb2o_4.sym} 150740 -13500 0 0 {name=X_63373_ }
C {devices/lab_pin.sym} 150700 -13350 0 0 {name=p150020 lab=_44539_/A }
C {devices/lab_pin.sym} 150780 -13350 0 1 {name=p150021 lab=_44539_/Y }
C {sky130_stdcells/inv_2.sym} 150740 -13350 0 0 {name=X_44539_ }
C {devices/lab_pin.sym} 150660 -13250 0 0 {name=p150022 lab=_75348_/Y }
C {devices/lab_pin.sym} 150660 -13210 0 0 {name=p150023 lab=_75349_/Y }
C {devices/lab_pin.sym} 150660 -13170 0 0 {name=p150024 lab=_75351_/A }
C {devices/lab_pin.sym} 150820 -13210 0 1 {name=p150025 lab=_75359_/X }
C {sky130_stdcells/o21a_4.sym} 150740 -13210 0 0 {name=X_75359_ }
C {devices/lab_pin.sym} 150660 -13110 0 0 {name=p150026 lab=_60583_/Y }
C {devices/lab_pin.sym} 150660 -13070 0 0 {name=p150027 lab=_60444_/Y }
C {devices/lab_pin.sym} 150660 -13030 0 0 {name=p150028 lab=_60584_/Y }
C {devices/lab_pin.sym} 150660 -12990 0 0 {name=p150029 lab=_79134_/A }
C {devices/lab_pin.sym} 150660 -12950 0 0 {name=p150030 lab=_60341_/X }
C {devices/lab_pin.sym} 150820 -13030 0 1 {name=p150031 lab=_60585_/X }
C {sky130_stdcells/o32a_4.sym} 150740 -13030 0 0 {name=X_60585_ }
C {devices/lab_pin.sym} 150660 -12890 0 0 {name=p150032 lab=_60151_/X }
C {devices/lab_pin.sym} 150660 -12850 0 0 {name=p150033 lab=_65102_/Y }
C {devices/lab_pin.sym} 150660 -12810 0 0 {name=p150034 lab=_65111_/Y }
C {devices/lab_pin.sym} 150820 -12850 0 1 {name=p150035 lab=_65112_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -12850 0 0 {name=X_65112_ }
C {devices/lab_pin.sym} 150680 -12740 0 0 {name=p150036 lab=_62597_/B }
C {devices/lab_pin.sym} 150680 -12700 0 0 {name=p150037 lab=_61844_/X }
C {devices/lab_pin.sym} 150680 -12660 0 0 {name=p150038 lab=_62237_/X }
C {devices/lab_pin.sym} 150680 -12620 0 0 {name=p150039 lab=_62280_/D }
C {devices/lab_pin.sym} 150800 -12680 0 1 {name=p150040 lab=_62324_/X }
C {sky130_stdcells/and4_4.sym} 150740 -12680 0 0 {name=X_62324_ }
C {devices/lab_pin.sym} 150660 -12550 0 0 {name=p150041 lab=_47254_/Y }
C {devices/lab_pin.sym} 150660 -12510 0 0 {name=p150042 lab=_47224_/X }
C {devices/lab_pin.sym} 150660 -12470 0 0 {name=p150043 lab=_47257_/X }
C {devices/lab_pin.sym} 150820 -12510 0 1 {name=p150044 lab=_86654_/D }
C {sky130_stdcells/a21oi_4.sym} 150740 -12510 0 0 {name=X_47258_ }
C {devices/lab_pin.sym} 150680 -12390 0 0 {name=p150045 lab=_66164_/A }
C {devices/lab_pin.sym} 150680 -12350 0 0 {name=p150046 lab=_65888_/B }
C {devices/lab_pin.sym} 150680 -12310 0 0 {name=p150047 lab=_66092_/C }
C {devices/lab_pin.sym} 150800 -12350 0 1 {name=p150048 lab=_66092_/Y }
C {sky130_stdcells/nor3_4.sym} 150740 -12350 0 0 {name=X_66092_ }
C {devices/lab_pin.sym} 150680 -12220 0 0 {name=p150049 lab=_60700_/C }
C {devices/lab_pin.sym} 150680 -12180 0 0 {name=p150050 lab=_78078_/B }
C {devices/lab_pin.sym} 150800 -12200 0 1 {name=p150051 lab=_78078_/X }
C {sky130_stdcells/xor2_4.sym} 150740 -12200 0 0 {name=X_78078_ }
C {devices/lab_pin.sym} 150700 -12070 0 0 {name=p150052 lab=_44244_/A }
C {devices/lab_pin.sym} 150780 -12070 0 1 {name=p150053 lab=_46210_/A }
C {sky130_stdcells/buf_2.sym} 150740 -12070 0 0 {name=X_46209_ }
C {devices/lab_pin.sym} 150660 -11970 0 0 {name=p150054 lab=_64915_/X }
C {devices/lab_pin.sym} 150660 -11930 0 0 {name=p150055 lab=_65031_/Y }
C {devices/lab_pin.sym} 150660 -11890 0 0 {name=p150056 lab=_65042_/Y }
C {devices/lab_pin.sym} 150820 -11930 0 1 {name=p150057 lab=_65043_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -11930 0 0 {name=X_65043_ }
C {devices/lab_pin.sym} 150680 -11800 0 0 {name=p150058 lab=_57804_/A }
C {devices/lab_pin.sym} 150680 -11760 0 0 {name=p150059 lab=_43741_/Y }
C {devices/lab_pin.sym} 150800 -11780 0 1 {name=p150060 lab=_69920_/Y }
C {sky130_stdcells/nor2_4.sym} 150740 -11780 0 0 {name=X_69920_ }
C {devices/lab_pin.sym} 150680 -11660 0 0 {name=p150061 lab=_77036_/A }
C {devices/lab_pin.sym} 150680 -11620 0 0 {name=p150062 lab=_77036_/B }
C {devices/lab_pin.sym} 150800 -11640 0 1 {name=p150063 lab=_77034_/C }
C {sky130_stdcells/xor2_4.sym} 150740 -11640 0 0 {name=X_77029_ }
C {devices/lab_pin.sym} 150660 -11530 0 0 {name=p150064 lab=_62252_/Y }
C {devices/lab_pin.sym} 150660 -11490 0 0 {name=p150065 lab=_62253_/X }
C {devices/lab_pin.sym} 150660 -11450 0 0 {name=p150066 lab=_62254_/Y }
C {devices/lab_pin.sym} 150820 -11490 0 1 {name=p150067 lab=_62255_/Y }
C {sky130_stdcells/a21oi_4.sym} 150740 -11490 0 0 {name=X_62255_ }
C {devices/lab_pin.sym} 150700 -11350 0 0 {name=p150068 lab=_47189_/A }
C {devices/lab_pin.sym} 150780 -11350 0 1 {name=p150069 lab=_51214_/D }
C {sky130_stdcells/buf_2.sym} 150740 -11350 0 0 {name=X_47189_ }
C {devices/lab_pin.sym} 150700 -11230 0 0 {name=p150070 lab=_64274_/A }
C {devices/lab_pin.sym} 150780 -11230 0 1 {name=p150071 lab=_64223_/C }
C {sky130_stdcells/buf_2.sym} 150740 -11230 0 0 {name=X_61206_ }
C {devices/lab_pin.sym} 150680 -11120 0 0 {name=p150072 lab=_60103_/C }
C {devices/lab_pin.sym} 150680 -11080 0 0 {name=p150073 lab=_80040_/B }
C {devices/lab_pin.sym} 150800 -11100 0 1 {name=p150074 lab=_80046_/B }
C {sky130_stdcells/xor2_4.sym} 150740 -11100 0 0 {name=X_80040_ }
C {devices/lab_pin.sym} 150660 -11000 0 0 {name=p150075 lab=_42036_/A }
C {devices/lab_pin.sym} 150660 -10960 0 0 {name=p150076 lab=_69582_/X }
C {devices/lab_pin.sym} 150660 -10920 0 0 {name=p150077 lab=_69567_/X }
C {devices/lab_pin.sym} 150660 -10880 0 0 {name=p150078 lab=_69850_/Y }
C {devices/lab_pin.sym} 150820 -10940 0 1 {name=p150079 lab=_69851_/X }
C {sky130_stdcells/a211o_4.sym} 150740 -10940 0 0 {name=X_69851_ }
C {devices/lab_pin.sym} 150700 -10790 0 0 {name=p150080 lab=_62186_/A }
C {devices/lab_pin.sym} 150780 -10790 0 1 {name=p150081 lab=_62186_/X }
C {sky130_stdcells/buf_2.sym} 150740 -10790 0 0 {name=X_62186_ }
C {devices/lab_pin.sym} 150680 -10680 0 0 {name=p150082 lab=_69735_/A }
C {devices/lab_pin.sym} 150680 -10640 0 0 {name=p150083 lab=_68802_/B }
C {devices/lab_pin.sym} 150800 -10660 0 1 {name=p150084 lab=_68802_/Y }
C {sky130_stdcells/nor2_4.sym} 150740 -10660 0 0 {name=X_68802_ }
C {devices/lab_pin.sym} 150700 -10530 0 0 {name=p150085 lab=_72543_/A }
C {devices/lab_pin.sym} 150780 -10530 0 1 {name=p150086 lab=_61165_/A }
C {sky130_stdcells/buf_2.sym} 150740 -10530 0 0 {name=X_61137_ }
C {devices/lab_pin.sym} 150660 -10430 0 0 {name=p150087 lab=_69778_/X }
C {devices/lab_pin.sym} 150660 -10390 0 0 {name=p150088 lab=_69781_/X }
C {devices/lab_pin.sym} 150660 -10350 0 0 {name=p150089 lab=_69768_/X }
C {devices/lab_pin.sym} 150820 -10390 0 1 {name=p150090 lab=_69785_/A }
C {sky130_stdcells/a21o_4.sym} 150740 -10390 0 0 {name=X_69782_ }
C {devices/lab_pin.sym} 150700 -10250 0 0 {name=p150091 lab=_66758_/X }
C {devices/lab_pin.sym} 150780 -10250 0 1 {name=p150092 lab=_66994_/X }
C {sky130_stdcells/buf_2.sym} 150740 -10250 0 0 {name=X_66994_ }
C {devices/lab_pin.sym} 150660 -10160 0 0 {name=p150093 lab=_73895_/A }
C {devices/lab_pin.sym} 150660 -10120 0 0 {name=p150094 lab=_68626_/X }
C {devices/lab_pin.sym} 150660 -10080 0 0 {name=p150095 lab=_68731_/X }
C {devices/lab_pin.sym} 150660 -10040 0 0 {name=p150096 lab=_68732_/Y }
C {devices/lab_pin.sym} 150820 -10100 0 1 {name=p150097 lab=_68733_/X }
C {sky130_stdcells/a211o_4.sym} 150740 -10100 0 0 {name=X_68733_ }
C {devices/lab_pin.sym} 150680 -9960 0 0 {name=p150098 lab=_65932_/A }
C {devices/lab_pin.sym} 150680 -9920 0 0 {name=p150099 lab=_73636_/B }
C {devices/lab_pin.sym} 150800 -9940 0 1 {name=p150100 lab=_65945_/X }
C {sky130_stdcells/and2_4.sym} 150740 -9940 0 0 {name=X_65945_ }
C {devices/lab_pin.sym} 150680 -9820 0 0 {name=p150101 lab=_61066_/Y }
C {devices/lab_pin.sym} 150680 -9780 0 0 {name=p150102 lab=_61112_/A }
C {devices/lab_pin.sym} 150800 -9800 0 1 {name=p150103 lab=_64361_/A }
C {sky130_stdcells/and2_4.sym} 150740 -9800 0 0 {name=X_61068_ }
C {devices/lab_pin.sym} 150650 -9670 0 0 {name=p150104 lab=_81990_/CLK }
C {devices/lab_pin.sym} 150650 -9650 0 0 {name=p150105 lab=_81991_/D }
C {devices/lab_pin.sym} 150830 -9670 0 1 {name=p150106 lab=_77036_/A }
C {sky130_stdcells/dfxtp_4.sym} 150740 -9660 0 0 {name=X_81991_ }
C {devices/lab_pin.sym} 150680 -9540 0 0 {name=p150107 lab=_52910_/A }
C {devices/lab_pin.sym} 150680 -9500 0 0 {name=p150108 lab=_47195_/X }
C {devices/lab_pin.sym} 150800 -9520 0 1 {name=p150109 lab=_52910_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -9520 0 0 {name=X_52910_ }
C {devices/lab_pin.sym} 150660 -9410 0 0 {name=p150110 lab=_60079_/B }
C {devices/lab_pin.sym} 150660 -9370 0 0 {name=p150111 lab=_59922_/C }
C {devices/lab_pin.sym} 150660 -9330 0 0 {name=p150112 lab=_62556_/A }
C {devices/lab_pin.sym} 150820 -9370 0 1 {name=p150113 lab=_60019_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -9370 0 0 {name=X_60019_ }
C {devices/lab_pin.sym} 150650 -9230 0 0 {name=p150114 lab=_84930_/CLK }
C {devices/lab_pin.sym} 150650 -9210 0 0 {name=p150115 lab=_70659_/Y }
C {devices/lab_pin.sym} 150830 -9230 0 1 {name=p150116 lab=_83730_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -9220 0 0 {name=X_83730_ }
C {devices/lab_pin.sym} 150650 -9090 0 0 {name=p150117 lab=_80818_/CLK }
C {devices/lab_pin.sym} 150650 -9070 0 0 {name=p150118 lab=_80986_/Q }
C {devices/lab_pin.sym} 150830 -9090 0 1 {name=p150119 lab=_74935_/A }
C {sky130_stdcells/dfxtp_4.sym} 150740 -9080 0 0 {name=X_80942_ }
C {devices/lab_pin.sym} 150660 -8970 0 0 {name=p150120 lab=_80822_/D }
C {devices/lab_pin.sym} 150660 -8930 0 0 {name=p150121 lab=_68586_/X }
C {devices/lab_pin.sym} 150660 -8890 0 0 {name=p150122 lab=_68663_/X }
C {devices/lab_pin.sym} 150820 -8930 0 1 {name=p150123 lab=_83966_/D }
C {sky130_stdcells/a21bo_4.sym} 150740 -8930 0 0 {name=X_68664_ }
C {devices/lab_pin.sym} 150700 -8790 0 0 {name=p150124 lab=clkbuf_7_93_0_CLK/A }
C {devices/lab_pin.sym} 150780 -8790 0 1 {name=p150125 lab=clkbuf_7_93_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 150740 -8790 0 0 {name=Xclkbuf_7_93_0_CLK }
C {devices/lab_pin.sym} 150680 -8680 0 0 {name=p150126 lab=_53871_/X }
C {devices/lab_pin.sym} 150680 -8640 0 0 {name=p150127 lab=_49106_/Y }
C {devices/lab_pin.sym} 150800 -8660 0 1 {name=p150128 lab=_53890_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -8660 0 0 {name=X_53890_ }
C {devices/lab_pin.sym} 150700 -8530 0 0 {name=p150129 lab=_65118_/A }
C {devices/lab_pin.sym} 150780 -8530 0 1 {name=p150130 lab=_65876_/X }
C {sky130_stdcells/buf_2.sym} 150740 -8530 0 0 {name=X_65876_ }
C {devices/lab_pin.sym} 150700 -8410 0 0 {name=p150131 lab=_66554_/X }
C {devices/lab_pin.sym} 150780 -8410 0 1 {name=p150132 lab=_67615_/X }
C {sky130_stdcells/buf_2.sym} 150740 -8410 0 0 {name=X_67615_ }
C {devices/lab_pin.sym} 150680 -8320 0 0 {name=p150133 lab=_52853_/A }
C {devices/lab_pin.sym} 150680 -8280 0 0 {name=p150134 lab=_52831_/B }
C {devices/lab_pin.sym} 150680 -8240 0 0 {name=p150135 lab=_52818_/C }
C {devices/lab_pin.sym} 150680 -8200 0 0 {name=p150136 lab=_52841_/D }
C {devices/lab_pin.sym} 150800 -8260 0 1 {name=p150137 lab=_52841_/X }
C {sky130_stdcells/and4_4.sym} 150740 -8260 0 0 {name=X_52841_ }
C {devices/lab_pin.sym} 150660 -8140 0 0 {name=p150138 lab=_64752_/X }
C {devices/lab_pin.sym} 150660 -8100 0 0 {name=p150139 lab=_86169_/Q }
C {devices/lab_pin.sym} 150660 -8060 0 0 {name=p150140 lab=_64716_/X }
C {devices/lab_pin.sym} 150660 -8020 0 0 {name=p150141 lab=_64826_/X }
C {devices/lab_pin.sym} 150820 -8080 0 1 {name=p150142 lab=_64827_/X }
C {sky130_stdcells/a211o_4.sym} 150740 -8080 0 0 {name=X_64827_ }
C {devices/lab_pin.sym} 150650 -7930 0 0 {name=p150143 lab=_83663_/CLK }
C {devices/lab_pin.sym} 150650 -7910 0 0 {name=p150144 lab=_83661_/D }
C {devices/lab_pin.sym} 150830 -7930 0 1 {name=p150145 lab=_83661_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -7920 0 0 {name=X_83661_ }
C {devices/lab_pin.sym} 150650 -7790 0 0 {name=p150146 lab=_80746_/CLK }
C {devices/lab_pin.sym} 150650 -7770 0 0 {name=p150147 lab=_75635_/B }
C {devices/lab_pin.sym} 150830 -7790 0 1 {name=p150148 lab=_80873_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -7780 0 0 {name=X_80873_ }
C {devices/lab_pin.sym} 150680 -7660 0 0 {name=p150149 lab=_68444_/A }
C {devices/lab_pin.sym} 150680 -7620 0 0 {name=p150150 lab=_68595_/B }
C {devices/lab_pin.sym} 150800 -7640 0 1 {name=p150151 lab=_68595_/X }
C {sky130_stdcells/and2_4.sym} 150740 -7640 0 0 {name=X_68595_ }
C {devices/lab_pin.sym} 150650 -7510 0 0 {name=p150152 lab=_83745_/CLK }
C {devices/lab_pin.sym} 150650 -7490 0 0 {name=p150153 lab=_54668_/Y }
C {devices/lab_pin.sym} 150830 -7510 0 1 {name=p150154 lab=_85400_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -7500 0 0 {name=X_85400_ }
C {devices/lab_pin.sym} 150650 -7370 0 0 {name=p150155 lab=_82518_/CLK }
C {devices/lab_pin.sym} 150650 -7350 0 0 {name=p150156 lab=_78975_/B }
C {devices/lab_pin.sym} 150830 -7370 0 1 {name=p150157 lab=_82612_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -7360 0 0 {name=X_82612_ }
C {devices/lab_pin.sym} 150680 -7240 0 0 {name=p150158 lab=_55475_/X }
C {devices/lab_pin.sym} 150680 -7200 0 0 {name=p150159 lab=_45488_/Y }
C {devices/lab_pin.sym} 150800 -7220 0 1 {name=p150160 lab=_55560_/Y }
C {sky130_stdcells/nor2_4.sym} 150740 -7220 0 0 {name=X_55560_ }
C {devices/lab_pin.sym} 150660 -7120 0 0 {name=p150161 lab=_87978_/Q }
C {devices/lab_pin.sym} 150660 -7080 0 0 {name=p150162 lab=_67473_/X }
C {devices/lab_pin.sym} 150660 -7040 0 0 {name=p150163 lab=_67524_/X }
C {devices/lab_pin.sym} 150660 -7000 0 0 {name=p150164 lab=_67545_/X }
C {devices/lab_pin.sym} 150820 -7060 0 1 {name=p150165 lab=_67546_/X }
C {sky130_stdcells/a211o_4.sym} 150740 -7060 0 0 {name=X_67546_ }
C {devices/lab_pin.sym} 150650 -6910 0 0 {name=p150166 lab=_86381_/CLK }
C {devices/lab_pin.sym} 150650 -6890 0 0 {name=p150167 lab=_49480_/Y }
C {devices/lab_pin.sym} 150830 -6910 0 1 {name=p150168 lab=_58830_/B }
C {sky130_stdcells/dfxtp_4.sym} 150740 -6900 0 0 {name=X_86380_ }
C {devices/lab_pin.sym} 150660 -6790 0 0 {name=p150169 lab=_52769_/Y }
C {devices/lab_pin.sym} 150660 -6750 0 0 {name=p150170 lab=_52755_/X }
C {devices/lab_pin.sym} 150660 -6710 0 0 {name=p150171 lab=_52771_/X }
C {devices/lab_pin.sym} 150820 -6750 0 1 {name=p150172 lab=_52772_/Y }
C {sky130_stdcells/a21oi_4.sym} 150740 -6750 0 0 {name=X_52772_ }
C {devices/lab_pin.sym} 150700 -6610 0 0 {name=p150173 lab=_45926_/X }
C {devices/lab_pin.sym} 150780 -6610 0 1 {name=p150174 lab=_64758_/X }
C {sky130_stdcells/buf_2.sym} 150740 -6610 0 0 {name=X_64758_ }
C {devices/lab_pin.sym} 150650 -6490 0 0 {name=p150175 lab=_83589_/CLK }
C {devices/lab_pin.sym} 150650 -6470 0 0 {name=p150176 lab=_83592_/D }
C {devices/lab_pin.sym} 150830 -6490 0 1 {name=p150177 lab=_83592_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -6480 0 0 {name=X_83592_ }
C {devices/lab_pin.sym} 150700 -6350 0 0 {name=p150178 lab=_54034_/A }
C {devices/lab_pin.sym} 150780 -6350 0 1 {name=p150179 lab=_54540_/A }
C {sky130_stdcells/buf_2.sym} 150740 -6350 0 0 {name=X_54511_ }
C {devices/lab_pin.sym} 150650 -6230 0 0 {name=p150180 lab=_85332_/CLK }
C {devices/lab_pin.sym} 150650 -6210 0 0 {name=p150181 lab=_85331_/D }
C {devices/lab_pin.sym} 150830 -6230 0 1 {name=p150182 lab=_85331_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -6220 0 0 {name=X_85331_ }
C {devices/lab_pin.sym} 150660 -6110 0 0 {name=p150183 lab=_51718_/Y }
C {devices/lab_pin.sym} 150660 -6070 0 0 {name=p150184 lab=_51719_/X }
C {devices/lab_pin.sym} 150660 -6030 0 0 {name=p150185 lab=_51722_/X }
C {devices/lab_pin.sym} 150820 -6070 0 1 {name=p150186 lab=_85958_/D }
C {sky130_stdcells/a21oi_4.sym} 150740 -6070 0 0 {name=X_51723_ }
C {devices/lab_pin.sym} 150660 -5970 0 0 {name=p150187 lab=_63368_/A }
C {devices/lab_pin.sym} 150660 -5930 0 0 {name=p150188 lab=_63703_/X }
C {devices/lab_pin.sym} 150660 -5890 0 0 {name=p150189 lab=_63704_/X }
C {devices/lab_pin.sym} 150660 -5850 0 0 {name=p150190 lab=_63707_/X }
C {devices/lab_pin.sym} 150660 -5810 0 0 {name=p150191 lab=_63708_/Y }
C {devices/lab_pin.sym} 150820 -5890 0 1 {name=p150192 lab=_63709_/Y }
C {sky130_stdcells/o41ai_4.sym} 150740 -5890 0 0 {name=X_63709_ }
C {devices/lab_pin.sym} 150650 -5730 0 0 {name=p150193 lab=_82553_/CLK }
C {devices/lab_pin.sym} 150650 -5710 0 0 {name=p150194 lab=_82543_/D }
C {devices/lab_pin.sym} 150830 -5730 0 1 {name=p150195 lab=_82543_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -5720 0 0 {name=X_82543_ }
C {devices/lab_pin.sym} 150680 -5600 0 0 {name=p150196 lab=_55491_/A }
C {devices/lab_pin.sym} 150680 -5560 0 0 {name=p150197 lab=_55490_/X }
C {devices/lab_pin.sym} 150800 -5580 0 1 {name=p150198 lab=_55491_/X }
C {sky130_stdcells/and2_4.sym} 150740 -5580 0 0 {name=X_55491_ }
C {devices/lab_pin.sym} 150700 -5450 0 0 {name=p150199 lab=_67359_/X }
C {devices/lab_pin.sym} 150780 -5450 0 1 {name=p150200 lab=_67477_/X }
C {sky130_stdcells/buf_2.sym} 150740 -5450 0 0 {name=X_67477_ }
C {devices/lab_pin.sym} 150680 -5350 0 0 {name=p150201 lab=_64689_/A }
C {devices/lab_pin.sym} 150680 -5310 0 0 {name=p150202 lab=_64741_/B }
C {devices/lab_pin.sym} 150680 -5270 0 0 {name=p150203 lab=_64688_/Y }
C {devices/lab_pin.sym} 150800 -5310 0 1 {name=p150204 lab=_64689_/Y }
C {sky130_stdcells/nor3_4.sym} 150740 -5310 0 0 {name=X_64689_ }
C {devices/lab_pin.sym} 150660 -5210 0 0 {name=p150205 lab=_72484_/A }
C {devices/lab_pin.sym} 150660 -5170 0 0 {name=p150206 lab=_72710_/A }
C {devices/lab_pin.sym} 150660 -5130 0 0 {name=p150207 lab=_46173_/X }
C {devices/lab_pin.sym} 150660 -5090 0 0 {name=p150208 lab=_57223_/D }
C {devices/lab_pin.sym} 150660 -5060 0 0 {name=p150209 lab=_56923_/Y }
C {devices/lab_pin.sym} 150820 -5130 0 1 {name=p150210 lab=_57230_/Y }
C {sky130_stdcells/a41oi_4.sym} 150740 -5130 0 0 {name=X_57230_ }
C {devices/lab_pin.sym} 150700 -4970 0 0 {name=p150211 lab=_69146_/A }
C {devices/lab_pin.sym} 150780 -4970 0 1 {name=p150212 lab=_69216_/X }
C {sky130_stdcells/buf_2.sym} 150740 -4970 0 0 {name=X_69216_ }
C {devices/lab_pin.sym} 150650 -4850 0 0 {name=p150213 lab=_88084_/CLK }
C {devices/lab_pin.sym} 150650 -4830 0 0 {name=p150214 lab=_88050_/D }
C {devices/lab_pin.sym} 150830 -4850 0 1 {name=p150215 lab=_88050_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -4840 0 0 {name=X_88050_ }
C {devices/lab_pin.sym} 150680 -4720 0 0 {name=p150216 lab=_54446_/A }
C {devices/lab_pin.sym} 150680 -4680 0 0 {name=p150217 lab=_54442_/B }
C {devices/lab_pin.sym} 150800 -4700 0 1 {name=p150218 lab=_54442_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -4700 0 0 {name=X_54442_ }
C {devices/lab_pin.sym} 150700 -4570 0 0 {name=p150219 lab=_84125_/Q }
C {devices/lab_pin.sym} 150780 -4570 0 1 {name=p150220 lab=_66429_/C }
C {sky130_stdcells/inv_2.sym} 150740 -4570 0 0 {name=X_66428_ }
C {devices/lab_pin.sym} 150650 -4450 0 0 {name=p150221 lab=_85198_/CLK }
C {devices/lab_pin.sym} 150650 -4430 0 0 {name=p150222 lab=_85262_/D }
C {devices/lab_pin.sym} 150830 -4450 0 1 {name=p150223 lab=_56243_/C }
C {sky130_stdcells/dfxtp_4.sym} 150740 -4440 0 0 {name=X_85262_ }
C {devices/lab_pin.sym} 150660 -4330 0 0 {name=p150224 lab=_85970_/Q }
C {devices/lab_pin.sym} 150660 -4290 0 0 {name=p150225 lab=_51647_/X }
C {devices/lab_pin.sym} 150660 -4250 0 0 {name=p150226 lab=_51653_/Y }
C {devices/lab_pin.sym} 150820 -4290 0 1 {name=p150227 lab=_51654_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -4290 0 0 {name=X_51654_ }
C {devices/lab_pin.sym} 150650 -4150 0 0 {name=p150228 lab=_82595_/CLK }
C {devices/lab_pin.sym} 150650 -4130 0 0 {name=p150229 lab=_82474_/D }
C {devices/lab_pin.sym} 150830 -4150 0 1 {name=p150230 lab=_78083_/B }
C {sky130_stdcells/dfxtp_4.sym} 150740 -4140 0 0 {name=X_82474_ }
C {devices/lab_pin.sym} 150650 -4010 0 0 {name=p150231 lab=_83139_/CLK }
C {devices/lab_pin.sym} 150650 -3990 0 0 {name=p150232 lab=_44685_/Y }
C {devices/lab_pin.sym} 150830 -4010 0 1 {name=p150233 lab=_87001_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -4000 0 0 {name=X_87001_ }
C {devices/lab_pin.sym} 150650 -3870 0 0 {name=p150234 lab=_84228_/CLK }
C {devices/lab_pin.sym} 150650 -3850 0 0 {name=p150235 lab=_65143_/X }
C {devices/lab_pin.sym} 150830 -3870 0 1 {name=p150236 lab=_84213_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -3860 0 0 {name=X_84213_ }
C {devices/lab_pin.sym} 150680 -3740 0 0 {name=p150237 lab=_50580_/A }
C {devices/lab_pin.sym} 150680 -3700 0 0 {name=p150238 lab=_71998_/B }
C {devices/lab_pin.sym} 150800 -3720 0 1 {name=p150239 lab=_50605_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -3720 0 0 {name=X_50605_ }
C {devices/lab_pin.sym} 150660 -3610 0 0 {name=p150240 lab=_55320_/B }
C {devices/lab_pin.sym} 150660 -3570 0 0 {name=p150241 lab=_57106_/X }
C {devices/lab_pin.sym} 150660 -3530 0 0 {name=p150242 lab=_57160_/Y }
C {devices/lab_pin.sym} 150820 -3570 0 1 {name=p150243 lab=_57161_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -3570 0 0 {name=X_57161_ }
C {devices/lab_pin.sym} 150650 -3430 0 0 {name=p150244 lab=_81333_/CLK }
C {devices/lab_pin.sym} 150650 -3410 0 0 {name=p150245 lab=_81425_/D }
C {devices/lab_pin.sym} 150830 -3430 0 1 {name=p150246 lab=_76027_/B }
C {sky130_stdcells/dfxtp_4.sym} 150740 -3420 0 0 {name=X_81425_ }
C {devices/lab_pin.sym} 150680 -3300 0 0 {name=p150247 lab=_69067_/A }
C {devices/lab_pin.sym} 150680 -3260 0 0 {name=p150248 lab=_69147_/B }
C {devices/lab_pin.sym} 150800 -3280 0 1 {name=p150249 lab=_69147_/X }
C {sky130_stdcells/and2_4.sym} 150740 -3280 0 0 {name=X_69147_ }
C {devices/lab_pin.sym} 150680 -3180 0 0 {name=p150250 lab=_54395_/A }
C {devices/lab_pin.sym} 150680 -3140 0 0 {name=p150251 lab=_54362_/B }
C {devices/lab_pin.sym} 150680 -3100 0 0 {name=p150252 lab=_54395_/C }
C {devices/lab_pin.sym} 150680 -3060 0 0 {name=p150253 lab=_46800_/Y }
C {devices/lab_pin.sym} 150800 -3120 0 1 {name=p150254 lab=_54373_/X }
C {sky130_stdcells/and4_4.sym} 150740 -3120 0 0 {name=X_54373_ }
C {devices/lab_pin.sym} 150680 -2990 0 0 {name=p150255 lab=_66318_/X }
C {devices/lab_pin.sym} 150680 -2950 0 0 {name=p150256 lab=_66319_/B }
C {devices/lab_pin.sym} 150680 -2910 0 0 {name=p150257 lab=_84138_/Q }
C {devices/lab_pin.sym} 150800 -2950 0 1 {name=p150258 lab=_66359_/X }
C {sky130_stdcells/and3_4.sym} 150740 -2950 0 0 {name=X_66359_ }
C {devices/lab_pin.sym} 150650 -2810 0 0 {name=p150259 lab=_85192_/CLK }
C {devices/lab_pin.sym} 150650 -2790 0 0 {name=p150260 lab=_56441_/Y }
C {devices/lab_pin.sym} 150830 -2810 0 1 {name=p150261 lab=_85193_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -2800 0 0 {name=X_85193_ }
C {devices/lab_pin.sym} 150700 -2670 0 0 {name=p150262 lab=_51639_/A }
C {devices/lab_pin.sym} 150780 -2670 0 1 {name=p150263 lab=_51585_/X }
C {sky130_stdcells/buf_2.sym} 150740 -2670 0 0 {name=X_51585_ }
C {devices/lab_pin.sym} 150700 -2550 0 0 {name=p150264 lab=clkbuf_7_31_0_CLK/A }
C {devices/lab_pin.sym} 150780 -2550 0 1 {name=p150265 lab=clkbuf_8_63_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 150740 -2550 0 0 {name=Xclkbuf_7_31_0_CLK }
C {devices/lab_pin.sym} 150700 -2430 0 0 {name=p150266 lab=_56142_/A }
C {devices/lab_pin.sym} 150780 -2430 0 1 {name=p150267 lab=_56112_/X }
C {sky130_stdcells/buf_2.sym} 150740 -2430 0 0 {name=X_56112_ }
C {devices/lab_pin.sym} 150700 -2310 0 0 {name=p150268 lab=_51900_/A }
C {devices/lab_pin.sym} 150780 -2310 0 1 {name=p150269 lab=_53324_/X }
C {sky130_stdcells/buf_2.sym} 150740 -2310 0 0 {name=X_53324_ }
C {devices/lab_pin.sym} 150700 -2190 0 0 {name=p150270 lab=clkbuf_7_85_0_CLK/X }
C {devices/lab_pin.sym} 150780 -2190 0 1 {name=p150271 lab=clkbuf_9_343_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 150740 -2190 0 0 {name=Xclkbuf_8_171_0_CLK }
C {devices/lab_pin.sym} 150650 -2070 0 0 {name=p150272 lab=_84175_/CLK }
C {devices/lab_pin.sym} 150650 -2050 0 0 {name=p150273 lab=_84144_/D }
C {devices/lab_pin.sym} 150830 -2070 0 1 {name=p150274 lab=_84144_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -2060 0 0 {name=X_84144_ }
C {devices/lab_pin.sym} 150660 -1950 0 0 {name=p150275 lab=_86182_/Q }
C {devices/lab_pin.sym} 150660 -1910 0 0 {name=p150276 lab=_50533_/X }
C {devices/lab_pin.sym} 150660 -1870 0 0 {name=p150277 lab=_50535_/Y }
C {devices/lab_pin.sym} 150820 -1910 0 1 {name=p150278 lab=_50536_/Y }
C {sky130_stdcells/o21ai_4.sym} 150740 -1910 0 0 {name=X_50536_ }
C {devices/lab_pin.sym} 150700 -1770 0 0 {name=p150279 lab=_73198_/B }
C {devices/lab_pin.sym} 150780 -1770 0 1 {name=p150280 lab=_57092_/X }
C {sky130_stdcells/buf_2.sym} 150740 -1770 0 0 {name=X_57092_ }
C {devices/lab_pin.sym} 150650 -1650 0 0 {name=p150281 lab=_81431_/CLK }
C {devices/lab_pin.sym} 150650 -1630 0 0 {name=p150282 lab=_76749_/Y }
C {devices/lab_pin.sym} 150830 -1650 0 1 {name=p150283 lab=_81356_/Q }
C {sky130_stdcells/dfxtp_4.sym} 150740 -1640 0 0 {name=X_81356_ }
C {devices/lab_pin.sym} 150680 -1520 0 0 {name=p150284 lab=_69011_/A }
C {devices/lab_pin.sym} 150680 -1480 0 0 {name=p150285 lab=_87222_/Q }
C {devices/lab_pin.sym} 150800 -1500 0 1 {name=p150286 lab=_69078_/X }
C {sky130_stdcells/and2_4.sym} 150740 -1500 0 0 {name=X_69078_ }
C {devices/lab_pin.sym} 150680 -1380 0 0 {name=p150287 lab=_55912_/X }
C {devices/lab_pin.sym} 150680 -1340 0 0 {name=p150288 lab=_55916_/X }
C {devices/lab_pin.sym} 150800 -1360 0 1 {name=p150289 lab=_56043_/X }
C {sky130_stdcells/and2_4.sym} 150740 -1360 0 0 {name=X_56043_ }
C {devices/lab_pin.sym} 150660 -1260 0 0 {name=p150290 lab=_87958_/Q }
C {devices/lab_pin.sym} 150660 -1220 0 0 {name=p150291 lab=_68006_/X }
C {devices/lab_pin.sym} 150660 -1180 0 0 {name=p150292 lab=_67984_/X }
C {devices/lab_pin.sym} 150660 -1140 0 0 {name=p150293 lab=_68028_/X }
C {devices/lab_pin.sym} 150820 -1200 0 1 {name=p150294 lab=_68029_/X }
C {sky130_stdcells/a211o_4.sym} 150740 -1200 0 0 {name=X_68029_ }
C {devices/lab_pin.sym} 150700 -1050 0 0 {name=p150295 lab=_80310_/B }
C {devices/lab_pin.sym} 150780 -1050 0 1 {name=p150296 lab=_80308_/A }
C {sky130_stdcells/inv_2.sym} 150740 -1050 0 0 {name=X_80307_ }
C {devices/lab_pin.sym} 150680 -940 0 0 {name=p150297 lab=_53259_/A }
C {devices/lab_pin.sym} 150680 -900 0 0 {name=p150298 lab=_53255_/B }
C {devices/lab_pin.sym} 150800 -920 0 1 {name=p150299 lab=_53255_/Y }
C {sky130_stdcells/nand2_4.sym} 150740 -920 0 0 {name=X_53255_ }
C {devices/lab_pin.sym} 150650 -790 0 0 {name=p150300 lab=_84074_/CLK }
C {devices/lab_pin.sym} 150650 -770 0 0 {name=p150301 lab=_84075_/D }
C {devices/lab_pin.sym} 150830 -790 0 1 {name=p150302 lab=_80899_/D }
C {sky130_stdcells/dfxtp_4.sym} 150740 -780 0 0 {name=X_84075_ }
C {devices/lab_pin.sym} 151580 -42170 0 0 {name=p150303 lab=_86195_/Q }
C {devices/lab_pin.sym} 151580 -42130 0 0 {name=p150304 lab=_50464_/X }
C {devices/lab_pin.sym} 151580 -42090 0 0 {name=p150305 lab=_50466_/Y }
C {devices/lab_pin.sym} 151740 -42130 0 1 {name=p150306 lab=_50467_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -42130 0 0 {name=X_50467_ }
C {devices/lab_pin.sym} 151570 -41990 0 0 {name=p150307 lab=_81603_/CLK }
C {devices/lab_pin.sym} 151570 -41970 0 0 {name=p150308 lab=_76975_/X }
C {devices/lab_pin.sym} 151750 -41990 0 1 {name=p150309 lab=_81255_/D }
C {sky130_stdcells/dfxtp_4.sym} 151660 -41980 0 0 {name=X_81287_ }
C {devices/lab_pin.sym} 151600 -41860 0 0 {name=p150310 lab=_52185_/X }
C {devices/lab_pin.sym} 151600 -41820 0 0 {name=p150311 lab=_48820_/B }
C {devices/lab_pin.sym} 151720 -41840 0 1 {name=p150312 lab=_52206_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -41840 0 0 {name=X_52206_ }
C {devices/lab_pin.sym} 151580 -41730 0 0 {name=p150313 lab=_53174_/B }
C {devices/lab_pin.sym} 151580 -41690 0 0 {name=p150314 lab=_71013_/A }
C {devices/lab_pin.sym} 151580 -41650 0 0 {name=p150315 lab=_71039_/Y }
C {devices/lab_pin.sym} 151740 -41690 0 1 {name=p150316 lab=_71040_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -41690 0 0 {name=X_71040_ }
C {devices/lab_pin.sym} 151570 -41550 0 0 {name=p150317 lab=_83025_/CLK }
C {devices/lab_pin.sym} 151570 -41530 0 0 {name=p150318 lab=_83026_/D }
C {devices/lab_pin.sym} 151750 -41550 0 1 {name=p150319 lab=_83026_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -41540 0 0 {name=X_83026_ }
C {devices/lab_pin.sym} 151570 -41410 0 0 {name=p150320 lab=_87898_/CLK }
C {devices/lab_pin.sym} 151570 -41390 0 0 {name=p150321 lab=_42360_/Y }
C {devices/lab_pin.sym} 151750 -41410 0 1 {name=p150322 lab=_87903_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -41400 0 0 {name=X_87903_ }
C {devices/lab_pin.sym} 151600 -41280 0 0 {name=p150323 lab=_84951_/Q }
C {devices/lab_pin.sym} 151600 -41240 0 0 {name=p150324 lab=_65466_/C }
C {devices/lab_pin.sym} 151720 -41260 0 1 {name=p150325 lab=_80238_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -41260 0 0 {name=X_80238_ }
C {devices/lab_pin.sym} 151620 -41130 0 0 {name=p150326 lab=clkbuf_7_47_0_CLK/A }
C {devices/lab_pin.sym} 151700 -41130 0 1 {name=p150327 lab=clkbuf_8_93_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 151660 -41130 0 0 {name=Xclkbuf_7_46_0_CLK }
C {devices/lab_pin.sym} 151580 -41030 0 0 {name=p150328 lab=_53184_/Y }
C {devices/lab_pin.sym} 151580 -40990 0 0 {name=p150329 lab=_53163_/X }
C {devices/lab_pin.sym} 151580 -40950 0 0 {name=p150330 lab=_53185_/X }
C {devices/lab_pin.sym} 151740 -40990 0 1 {name=p150331 lab=_85681_/D }
C {sky130_stdcells/a21oi_4.sym} 151660 -40990 0 0 {name=X_53186_ }
C {devices/lab_pin.sym} 151600 -40860 0 0 {name=p150332 lab=_50398_/A }
C {devices/lab_pin.sym} 151600 -40820 0 0 {name=p150333 lab=_48368_/X }
C {devices/lab_pin.sym} 151720 -40840 0 1 {name=p150334 lab=_50398_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -40840 0 0 {name=X_50398_ }
C {devices/lab_pin.sym} 151620 -40710 0 0 {name=p150335 lab=clkbuf_7_93_0_CLK/X }
C {devices/lab_pin.sym} 151700 -40710 0 1 {name=p150336 lab=clkbuf_9_373_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 151660 -40710 0 0 {name=Xclkbuf_8_186_0_CLK }
C {devices/lab_pin.sym} 151620 -40590 0 0 {name=p150337 lab=_70009_/A }
C {devices/lab_pin.sym} 151700 -40590 0 1 {name=p150338 lab=_59802_/X }
C {sky130_stdcells/buf_2.sym} 151660 -40590 0 0 {name=X_59802_ }
C {devices/lab_pin.sym} 151620 -40470 0 0 {name=p150339 lab=clkbuf_9_90_0_CLK/X }
C {devices/lab_pin.sym} 151700 -40470 0 1 {name=p150340 lab=_83337_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 151660 -40470 0 0 {name=Xclkbuf_10_181_0_CLK }
C {devices/lab_pin.sym} 151600 -40360 0 0 {name=p150341 lab=_52127_/X }
C {devices/lab_pin.sym} 151600 -40320 0 0 {name=p150342 lab=_52137_/B }
C {devices/lab_pin.sym} 151720 -40340 0 1 {name=p150343 lab=_52137_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -40340 0 0 {name=X_52137_ }
C {devices/lab_pin.sym} 151570 -40210 0 0 {name=p150344 lab=_87834_/CLK }
C {devices/lab_pin.sym} 151570 -40190 0 0 {name=p150345 lab=_87834_/D }
C {devices/lab_pin.sym} 151750 -40210 0 1 {name=p150346 lab=_74143_/A }
C {sky130_stdcells/dfxtp_4.sym} 151660 -40200 0 0 {name=X_87834_ }
C {devices/lab_pin.sym} 151600 -40080 0 0 {name=p150347 lab=_80151_/Y }
C {devices/lab_pin.sym} 151600 -40040 0 0 {name=p150348 lab=_80169_/B }
C {devices/lab_pin.sym} 151720 -40060 0 1 {name=p150349 lab=_80169_/X }
C {sky130_stdcells/or2_4.sym} 151660 -40060 0 0 {name=X_80169_ }
C {devices/lab_pin.sym} 151580 -39970 0 0 {name=p150350 lab=_57989_/X }
C {devices/lab_pin.sym} 151580 -39930 0 0 {name=p150351 lab=_57991_/Y }
C {devices/lab_pin.sym} 151580 -39890 0 0 {name=p150352 lab=_57992_/Y }
C {devices/lab_pin.sym} 151580 -39850 0 0 {name=p150353 lab=_57893_/X }
C {devices/lab_pin.sym} 151580 -39810 0 0 {name=p150354 lab=_57993_/X }
C {devices/lab_pin.sym} 151740 -39890 0 1 {name=p150355 lab=_57994_/X }
C {sky130_stdcells/o32a_4.sym} 151660 -39890 0 0 {name=X_57994_ }
C {devices/lab_pin.sym} 151600 -39750 0 0 {name=p150356 lab=_59754_/A }
C {devices/lab_pin.sym} 151600 -39710 0 0 {name=p150357 lab=_59731_/Y }
C {devices/lab_pin.sym} 151600 -39670 0 0 {name=p150358 lab=_59754_/C }
C {devices/lab_pin.sym} 151720 -39710 0 1 {name=p150359 lab=_59733_/Y }
C {sky130_stdcells/nand3_4.sym} 151660 -39710 0 0 {name=X_59733_ }
C {devices/lab_pin.sym} 151580 -39600 0 0 {name=p150360 lab=_44214_/X }
C {devices/lab_pin.sym} 151580 -39560 0 0 {name=p150361 lab=_56575_/X }
C {devices/lab_pin.sym} 151580 -39520 0 0 {name=p150362 lab=_85119_/Q }
C {devices/lab_pin.sym} 151580 -39480 0 0 {name=p150363 lab=_56943_/X }
C {devices/lab_pin.sym} 151740 -39540 0 1 {name=p150364 lab=_85119_/D }
C {sky130_stdcells/a2bb2o_4.sym} 151660 -39540 0 0 {name=X_56945_ }
C {devices/lab_pin.sym} 151600 -39400 0 0 {name=p150365 lab=_52083_/A }
C {devices/lab_pin.sym} 151600 -39360 0 0 {name=p150366 lab=_50368_/B }
C {devices/lab_pin.sym} 151720 -39380 0 1 {name=p150367 lab=_52068_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -39380 0 0 {name=X_52068_ }
C {devices/lab_pin.sym} 151570 -39250 0 0 {name=p150368 lab=_87766_/CLK }
C {devices/lab_pin.sym} 151570 -39230 0 0 {name=p150369 lab=_87765_/D }
C {devices/lab_pin.sym} 151750 -39250 0 1 {name=p150370 lab=_69542_/B }
C {sky130_stdcells/dfxtp_4.sym} 151660 -39240 0 0 {name=X_87765_ }
C {devices/lab_pin.sym} 151580 -39130 0 0 {name=p150371 lab=_72987_/X }
C {devices/lab_pin.sym} 151580 -39090 0 0 {name=p150372 lab=_72990_/X }
C {devices/lab_pin.sym} 151580 -39050 0 0 {name=p150373 lab=_72739_/X }
C {devices/lab_pin.sym} 151740 -39090 0 1 {name=p150374 lab=_72995_/A }
C {sky130_stdcells/a21o_4.sym} 151660 -39090 0 0 {name=X_72991_ }
C {devices/lab_pin.sym} 151570 -38950 0 0 {name=p150375 lab=_86238_/CLK }
C {devices/lab_pin.sym} 151570 -38930 0 0 {name=p150376 lab=_84977_/D }
C {devices/lab_pin.sym} 151750 -38950 0 1 {name=p150377 lab=_84977_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -38940 0 0 {name=X_84977_ }
C {devices/lab_pin.sym} 151580 -38840 0 0 {name=p150378 lab=_41367_/X }
C {devices/lab_pin.sym} 151580 -38800 0 0 {name=p150379 lab=_43907_/X }
C {devices/lab_pin.sym} 151580 -38760 0 0 {name=p150380 lab=_87204_/Q }
C {devices/lab_pin.sym} 151580 -38720 0 0 {name=p150381 lab=_43908_/X }
C {devices/lab_pin.sym} 151740 -38780 0 1 {name=p150382 lab=_43910_/X }
C {sky130_stdcells/a2bb2o_4.sym} 151660 -38780 0 0 {name=X_43910_ }
C {devices/lab_pin.sym} 151580 -38650 0 0 {name=p150383 lab=_51017_/Y }
C {devices/lab_pin.sym} 151580 -38610 0 0 {name=p150384 lab=_51011_/X }
C {devices/lab_pin.sym} 151580 -38570 0 0 {name=p150385 lab=_51018_/X }
C {devices/lab_pin.sym} 151740 -38610 0 1 {name=p150386 lab=_86089_/D }
C {sky130_stdcells/a21oi_4.sym} 151660 -38610 0 0 {name=X_51019_ }
C {devices/lab_pin.sym} 151570 -38470 0 0 {name=p150387 lab=_86398_/CLK }
C {devices/lab_pin.sym} 151570 -38450 0 0 {name=p150388 lab=_46671_/Y }
C {devices/lab_pin.sym} 151750 -38470 0 1 {name=p150389 lab=_58634_/A }
C {sky130_stdcells/dfxtp_4.sym} 151660 -38460 0 0 {name=X_86716_ }
C {devices/lab_pin.sym} 151600 -38360 0 0 {name=p150390 lab=_74722_/Y }
C {devices/lab_pin.sym} 151600 -38320 0 0 {name=p150391 lab=_74730_/B }
C {devices/lab_pin.sym} 151600 -38280 0 0 {name=p150392 lab=_74730_/C }
C {devices/lab_pin.sym} 151600 -38240 0 0 {name=p150393 lab=_74729_/Y }
C {devices/lab_pin.sym} 151720 -38300 0 1 {name=p150394 lab=_74730_/Y }
C {sky130_stdcells/nand4_4.sym} 151660 -38300 0 0 {name=X_74730_ }
C {devices/lab_pin.sym} 151570 -38150 0 0 {name=p150395 lab=_81473_/CLK }
C {devices/lab_pin.sym} 151570 -38130 0 0 {name=p150396 lab=_69380_/X }
C {devices/lab_pin.sym} 151750 -38150 0 1 {name=p150397 lab=_83928_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -38140 0 0 {name=X_83928_ }
C {devices/lab_pin.sym} 151620 -38010 0 0 {name=p150398 lab=_71938_/Y }
C {devices/lab_pin.sym} 151700 -38010 0 1 {name=p150399 lab=_71942_/Y }
C {sky130_stdcells/inv_2.sym} 151660 -38010 0 0 {name=X_71942_ }
C {devices/lab_pin.sym} 151600 -37920 0 0 {name=p150400 lab=_59664_/A }
C {devices/lab_pin.sym} 151600 -37880 0 0 {name=p150401 lab=_59679_/A }
C {devices/lab_pin.sym} 151600 -37840 0 0 {name=p150402 lab=_59664_/C }
C {devices/lab_pin.sym} 151600 -37800 0 0 {name=p150403 lab=_59754_/D }
C {devices/lab_pin.sym} 151720 -37860 0 1 {name=p150404 lab=_59665_/A }
C {sky130_stdcells/and4_4.sym} 151660 -37860 0 0 {name=X_59664_ }
C {devices/lab_pin.sym} 151580 -37730 0 0 {name=p150405 lab=_44877_/Y }
C {devices/lab_pin.sym} 151580 -37690 0 0 {name=p150406 lab=_44886_/Y }
C {devices/lab_pin.sym} 151580 -37650 0 0 {name=p150407 lab=_44889_/X }
C {devices/lab_pin.sym} 151740 -37690 0 1 {name=p150408 lab=_44890_/X }
C {sky130_stdcells/a21o_4.sym} 151660 -37690 0 0 {name=X_44890_ }
C {devices/lab_pin.sym} 151620 -37550 0 0 {name=p150409 lab=_83331_/Q }
C {devices/lab_pin.sym} 151700 -37550 0 1 {name=p150410 lab=_56876_/X }
C {sky130_stdcells/buf_2.sym} 151660 -37550 0 0 {name=X_56876_ }
C {devices/lab_pin.sym} 151570 -37430 0 0 {name=p150411 lab=_87952_/CLK }
C {devices/lab_pin.sym} 151570 -37410 0 0 {name=p150412 lab=_87696_/D }
C {devices/lab_pin.sym} 151750 -37430 0 1 {name=p150413 lab=_66651_/B }
C {sky130_stdcells/dfxtp_4.sym} 151660 -37420 0 0 {name=X_87696_ }
C {devices/lab_pin.sym} 151620 -37290 0 0 {name=p150414 lab=clkbuf_9_98_0_CLK/X }
C {devices/lab_pin.sym} 151700 -37290 0 1 {name=p150415 lab=_84668_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 151660 -37290 0 0 {name=Xclkbuf_10_196_0_CLK }
C {devices/lab_pin.sym} 151580 -37210 0 0 {name=p150416 lab=_58585_/X }
C {devices/lab_pin.sym} 151580 -37170 0 0 {name=p150417 lab=_58613_/Y }
C {devices/lab_pin.sym} 151580 -37130 0 0 {name=p150418 lab=_58614_/Y }
C {devices/lab_pin.sym} 151580 -37090 0 0 {name=p150419 lab=_58603_/X }
C {devices/lab_pin.sym} 151580 -37050 0 0 {name=p150420 lab=_58589_/X }
C {devices/lab_pin.sym} 151740 -37130 0 1 {name=p150421 lab=_58615_/X }
C {sky130_stdcells/o32a_4.sym} 151660 -37130 0 0 {name=X_58615_ }
C {devices/lab_pin.sym} 151620 -36970 0 0 {name=p150422 lab=_43602_/X }
C {devices/lab_pin.sym} 151700 -36970 0 1 {name=p150423 lab=_43842_/A }
C {sky130_stdcells/buf_2.sym} 151660 -36970 0 0 {name=X_43841_ }
C {devices/lab_pin.sym} 151580 -36880 0 0 {name=p150424 lab=_45181_/A }
C {devices/lab_pin.sym} 151580 -36840 0 0 {name=p150425 lab=_55498_/X }
C {devices/lab_pin.sym} 151580 -36800 0 0 {name=p150426 lab=_44096_/X }
C {devices/lab_pin.sym} 151580 -36760 0 0 {name=p150427 lab=_55826_/X }
C {devices/lab_pin.sym} 151740 -36820 0 1 {name=p150428 lab=_55827_/X }
C {sky130_stdcells/a211o_4.sym} 151660 -36820 0 0 {name=X_55827_ }
C {devices/lab_pin.sym} 151580 -36690 0 0 {name=p150429 lab=_56696_/A }
C {devices/lab_pin.sym} 151580 -36650 0 0 {name=p150430 lab=_74641_/X }
C {devices/lab_pin.sym} 151580 -36610 0 0 {name=p150431 lab=_74660_/Y }
C {devices/lab_pin.sym} 151740 -36650 0 1 {name=p150432 lab=_82993_/D }
C {sky130_stdcells/a21boi_4.sym} 151660 -36650 0 0 {name=X_74661_ }
C {devices/lab_pin.sym} 151570 -36510 0 0 {name=p150433 lab=_86647_/CLK }
C {devices/lab_pin.sym} 151570 -36490 0 0 {name=p150434 lab=_86647_/D }
C {devices/lab_pin.sym} 151750 -36510 0 1 {name=p150435 lab=_86647_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -36500 0 0 {name=X_86647_ }
C {devices/lab_pin.sym} 151620 -36370 0 0 {name=p150436 lab=_71783_/C }
C {devices/lab_pin.sym} 151700 -36370 0 1 {name=p150437 lab=_71873_/X }
C {sky130_stdcells/buf_2.sym} 151660 -36370 0 0 {name=X_71873_ }
C {devices/lab_pin.sym} 151600 -36270 0 0 {name=p150438 lab=_45941_/A }
C {devices/lab_pin.sym} 151600 -36230 0 0 {name=p150439 lab=_44003_/A }
C {devices/lab_pin.sym} 151600 -36190 0 0 {name=p150440 lab=_59584_/C }
C {devices/lab_pin.sym} 151720 -36230 0 1 {name=p150441 lab=_60182_/A }
C {sky130_stdcells/nor3_4.sym} 151660 -36230 0 0 {name=X_59595_ }
C {devices/lab_pin.sym} 151570 -36090 0 0 {name=p150442 lab=_82541_/CLK }
C {devices/lab_pin.sym} 151570 -36070 0 0 {name=p150443 lab=_70066_/X }
C {devices/lab_pin.sym} 151750 -36090 0 1 {name=p150444 lab=_83859_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -36080 0 0 {name=X_83859_ }
C {devices/lab_pin.sym} 151600 -35970 0 0 {name=p150445 lab=_76391_/X }
C {devices/lab_pin.sym} 151600 -35930 0 0 {name=p150446 lab=_76396_/X }
C {devices/lab_pin.sym} 151600 -35890 0 0 {name=p150447 lab=_76400_/C }
C {devices/lab_pin.sym} 151720 -35930 0 1 {name=p150448 lab=_76400_/X }
C {sky130_stdcells/or3_4.sym} 151660 -35930 0 0 {name=X_76400_ }
C {devices/lab_pin.sym} 151620 -35790 0 0 {name=p150449 lab=_73262_/A }
C {devices/lab_pin.sym} 151700 -35790 0 1 {name=p150450 lab=_73612_/X }
C {sky130_stdcells/buf_2.sym} 151660 -35790 0 0 {name=X_73612_ }
C {devices/lab_pin.sym} 151620 -35670 0 0 {name=p150451 lab=_70824_/A }
C {devices/lab_pin.sym} 151700 -35670 0 1 {name=p150452 lab=_71066_/B }
C {sky130_stdcells/buf_2.sym} 151660 -35670 0 0 {name=X_70824_ }
C {devices/lab_pin.sym} 151620 -35550 0 0 {name=p150453 lab=_51376_/B }
C {devices/lab_pin.sym} 151700 -35550 0 1 {name=p150454 lab=_54075_/B }
C {sky130_stdcells/buf_2.sym} 151660 -35550 0 0 {name=X_46560_ }
C {devices/lab_pin.sym} 151620 -35430 0 0 {name=p150455 lab=_58546_/A }
C {devices/lab_pin.sym} 151700 -35430 0 1 {name=p150456 lab=_58546_/Y }
C {sky130_stdcells/inv_2.sym} 151660 -35430 0 0 {name=X_58546_ }
C {devices/lab_pin.sym} 151600 -35320 0 0 {name=p150457 lab=_77380_/A }
C {devices/lab_pin.sym} 151600 -35280 0 0 {name=p150458 lab=_82093_/D }
C {devices/lab_pin.sym} 151720 -35300 0 1 {name=p150459 lab=_77381_/A }
C {sky130_stdcells/nand2_4.sym} 151660 -35300 0 0 {name=X_77380_ }
C {devices/lab_pin.sym} 151620 -35170 0 0 {name=p150460 lab=_43802_/A }
C {devices/lab_pin.sym} 151700 -35170 0 1 {name=p150461 lab=_43772_/X }
C {sky130_stdcells/buf_2.sym} 151660 -35170 0 0 {name=X_43772_ }
C {devices/lab_pin.sym} 151600 -35060 0 0 {name=p150462 lab=_55192_/A }
C {devices/lab_pin.sym} 151600 -35020 0 0 {name=p150463 lab=_85159_/Q }
C {devices/lab_pin.sym} 151720 -35040 0 1 {name=p150464 lab=_55758_/X }
C {sky130_stdcells/and2_4.sym} 151660 -35040 0 0 {name=X_55758_ }
C {devices/lab_pin.sym} 151570 -34910 0 0 {name=p150465 lab=_86578_/CLK }
C {devices/lab_pin.sym} 151570 -34890 0 0 {name=p150466 lab=_47997_/Y }
C {devices/lab_pin.sym} 151750 -34910 0 1 {name=p150467 lab=_73927_/B }
C {sky130_stdcells/dfxtp_4.sym} 151660 -34900 0 0 {name=X_86578_ }
C {devices/lab_pin.sym} 151580 -34800 0 0 {name=p150468 lab=_74591_/X }
C {devices/lab_pin.sym} 151580 -34760 0 0 {name=p150469 lab=_74583_/X }
C {devices/lab_pin.sym} 151580 -34720 0 0 {name=p150470 lab=_56102_/X }
C {devices/lab_pin.sym} 151580 -34680 0 0 {name=p150471 lab=_74584_/X }
C {devices/lab_pin.sym} 151740 -34740 0 1 {name=p150472 lab=_74592_/X }
C {sky130_stdcells/a211o_4.sym} 151660 -34740 0 0 {name=X_74592_ }
C {devices/lab_pin.sym} 151600 -34600 0 0 {name=p150473 lab=_40937_/A }
C {devices/lab_pin.sym} 151600 -34560 0 0 {name=p150474 lab=_40984_/B }
C {devices/lab_pin.sym} 151720 -34580 0 1 {name=p150475 lab=_40984_/X }
C {sky130_stdcells/or2_4.sym} 151660 -34580 0 0 {name=X_40984_ }
C {devices/lab_pin.sym} 151620 -34450 0 0 {name=p150476 lab=clkbuf_7_62_0_CLK/X }
C {devices/lab_pin.sym} 151700 -34450 0 1 {name=p150477 lab=clkbuf_8_124_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 151660 -34450 0 0 {name=Xclkbuf_8_124_0_CLK }
C {devices/lab_pin.sym} 151620 -34330 0 0 {name=p150478 lab=_45668_/A }
C {devices/lab_pin.sym} 151700 -34330 0 1 {name=p150479 lab=_45511_/X }
C {sky130_stdcells/buf_2.sym} 151660 -34330 0 0 {name=X_45511_ }
C {devices/lab_pin.sym} 151600 -34220 0 0 {name=p150480 lab=_76332_/A }
C {devices/lab_pin.sym} 151600 -34180 0 0 {name=p150481 lab=_81563_/Q }
C {devices/lab_pin.sym} 151720 -34200 0 1 {name=p150482 lab=_76331_/Y }
C {sky130_stdcells/nor2_4.sym} 151660 -34200 0 0 {name=X_76331_ }
C {devices/lab_pin.sym} 151570 -34070 0 0 {name=p150483 lab=_88326_/CLK }
C {devices/lab_pin.sym} 151570 -34050 0 0 {name=p150484 lab=_40887_/Y }
C {devices/lab_pin.sym} 151750 -34070 0 1 {name=p150485 lab=_69865_/B }
C {sky130_stdcells/dfxtp_4.sym} 151660 -34060 0 0 {name=X_88317_ }
C {devices/lab_pin.sym} 151620 -33930 0 0 {name=p150486 lab=_42723_/A }
C {devices/lab_pin.sym} 151700 -33930 0 1 {name=p150487 lab=_42723_/X }
C {sky130_stdcells/buf_2.sym} 151660 -33930 0 0 {name=X_42723_ }
C {devices/lab_pin.sym} 151600 -33820 0 0 {name=p150488 lab=_54718_/A }
C {devices/lab_pin.sym} 151600 -33780 0 0 {name=p150489 lab=_47385_/Y }
C {devices/lab_pin.sym} 151720 -33800 0 1 {name=p150490 lab=_54709_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -33800 0 0 {name=X_54709_ }
C {devices/lab_pin.sym} 151600 -33680 0 0 {name=p150491 lab=_48704_/Y }
C {devices/lab_pin.sym} 151600 -33640 0 0 {name=p150492 lab=_73543_/B }
C {devices/lab_pin.sym} 151720 -33660 0 1 {name=p150493 lab=_73543_/X }
C {sky130_stdcells/xor2_4.sym} 151660 -33660 0 0 {name=X_73543_ }
C {devices/lab_pin.sym} 151570 -33530 0 0 {name=p150494 lab=_85529_/CLK }
C {devices/lab_pin.sym} 151570 -33510 0 0 {name=p150495 lab=_53984_/Y }
C {devices/lab_pin.sym} 151750 -33530 0 1 {name=p150496 lab=_85529_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -33520 0 0 {name=X_85529_ }
C {devices/lab_pin.sym} 151600 -33400 0 0 {name=p150497 lab=_46491_/A }
C {devices/lab_pin.sym} 151600 -33360 0 0 {name=p150498 lab=_50832_/B }
C {devices/lab_pin.sym} 151720 -33380 0 1 {name=p150499 lab=_46491_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -33380 0 0 {name=X_46491_ }
C {devices/lab_pin.sym} 151600 -33260 0 0 {name=p150500 lab=_70755_/A }
C {devices/lab_pin.sym} 151600 -33220 0 0 {name=p150501 lab=_70727_/A }
C {devices/lab_pin.sym} 151720 -33240 0 1 {name=p150502 lab=_70755_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -33240 0 0 {name=X_70755_ }
C {devices/lab_pin.sym} 151620 -33110 0 0 {name=p150503 lab=_64422_/C }
C {devices/lab_pin.sym} 151700 -33110 0 1 {name=p150504 lab=_58478_/A }
C {sky130_stdcells/buf_2.sym} 151660 -33110 0 0 {name=X_58477_ }
C {devices/lab_pin.sym} 151620 -32990 0 0 {name=p150505 lab=_55689_/A }
C {devices/lab_pin.sym} 151700 -32990 0 1 {name=p150506 lab=_55690_/A }
C {sky130_stdcells/buf_2.sym} 151660 -32990 0 0 {name=X_55689_ }
C {devices/lab_pin.sym} 151580 -32890 0 0 {name=p150507 lab=_48225_/Y }
C {devices/lab_pin.sym} 151580 -32850 0 0 {name=p150508 lab=_48226_/X }
C {devices/lab_pin.sym} 151580 -32810 0 0 {name=p150509 lab=_48229_/Y }
C {devices/lab_pin.sym} 151740 -32850 0 1 {name=p150510 lab=_86552_/D }
C {sky130_stdcells/a21boi_4.sym} 151660 -32850 0 0 {name=X_48230_ }
C {devices/lab_pin.sym} 151620 -32710 0 0 {name=p150511 lab=_82653_/Q }
C {devices/lab_pin.sym} 151700 -32710 0 1 {name=p150512 lab=_79053_/B }
C {sky130_stdcells/inv_2.sym} 151660 -32710 0 0 {name=X_79050_ }
C {devices/lab_pin.sym} 151620 -32590 0 0 {name=p150513 lab=_85022_/Q }
C {devices/lab_pin.sym} 151700 -32590 0 1 {name=p150514 lab=_55596_/B }
C {sky130_stdcells/inv_2.sym} 151660 -32590 0 0 {name=X_45442_ }
C {devices/lab_pin.sym} 151580 -32490 0 0 {name=p150515 lab=_57408_/X }
C {devices/lab_pin.sym} 151580 -32450 0 0 {name=p150516 lab=_57426_/X }
C {devices/lab_pin.sym} 151580 -32410 0 0 {name=p150517 lab=_57427_/Y }
C {devices/lab_pin.sym} 151740 -32450 0 1 {name=p150518 lab=_57429_/A }
C {sky130_stdcells/o21ai_4.sym} 151660 -32450 0 0 {name=X_57428_ }
C {devices/lab_pin.sym} 151600 -32320 0 0 {name=p150519 lab=_76260_/X }
C {devices/lab_pin.sym} 151600 -32280 0 0 {name=p150520 lab=_81642_/Q }
C {devices/lab_pin.sym} 151720 -32300 0 1 {name=p150521 lab=_76262_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -32300 0 0 {name=X_76262_ }
C {devices/lab_pin.sym} 151570 -32170 0 0 {name=p150522 lab=_88247_/CLK }
C {devices/lab_pin.sym} 151570 -32150 0 0 {name=p150523 lab=_41265_/X }
C {devices/lab_pin.sym} 151750 -32170 0 1 {name=p150524 lab=_88248_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -32160 0 0 {name=X_88248_ }
C {devices/lab_pin.sym} 151580 -32060 0 0 {name=p150525 lab=_40982_/X }
C {devices/lab_pin.sym} 151580 -32020 0 0 {name=p150526 lab=_42652_/X }
C {devices/lab_pin.sym} 151580 -31980 0 0 {name=p150527 lab=_87786_/Q }
C {devices/lab_pin.sym} 151580 -31940 0 0 {name=p150528 lab=_42653_/X }
C {devices/lab_pin.sym} 151740 -32000 0 1 {name=p150529 lab=_42654_/X }
C {sky130_stdcells/a2bb2o_4.sym} 151660 -32000 0 0 {name=X_42654_ }
C {devices/lab_pin.sym} 151580 -31880 0 0 {name=p150530 lab=_73355_/X }
C {devices/lab_pin.sym} 151580 -31840 0 0 {name=p150531 lab=_85573_/Q }
C {devices/lab_pin.sym} 151580 -31800 0 0 {name=p150532 lab=_73472_/X }
C {devices/lab_pin.sym} 151580 -31760 0 0 {name=p150533 lab=_73473_/X }
C {devices/lab_pin.sym} 151740 -31820 0 1 {name=p150534 lab=_73474_/X }
C {sky130_stdcells/a211o_4.sym} 151660 -31820 0 0 {name=X_73474_ }
C {devices/lab_pin.sym} 151600 -31690 0 0 {name=p150535 lab=_71411_/A }
C {devices/lab_pin.sym} 151600 -31650 0 0 {name=p150536 lab=_70692_/B }
C {devices/lab_pin.sym} 151600 -31610 0 0 {name=p150537 lab=_70692_/C }
C {devices/lab_pin.sym} 151720 -31650 0 1 {name=p150538 lab=_70686_/Y }
C {sky130_stdcells/nor3_4.sym} 151660 -31650 0 0 {name=X_70686_ }
C {devices/lab_pin.sym} 151580 -31530 0 0 {name=p150539 lab=_77993_/A }
C {devices/lab_pin.sym} 151580 -31490 0 0 {name=p150540 lab=_77993_/B }
C {devices/lab_pin.sym} 151580 -31450 0 0 {name=p150541 lab=_78000_/Y }
C {devices/lab_pin.sym} 151740 -31490 0 1 {name=p150542 lab=_78001_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -31490 0 0 {name=X_78001_ }
C {devices/lab_pin.sym} 151600 -31360 0 0 {name=p150543 lab=_80684_/Q }
C {devices/lab_pin.sym} 151600 -31320 0 0 {name=p150544 lab=_80984_/Q }
C {devices/lab_pin.sym} 151720 -31340 0 1 {name=p150545 lab=_75214_/B }
C {sky130_stdcells/xor2_4.sym} 151660 -31340 0 0 {name=X_75213_ }
C {devices/lab_pin.sym} 151620 -31210 0 0 {name=p150546 lab=clkbuf_8_120_0_CLK/X }
C {devices/lab_pin.sym} 151700 -31210 0 1 {name=p150547 lab=clkbuf_9_240_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 151660 -31210 0 0 {name=Xclkbuf_9_240_0_CLK }
C {devices/lab_pin.sym} 151580 -31110 0 0 {name=p150548 lab=_41603_/X }
C {devices/lab_pin.sym} 151580 -31070 0 0 {name=p150549 lab=_40530_/B }
C {devices/lab_pin.sym} 151580 -31030 0 0 {name=p150550 lab=_41604_/X }
C {devices/lab_pin.sym} 151740 -31070 0 1 {name=p150551 lab=_41605_/X }
C {sky130_stdcells/o21a_4.sym} 151660 -31070 0 0 {name=X_41605_ }
C {devices/lab_pin.sym} 151580 -30950 0 0 {name=p150552 lab=_72421_/Y }
C {devices/lab_pin.sym} 151580 -30910 0 0 {name=p150553 lab=_72424_/Y }
C {devices/lab_pin.sym} 151580 -30870 0 0 {name=p150554 lab=_72344_/X }
C {devices/lab_pin.sym} 151740 -30910 0 1 {name=p150555 lab=_72425_/X }
C {sky130_stdcells/a21o_4.sym} 151660 -30910 0 0 {name=X_72425_ }
C {devices/lab_pin.sym} 151580 -30790 0 0 {name=p150556 lab=_48155_/Y }
C {devices/lab_pin.sym} 151580 -30750 0 0 {name=p150557 lab=_48156_/X }
C {devices/lab_pin.sym} 151580 -30710 0 0 {name=p150558 lab=_48160_/X }
C {devices/lab_pin.sym} 151740 -30750 0 1 {name=p150559 lab=_86562_/D }
C {sky130_stdcells/a21oi_4.sym} 151660 -30750 0 0 {name=X_48161_ }
C {devices/lab_pin.sym} 151580 -30630 0 0 {name=p150560 lab=_55736_/B }
C {devices/lab_pin.sym} 151580 -30590 0 0 {name=p150561 lab=_45354_/X }
C {devices/lab_pin.sym} 151580 -30550 0 0 {name=p150562 lab=_45311_/X }
C {devices/lab_pin.sym} 151740 -30590 0 1 {name=p150563 lab=_45373_/X }
C {sky130_stdcells/o21a_4.sym} 151660 -30590 0 0 {name=X_45373_ }
C {devices/lab_pin.sym} 151600 -30470 0 0 {name=p150564 lab=_57359_/A }
C {devices/lab_pin.sym} 151600 -30430 0 0 {name=p150565 lab=_85029_/Q }
C {devices/lab_pin.sym} 151600 -30390 0 0 {name=p150566 lab=_57249_/X }
C {devices/lab_pin.sym} 151720 -30430 0 1 {name=p150567 lab=_57359_/Y }
C {sky130_stdcells/nor3_4.sym} 151660 -30430 0 0 {name=X_57359_ }
C {devices/lab_pin.sym} 151600 -30310 0 0 {name=p150568 lab=_76193_/A }
C {devices/lab_pin.sym} 151600 -30270 0 0 {name=p150569 lab=_76188_/X }
C {devices/lab_pin.sym} 151600 -30230 0 0 {name=p150570 lab=_76193_/C }
C {devices/lab_pin.sym} 151720 -30270 0 1 {name=p150571 lab=_76196_/B }
C {sky130_stdcells/nand3_4.sym} 151660 -30270 0 0 {name=X_76193_ }
C {devices/lab_pin.sym} 151570 -30130 0 0 {name=p150572 lab=_87926_/CLK }
C {devices/lab_pin.sym} 151570 -30110 0 0 {name=p150573 lab=_88179_/D }
C {devices/lab_pin.sym} 151750 -30130 0 1 {name=p150574 lab=_67349_/B }
C {sky130_stdcells/dfxtp_4.sym} 151660 -30120 0 0 {name=X_88179_ }
C {devices/lab_pin.sym} 151580 -30030 0 0 {name=p150575 lab=_42573_/X }
C {devices/lab_pin.sym} 151580 -29990 0 0 {name=p150576 lab=_42574_/X }
C {devices/lab_pin.sym} 151580 -29950 0 0 {name=p150577 lab=_40849_/X }
C {devices/lab_pin.sym} 151580 -29910 0 0 {name=p150578 lab=_87811_/Q }
C {devices/lab_pin.sym} 151580 -29870 0 0 {name=p150579 lab=_42580_/X }
C {devices/lab_pin.sym} 151740 -29950 0 1 {name=p150580 lab=_42585_/Y }
C {sky130_stdcells/o32ai_4.sym} 151660 -29950 0 0 {name=X_42585_ }
C {devices/lab_pin.sym} 151620 -29790 0 0 {name=p150581 lab=clkbuf_7_69_0_CLK/X }
C {devices/lab_pin.sym} 151700 -29790 0 1 {name=p150582 lab=clkbuf_9_278_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 151660 -29790 0 0 {name=Xclkbuf_8_139_0_CLK }
C {devices/lab_pin.sym} 151620 -29670 0 0 {name=p150583 lab=_54553_/D }
C {devices/lab_pin.sym} 151700 -29670 0 1 {name=p150584 lab=_52861_/D }
C {sky130_stdcells/buf_2.sym} 151660 -29670 0 0 {name=X_47112_ }
C {devices/lab_pin.sym} 151620 -29550 0 0 {name=p150585 lab=clkbuf_9_67_0_CLK/X }
C {devices/lab_pin.sym} 151700 -29550 0 1 {name=p150586 lab=_83820_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 151660 -29550 0 0 {name=Xclkbuf_10_134_0_CLK }
C {devices/lab_pin.sym} 151580 -29460 0 0 {name=p150587 lab=_41643_/X }
C {devices/lab_pin.sym} 151580 -29420 0 0 {name=p150588 lab=_40543_/X }
C {devices/lab_pin.sym} 151580 -29380 0 0 {name=p150589 lab=_87165_/Q }
C {devices/lab_pin.sym} 151580 -29340 0 0 {name=p150590 lab=_40544_/X }
C {devices/lab_pin.sym} 151740 -29400 0 1 {name=p150591 lab=_87165_/D }
C {sky130_stdcells/a2bb2o_4.sym} 151660 -29400 0 0 {name=X_44324_ }
C {devices/lab_pin.sym} 151580 -29270 0 0 {name=p150592 lab=_75141_/X }
C {devices/lab_pin.sym} 151580 -29230 0 0 {name=p150593 lab=_75145_/C }
C {devices/lab_pin.sym} 151580 -29190 0 0 {name=p150594 lab=_75143_/Y }
C {devices/lab_pin.sym} 151740 -29230 0 1 {name=p150595 lab=_75144_/Y }
C {sky130_stdcells/a21oi_4.sym} 151660 -29230 0 0 {name=X_75144_ }
C {devices/lab_pin.sym} 151620 -29090 0 0 {name=p150596 lab=_41535_/X }
C {devices/lab_pin.sym} 151700 -29090 0 1 {name=p150597 lab=_41536_/X }
C {sky130_stdcells/buf_2.sym} 151660 -29090 0 0 {name=X_41536_ }
C {devices/lab_pin.sym} 151600 -28980 0 0 {name=p150598 lab=_48092_/A }
C {devices/lab_pin.sym} 151600 -28940 0 0 {name=p150599 lab=_50358_/B }
C {devices/lab_pin.sym} 151720 -28960 0 1 {name=p150600 lab=_48092_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -28960 0 0 {name=X_48092_ }
C {devices/lab_pin.sym} 151620 -28830 0 0 {name=p150601 lab=_60369_/X }
C {devices/lab_pin.sym} 151700 -28830 0 1 {name=p150602 lab=_60370_/Y }
C {sky130_stdcells/inv_2.sym} 151660 -28830 0 0 {name=X_60370_ }
C {devices/lab_pin.sym} 151580 -28740 0 0 {name=p150603 lab=_83262_/Q }
C {devices/lab_pin.sym} 151580 -28700 0 0 {name=p150604 lab=_72250_/X }
C {devices/lab_pin.sym} 151580 -28660 0 0 {name=p150605 lab=_72349_/X }
C {devices/lab_pin.sym} 151580 -28620 0 0 {name=p150606 lab=_72355_/X }
C {devices/lab_pin.sym} 151740 -28680 0 1 {name=p150607 lab=_83262_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 151660 -28680 0 0 {name=X_72356_ }
C {devices/lab_pin.sym} 151620 -28530 0 0 {name=p150608 lab=clkbuf_9_382_0_CLK/X }
C {devices/lab_pin.sym} 151700 -28530 0 1 {name=p150609 lab=_88044_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 151660 -28530 0 0 {name=Xclkbuf_10_764_0_CLK }
C {devices/lab_pin.sym} 151600 -28420 0 0 {name=p150610 lab=_47008_/A }
C {devices/lab_pin.sym} 151600 -28380 0 0 {name=p150611 lab=_51130_/B }
C {devices/lab_pin.sym} 151720 -28400 0 1 {name=p150612 lab=_47043_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -28400 0 0 {name=X_47043_ }
C {devices/lab_pin.sym} 151600 -28280 0 0 {name=p150613 lab=_59029_/A }
C {devices/lab_pin.sym} 151600 -28240 0 0 {name=p150614 lab=_86366_/Q }
C {devices/lab_pin.sym} 151720 -28260 0 1 {name=p150615 lab=_59029_/Y }
C {sky130_stdcells/nor2_4.sym} 151660 -28260 0 0 {name=X_59029_ }
C {devices/lab_pin.sym} 151580 -28150 0 0 {name=p150616 lab=_52036_/B }
C {devices/lab_pin.sym} 151580 -28110 0 0 {name=p150617 lab=_71290_/X }
C {devices/lab_pin.sym} 151580 -28070 0 0 {name=p150618 lab=_71306_/Y }
C {devices/lab_pin.sym} 151740 -28110 0 1 {name=p150619 lab=_71307_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -28110 0 0 {name=X_71307_ }
C {devices/lab_pin.sym} 151580 -28010 0 0 {name=p150620 lab=_45950_/A }
C {devices/lab_pin.sym} 151580 -27970 0 0 {name=p150621 lab=_44227_/Y }
C {devices/lab_pin.sym} 151580 -27930 0 0 {name=p150622 lab=_44210_/X }
C {devices/lab_pin.sym} 151580 -27890 0 0 {name=p150623 lab=_43972_/B }
C {devices/lab_pin.sym} 151580 -27850 0 0 {name=p150624 lab=_44254_/X }
C {devices/lab_pin.sym} 151740 -27930 0 1 {name=p150625 lab=_44255_/X }
C {sky130_stdcells/o32a_4.sym} 151660 -27930 0 0 {name=X_44255_ }
C {devices/lab_pin.sym} 151580 -27790 0 0 {name=p150626 lab=_75072_/Y }
C {devices/lab_pin.sym} 151580 -27750 0 0 {name=p150627 lab=_75074_/B }
C {devices/lab_pin.sym} 151580 -27710 0 0 {name=p150628 lab=_75076_/B }
C {devices/lab_pin.sym} 151740 -27750 0 1 {name=p150629 lab=_75075_/Y }
C {sky130_stdcells/a21oi_4.sym} 151660 -27750 0 0 {name=X_75075_ }
C {devices/lab_pin.sym} 151600 -27620 0 0 {name=p150630 lab=_84926_/Q }
C {devices/lab_pin.sym} 151600 -27580 0 0 {name=p150631 lab=_84174_/Q }
C {devices/lab_pin.sym} 151720 -27600 0 1 {name=p150632 lab=_79952_/X }
C {sky130_stdcells/or2_4.sym} 151660 -27600 0 0 {name=X_79952_ }
C {devices/lab_pin.sym} 151600 -27480 0 0 {name=p150633 lab=_81183_/Q }
C {devices/lab_pin.sym} 151600 -27440 0 0 {name=p150634 lab=_41459_/B }
C {devices/lab_pin.sym} 151720 -27460 0 1 {name=p150635 lab=_41467_/X }
C {sky130_stdcells/or2_4.sym} 151660 -27460 0 0 {name=X_41467_ }
C {devices/lab_pin.sym} 151620 -27330 0 0 {name=p150636 lab=_57711_/X }
C {devices/lab_pin.sym} 151700 -27330 0 1 {name=p150637 lab=_72287_/X }
C {sky130_stdcells/buf_2.sym} 151660 -27330 0 0 {name=X_72287_ }
C {devices/lab_pin.sym} 151620 -27210 0 0 {name=p150638 lab=clkbuf_9_255_0_CLK/A }
C {devices/lab_pin.sym} 151700 -27210 0 1 {name=p150639 lab=clkbuf_9_255_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 151660 -27210 0 0 {name=Xclkbuf_9_255_0_CLK }
C {devices/lab_pin.sym} 151580 -27120 0 0 {name=p150640 lab=_40939_/X }
C {devices/lab_pin.sym} 151580 -27080 0 0 {name=p150641 lab=_43180_/X }
C {devices/lab_pin.sym} 151580 -27040 0 0 {name=p150642 lab=_87538_/Q }
C {devices/lab_pin.sym} 151580 -27000 0 0 {name=p150643 lab=_43185_/X }
C {devices/lab_pin.sym} 151740 -27060 0 1 {name=p150644 lab=_43206_/X }
C {sky130_stdcells/a2bb2o_4.sym} 151660 -27060 0 0 {name=X_43206_ }
C {devices/lab_pin.sym} 151600 -26920 0 0 {name=p150645 lab=_53552_/B }
C {devices/lab_pin.sym} 151600 -26880 0 0 {name=p150646 lab=_74026_/B }
C {devices/lab_pin.sym} 151720 -26900 0 1 {name=p150647 lab=_74026_/X }
C {sky130_stdcells/xor2_4.sym} 151660 -26900 0 0 {name=X_74026_ }
C {devices/lab_pin.sym} 151580 -26800 0 0 {name=p150648 lab=_63611_/A }
C {devices/lab_pin.sym} 151580 -26760 0 0 {name=p150649 lab=_59825_/B }
C {devices/lab_pin.sym} 151580 -26720 0 0 {name=p150650 lab=_61572_/A }
C {devices/lab_pin.sym} 151580 -26680 0 0 {name=p150651 lab=_61981_/X }
C {devices/lab_pin.sym} 151740 -26740 0 1 {name=p150652 lab=_62040_/X }
C {sky130_stdcells/a2bb2o_4.sym} 151660 -26740 0 0 {name=X_62040_ }
C {devices/lab_pin.sym} 151600 -26600 0 0 {name=p150653 lab=_82845_/Q }
C {devices/lab_pin.sym} 151600 -26560 0 0 {name=p150654 lab=_78903_/B }
C {devices/lab_pin.sym} 151720 -26580 0 1 {name=p150655 lab=_78903_/Y }
C {sky130_stdcells/xnor2_4.sym} 151660 -26580 0 0 {name=X_78903_ }
C {devices/lab_pin.sym} 151620 -26450 0 0 {name=p150656 lab=_40417_/Y }
C {devices/lab_pin.sym} 151700 -26450 0 1 {name=p150657 lab=_40418_/X }
C {sky130_stdcells/buf_2.sym} 151660 -26450 0 0 {name=X_40418_ }
C {devices/lab_pin.sym} 151600 -26340 0 0 {name=p150658 lab=_71137_/A }
C {devices/lab_pin.sym} 151600 -26300 0 0 {name=p150659 lab=_71238_/B }
C {devices/lab_pin.sym} 151720 -26320 0 1 {name=p150660 lab=_71239_/A }
C {sky130_stdcells/nor2_4.sym} 151660 -26320 0 0 {name=X_71238_ }
C {devices/lab_pin.sym} 151600 -26200 0 0 {name=p150661 lab=_44186_/A }
C {devices/lab_pin.sym} 151600 -26160 0 0 {name=p150662 lab=_44185_/X }
C {devices/lab_pin.sym} 151720 -26180 0 1 {name=p150663 lab=_44186_/X }
C {sky130_stdcells/or2_4.sym} 151660 -26180 0 0 {name=X_44186_ }
C {devices/lab_pin.sym} 151600 -26060 0 0 {name=p150664 lab=_60214_/C }
C {devices/lab_pin.sym} 151600 -26020 0 0 {name=p150665 lab=_79883_/B }
C {devices/lab_pin.sym} 151720 -26040 0 1 {name=p150666 lab=_79883_/X }
C {sky130_stdcells/xor2_4.sym} 151660 -26040 0 0 {name=X_79883_ }
C {devices/lab_pin.sym} 151580 -25940 0 0 {name=p150667 lab=_41397_/X }
C {devices/lab_pin.sym} 151580 -25900 0 0 {name=p150668 lab=_41362_/X }
C {devices/lab_pin.sym} 151580 -25860 0 0 {name=p150669 lab=_67848_/B }
C {devices/lab_pin.sym} 151580 -25820 0 0 {name=p150670 lab=_41363_/X }
C {devices/lab_pin.sym} 151740 -25880 0 1 {name=p150671 lab=_88222_/D }
C {sky130_stdcells/a2bb2o_4.sym} 151660 -25880 0 0 {name=X_41398_ }
C {devices/lab_pin.sym} 151620 -25730 0 0 {name=p150672 lab=clkbuf_9_74_0_CLK/X }
C {devices/lab_pin.sym} 151700 -25730 0 1 {name=p150673 lab=_81696_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 151660 -25730 0 0 {name=Xclkbuf_10_149_0_CLK }
C {devices/lab_pin.sym} 151620 -25610 0 0 {name=p150674 lab=_43137_/A }
C {devices/lab_pin.sym} 151700 -25610 0 1 {name=p150675 lab=_43137_/Y }
C {sky130_stdcells/inv_2.sym} 151660 -25610 0 0 {name=X_43137_ }
C {devices/lab_pin.sym} 151600 -25500 0 0 {name=p150676 lab=_78841_/B }
C {devices/lab_pin.sym} 151600 -25460 0 0 {name=p150677 lab=_78833_/Y }
C {devices/lab_pin.sym} 151720 -25480 0 1 {name=p150678 lab=_78834_/X }
C {sky130_stdcells/xor2_4.sym} 151660 -25480 0 0 {name=X_78834_ }
C {devices/lab_pin.sym} 151620 -25350 0 0 {name=p150679 lab=_41869_/A }
C {devices/lab_pin.sym} 151700 -25350 0 1 {name=p150680 lab=_42447_/A }
C {sky130_stdcells/inv_2.sym} 151660 -25350 0 0 {name=X_40349_ }
C {devices/lab_pin.sym} 151580 -25250 0 0 {name=p150681 lab=_52137_/B }
C {devices/lab_pin.sym} 151580 -25210 0 0 {name=p150682 lab=_71165_/X }
C {devices/lab_pin.sym} 151580 -25170 0 0 {name=p150683 lab=_71168_/Y }
C {devices/lab_pin.sym} 151740 -25210 0 1 {name=p150684 lab=_71169_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -25210 0 0 {name=X_71169_ }
C {devices/lab_pin.sym} 151620 -25070 0 0 {name=p150685 lab=clkbuf_9_389_0_CLK/X }
C {devices/lab_pin.sym} 151700 -25070 0 1 {name=p150686 lab=_82575_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 151660 -25070 0 0 {name=Xclkbuf_10_779_0_CLK }
C {devices/lab_pin.sym} 151580 -24970 0 0 {name=p150687 lab=_86454_/Q }
C {devices/lab_pin.sym} 151580 -24930 0 0 {name=p150688 lab=_48952_/X }
C {devices/lab_pin.sym} 151580 -24890 0 0 {name=p150689 lab=_48993_/Y }
C {devices/lab_pin.sym} 151740 -24930 0 1 {name=p150690 lab=_48994_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -24930 0 0 {name=X_48994_ }
C {devices/lab_pin.sym} 151620 -24790 0 0 {name=p150691 lab=_51988_/A }
C {devices/lab_pin.sym} 151700 -24790 0 1 {name=p150692 lab=_48234_/A }
C {sky130_stdcells/buf_2.sym} 151660 -24790 0 0 {name=X_47945_ }
C {devices/lab_pin.sym} 151620 -24670 0 0 {name=p150693 lab=_43068_/A }
C {devices/lab_pin.sym} 151700 -24670 0 1 {name=p150694 lab=_43068_/Y }
C {sky130_stdcells/inv_2.sym} 151660 -24670 0 0 {name=X_43068_ }
C {devices/lab_pin.sym} 151600 -24560 0 0 {name=p150695 lab=_78761_/X }
C {devices/lab_pin.sym} 151600 -24520 0 0 {name=p150696 lab=_78762_/A }
C {devices/lab_pin.sym} 151720 -24540 0 1 {name=p150697 lab=_78765_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -24540 0 0 {name=X_78765_ }
C {devices/lab_pin.sym} 151620 -24410 0 0 {name=p150698 lab=_63734_/A }
C {devices/lab_pin.sym} 151700 -24410 0 1 {name=p150699 lab=_64053_/A }
C {sky130_stdcells/buf_2.sym} 151660 -24410 0 0 {name=X_63991_ }
C {devices/lab_pin.sym} 151600 -24300 0 0 {name=p150700 lab=_75969_/B }
C {devices/lab_pin.sym} 151600 -24260 0 0 {name=p150701 lab=_75977_/B }
C {devices/lab_pin.sym} 151720 -24280 0 1 {name=p150702 lab=_75977_/Y }
C {sky130_stdcells/nor2_4.sym} 151660 -24280 0 0 {name=X_75977_ }
C {devices/lab_pin.sym} 151620 -24150 0 0 {name=p150703 lab=_42018_/Y }
C {devices/lab_pin.sym} 151700 -24150 0 1 {name=p150704 lab=_88069_/D }
C {sky130_stdcells/inv_2.sym} 151660 -24150 0 0 {name=X_42019_ }
C {devices/lab_pin.sym} 151600 -24050 0 0 {name=p150705 lab=_65134_/X }
C {devices/lab_pin.sym} 151600 -24010 0 0 {name=p150706 lab=_65653_/B }
C {devices/lab_pin.sym} 151600 -23970 0 0 {name=p150707 lab=_65138_/X }
C {devices/lab_pin.sym} 151720 -24010 0 1 {name=p150708 lab=_65742_/A }
C {sky130_stdcells/nand3_4.sym} 151660 -24010 0 0 {name=X_65730_ }
C {devices/lab_pin.sym} 151600 -23880 0 0 {name=p150709 lab=_82125_/Q }
C {devices/lab_pin.sym} 151600 -23840 0 0 {name=p150710 lab=_77716_/B }
C {devices/lab_pin.sym} 151720 -23860 0 1 {name=p150711 lab=_77717_/A }
C {sky130_stdcells/xor2_4.sym} 151660 -23860 0 0 {name=X_77716_ }
C {devices/lab_pin.sym} 151620 -23730 0 0 {name=p150712 lab=_62893_/A }
C {devices/lab_pin.sym} 151700 -23730 0 1 {name=p150713 lab=_62942_/X }
C {sky130_stdcells/buf_2.sym} 151660 -23730 0 0 {name=X_62942_ }
C {devices/lab_pin.sym} 151600 -23620 0 0 {name=p150714 lab=_81134_/D }
C {devices/lab_pin.sym} 151600 -23580 0 0 {name=p150715 lab=_74928_/B }
C {devices/lab_pin.sym} 151720 -23600 0 1 {name=p150716 lab=_74942_/A }
C {sky130_stdcells/xor2_4.sym} 151660 -23600 0 0 {name=X_74928_ }
C {devices/lab_pin.sym} 151620 -23470 0 0 {name=p150717 lab=_47918_/A }
C {devices/lab_pin.sym} 151700 -23470 0 1 {name=p150718 lab=_47877_/A }
C {sky130_stdcells/buf_2.sym} 151660 -23470 0 0 {name=X_47876_ }
C {devices/lab_pin.sym} 151620 -23350 0 0 {name=p150719 lab=_78695_/X }
C {devices/lab_pin.sym} 151700 -23350 0 1 {name=p150720 lab=_78696_/Y }
C {sky130_stdcells/inv_2.sym} 151660 -23350 0 0 {name=X_78696_ }
C {devices/lab_pin.sym} 151620 -23230 0 0 {name=p150721 lab=clkbuf_9_351_0_CLK/X }
C {devices/lab_pin.sym} 151700 -23230 0 1 {name=p150722 lab=_87126_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 151660 -23230 0 0 {name=Xclkbuf_10_702_0_CLK }
C {devices/lab_pin.sym} 151600 -23140 0 0 {name=p150723 lab=_49610_/A }
C {devices/lab_pin.sym} 151600 -23100 0 0 {name=p150724 lab=_49614_/X }
C {devices/lab_pin.sym} 151600 -23060 0 0 {name=p150725 lab=_49615_/C }
C {devices/lab_pin.sym} 151600 -23020 0 0 {name=p150726 lab=_52831_/D }
C {devices/lab_pin.sym} 151720 -23080 0 1 {name=p150727 lab=_49615_/X }
C {sky130_stdcells/and4_4.sym} 151660 -23080 0 0 {name=X_49615_ }
C {devices/lab_pin.sym} 151580 -22950 0 0 {name=p150728 lab=_58853_/A }
C {devices/lab_pin.sym} 151580 -22910 0 0 {name=p150729 lab=_46813_/X }
C {devices/lab_pin.sym} 151580 -22870 0 0 {name=p150730 lab=_46826_/Y }
C {devices/lab_pin.sym} 151740 -22910 0 1 {name=p150731 lab=_46827_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -22910 0 0 {name=X_46827_ }
C {devices/lab_pin.sym} 151600 -22780 0 0 {name=p150732 lab=_65769_/A }
C {devices/lab_pin.sym} 151600 -22740 0 0 {name=p150733 lab=_86514_/Q }
C {devices/lab_pin.sym} 151720 -22760 0 1 {name=p150734 lab=_65661_/X }
C {sky130_stdcells/and2_4.sym} 151660 -22760 0 0 {name=X_65661_ }
C {devices/lab_pin.sym} 151580 -22650 0 0 {name=p150735 lab=_77648_/A }
C {devices/lab_pin.sym} 151580 -22610 0 0 {name=p150736 lab=_77648_/C }
C {devices/lab_pin.sym} 151580 -22570 0 0 {name=p150737 lab=_81949_/Q }
C {devices/lab_pin.sym} 151740 -22610 0 1 {name=p150738 lab=_77650_/A }
C {sky130_stdcells/a21oi_4.sym} 151660 -22610 0 0 {name=X_77647_ }
C {devices/lab_pin.sym} 151600 -22490 0 0 {name=p150739 lab=_62894_/A }
C {devices/lab_pin.sym} 151600 -22450 0 0 {name=p150740 lab=_62852_/X }
C {devices/lab_pin.sym} 151600 -22410 0 0 {name=p150741 lab=_62873_/C }
C {devices/lab_pin.sym} 151720 -22450 0 1 {name=p150742 lab=_62873_/Y }
C {sky130_stdcells/nor3_4.sym} 151660 -22450 0 0 {name=X_62873_ }
C {devices/lab_pin.sym} 151600 -22320 0 0 {name=p150743 lab=_81123_/D }
C {devices/lab_pin.sym} 151600 -22280 0 0 {name=p150744 lab=_80835_/Q }
C {devices/lab_pin.sym} 151720 -22300 0 1 {name=p150745 lab=_74859_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -22300 0 0 {name=X_74859_ }
C {devices/lab_pin.sym} 151580 -22200 0 0 {name=p150746 lab=_86973_/Q }
C {devices/lab_pin.sym} 151580 -22160 0 0 {name=p150747 lab=_67348_/X }
C {devices/lab_pin.sym} 151580 -22120 0 0 {name=p150748 lab=_67398_/X }
C {devices/lab_pin.sym} 151580 -22080 0 0 {name=p150749 lab=_67399_/X }
C {devices/lab_pin.sym} 151740 -22140 0 1 {name=p150750 lab=_67400_/X }
C {sky130_stdcells/a211o_4.sym} 151660 -22140 0 0 {name=X_67400_ }
C {devices/lab_pin.sym} 151580 -22020 0 0 {name=p150751 lab=_64564_/X }
C {devices/lab_pin.sym} 151580 -21980 0 0 {name=p150752 lab=_86144_/Q }
C {devices/lab_pin.sym} 151580 -21940 0 0 {name=p150753 lab=_64566_/X }
C {devices/lab_pin.sym} 151580 -21900 0 0 {name=p150754 lab=_64611_/X }
C {devices/lab_pin.sym} 151740 -21960 0 1 {name=p150755 lab=_64612_/X }
C {sky130_stdcells/a211o_4.sym} 151660 -21960 0 0 {name=X_64612_ }
C {devices/lab_pin.sym} 151600 -21820 0 0 {name=p150756 lab=_49546_/A }
C {devices/lab_pin.sym} 151600 -21780 0 0 {name=p150757 lab=_52760_/B }
C {devices/lab_pin.sym} 151720 -21800 0 1 {name=p150758 lab=_49546_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -21800 0 0 {name=X_49546_ }
C {devices/lab_pin.sym} 151620 -21670 0 0 {name=p150759 lab=_61728_/A }
C {devices/lab_pin.sym} 151700 -21670 0 1 {name=p150760 lab=_61824_/X }
C {sky130_stdcells/buf_2.sym} 151660 -21670 0 0 {name=X_61824_ }
C {devices/lab_pin.sym} 151620 -21550 0 0 {name=p150761 lab=_68380_/A }
C {devices/lab_pin.sym} 151700 -21550 0 1 {name=p150762 lab=_68380_/Y }
C {sky130_stdcells/inv_2.sym} 151660 -21550 0 0 {name=X_68380_ }
C {devices/lab_pin.sym} 151620 -21430 0 0 {name=p150763 lab=_52658_/B }
C {devices/lab_pin.sym} 151700 -21430 0 1 {name=p150764 lab=_46758_/X }
C {sky130_stdcells/buf_2.sym} 151660 -21430 0 0 {name=X_46758_ }
C {devices/lab_pin.sym} 151600 -21320 0 0 {name=p150765 lab=_65592_/A }
C {devices/lab_pin.sym} 151600 -21280 0 0 {name=p150766 lab=_86486_/Q }
C {devices/lab_pin.sym} 151720 -21300 0 1 {name=p150767 lab=_65592_/X }
C {sky130_stdcells/and2_4.sym} 151660 -21300 0 0 {name=X_65592_ }
C {devices/lab_pin.sym} 151600 -21180 0 0 {name=p150768 lab=_77578_/A }
C {devices/lab_pin.sym} 151600 -21140 0 0 {name=p150769 lab=_77577_/Y }
C {devices/lab_pin.sym} 151720 -21160 0 1 {name=p150770 lab=_82201_/D }
C {sky130_stdcells/xor2_4.sym} 151660 -21160 0 0 {name=X_77578_ }
C {devices/lab_pin.sym} 151620 -21030 0 0 {name=p150771 lab=_67806_/A }
C {devices/lab_pin.sym} 151700 -21030 0 1 {name=p150772 lab=_67331_/X }
C {sky130_stdcells/buf_2.sym} 151660 -21030 0 0 {name=X_67331_ }
C {devices/lab_pin.sym} 151600 -20920 0 0 {name=p150773 lab=_79334_/B }
C {devices/lab_pin.sym} 151600 -20880 0 0 {name=p150774 lab=_79316_/Y }
C {devices/lab_pin.sym} 151720 -20900 0 1 {name=p150775 lab=_82830_/D }
C {sky130_stdcells/xor2_4.sym} 151660 -20900 0 0 {name=X_79317_ }
C {devices/lab_pin.sym} 151620 -20770 0 0 {name=p150776 lab=_45709_/A }
C {devices/lab_pin.sym} 151700 -20770 0 1 {name=p150777 lab=_45709_/X }
C {sky130_stdcells/buf_2.sym} 151660 -20770 0 0 {name=X_45709_ }
C {devices/lab_pin.sym} 151600 -20660 0 0 {name=p150778 lab=_58370_/A }
C {devices/lab_pin.sym} 151600 -20620 0 0 {name=p150779 lab=_64521_/X }
C {devices/lab_pin.sym} 151720 -20640 0 1 {name=p150780 lab=_64543_/Y }
C {sky130_stdcells/nor2_4.sym} 151660 -20640 0 0 {name=X_64543_ }
C {devices/lab_pin.sym} 151600 -20520 0 0 {name=p150781 lab=_76584_/A }
C {devices/lab_pin.sym} 151600 -20480 0 0 {name=p150782 lab=_76529_/B }
C {devices/lab_pin.sym} 151720 -20500 0 1 {name=p150783 lab=_81627_/D }
C {sky130_stdcells/xnor2_4.sym} 151660 -20500 0 0 {name=X_76529_ }
C {devices/lab_pin.sym} 151580 -20390 0 0 {name=p150784 lab=_58830_/B }
C {devices/lab_pin.sym} 151580 -20350 0 0 {name=p150785 lab=_49470_/X }
C {devices/lab_pin.sym} 151580 -20310 0 0 {name=p150786 lab=_49476_/Y }
C {devices/lab_pin.sym} 151740 -20350 0 1 {name=p150787 lab=_49477_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -20350 0 0 {name=X_49477_ }
C {devices/lab_pin.sym} 151620 -20210 0 0 {name=p150788 lab=_61755_/A }
C {devices/lab_pin.sym} 151700 -20210 0 1 {name=p150789 lab=_61755_/X }
C {sky130_stdcells/buf_2.sym} 151660 -20210 0 0 {name=X_61755_ }
C {devices/lab_pin.sym} 151620 -20090 0 0 {name=p150790 lab=_46688_/Y }
C {devices/lab_pin.sym} 151700 -20090 0 1 {name=p150791 lab=_51787_/D }
C {sky130_stdcells/buf_2.sym} 151660 -20090 0 0 {name=X_46689_ }
C {devices/lab_pin.sym} 151620 -19970 0 0 {name=p150792 lab=clkbuf_9_358_0_CLK/X }
C {devices/lab_pin.sym} 151700 -19970 0 1 {name=p150793 lab=_88263_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 151660 -19970 0 0 {name=Xclkbuf_10_717_0_CLK }
C {devices/lab_pin.sym} 151580 -19870 0 0 {name=p150794 lab=_48372_/X }
C {devices/lab_pin.sym} 151580 -19830 0 0 {name=p150795 lab=_82363_/Q }
C {devices/lab_pin.sym} 151580 -19790 0 0 {name=p150796 lab=_48427_/Y }
C {devices/lab_pin.sym} 151740 -19830 0 1 {name=p150797 lab=_74396_/A }
C {sky130_stdcells/o21ai_4.sym} 151660 -19830 0 0 {name=X_48428_ }
C {devices/lab_pin.sym} 151580 -19730 0 0 {name=p150798 lab=_60359_/X }
C {devices/lab_pin.sym} 151580 -19690 0 0 {name=p150799 lab=_60704_/Y }
C {devices/lab_pin.sym} 151580 -19650 0 0 {name=p150800 lab=_60694_/Y }
C {devices/lab_pin.sym} 151580 -19610 0 0 {name=p150801 lab=_60696_/Y }
C {devices/lab_pin.sym} 151580 -19580 0 0 {name=p150802 lab=_60705_/Y }
C {devices/lab_pin.sym} 151740 -19650 0 1 {name=p150803 lab=_60706_/Y }
C {sky130_stdcells/a41oi_4.sym} 151660 -19650 0 0 {name=X_60706_ }
C {devices/lab_pin.sym} 151600 -19500 0 0 {name=p150804 lab=_67308_/A }
C {devices/lab_pin.sym} 151600 -19460 0 0 {name=p150805 lab=_86809_/Q }
C {devices/lab_pin.sym} 151720 -19480 0 1 {name=p150806 lab=_67262_/X }
C {sky130_stdcells/and2_4.sym} 151660 -19480 0 0 {name=X_67262_ }
C {devices/lab_pin.sym} 151600 -19370 0 0 {name=p150807 lab=_79246_/Y }
C {devices/lab_pin.sym} 151600 -19330 0 0 {name=p150808 lab=_79229_/Y }
C {devices/lab_pin.sym} 151600 -19290 0 0 {name=p150809 lab=_79248_/C }
C {devices/lab_pin.sym} 151720 -19330 0 1 {name=p150810 lab=_79248_/Y }
C {sky130_stdcells/nand3_4.sym} 151660 -19330 0 0 {name=X_79248_ }
C {devices/lab_pin.sym} 151620 -19190 0 0 {name=p150811 lab=_64474_/A }
C {devices/lab_pin.sym} 151700 -19190 0 1 {name=p150812 lab=_64474_/X }
C {sky130_stdcells/buf_2.sym} 151660 -19190 0 0 {name=X_64474_ }
C {devices/lab_pin.sym} 151620 -19070 0 0 {name=p150813 lab=_61686_/A }
C {devices/lab_pin.sym} 151700 -19070 0 1 {name=p150814 lab=_72555_/B }
C {sky130_stdcells/buf_2.sym} 151660 -19070 0 0 {name=X_61686_ }
C {devices/lab_pin.sym} 151620 -18950 0 0 {name=p150815 lab=clkbuf_8_104_0_CLK/X }
C {devices/lab_pin.sym} 151700 -18950 0 1 {name=p150816 lab=clkbuf_9_208_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 151660 -18950 0 0 {name=Xclkbuf_9_208_0_CLK }
C {devices/lab_pin.sym} 151600 -18840 0 0 {name=p150817 lab=_69001_/A }
C {devices/lab_pin.sym} 151600 -18800 0 0 {name=p150818 lab=_42528_/Y }
C {devices/lab_pin.sym} 151720 -18820 0 1 {name=p150819 lab=_69001_/Y }
C {sky130_stdcells/nor2_4.sym} 151660 -18820 0 0 {name=X_69001_ }
C {devices/lab_pin.sym} 151580 -18710 0 0 {name=p150820 lab=_66210_/X }
C {devices/lab_pin.sym} 151580 -18670 0 0 {name=p150821 lab=_66212_/X }
C {devices/lab_pin.sym} 151580 -18630 0 0 {name=p150822 lab=_65304_/X }
C {devices/lab_pin.sym} 151740 -18670 0 1 {name=p150823 lab=_66216_/A }
C {sky130_stdcells/a21o_4.sym} 151660 -18670 0 0 {name=X_66213_ }
C {devices/lab_pin.sym} 151580 -18560 0 0 {name=p150824 lab=_58421_/A }
C {devices/lab_pin.sym} 151580 -18520 0 0 {name=p150825 lab=_63370_/X }
C {devices/lab_pin.sym} 151580 -18480 0 0 {name=p150826 lab=_61390_/A }
C {devices/lab_pin.sym} 151580 -18440 0 0 {name=p150827 lab=_63372_/X }
C {devices/lab_pin.sym} 151740 -18500 0 1 {name=p150828 lab=_63425_/X }
C {sky130_stdcells/a2bb2o_4.sym} 151660 -18500 0 0 {name=X_63425_ }
C {devices/lab_pin.sym} 151600 -18360 0 0 {name=p150829 lab=_48392_/A }
C {devices/lab_pin.sym} 151600 -18320 0 0 {name=p150830 lab=_48358_/X }
C {devices/lab_pin.sym} 151720 -18340 0 1 {name=p150831 lab=_48359_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -18340 0 0 {name=X_48359_ }
C {devices/lab_pin.sym} 151620 -18210 0 0 {name=p150832 lab=_60637_/A }
C {devices/lab_pin.sym} 151700 -18210 0 1 {name=p150833 lab=_60642_/A }
C {sky130_stdcells/buf_2.sym} 151660 -18210 0 0 {name=X_60637_ }
C {devices/lab_pin.sym} 151620 -18090 0 0 {name=p150834 lab=_66953_/X }
C {devices/lab_pin.sym} 151700 -18090 0 1 {name=p150835 lab=_67193_/X }
C {sky130_stdcells/buf_2.sym} 151660 -18090 0 0 {name=X_67193_ }
C {devices/lab_pin.sym} 151580 -17990 0 0 {name=p150836 lab=_79175_/Y }
C {devices/lab_pin.sym} 151580 -17950 0 0 {name=p150837 lab=_79165_/Y }
C {devices/lab_pin.sym} 151580 -17910 0 0 {name=p150838 lab=_79173_/Y }
C {devices/lab_pin.sym} 151740 -17950 0 1 {name=p150839 lab=_79189_/A }
C {sky130_stdcells/a21oi_4.sym} 151660 -17950 0 0 {name=X_79179_ }
C {devices/lab_pin.sym} 151570 -17810 0 0 {name=p150840 lab=_84111_/CLK }
C {devices/lab_pin.sym} 151570 -17790 0 0 {name=p150841 lab=_75078_/Y }
C {devices/lab_pin.sym} 151750 -17810 0 1 {name=p150842 lab=_48959_/A }
C {sky130_stdcells/dfxtp_4.sym} 151660 -17800 0 0 {name=X_81210_ }
C {devices/lab_pin.sym} 151580 -17700 0 0 {name=p150843 lab=_64722_/X }
C {devices/lab_pin.sym} 151580 -17660 0 0 {name=p150844 lab=_85617_/Q }
C {devices/lab_pin.sym} 151580 -17620 0 0 {name=p150845 lab=_64724_/X }
C {devices/lab_pin.sym} 151580 -17580 0 0 {name=p150846 lab=_66143_/X }
C {devices/lab_pin.sym} 151740 -17640 0 1 {name=p150847 lab=_66144_/X }
C {sky130_stdcells/a211o_4.sym} 151660 -17640 0 0 {name=X_66144_ }
C {devices/lab_pin.sym} 151600 -17500 0 0 {name=p150848 lab=_51364_/A }
C {devices/lab_pin.sym} 151600 -17460 0 0 {name=p150849 lab=_50858_/B }
C {devices/lab_pin.sym} 151720 -17480 0 1 {name=p150850 lab=_51370_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -17480 0 0 {name=X_51370_ }
C {devices/lab_pin.sym} 151600 -17370 0 0 {name=p150851 lab=_60677_/A }
C {devices/lab_pin.sym} 151600 -17330 0 0 {name=p150852 lab=_63632_/A }
C {devices/lab_pin.sym} 151600 -17290 0 0 {name=p150853 lab=_60702_/C }
C {devices/lab_pin.sym} 151720 -17330 0 1 {name=p150854 lab=_63356_/X }
C {sky130_stdcells/and3_4.sym} 151660 -17330 0 0 {name=X_63356_ }
C {devices/lab_pin.sym} 151570 -17190 0 0 {name=p150855 lab=_84945_/CLK }
C {devices/lab_pin.sym} 151570 -17170 0 0 {name=p150856 lab=_82190_/D }
C {devices/lab_pin.sym} 151750 -17190 0 1 {name=p150857 lab=_82190_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -17180 0 0 {name=X_82190_ }
C {devices/lab_pin.sym} 151600 -17070 0 0 {name=p150858 lab=_60612_/A }
C {devices/lab_pin.sym} 151600 -17030 0 0 {name=p150859 lab=_60526_/B }
C {devices/lab_pin.sym} 151600 -16990 0 0 {name=p150860 lab=_79138_/A }
C {devices/lab_pin.sym} 151720 -17030 0 1 {name=p150861 lab=_60568_/Y }
C {sky130_stdcells/nor3_4.sym} 151660 -17030 0 0 {name=X_60568_ }
C {devices/lab_pin.sym} 151620 -16890 0 0 {name=p150862 lab=_50572_/A }
C {devices/lab_pin.sym} 151700 -16890 0 1 {name=p150863 lab=_50356_/A }
C {sky130_stdcells/buf_2.sym} 151660 -16890 0 0 {name=X_50321_ }
C {devices/lab_pin.sym} 151600 -16800 0 0 {name=p150864 lab=_61406_/A }
C {devices/lab_pin.sym} 151600 -16760 0 0 {name=p150865 lab=_62247_/X }
C {devices/lab_pin.sym} 151600 -16720 0 0 {name=p150866 lab=_62259_/X }
C {devices/lab_pin.sym} 151600 -16680 0 0 {name=p150867 lab=_62631_/D }
C {devices/lab_pin.sym} 151720 -16740 0 1 {name=p150868 lab=_62307_/Y }
C {sky130_stdcells/nand4_4.sym} 151660 -16740 0 0 {name=X_62307_ }
C {devices/lab_pin.sym} 151570 -16590 0 0 {name=p150869 lab=_86758_/CLK }
C {devices/lab_pin.sym} 151570 -16570 0 0 {name=p150870 lab=_81141_/D }
C {devices/lab_pin.sym} 151750 -16590 0 1 {name=p150871 lab=_40654_/A }
C {sky130_stdcells/dfxtp_4.sym} 151660 -16580 0 0 {name=X_81141_ }
C {devices/lab_pin.sym} 151580 -16480 0 0 {name=p150872 lab=_65308_/X }
C {devices/lab_pin.sym} 151580 -16440 0 0 {name=p150873 lab=_84982_/Q }
C {devices/lab_pin.sym} 151580 -16400 0 0 {name=p150874 lab=_65309_/X }
C {devices/lab_pin.sym} 151580 -16360 0 0 {name=p150875 lab=_66074_/X }
C {devices/lab_pin.sym} 151740 -16420 0 1 {name=p150876 lab=_66075_/X }
C {sky130_stdcells/a211o_4.sym} 151660 -16420 0 0 {name=X_66075_ }
C {devices/lab_pin.sym} 151580 -16310 0 0 {name=p150877 lab=_59427_/Y }
C {devices/lab_pin.sym} 151580 -16270 0 0 {name=p150878 lab=_63259_/X }
C {devices/lab_pin.sym} 151580 -16230 0 0 {name=p150879 lab=_63234_/X }
C {devices/lab_pin.sym} 151580 -16190 0 0 {name=p150880 lab=_58973_/A }
C {devices/lab_pin.sym} 151580 -16150 0 0 {name=p150881 lab=_63235_/X }
C {devices/lab_pin.sym} 151740 -16230 0 1 {name=p150882 lab=_63287_/Y }
C {sky130_stdcells/o32ai_4.sym} 151660 -16230 0 0 {name=X_63287_ }
C {devices/lab_pin.sym} 151580 -16110 0 0 {name=p150883 lab=_60387_/A }
C {devices/lab_pin.sym} 151580 -16070 0 0 {name=p150884 lab=_60392_/A }
C {devices/lab_pin.sym} 151580 -16030 0 0 {name=p150885 lab=_60392_/C }
C {devices/lab_pin.sym} 151580 -15990 0 0 {name=p150886 lab=_60387_/C }
C {devices/lab_pin.sym} 151580 -15960 0 0 {name=p150887 lab=_60383_/A }
C {devices/lab_pin.sym} 151740 -16030 0 1 {name=p150888 lab=_60566_/A }
C {sky130_stdcells/a41oi_4.sym} 151660 -16030 0 0 {name=X_60499_ }
C {devices/lab_pin.sym} 151620 -15870 0 0 {name=p150889 lab=_53147_/A }
C {devices/lab_pin.sym} 151700 -15870 0 1 {name=p150890 lab=_53040_/X }
C {sky130_stdcells/buf_2.sym} 151660 -15870 0 0 {name=X_53040_ }
C {devices/lab_pin.sym} 151580 -15780 0 0 {name=p150891 lab=_64846_/X }
C {devices/lab_pin.sym} 151580 -15740 0 0 {name=p150892 lab=_85521_/Q }
C {devices/lab_pin.sym} 151580 -15700 0 0 {name=p150893 lab=_64919_/X }
C {devices/lab_pin.sym} 151580 -15660 0 0 {name=p150894 lab=_65025_/X }
C {devices/lab_pin.sym} 151740 -15720 0 1 {name=p150895 lab=_65026_/X }
C {sky130_stdcells/a211o_4.sym} 151660 -15720 0 0 {name=X_65026_ }
C {devices/lab_pin.sym} 151580 -15590 0 0 {name=p150896 lab=_69484_/X }
C {devices/lab_pin.sym} 151580 -15550 0 0 {name=p150897 lab=_69487_/X }
C {devices/lab_pin.sym} 151580 -15510 0 0 {name=p150898 lab=_69816_/X }
C {devices/lab_pin.sym} 151740 -15550 0 1 {name=p150899 lab=_69903_/Y }
C {sky130_stdcells/a21oi_4.sym} 151660 -15550 0 0 {name=X_69903_ }
C {devices/lab_pin.sym} 151600 -15420 0 0 {name=p150900 lab=_50251_/X }
C {devices/lab_pin.sym} 151600 -15380 0 0 {name=p150901 lab=_51954_/B }
C {devices/lab_pin.sym} 151720 -15400 0 1 {name=p150902 lab=_50252_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -15400 0 0 {name=X_50252_ }
C {devices/lab_pin.sym} 151600 -15300 0 0 {name=p150903 lab=_62597_/B }
C {devices/lab_pin.sym} 151600 -15260 0 0 {name=p150904 lab=_61744_/X }
C {devices/lab_pin.sym} 151600 -15220 0 0 {name=p150905 lab=_62237_/X }
C {devices/lab_pin.sym} 151600 -15180 0 0 {name=p150906 lab=_62515_/C }
C {devices/lab_pin.sym} 151720 -15240 0 1 {name=p150907 lab=_62238_/X }
C {sky130_stdcells/and4_4.sym} 151660 -15240 0 0 {name=X_62238_ }
C {devices/lab_pin.sym} 151570 -15090 0 0 {name=p150908 lab=_81038_/CLK }
C {devices/lab_pin.sym} 151570 -15070 0 0 {name=p150909 lab=_81104_/Q }
C {devices/lab_pin.sym} 151750 -15090 0 1 {name=p150910 lab=_75267_/A }
C {sky130_stdcells/dfxtp_4.sym} 151660 -15080 0 0 {name=X_81072_ }
C {devices/lab_pin.sym} 151600 -14960 0 0 {name=p150911 lab=_80023_/A }
C {devices/lab_pin.sym} 151600 -14920 0 0 {name=p150912 lab=_80023_/B }
C {devices/lab_pin.sym} 151720 -14940 0 1 {name=p150913 lab=_80023_/Y }
C {sky130_stdcells/xnor2_4.sym} 151660 -14940 0 0 {name=X_80023_ }
C {devices/lab_pin.sym} 151570 -14810 0 0 {name=p150914 lab=_84727_/CLK }
C {devices/lab_pin.sym} 151570 -14790 0 0 {name=p150915 lab=_58239_/Y }
C {devices/lab_pin.sym} 151750 -14810 0 1 {name=p150916 lab=_84900_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -14800 0 0 {name=X_84900_ }
C {devices/lab_pin.sym} 151620 -14670 0 0 {name=p150917 lab=_87807_/Q }
C {devices/lab_pin.sym} 151700 -14670 0 1 {name=p150918 lab=_69835_/B }
C {sky130_stdcells/inv_2.sym} 151660 -14670 0 0 {name=X_69834_ }
C {devices/lab_pin.sym} 151620 -14550 0 0 {name=p150919 lab=clkbuf_4_9_0_CLK/A }
C {devices/lab_pin.sym} 151700 -14550 0 1 {name=p150920 lab=clkbuf_4_8_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 151660 -14550 0 0 {name=Xclkbuf_4_8_0_CLK }
C {devices/lab_pin.sym} 151600 -14440 0 0 {name=p150921 lab=_50131_/A }
C {devices/lab_pin.sym} 151600 -14400 0 0 {name=p150922 lab=_50183_/B }
C {devices/lab_pin.sym} 151720 -14420 0 1 {name=p150923 lab=_50183_/X }
C {sky130_stdcells/and2_4.sym} 151660 -14420 0 0 {name=X_50183_ }
C {devices/lab_pin.sym} 151600 -14320 0 0 {name=p150924 lab=_62065_/B }
C {devices/lab_pin.sym} 151600 -14280 0 0 {name=p150925 lab=_62063_/X }
C {devices/lab_pin.sym} 151600 -14240 0 0 {name=p150926 lab=_63703_/B }
C {devices/lab_pin.sym} 151600 -14200 0 0 {name=p150927 lab=_62183_/D }
C {devices/lab_pin.sym} 151720 -14260 0 1 {name=p150928 lab=_62169_/X }
C {sky130_stdcells/and4_4.sym} 151660 -14260 0 0 {name=X_62169_ }
C {devices/lab_pin.sym} 151570 -14110 0 0 {name=p150929 lab=_85879_/CLK }
C {devices/lab_pin.sym} 151570 -14090 0 0 {name=p150930 lab=_85880_/D }
C {devices/lab_pin.sym} 151750 -14110 0 1 {name=p150931 lab=_85880_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -14100 0 0 {name=X_85880_ }
C {devices/lab_pin.sym} 151570 -13970 0 0 {name=p150932 lab=_84960_/CLK }
C {devices/lab_pin.sym} 151570 -13950 0 0 {name=p150933 lab=_58512_/Y }
C {devices/lab_pin.sym} 151750 -13970 0 1 {name=p150934 lab=_64335_/C }
C {sky130_stdcells/dfxtp_4.sym} 151660 -13960 0 0 {name=X_84831_ }
C {devices/lab_pin.sym} 151580 -13860 0 0 {name=p150935 lab=_87556_/Q }
C {devices/lab_pin.sym} 151580 -13820 0 0 {name=p150936 lab=_69747_/X }
C {devices/lab_pin.sym} 151580 -13780 0 0 {name=p150937 lab=_68348_/X }
C {devices/lab_pin.sym} 151580 -13740 0 0 {name=p150938 lab=_69764_/X }
C {devices/lab_pin.sym} 151740 -13800 0 1 {name=p150939 lab=_69765_/X }
C {sky130_stdcells/a211o_4.sym} 151660 -13800 0 0 {name=X_69765_ }
C {devices/lab_pin.sym} 151620 -13650 0 0 {name=p150940 lab=_54888_/A }
C {devices/lab_pin.sym} 151700 -13650 0 1 {name=p150941 lab=_55013_/A }
C {sky130_stdcells/buf_2.sym} 151660 -13650 0 0 {name=X_54991_ }
C {devices/lab_pin.sym} 151580 -13550 0 0 {name=p150942 lab=_66974_/X }
C {devices/lab_pin.sym} 151580 -13510 0 0 {name=p150943 lab=_66976_/X }
C {devices/lab_pin.sym} 151580 -13470 0 0 {name=p150944 lab=_66905_/X }
C {devices/lab_pin.sym} 151740 -13510 0 1 {name=p150945 lab=_66977_/X }
C {sky130_stdcells/a21o_4.sym} 151660 -13510 0 0 {name=X_66977_ }
C {devices/lab_pin.sym} 151620 -13370 0 0 {name=p150946 lab=_56729_/X }
C {devices/lab_pin.sym} 151700 -13370 0 1 {name=p150947 lab=_56730_/X }
C {sky130_stdcells/buf_2.sym} 151660 -13370 0 0 {name=X_56730_ }
C {devices/lab_pin.sym} 151600 -13260 0 0 {name=p150948 lab=_68542_/X }
C {devices/lab_pin.sym} 151600 -13220 0 0 {name=p150949 lab=_87749_/Q }
C {devices/lab_pin.sym} 151720 -13240 0 1 {name=p150950 lab=_68716_/X }
C {sky130_stdcells/and2_4.sym} 151660 -13240 0 0 {name=X_68716_ }
C {devices/lab_pin.sym} 151570 -13110 0 0 {name=p150951 lab=_87820_/CLK }
C {devices/lab_pin.sym} 151570 -13090 0 0 {name=p150952 lab=_43171_/Y }
C {devices/lab_pin.sym} 151750 -13110 0 1 {name=p150953 lab=_43170_/A }
C {sky130_stdcells/dfxtp_4.sym} 151660 -13100 0 0 {name=X_87550_ }
C {devices/lab_pin.sym} 151600 -12980 0 0 {name=p150954 lab=_53942_/A }
C {devices/lab_pin.sym} 151600 -12940 0 0 {name=p150955 lab=_46242_/Y }
C {devices/lab_pin.sym} 151720 -12960 0 1 {name=p150956 lab=_53942_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -12960 0 0 {name=X_53942_ }
C {devices/lab_pin.sym} 151600 -12840 0 0 {name=p150957 lab=_65928_/A }
C {devices/lab_pin.sym} 151600 -12800 0 0 {name=p150958 lab=_65927_/Y }
C {devices/lab_pin.sym} 151720 -12820 0 1 {name=p150959 lab=_65928_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -12820 0 0 {name=X_65928_ }
C {devices/lab_pin.sym} 151570 -12690 0 0 {name=p150960 lab=_85485_/CLK }
C {devices/lab_pin.sym} 151570 -12670 0 0 {name=p150961 lab=_84762_/D }
C {devices/lab_pin.sym} 151750 -12690 0 1 {name=p150962 lab=_84762_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -12680 0 0 {name=X_84762_ }
C {devices/lab_pin.sym} 151620 -12550 0 0 {name=p150963 lab=_69696_/A }
C {devices/lab_pin.sym} 151700 -12550 0 1 {name=p150964 lab=_69696_/X }
C {sky130_stdcells/buf_2.sym} 151660 -12550 0 0 {name=X_69696_ }
C {devices/lab_pin.sym} 151570 -12430 0 0 {name=p150965 lab=_82234_/CLK }
C {devices/lab_pin.sym} 151570 -12410 0 0 {name=p150966 lab=_83902_/Q }
C {devices/lab_pin.sym} 151750 -12430 0 1 {name=p150967 lab=_81974_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -12420 0 0 {name=X_81974_ }
C {devices/lab_pin.sym} 151570 -12290 0 0 {name=p150968 lab=_86499_/CLK }
C {devices/lab_pin.sym} 151570 -12270 0 0 {name=p150969 lab=_48681_/Y }
C {devices/lab_pin.sym} 151750 -12290 0 1 {name=p150970 lab=_86501_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -12280 0 0 {name=X_86501_ }
C {devices/lab_pin.sym} 151570 -12150 0 0 {name=p150971 lab=_86303_/CLK }
C {devices/lab_pin.sym} 151570 -12130 0 0 {name=p150972 lab=_70741_/Y }
C {devices/lab_pin.sym} 151750 -12150 0 1 {name=p150973 lab=_47526_/A }
C {sky130_stdcells/dfxtp_4.sym} 151660 -12140 0 0 {name=X_83713_ }
C {devices/lab_pin.sym} 151570 -12010 0 0 {name=p150974 lab=_80928_/CLK }
C {devices/lab_pin.sym} 151570 -11990 0 0 {name=p150975 lab=_84101_/Q }
C {devices/lab_pin.sym} 151750 -12010 0 1 {name=p150976 lab=_80925_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -12000 0 0 {name=X_80925_ }
C {devices/lab_pin.sym} 151600 -11890 0 0 {name=p150977 lab=_56651_/Y }
C {devices/lab_pin.sym} 151600 -11850 0 0 {name=p150978 lab=_56655_/Y }
C {devices/lab_pin.sym} 151600 -11810 0 0 {name=p150979 lab=_56661_/C }
C {devices/lab_pin.sym} 151720 -11850 0 1 {name=p150980 lab=_56661_/Y }
C {sky130_stdcells/nor3_4.sym} 151660 -11850 0 0 {name=X_56661_ }
C {devices/lab_pin.sym} 151600 -11720 0 0 {name=p150981 lab=_68647_/A }
C {devices/lab_pin.sym} 151600 -11680 0 0 {name=p150982 lab=_68646_/X }
C {devices/lab_pin.sym} 151720 -11700 0 1 {name=p150983 lab=_68647_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -11700 0 0 {name=X_68647_ }
C {devices/lab_pin.sym} 151570 -11570 0 0 {name=p150984 lab=_87993_/CLK }
C {devices/lab_pin.sym} 151570 -11550 0 0 {name=p150985 lab=_87481_/D }
C {devices/lab_pin.sym} 151750 -11570 0 1 {name=p150986 lab=_87481_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -11560 0 0 {name=X_87481_ }
C {devices/lab_pin.sym} 151580 -11450 0 0 {name=p150987 lab=_85551_/Q }
C {devices/lab_pin.sym} 151580 -11410 0 0 {name=p150988 lab=_53869_/X }
C {devices/lab_pin.sym} 151580 -11370 0 0 {name=p150989 lab=_53872_/Y }
C {devices/lab_pin.sym} 151740 -11410 0 1 {name=p150990 lab=_53873_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -11410 0 0 {name=X_53873_ }
C {devices/lab_pin.sym} 151620 -11270 0 0 {name=p150991 lab=_65859_/A }
C {devices/lab_pin.sym} 151700 -11270 0 1 {name=p150992 lab=_65859_/X }
C {sky130_stdcells/buf_2.sym} 151660 -11270 0 0 {name=X_65859_ }
C {devices/lab_pin.sym} 151570 -11150 0 0 {name=p150993 lab=_84713_/CLK }
C {devices/lab_pin.sym} 151570 -11130 0 0 {name=p150994 lab=_84693_/D }
C {devices/lab_pin.sym} 151750 -11150 0 1 {name=p150995 lab=_80413_/A }
C {sky130_stdcells/dfxtp_4.sym} 151660 -11140 0 0 {name=X_84693_ }
C {devices/lab_pin.sym} 151600 -11020 0 0 {name=p150996 lab=_58400_/A }
C {devices/lab_pin.sym} 151600 -10980 0 0 {name=p150997 lab=_58403_/B }
C {devices/lab_pin.sym} 151720 -11000 0 1 {name=p150998 lab=_58400_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -11000 0 0 {name=X_58400_ }
C {devices/lab_pin.sym} 151600 -10880 0 0 {name=p150999 lab=_55607_/A }
C {devices/lab_pin.sym} 151600 -10840 0 0 {name=p151000 lab=_45425_/Y }
C {devices/lab_pin.sym} 151720 -10860 0 1 {name=p151001 lab=_55612_/Y }
C {sky130_stdcells/nor2_4.sym} 151660 -10860 0 0 {name=X_55612_ }
C {devices/lab_pin.sym} 151570 -10730 0 0 {name=p151002 lab=_85535_/CLK }
C {devices/lab_pin.sym} 151570 -10710 0 0 {name=p151003 lab=_49217_/Y }
C {devices/lab_pin.sym} 151750 -10730 0 1 {name=p151004 lab=_86432_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -10720 0 0 {name=X_86432_ }
C {devices/lab_pin.sym} 151580 -10610 0 0 {name=p151005 lab=_85748_/Q }
C {devices/lab_pin.sym} 151580 -10570 0 0 {name=p151006 lab=_52821_/X }
C {devices/lab_pin.sym} 151580 -10530 0 0 {name=p151007 lab=_52823_/Y }
C {devices/lab_pin.sym} 151740 -10570 0 1 {name=p151008 lab=_52824_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -10570 0 0 {name=X_52824_ }
C {devices/lab_pin.sym} 151580 -10450 0 0 {name=p151009 lab=_59331_/X }
C {devices/lab_pin.sym} 151580 -10410 0 0 {name=p151010 lab=_85410_/Q }
C {devices/lab_pin.sym} 151580 -10370 0 0 {name=p151011 lab=_59379_/X }
C {devices/lab_pin.sym} 151740 -10410 0 1 {name=p151012 lab=_59380_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -10410 0 0 {name=X_59380_ }
C {devices/lab_pin.sym} 151570 -10270 0 0 {name=p151013 lab=_86422_/CLK }
C {devices/lab_pin.sym} 151570 -10250 0 0 {name=p151014 lab=_83644_/D }
C {devices/lab_pin.sym} 151750 -10270 0 1 {name=p151015 lab=_83644_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -10260 0 0 {name=X_83644_ }
C {devices/lab_pin.sym} 151620 -10130 0 0 {name=p151016 lab=_46233_/Y }
C {devices/lab_pin.sym} 151700 -10130 0 1 {name=p151017 lab=_56593_/A }
C {sky130_stdcells/buf_2.sym} 151660 -10130 0 0 {name=X_56592_ }
C {devices/lab_pin.sym} 151570 -10010 0 0 {name=p151018 lab=_80740_/CLK }
C {devices/lab_pin.sym} 151570 -9990 0 0 {name=p151019 lab=_80888_/Q }
C {devices/lab_pin.sym} 151750 -10010 0 1 {name=p151020 lab=_75020_/C }
C {sky130_stdcells/dfxtp_4.sym} 151660 -10000 0 0 {name=X_80856_ }
C {devices/lab_pin.sym} 151580 -9900 0 0 {name=p151021 lab=_87499_/Q }
C {devices/lab_pin.sym} 151580 -9860 0 0 {name=p151022 lab=_68504_/X }
C {devices/lab_pin.sym} 151580 -9820 0 0 {name=p151023 lab=_68450_/X }
C {devices/lab_pin.sym} 151580 -9780 0 0 {name=p151024 lab=_68577_/X }
C {devices/lab_pin.sym} 151740 -9840 0 1 {name=p151025 lab=_68578_/X }
C {sky130_stdcells/a211o_4.sym} 151660 -9840 0 0 {name=X_68578_ }
C {devices/lab_pin.sym} 151600 -9700 0 0 {name=p151026 lab=_58331_/A }
C {devices/lab_pin.sym} 151600 -9660 0 0 {name=p151027 lab=_58364_/B }
C {devices/lab_pin.sym} 151720 -9680 0 1 {name=p151028 lab=_58331_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -9680 0 0 {name=X_58331_ }
C {devices/lab_pin.sym} 151580 -9580 0 0 {name=p151029 lab=_85113_/Q }
C {devices/lab_pin.sym} 151580 -9540 0 0 {name=p151030 lab=_55510_/X }
C {devices/lab_pin.sym} 151580 -9500 0 0 {name=p151031 lab=_44048_/X }
C {devices/lab_pin.sym} 151580 -9460 0 0 {name=p151032 lab=_55542_/Y }
C {devices/lab_pin.sym} 151740 -9520 0 1 {name=p151033 lab=_55543_/X }
C {sky130_stdcells/a211o_4.sym} 151660 -9520 0 0 {name=X_55543_ }
C {devices/lab_pin.sym} 151580 -9390 0 0 {name=p151034 lab=_67526_/X }
C {devices/lab_pin.sym} 151580 -9350 0 0 {name=p151035 lab=_67528_/X }
C {devices/lab_pin.sym} 151580 -9310 0 0 {name=p151036 lab=_67502_/X }
C {devices/lab_pin.sym} 151740 -9350 0 1 {name=p151037 lab=_67532_/A }
C {sky130_stdcells/a21o_4.sym} 151660 -9350 0 0 {name=X_67529_ }
C {devices/lab_pin.sym} 151570 -9210 0 0 {name=p151038 lab=_83049_/CLK }
C {devices/lab_pin.sym} 151570 -9190 0 0 {name=p151039 lab=_86363_/D }
C {devices/lab_pin.sym} 151750 -9210 0 1 {name=p151040 lab=_86363_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -9200 0 0 {name=X_86363_ }
C {devices/lab_pin.sym} 151620 -9070 0 0 {name=p151041 lab=_52783_/A }
C {devices/lab_pin.sym} 151700 -9070 0 1 {name=p151042 lab=_52755_/X }
C {sky130_stdcells/buf_2.sym} 151660 -9070 0 0 {name=X_52755_ }
C {devices/lab_pin.sym} 151570 -8950 0 0 {name=p151043 lab=_86505_/CLK }
C {devices/lab_pin.sym} 151570 -8930 0 0 {name=p151044 lab=_71200_/Y }
C {devices/lab_pin.sym} 151750 -8950 0 1 {name=p151045 lab=_48559_/A }
C {sky130_stdcells/dfxtp_4.sym} 151660 -8940 0 0 {name=X_83575_ }
C {devices/lab_pin.sym} 151570 -8810 0 0 {name=p151046 lab=_80754_/CLK }
C {devices/lab_pin.sym} 151570 -8790 0 0 {name=p151047 lab=_80787_/D }
C {devices/lab_pin.sym} 151750 -8810 0 1 {name=p151048 lab=_75329_/A }
C {sky130_stdcells/dfxtp_4.sym} 151660 -8800 0 0 {name=X_80787_ }
C {devices/lab_pin.sym} 151570 -8670 0 0 {name=p151049 lab=_88108_/CLK }
C {devices/lab_pin.sym} 151570 -8650 0 0 {name=p151050 lab=_41930_/Y }
C {devices/lab_pin.sym} 151750 -8670 0 1 {name=p151051 lab=_88102_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -8660 0 0 {name=X_88102_ }
C {devices/lab_pin.sym} 151570 -8530 0 0 {name=p151052 lab=_85346_/CLK }
C {devices/lab_pin.sym} 151570 -8510 0 0 {name=p151053 lab=_85314_/D }
C {devices/lab_pin.sym} 151750 -8530 0 1 {name=p151054 lab=_85314_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -8520 0 0 {name=X_85314_ }
C {devices/lab_pin.sym} 151580 -8410 0 0 {name=p151055 lab=_51704_/Y }
C {devices/lab_pin.sym} 151580 -8370 0 0 {name=p151056 lab=_51693_/X }
C {devices/lab_pin.sym} 151580 -8330 0 0 {name=p151057 lab=_51705_/X }
C {devices/lab_pin.sym} 151740 -8370 0 1 {name=p151058 lab=_51706_/Y }
C {sky130_stdcells/a21oi_4.sym} 151660 -8370 0 0 {name=X_51706_ }
C {devices/lab_pin.sym} 151620 -8230 0 0 {name=p151059 lab=_71215_/C }
C {devices/lab_pin.sym} 151700 -8230 0 1 {name=p151060 lab=_70550_/D }
C {sky130_stdcells/buf_2.sym} 151660 -8230 0 0 {name=X_70540_ }
C {devices/lab_pin.sym} 151600 -8120 0 0 {name=p151061 lab=_58261_/Y }
C {devices/lab_pin.sym} 151600 -8080 0 0 {name=p151062 lab=_58268_/B }
C {devices/lab_pin.sym} 151720 -8100 0 1 {name=p151063 lab=_58262_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -8100 0 0 {name=X_58262_ }
C {devices/lab_pin.sym} 151570 -7970 0 0 {name=p151064 lab=_82624_/CLK }
C {devices/lab_pin.sym} 151570 -7950 0 0 {name=p151065 lab=_79090_/Y }
C {devices/lab_pin.sym} 151750 -7970 0 1 {name=p151066 lab=_78748_/A }
C {sky130_stdcells/dfxtp_4.sym} 151660 -7960 0 0 {name=X_82526_ }
C {devices/lab_pin.sym} 151580 -7850 0 0 {name=p151067 lab=_55471_/X }
C {devices/lab_pin.sym} 151580 -7810 0 0 {name=p151068 lab=_55473_/X }
C {devices/lab_pin.sym} 151580 -7770 0 0 {name=p151069 lab=_44112_/X }
C {devices/lab_pin.sym} 151740 -7810 0 1 {name=p151070 lab=_55474_/X }
C {sky130_stdcells/a21o_4.sym} 151660 -7810 0 0 {name=X_55474_ }
C {devices/lab_pin.sym} 151570 -7670 0 0 {name=p151071 lab=_86611_/CLK }
C {devices/lab_pin.sym} 151570 -7650 0 0 {name=p151072 lab=_49948_/Y }
C {devices/lab_pin.sym} 151750 -7670 0 1 {name=p151073 lab=_72251_/B }
C {sky130_stdcells/dfxtp_4.sym} 151660 -7660 0 0 {name=X_86294_ }
C {devices/lab_pin.sym} 151600 -7540 0 0 {name=p151074 lab=_52706_/A }
C {devices/lab_pin.sym} 151600 -7500 0 0 {name=p151075 lab=_52686_/B }
C {devices/lab_pin.sym} 151720 -7520 0 1 {name=p151076 lab=_52686_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -7520 0 0 {name=X_52686_ }
C {devices/lab_pin.sym} 151620 -7390 0 0 {name=p151077 lab=clkbuf_9_510_0_CLK/X }
C {devices/lab_pin.sym} 151700 -7390 0 1 {name=p151078 lab=_86499_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 151660 -7390 0 0 {name=Xclkbuf_10_1021_0_CLK }
C {devices/lab_pin.sym} 151580 -7300 0 0 {name=p151079 lab=_57096_/Y }
C {devices/lab_pin.sym} 151580 -7260 0 0 {name=p151080 lab=_57209_/Y }
C {devices/lab_pin.sym} 151580 -7220 0 0 {name=p151081 lab=_57210_/Y }
C {devices/lab_pin.sym} 151580 -7180 0 0 {name=p151082 lab=_57212_/Y }
C {devices/lab_pin.sym} 151740 -7240 0 1 {name=p151083 lab=_57214_/A }
C {sky130_stdcells/a211o_4.sym} 151660 -7240 0 0 {name=X_57213_ }
C {devices/lab_pin.sym} 151570 -7090 0 0 {name=p151084 lab=_88036_/CLK }
C {devices/lab_pin.sym} 151570 -7070 0 0 {name=p151085 lab=_88033_/D }
C {devices/lab_pin.sym} 151750 -7090 0 1 {name=p151086 lab=_88033_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -7080 0 0 {name=X_88033_ }
C {devices/lab_pin.sym} 151600 -6960 0 0 {name=p151087 lab=_54425_/A }
C {devices/lab_pin.sym} 151600 -6920 0 0 {name=p151088 lab=_52732_/B }
C {devices/lab_pin.sym} 151720 -6940 0 1 {name=p151089 lab=_54425_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -6940 0 0 {name=X_54425_ }
C {devices/lab_pin.sym} 151570 -6810 0 0 {name=p151090 lab=_85244_/CLK }
C {devices/lab_pin.sym} 151570 -6790 0 0 {name=p151091 lab=_85245_/D }
C {devices/lab_pin.sym} 151750 -6810 0 1 {name=p151092 lab=_85245_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -6800 0 0 {name=X_85245_ }
C {devices/lab_pin.sym} 151600 -6680 0 0 {name=p151093 lab=_51627_/A }
C {devices/lab_pin.sym} 151600 -6640 0 0 {name=p151094 lab=_53161_/B }
C {devices/lab_pin.sym} 151720 -6660 0 1 {name=p151095 lab=_51637_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -6660 0 0 {name=X_51637_ }
C {devices/lab_pin.sym} 151580 -6550 0 0 {name=p151096 lab=_70466_/Y }
C {devices/lab_pin.sym} 151580 -6510 0 0 {name=p151097 lab=_83768_/Q }
C {devices/lab_pin.sym} 151580 -6470 0 0 {name=p151098 lab=_70470_/X }
C {devices/lab_pin.sym} 151740 -6510 0 1 {name=p151099 lab=_70471_/X }
C {sky130_stdcells/a21o_4.sym} 151660 -6510 0 0 {name=X_70471_ }
C {devices/lab_pin.sym} 151620 -6370 0 0 {name=p151100 lab=_62124_/B }
C {devices/lab_pin.sym} 151700 -6370 0 1 {name=p151101 lab=_58194_/A }
C {sky130_stdcells/buf_2.sym} 151660 -6370 0 0 {name=X_58193_ }
C {devices/lab_pin.sym} 151570 -6250 0 0 {name=p151102 lab=_82425_/CLK }
C {devices/lab_pin.sym} 151570 -6230 0 0 {name=p151103 lab=_79149_/X }
C {devices/lab_pin.sym} 151750 -6250 0 1 {name=p151104 lab=_82457_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -6240 0 0 {name=X_82457_ }
C {devices/lab_pin.sym} 151580 -6130 0 0 {name=p151105 lab=_72123_/X }
C {devices/lab_pin.sym} 151580 -6090 0 0 {name=p151106 lab=_85690_/Q }
C {devices/lab_pin.sym} 151580 -6050 0 0 {name=p151107 lab=_72146_/X }
C {devices/lab_pin.sym} 151740 -6090 0 1 {name=p151108 lab=_72210_/X }
C {sky130_stdcells/o21a_4.sym} 151660 -6090 0 0 {name=X_72210_ }
C {devices/lab_pin.sym} 151580 -5970 0 0 {name=p151109 lab=_57142_/X }
C {devices/lab_pin.sym} 151580 -5930 0 0 {name=p151110 lab=_57143_/X }
C {devices/lab_pin.sym} 151580 -5890 0 0 {name=p151111 lab=_45835_/A }
C {devices/lab_pin.sym} 151740 -5930 0 1 {name=p151112 lab=_57144_/X }
C {sky130_stdcells/a21o_4.sym} 151660 -5930 0 0 {name=X_57144_ }
C {devices/lab_pin.sym} 151570 -5790 0 0 {name=p151113 lab=_81351_/CLK }
C {devices/lab_pin.sym} 151570 -5770 0 0 {name=p151114 lab=_83944_/Q }
C {devices/lab_pin.sym} 151750 -5790 0 1 {name=p151115 lab=_76773_/B }
C {sky130_stdcells/dfxtp_4.sym} 151660 -5780 0 0 {name=X_81408_ }
C {devices/lab_pin.sym} 151580 -5670 0 0 {name=p151116 lab=_85457_/Q }
C {devices/lab_pin.sym} 151580 -5630 0 0 {name=p151117 lab=_54349_/X }
C {devices/lab_pin.sym} 151580 -5590 0 0 {name=p151118 lab=_54355_/Y }
C {devices/lab_pin.sym} 151740 -5630 0 1 {name=p151119 lab=_54356_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -5630 0 0 {name=X_54356_ }
C {devices/lab_pin.sym} 151620 -5490 0 0 {name=p151120 lab=_41872_/A }
C {devices/lab_pin.sym} 151700 -5490 0 1 {name=p151121 lab=_42370_/X }
C {sky130_stdcells/buf_2.sym} 151660 -5490 0 0 {name=X_42370_ }
C {devices/lab_pin.sym} 151600 -5380 0 0 {name=p151122 lab=_73180_/Y }
C {devices/lab_pin.sym} 151600 -5340 0 0 {name=p151123 lab=_73189_/X }
C {devices/lab_pin.sym} 151720 -5360 0 1 {name=p151124 lab=_73190_/X }
C {sky130_stdcells/xor2_4.sym} 151660 -5360 0 0 {name=X_73190_ }
C {devices/lab_pin.sym} 151570 -5230 0 0 {name=p151125 lab=_85270_/CLK }
C {devices/lab_pin.sym} 151570 -5210 0 0 {name=p151126 lab=_85176_/D }
C {devices/lab_pin.sym} 151750 -5230 0 1 {name=p151127 lab=_85176_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -5220 0 0 {name=X_85176_ }
C {devices/lab_pin.sym} 151600 -5100 0 0 {name=p151128 lab=_51590_/A }
C {devices/lab_pin.sym} 151600 -5060 0 0 {name=p151129 lab=_53095_/B }
C {devices/lab_pin.sym} 151720 -5080 0 1 {name=p151130 lab=_51568_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -5080 0 0 {name=X_51568_ }
C {devices/lab_pin.sym} 151570 -4950 0 0 {name=p151131 lab=_85491_/CLK }
C {devices/lab_pin.sym} 151570 -4930 0 0 {name=p151132 lab=_82196_/Q }
C {devices/lab_pin.sym} 151750 -4950 0 1 {name=p151133 lab=_47046_/A }
C {sky130_stdcells/dfxtp_4.sym} 151660 -4940 0 0 {name=X_82388_ }
C {devices/lab_pin.sym} 151620 -4810 0 0 {name=p151134 lab=_41320_/X }
C {devices/lab_pin.sym} 151700 -4810 0 1 {name=p151135 lab=_41321_/X }
C {sky130_stdcells/buf_2.sym} 151660 -4810 0 0 {name=X_41321_ }
C {devices/lab_pin.sym} 151600 -4720 0 0 {name=p151136 lab=_53293_/A }
C {devices/lab_pin.sym} 151600 -4680 0 0 {name=p151137 lab=_53293_/B }
C {devices/lab_pin.sym} 151600 -4640 0 0 {name=p151138 lab=_53302_/X }
C {devices/lab_pin.sym} 151600 -4600 0 0 {name=p151139 lab=_52790_/D }
C {devices/lab_pin.sym} 151720 -4660 0 1 {name=p151140 lab=_53307_/X }
C {sky130_stdcells/and4_4.sym} 151660 -4660 0 0 {name=X_53307_ }
C {devices/lab_pin.sym} 151620 -4510 0 0 {name=p151141 lab=_72417_/A }
C {devices/lab_pin.sym} 151700 -4510 0 1 {name=p151142 lab=_72141_/X }
C {sky130_stdcells/buf_2.sym} 151660 -4510 0 0 {name=X_72141_ }
C {devices/lab_pin.sym} 151570 -4390 0 0 {name=p151143 lab=_84166_/CLK }
C {devices/lab_pin.sym} 151570 -4370 0 0 {name=p151144 lab=_84127_/D }
C {devices/lab_pin.sym} 151750 -4390 0 1 {name=p151145 lab=_66420_/C }
C {sky130_stdcells/dfxtp_4.sym} 151660 -4380 0 0 {name=X_84127_ }
C {devices/lab_pin.sym} 151600 -4270 0 0 {name=p151146 lab=_48841_/A }
C {devices/lab_pin.sym} 151600 -4230 0 0 {name=p151147 lab=_50526_/B }
C {devices/lab_pin.sym} 151600 -4190 0 0 {name=p151148 lab=_50526_/C }
C {devices/lab_pin.sym} 151720 -4230 0 1 {name=p151149 lab=_50519_/X }
C {sky130_stdcells/and3_4.sym} 151660 -4230 0 0 {name=X_50519_ }
C {devices/lab_pin.sym} 151620 -4090 0 0 {name=p151150 lab=_57075_/A }
C {devices/lab_pin.sym} 151700 -4090 0 1 {name=p151151 lab=_57075_/Y }
C {sky130_stdcells/inv_2.sym} 151660 -4090 0 0 {name=X_57075_ }
C {devices/lab_pin.sym} 151570 -3970 0 0 {name=p151152 lab=_81575_/CLK }
C {devices/lab_pin.sym} 151570 -3950 0 0 {name=p151153 lab=_81339_/D }
C {devices/lab_pin.sym} 151750 -3970 0 1 {name=p151154 lab=_81339_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -3960 0 0 {name=X_81339_ }
C {devices/lab_pin.sym} 151580 -3850 0 0 {name=p151155 lab=_54282_/Y }
C {devices/lab_pin.sym} 151580 -3810 0 0 {name=p151156 lab=_54285_/X }
C {devices/lab_pin.sym} 151580 -3770 0 0 {name=p151157 lab=_54286_/X }
C {devices/lab_pin.sym} 151740 -3810 0 1 {name=p151158 lab=_54287_/Y }
C {sky130_stdcells/a21oi_4.sym} 151660 -3810 0 0 {name=X_54287_ }
C {devices/lab_pin.sym} 151600 -3700 0 0 {name=p151159 lab=_51509_/A }
C {devices/lab_pin.sym} 151600 -3660 0 0 {name=p151160 lab=_51494_/B }
C {devices/lab_pin.sym} 151600 -3620 0 0 {name=p151161 lab=_51522_/C }
C {devices/lab_pin.sym} 151600 -3580 0 0 {name=p151162 lab=_53023_/D }
C {devices/lab_pin.sym} 151720 -3640 0 1 {name=p151163 lab=_51499_/X }
C {sky130_stdcells/and4_4.sym} 151660 -3640 0 0 {name=X_51499_ }
C {devices/lab_pin.sym} 151580 -3530 0 0 {name=p151164 lab=_60371_/A }
C {devices/lab_pin.sym} 151580 -3490 0 0 {name=p151165 lab=_44031_/X }
C {devices/lab_pin.sym} 151580 -3450 0 0 {name=p151166 lab=_57811_/A }
C {devices/lab_pin.sym} 151580 -3410 0 0 {name=p151167 lab=_59297_/A }
C {devices/lab_pin.sym} 151580 -3380 0 0 {name=p151168 lab=_44039_/X }
C {devices/lab_pin.sym} 151740 -3450 0 1 {name=p151169 lab=_44160_/A }
C {sky130_stdcells/a41oi_4.sym} 151660 -3450 0 0 {name=X_44040_ }
C {devices/lab_pin.sym} 151620 -3290 0 0 {name=p151170 lab=_56025_/X }
C {devices/lab_pin.sym} 151700 -3290 0 1 {name=p151171 lab=_56026_/X }
C {sky130_stdcells/buf_2.sym} 151660 -3290 0 0 {name=X_56026_ }
C {devices/lab_pin.sym} 151620 -3170 0 0 {name=p151172 lab=_40755_/A }
C {devices/lab_pin.sym} 151700 -3170 0 1 {name=p151173 lab=_41253_/A }
C {sky130_stdcells/buf_2.sym} 151660 -3170 0 0 {name=X_41252_ }
C {devices/lab_pin.sym} 151600 -3080 0 0 {name=p151174 lab=_53217_/A }
C {devices/lab_pin.sym} 151600 -3040 0 0 {name=p151175 lab=_53244_/B }
C {devices/lab_pin.sym} 151600 -3000 0 0 {name=p151176 lab=_53222_/X }
C {devices/lab_pin.sym} 151600 -2960 0 0 {name=p151177 lab=_53238_/D }
C {devices/lab_pin.sym} 151720 -3020 0 1 {name=p151178 lab=_53238_/X }
C {sky130_stdcells/and4_4.sym} 151660 -3020 0 0 {name=X_53238_ }
C {devices/lab_pin.sym} 151600 -2880 0 0 {name=p151179 lab=_72053_/A }
C {devices/lab_pin.sym} 151600 -2840 0 0 {name=p151180 lab=_72072_/B }
C {devices/lab_pin.sym} 151720 -2860 0 1 {name=p151181 lab=_72072_/Y }
C {sky130_stdcells/nand2_4.sym} 151660 -2860 0 0 {name=X_72072_ }
C {devices/lab_pin.sym} 151570 -2730 0 0 {name=p151182 lab=_81461_/CLK }
C {devices/lab_pin.sym} 151570 -2710 0 0 {name=p151183 lab=_67712_/X }
C {devices/lab_pin.sym} 151750 -2730 0 1 {name=p151184 lab=_81490_/D }
C {sky130_stdcells/dfxtp_4.sym} 151660 -2720 0 0 {name=X_84058_ }
C {devices/lab_pin.sym} 151620 -2590 0 0 {name=p151185 lab=_70771_/A }
C {devices/lab_pin.sym} 151700 -2590 0 1 {name=p151186 lab=_71173_/A }
C {sky130_stdcells/buf_2.sym} 151660 -2590 0 0 {name=X_71023_ }
C {devices/lab_pin.sym} 151600 -2480 0 0 {name=p151187 lab=_61250_/C }
C {devices/lab_pin.sym} 151600 -2440 0 0 {name=p151188 lab=_62921_/C }
C {devices/lab_pin.sym} 151720 -2460 0 1 {name=p151189 lab=_75900_/X }
C {sky130_stdcells/xor2_4.sym} 151660 -2460 0 0 {name=X_75900_ }
C {devices/lab_pin.sym} 151570 -2330 0 0 {name=p151190 lab=_85075_/CLK }
C {devices/lab_pin.sym} 151570 -2310 0 0 {name=p151191 lab=_83009_/D }
C {devices/lab_pin.sym} 151750 -2330 0 1 {name=p151192 lab=_83009_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -2320 0 0 {name=X_83009_ }
C {devices/lab_pin.sym} 151580 -2220 0 0 {name=p151193 lab=_41179_/X }
C {devices/lab_pin.sym} 151580 -2180 0 0 {name=p151194 lab=_41181_/X }
C {devices/lab_pin.sym} 151580 -2140 0 0 {name=p151195 lab=_68708_/B }
C {devices/lab_pin.sym} 151580 -2100 0 0 {name=p151196 lab=_41182_/X }
C {devices/lab_pin.sym} 151740 -2160 0 1 {name=p151197 lab=_41183_/X }
C {sky130_stdcells/a2bb2o_4.sym} 151660 -2160 0 0 {name=X_41183_ }
C {devices/lab_pin.sym} 151620 -2010 0 0 {name=p151198 lab=_53195_/A }
C {devices/lab_pin.sym} 151700 -2010 0 1 {name=p151199 lab=_53169_/X }
C {sky130_stdcells/buf_2.sym} 151660 -2010 0 0 {name=X_53169_ }
C {devices/lab_pin.sym} 151600 -1900 0 0 {name=p151200 lab=_76874_/Y }
C {devices/lab_pin.sym} 151600 -1860 0 0 {name=p151201 lab=_76873_/Y }
C {devices/lab_pin.sym} 151720 -1880 0 1 {name=p151202 lab=_76881_/C }
C {sky130_stdcells/nand2_4.sym} 151660 -1880 0 0 {name=X_76880_ }
C {devices/lab_pin.sym} 151620 -1750 0 0 {name=p151203 lab=_75831_/A }
C {devices/lab_pin.sym} 151700 -1750 0 1 {name=p151204 lab=_75836_/A }
C {sky130_stdcells/inv_2.sym} 151660 -1750 0 0 {name=X_75831_ }
C {devices/lab_pin.sym} 151570 -1630 0 0 {name=p151205 lab=_88326_/CLK }
C {devices/lab_pin.sym} 151570 -1610 0 0 {name=p151206 lab=_42567_/Y }
C {devices/lab_pin.sym} 151750 -1630 0 1 {name=p151207 lab=_87817_/Q }
C {sky130_stdcells/dfxtp_4.sym} 151660 -1620 0 0 {name=X_87817_ }
C {devices/lab_pin.sym} 151620 -1490 0 0 {name=p151208 lab=_45991_/A }
C {devices/lab_pin.sym} 151700 -1490 0 1 {name=p151209 lab=_45991_/Y }
C {sky130_stdcells/inv_2.sym} 151660 -1490 0 0 {name=X_45991_ }
C {devices/lab_pin.sym} 151580 -1390 0 0 {name=p151210 lab=_57939_/X }
C {devices/lab_pin.sym} 151580 -1350 0 0 {name=p151211 lab=_85999_/Q }
C {devices/lab_pin.sym} 151580 -1310 0 0 {name=p151212 lab=_57976_/X }
C {devices/lab_pin.sym} 151740 -1350 0 1 {name=p151213 lab=_57977_/Y }
C {sky130_stdcells/o21ai_4.sym} 151660 -1350 0 0 {name=X_57977_ }
C {devices/lab_pin.sym} 151620 -1210 0 0 {name=p151214 lab=_47729_/Y }
C {devices/lab_pin.sym} 151700 -1210 0 1 {name=p151215 lab=_53211_/D }
C {sky130_stdcells/buf_2.sym} 151660 -1210 0 0 {name=X_47730_ }
C {devices/lab_pin.sym} 151600 -1110 0 0 {name=p151216 lab=_59716_/A }
C {devices/lab_pin.sym} 151600 -1070 0 0 {name=p151217 lab=_59716_/B }
C {devices/lab_pin.sym} 151600 -1030 0 0 {name=p151218 lab=_60132_/A }
C {devices/lab_pin.sym} 151720 -1070 0 1 {name=p151219 lab=_59716_/Y }
C {sky130_stdcells/nand3_4.sym} 151660 -1070 0 0 {name=X_59716_ }
C {devices/lab_pin.sym} 151600 -940 0 0 {name=p151220 lab=_78549_/A }
C {devices/lab_pin.sym} 151600 -900 0 0 {name=p151221 lab=_82675_/D }
C {devices/lab_pin.sym} 151720 -920 0 1 {name=p151222 lab=_78551_/A }
C {sky130_stdcells/nand2_4.sym} 151660 -920 0 0 {name=X_78550_ }
C {devices/lab_pin.sym} 151580 -810 0 0 {name=p151223 lab=_44931_/X }
C {devices/lab_pin.sym} 151580 -770 0 0 {name=p151224 lab=_44939_/X }
C {devices/lab_pin.sym} 151580 -730 0 0 {name=p151225 lab=_44941_/Y }
C {devices/lab_pin.sym} 151740 -770 0 1 {name=p151226 lab=_44942_/Y }
C {sky130_stdcells/a21oi_4.sym} 151660 -770 0 0 {name=X_44942_ }
C {devices/lab_pin.sym} 152500 -42170 0 0 {name=p151227 lab=_44137_/A }
C {devices/lab_pin.sym} 152500 -42130 0 0 {name=p151228 lab=_56923_/Y }
C {devices/lab_pin.sym} 152500 -42090 0 0 {name=p151229 lab=_56927_/Y }
C {devices/lab_pin.sym} 152660 -42130 0 1 {name=p151230 lab=_56928_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -42130 0 0 {name=X_56928_ }
C {devices/lab_pin.sym} 152520 -42000 0 0 {name=p151231 lab=_81095_/Q }
C {devices/lab_pin.sym} 152520 -41960 0 0 {name=p151232 lab=_80807_/Q }
C {devices/lab_pin.sym} 152640 -41980 0 1 {name=p151233 lab=_75762_/Y }
C {sky130_stdcells/xnor2_4.sym} 152580 -41980 0 0 {name=X_75762_ }
C {devices/lab_pin.sym} 152490 -41850 0 0 {name=p151234 lab=_87748_/CLK }
C {devices/lab_pin.sym} 152490 -41830 0 0 {name=p151235 lab=_87748_/D }
C {devices/lab_pin.sym} 152670 -41850 0 1 {name=p151236 lab=_68755_/B }
C {sky130_stdcells/dfxtp_4.sym} 152580 -41840 0 0 {name=X_87748_ }
C {devices/lab_pin.sym} 152540 -41710 0 0 {name=p151237 lab=_72722_/X }
C {devices/lab_pin.sym} 152620 -41710 0 1 {name=p151238 lab=_72974_/X }
C {sky130_stdcells/buf_2.sym} 152580 -41710 0 0 {name=X_72974_ }
C {devices/lab_pin.sym} 152500 -41610 0 0 {name=p151239 lab=_77465_/B }
C {devices/lab_pin.sym} 152500 -41570 0 0 {name=p151240 lab=_77498_/X }
C {devices/lab_pin.sym} 152500 -41530 0 0 {name=p151241 lab=_77500_/Y }
C {devices/lab_pin.sym} 152660 -41570 0 1 {name=p151242 lab=_77501_/Y }
C {sky130_stdcells/a21oi_4.sym} 152580 -41570 0 0 {name=X_77501_ }
C {devices/lab_pin.sym} 152540 -41430 0 0 {name=p151243 lab=MACRO_RD_SELECT }
C {devices/lab_pin.sym} 152620 -41430 0 1 {name=p151244 lab=_74713_/Y }
C {sky130_stdcells/inv_2.sym} 152580 -41430 0 0 {name=X_74713_ }
C {devices/lab_pin.sym} 152540 -41310 0 0 {name=p151245 lab=_47661_/A }
C {devices/lab_pin.sym} 152620 -41310 0 1 {name=p151246 lab=_47692_/C }
C {sky130_stdcells/buf_2.sym} 152580 -41310 0 0 {name=X_47661_ }
C {devices/lab_pin.sym} 152540 -41190 0 0 {name=p151247 lab=_70591_/A }
C {devices/lab_pin.sym} 152620 -41190 0 1 {name=p151248 lab=_71940_/C }
C {sky130_stdcells/buf_2.sym} 152580 -41190 0 0 {name=X_71925_ }
C {devices/lab_pin.sym} 152540 -41070 0 0 {name=p151249 lab=_59824_/B }
C {devices/lab_pin.sym} 152620 -41070 0 1 {name=p151250 lab=_59649_/A }
C {sky130_stdcells/buf_2.sym} 152580 -41070 0 0 {name=X_59647_ }
C {devices/lab_pin.sym} 152500 -40970 0 0 {name=p151251 lab=_78476_/Y }
C {devices/lab_pin.sym} 152500 -40930 0 0 {name=p151252 lab=_78453_/B }
C {devices/lab_pin.sym} 152500 -40890 0 0 {name=p151253 lab=_78480_/X }
C {devices/lab_pin.sym} 152660 -40930 0 1 {name=p151254 lab=_78482_/B }
C {sky130_stdcells/o21ai_4.sym} 152580 -40930 0 0 {name=X_78481_ }
C {devices/lab_pin.sym} 152540 -40790 0 0 {name=p151255 lab=_45193_/A }
C {devices/lab_pin.sym} 152620 -40790 0 1 {name=p151256 lab=_45197_/A }
C {sky130_stdcells/buf_2.sym} 152580 -40790 0 0 {name=X_44873_ }
C {devices/lab_pin.sym} 152540 -40670 0 0 {name=p151257 lab=_83333_/Q }
C {devices/lab_pin.sym} 152620 -40670 0 1 {name=p151258 lab=_56859_/X }
C {sky130_stdcells/buf_2.sym} 152580 -40670 0 0 {name=X_56859_ }
C {devices/lab_pin.sym} 152490 -40550 0 0 {name=p151259 lab=_87686_/CLK }
C {devices/lab_pin.sym} 152490 -40530 0 0 {name=p151260 lab=_42865_/Y }
C {devices/lab_pin.sym} 152670 -40550 0 1 {name=p151261 lab=_67047_/B }
C {sky130_stdcells/dfxtp_4.sym} 152580 -40540 0 0 {name=X_87679_ }
C {devices/lab_pin.sym} 152520 -40420 0 0 {name=p151262 lab=_81007_/Q }
C {devices/lab_pin.sym} 152520 -40380 0 0 {name=p151263 lab=_75693_/B }
C {devices/lab_pin.sym} 152640 -40400 0 1 {name=p151264 lab=_75693_/X }
C {sky130_stdcells/xor2_4.sym} 152580 -40400 0 0 {name=X_75693_ }
C {devices/lab_pin.sym} 152500 -40290 0 0 {name=p151265 lab=_86394_/Q }
C {devices/lab_pin.sym} 152500 -40250 0 0 {name=p151266 lab=_49388_/X }
C {devices/lab_pin.sym} 152500 -40210 0 0 {name=p151267 lab=_49399_/Y }
C {devices/lab_pin.sym} 152660 -40250 0 1 {name=p151268 lab=_49400_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -40250 0 0 {name=X_49400_ }
C {devices/lab_pin.sym} 152540 -40110 0 0 {name=p151269 lab=_46612_/A }
C {devices/lab_pin.sym} 152620 -40110 0 1 {name=p151270 lab=_53097_/A }
C {sky130_stdcells/buf_2.sym} 152580 -40110 0 0 {name=X_46612_ }
C {devices/lab_pin.sym} 152520 -40000 0 0 {name=p151271 lab=_77430_/X }
C {devices/lab_pin.sym} 152520 -39960 0 0 {name=p151272 lab=_77431_/Y }
C {devices/lab_pin.sym} 152640 -39980 0 1 {name=p151273 lab=_77433_/A }
C {sky130_stdcells/and2_4.sym} 152580 -39980 0 0 {name=X_77432_ }
C {devices/lab_pin.sym} 152540 -39850 0 0 {name=p151274 lab=_43854_/A }
C {devices/lab_pin.sym} 152620 -39850 0 1 {name=p151275 lab=_43824_/X }
C {sky130_stdcells/buf_2.sym} 152580 -39850 0 0 {name=X_43824_ }
C {devices/lab_pin.sym} 152500 -39750 0 0 {name=p151276 lab=_56600_/A }
C {devices/lab_pin.sym} 152500 -39710 0 0 {name=p151277 lab=_74641_/X }
C {devices/lab_pin.sym} 152500 -39670 0 0 {name=p151278 lab=_74643_/Y }
C {devices/lab_pin.sym} 152660 -39710 0 1 {name=p151279 lab=_83003_/D }
C {sky130_stdcells/a21boi_4.sym} 152580 -39710 0 0 {name=X_74644_ }
C {devices/lab_pin.sym} 152500 -39590 0 0 {name=p151280 lab=_86618_/Q }
C {devices/lab_pin.sym} 152500 -39550 0 0 {name=p151281 lab=_47570_/X }
C {devices/lab_pin.sym} 152500 -39510 0 0 {name=p151282 lab=_47591_/Y }
C {devices/lab_pin.sym} 152660 -39550 0 1 {name=p151283 lab=_47592_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -39550 0 0 {name=X_47592_ }
C {devices/lab_pin.sym} 152500 -39430 0 0 {name=p151284 lab=_71848_/X }
C {devices/lab_pin.sym} 152500 -39390 0 0 {name=p151285 lab=_83352_/Q }
C {devices/lab_pin.sym} 152500 -39350 0 0 {name=p151286 lab=_71855_/Y }
C {devices/lab_pin.sym} 152660 -39390 0 1 {name=p151287 lab=_83352_/D }
C {sky130_stdcells/a21o_4.sym} 152580 -39390 0 0 {name=X_71856_ }
C {devices/lab_pin.sym} 152540 -39250 0 0 {name=p151288 lab=_59577_/X }
C {devices/lab_pin.sym} 152620 -39250 0 1 {name=p151289 lab=_59579_/A }
C {sky130_stdcells/buf_2.sym} 152580 -39250 0 0 {name=X_59578_ }
C {devices/lab_pin.sym} 152500 -39150 0 0 {name=p151290 lab=_86408_/Q }
C {devices/lab_pin.sym} 152500 -39110 0 0 {name=p151291 lab=_49285_/X }
C {devices/lab_pin.sym} 152500 -39070 0 0 {name=p151292 lab=_49330_/Y }
C {devices/lab_pin.sym} 152660 -39110 0 1 {name=p151293 lab=_49331_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -39110 0 0 {name=X_49331_ }
C {devices/lab_pin.sym} 152540 -38970 0 0 {name=p151294 lab=_46542_/X }
C {devices/lab_pin.sym} 152620 -38970 0 1 {name=p151295 lab=_46543_/X }
C {sky130_stdcells/buf_2.sym} 152580 -38970 0 0 {name=X_46543_ }
C {devices/lab_pin.sym} 152520 -38870 0 0 {name=p151296 lab=_70810_/A }
C {devices/lab_pin.sym} 152520 -38830 0 0 {name=p151297 lab=_70940_/B }
C {devices/lab_pin.sym} 152520 -38790 0 0 {name=p151298 lab=_70810_/C }
C {devices/lab_pin.sym} 152640 -38830 0 1 {name=p151299 lab=_70807_/Y }
C {sky130_stdcells/nand3_4.sym} 152580 -38830 0 0 {name=X_70807_ }
C {devices/lab_pin.sym} 152500 -38710 0 0 {name=p151300 lab=_58517_/X }
C {devices/lab_pin.sym} 152500 -38670 0 0 {name=p151301 lab=_58526_/Y }
C {devices/lab_pin.sym} 152500 -38630 0 0 {name=p151302 lab=_58528_/Y }
C {devices/lab_pin.sym} 152660 -38670 0 1 {name=p151303 lab=_84827_/D }
C {sky130_stdcells/a21oi_4.sym} 152580 -38670 0 0 {name=X_58529_ }
C {devices/lab_pin.sym} 152500 -38550 0 0 {name=p151304 lab=_77351_/B }
C {devices/lab_pin.sym} 152500 -38510 0 0 {name=p151305 lab=_77345_/A }
C {devices/lab_pin.sym} 152500 -38470 0 0 {name=p151306 lab=_77345_/B }
C {devices/lab_pin.sym} 152660 -38510 0 1 {name=p151307 lab=_77363_/Y }
C {sky130_stdcells/a21boi_4.sym} 152580 -38510 0 0 {name=X_77363_ }
C {devices/lab_pin.sym} 152540 -38370 0 0 {name=p151308 lab=_43591_/A }
C {devices/lab_pin.sym} 152620 -38370 0 1 {name=p151309 lab=_43756_/A }
C {sky130_stdcells/inv_2.sym} 152580 -38370 0 0 {name=X_43755_ }
C {devices/lab_pin.sym} 152540 -38250 0 0 {name=p151310 lab=_56863_/X }
C {devices/lab_pin.sym} 152620 -38250 0 1 {name=p151311 lab=_74575_/X }
C {sky130_stdcells/buf_2.sym} 152580 -38250 0 0 {name=X_74575_ }
C {devices/lab_pin.sym} 152500 -38150 0 0 {name=p151312 lab=_40931_/X }
C {devices/lab_pin.sym} 152500 -38110 0 0 {name=p151313 lab=_81723_/Q }
C {devices/lab_pin.sym} 152500 -38070 0 0 {name=p151314 lab=_40966_/X }
C {devices/lab_pin.sym} 152660 -38110 0 1 {name=p151315 lab=_40968_/A }
C {sky130_stdcells/o21ai_4.sym} 152580 -38110 0 0 {name=X_40967_ }
C {devices/lab_pin.sym} 152500 -37990 0 0 {name=p151316 lab=_58181_/Y }
C {devices/lab_pin.sym} 152500 -37950 0 0 {name=p151317 lab=_71784_/X }
C {devices/lab_pin.sym} 152500 -37910 0 0 {name=p151318 lab=_71786_/Y }
C {devices/lab_pin.sym} 152660 -37950 0 1 {name=p151319 lab=_83377_/D }
C {sky130_stdcells/o21ai_4.sym} 152580 -37950 0 0 {name=X_71787_ }
C {devices/lab_pin.sym} 152520 -37820 0 0 {name=p151320 lab=_79101_/Y }
C {devices/lab_pin.sym} 152520 -37780 0 0 {name=p151321 lab=_79086_/A }
C {devices/lab_pin.sym} 152640 -37800 0 1 {name=p151322 lab=_79102_/X }
C {sky130_stdcells/and2_4.sym} 152580 -37800 0 0 {name=X_79102_ }
C {devices/lab_pin.sym} 152540 -37670 0 0 {name=p151323 lab=_76314_/A }
C {devices/lab_pin.sym} 152620 -37670 0 1 {name=p151324 lab=_76316_/A }
C {sky130_stdcells/inv_2.sym} 152580 -37670 0 0 {name=X_76314_ }
C {devices/lab_pin.sym} 152500 -37580 0 0 {name=p151325 lab=_41130_/X }
C {devices/lab_pin.sym} 152500 -37540 0 0 {name=p151326 lab=_42695_/X }
C {devices/lab_pin.sym} 152500 -37500 0 0 {name=p151327 lab=_87760_/Q }
C {devices/lab_pin.sym} 152500 -37460 0 0 {name=p151328 lab=_42696_/X }
C {devices/lab_pin.sym} 152660 -37520 0 1 {name=p151329 lab=_42706_/X }
C {sky130_stdcells/a2bb2o_4.sym} 152580 -37520 0 0 {name=X_42706_ }
C {devices/lab_pin.sym} 152500 -37390 0 0 {name=p151330 lab=_86422_/Q }
C {devices/lab_pin.sym} 152500 -37350 0 0 {name=p151331 lab=_49255_/X }
C {devices/lab_pin.sym} 152500 -37310 0 0 {name=p151332 lab=_49261_/Y }
C {devices/lab_pin.sym} 152660 -37350 0 1 {name=p151333 lab=_49262_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -37350 0 0 {name=X_49262_ }
C {devices/lab_pin.sym} 152500 -37230 0 0 {name=p151334 lab=_83147_/Q }
C {devices/lab_pin.sym} 152500 -37190 0 0 {name=p151335 lab=_73437_/X }
C {devices/lab_pin.sym} 152500 -37150 0 0 {name=p151336 lab=_73525_/Y }
C {devices/lab_pin.sym} 152660 -37190 0 1 {name=p151337 lab=_83147_/D }
C {sky130_stdcells/a21o_4.sym} 152580 -37190 0 0 {name=X_73526_ }
C {devices/lab_pin.sym} 152540 -37050 0 0 {name=p151338 lab=_84864_/Q }
C {devices/lab_pin.sym} 152620 -37050 0 1 {name=p151339 lab=_61541_/B }
C {sky130_stdcells/buf_2.sym} 152580 -37050 0 0 {name=X_61540_ }
C {devices/lab_pin.sym} 152540 -36930 0 0 {name=p151340 lab=_46719_/A }
C {devices/lab_pin.sym} 152620 -36930 0 1 {name=p151341 lab=_46474_/X }
C {sky130_stdcells/buf_2.sym} 152580 -36930 0 0 {name=X_46474_ }
C {devices/lab_pin.sym} 152540 -36810 0 0 {name=p151342 lab=_70755_/A }
C {devices/lab_pin.sym} 152620 -36810 0 1 {name=p151343 lab=_70738_/X }
C {sky130_stdcells/buf_2.sym} 152580 -36810 0 0 {name=X_70738_ }
C {devices/lab_pin.sym} 152520 -36700 0 0 {name=p151344 lab=_77294_/A }
C {devices/lab_pin.sym} 152520 -36660 0 0 {name=p151345 lab=_77294_/B }
C {devices/lab_pin.sym} 152640 -36680 0 1 {name=p151346 lab=_77294_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -36680 0 0 {name=X_77294_ }
C {devices/lab_pin.sym} 152540 -36550 0 0 {name=p151347 lab=_43673_/A }
C {devices/lab_pin.sym} 152620 -36550 0 1 {name=p151348 lab=_43686_/X }
C {sky130_stdcells/buf_2.sym} 152580 -36550 0 0 {name=X_43686_ }
C {devices/lab_pin.sym} 152500 -36450 0 0 {name=p151349 lab=_40817_/X }
C {devices/lab_pin.sym} 152500 -36410 0 0 {name=p151350 lab=_82280_/Q }
C {devices/lab_pin.sym} 152500 -36370 0 0 {name=p151351 lab=_40897_/X }
C {devices/lab_pin.sym} 152660 -36410 0 1 {name=p151352 lab=_40898_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -36410 0 0 {name=X_40898_ }
C {devices/lab_pin.sym} 152520 -36280 0 0 {name=p151353 lab=_48184_/A }
C {devices/lab_pin.sym} 152520 -36240 0 0 {name=p151354 lab=_53488_/B }
C {devices/lab_pin.sym} 152640 -36260 0 1 {name=p151355 lab=_48213_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -36260 0 0 {name=X_48213_ }
C {devices/lab_pin.sym} 152500 -36150 0 0 {name=p151356 lab=_79027_/B }
C {devices/lab_pin.sym} 152500 -36110 0 0 {name=p151357 lab=_79027_/A }
C {devices/lab_pin.sym} 152500 -36070 0 0 {name=p151358 lab=_79032_/X }
C {devices/lab_pin.sym} 152660 -36110 0 1 {name=p151359 lab=_79033_/Y }
C {sky130_stdcells/a21oi_4.sym} 152580 -36110 0 0 {name=X_79033_ }
C {devices/lab_pin.sym} 152540 -35970 0 0 {name=p151360 lab=_85023_/Q }
C {devices/lab_pin.sym} 152620 -35970 0 1 {name=p151361 lab=_45425_/Y }
C {sky130_stdcells/inv_2.sym} 152580 -35970 0 0 {name=X_45425_ }
C {devices/lab_pin.sym} 152520 -35860 0 0 {name=p151362 lab=_81257_/Q }
C {devices/lab_pin.sym} 152520 -35820 0 0 {name=p151363 lab=_81513_/D }
C {devices/lab_pin.sym} 152640 -35840 0 1 {name=p151364 lab=_76245_/Y }
C {sky130_stdcells/nor2_4.sym} 152580 -35840 0 0 {name=X_76245_ }
C {devices/lab_pin.sym} 152540 -35710 0 0 {name=p151365 lab=_42580_/A }
C {devices/lab_pin.sym} 152620 -35710 0 1 {name=p151366 lab=_42637_/X }
C {sky130_stdcells/buf_2.sym} 152580 -35710 0 0 {name=X_42637_ }
C {devices/lab_pin.sym} 152520 -35600 0 0 {name=p151367 lab=_49173_/A }
C {devices/lab_pin.sym} 152520 -35560 0 0 {name=p151368 lab=_50719_/B }
C {devices/lab_pin.sym} 152640 -35580 0 1 {name=p151369 lab=_49193_/X }
C {sky130_stdcells/and2_4.sym} 152580 -35580 0 0 {name=X_49193_ }
C {devices/lab_pin.sym} 152520 -35480 0 0 {name=p151370 lab=_59403_/A }
C {devices/lab_pin.sym} 152520 -35440 0 0 {name=p151371 lab=_61484_/B }
C {devices/lab_pin.sym} 152520 -35400 0 0 {name=p151372 lab=_61484_/C }
C {devices/lab_pin.sym} 152520 -35360 0 0 {name=p151373 lab=_61452_/D }
C {devices/lab_pin.sym} 152640 -35420 0 1 {name=p151374 lab=_61471_/Y }
C {sky130_stdcells/nand4_4.sym} 152580 -35420 0 0 {name=X_61471_ }
C {devices/lab_pin.sym} 152520 -35280 0 0 {name=p151375 lab=_73457_/A }
C {devices/lab_pin.sym} 152520 -35240 0 0 {name=p151376 lab=_73456_/X }
C {devices/lab_pin.sym} 152640 -35260 0 1 {name=p151377 lab=_73457_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -35260 0 0 {name=X_73457_ }
C {devices/lab_pin.sym} 152540 -35130 0 0 {name=p151378 lab=_70669_/A }
C {devices/lab_pin.sym} 152620 -35130 0 1 {name=p151379 lab=_70676_/C }
C {sky130_stdcells/buf_2.sym} 152580 -35130 0 0 {name=X_70669_ }
C {devices/lab_pin.sym} 152500 -35030 0 0 {name=p151380 lab=_63207_/Y }
C {devices/lab_pin.sym} 152500 -34990 0 0 {name=p151381 lab=_63209_/X }
C {devices/lab_pin.sym} 152500 -34950 0 0 {name=p151382 lab=_63172_/X }
C {devices/lab_pin.sym} 152660 -34990 0 1 {name=p151383 lab=_63210_/Y }
C {sky130_stdcells/a21oi_4.sym} 152580 -34990 0 0 {name=X_63210_ }
C {devices/lab_pin.sym} 152540 -34850 0 0 {name=p151384 lab=_60422_/A }
C {devices/lab_pin.sym} 152620 -34850 0 1 {name=p151385 lab=_60513_/B }
C {sky130_stdcells/buf_2.sym} 152580 -34850 0 0 {name=X_60422_ }
C {devices/lab_pin.sym} 152540 -34730 0 0 {name=p151386 lab=_48144_/A }
C {devices/lab_pin.sym} 152620 -34730 0 1 {name=p151387 lab=_50105_/A }
C {sky130_stdcells/buf_2.sym} 152580 -34730 0 0 {name=X_48144_ }
C {devices/lab_pin.sym} 152500 -34630 0 0 {name=p151388 lab=_72305_/X }
C {devices/lab_pin.sym} 152500 -34590 0 0 {name=p151389 lab=_85353_/Q }
C {devices/lab_pin.sym} 152500 -34550 0 0 {name=p151390 lab=_72407_/X }
C {devices/lab_pin.sym} 152660 -34590 0 1 {name=p151391 lab=_72408_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -34590 0 0 {name=X_72408_ }
C {devices/lab_pin.sym} 152500 -34470 0 0 {name=p151392 lab=_56270_/C }
C {devices/lab_pin.sym} 152500 -34430 0 0 {name=p151393 lab=_45297_/X }
C {devices/lab_pin.sym} 152500 -34390 0 0 {name=p151394 lab=_45355_/X }
C {devices/lab_pin.sym} 152660 -34430 0 1 {name=p151395 lab=_45356_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -34430 0 0 {name=X_45356_ }
C {devices/lab_pin.sym} 152540 -34290 0 0 {name=p151396 lab=_76176_/A }
C {devices/lab_pin.sym} 152620 -34290 0 1 {name=p151397 lab=_76176_/Y }
C {sky130_stdcells/inv_2.sym} 152580 -34290 0 0 {name=X_76176_ }
C {devices/lab_pin.sym} 152520 -34200 0 0 {name=p151398 lab=_64190_/A }
C {devices/lab_pin.sym} 152520 -34160 0 0 {name=p151399 lab=_64190_/B }
C {devices/lab_pin.sym} 152520 -34120 0 0 {name=p151400 lab=_64189_/D }
C {devices/lab_pin.sym} 152520 -34080 0 0 {name=p151401 lab=_64190_/D }
C {devices/lab_pin.sym} 152640 -34140 0 1 {name=p151402 lab=_64190_/Y }
C {sky130_stdcells/nand4_4.sym} 152580 -34140 0 0 {name=X_64190_ }
C {devices/lab_pin.sym} 152540 -33990 0 0 {name=p151403 lab=_42554_/A }
C {devices/lab_pin.sym} 152620 -33990 0 1 {name=p151404 lab=_42568_/X }
C {sky130_stdcells/buf_2.sym} 152580 -33990 0 0 {name=X_42568_ }
C {devices/lab_pin.sym} 152520 -33880 0 0 {name=p151405 lab=_73384_/X }
C {devices/lab_pin.sym} 152520 -33840 0 0 {name=p151406 lab=_73387_/X }
C {devices/lab_pin.sym} 152640 -33860 0 1 {name=p151407 lab=_73388_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -33860 0 0 {name=X_73388_ }
C {devices/lab_pin.sym} 152540 -33730 0 0 {name=p151408 lab=clkbuf_8_97_0_CLK/X }
C {devices/lab_pin.sym} 152620 -33730 0 1 {name=p151409 lab=clkbuf_9_194_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 152580 -33730 0 0 {name=Xclkbuf_9_194_0_CLK }
C {devices/lab_pin.sym} 152520 -33640 0 0 {name=p151410 lab=_44120_/Y }
C {devices/lab_pin.sym} 152520 -33600 0 0 {name=p151411 lab=_44010_/A }
C {devices/lab_pin.sym} 152520 -33560 0 0 {name=p151412 lab=_74095_/B }
C {devices/lab_pin.sym} 152520 -33520 0 0 {name=p151413 lab=_44307_/D }
C {devices/lab_pin.sym} 152640 -33580 0 1 {name=p151414 lab=_44308_/A }
C {sky130_stdcells/and4_4.sym} 152580 -33580 0 0 {name=X_44307_ }
C {devices/lab_pin.sym} 152500 -33450 0 0 {name=p151415 lab=_79394_/A }
C {devices/lab_pin.sym} 152500 -33410 0 0 {name=p151416 lab=_63130_/X }
C {devices/lab_pin.sym} 152500 -33370 0 0 {name=p151417 lab=_63140_/Y }
C {devices/lab_pin.sym} 152660 -33410 0 1 {name=p151418 lab=_63141_/X }
C {sky130_stdcells/a21o_4.sym} 152580 -33410 0 0 {name=X_63141_ }
C {devices/lab_pin.sym} 152520 -33290 0 0 {name=p151419 lab=_75124_/X }
C {devices/lab_pin.sym} 152520 -33250 0 0 {name=p151420 lab=_81062_/Q }
C {devices/lab_pin.sym} 152520 -33210 0 0 {name=p151421 lab=_75127_/C }
C {devices/lab_pin.sym} 152640 -33250 0 1 {name=p151422 lab=_75143_/A }
C {sky130_stdcells/nand3_4.sym} 152580 -33250 0 0 {name=X_75127_ }
C {devices/lab_pin.sym} 152500 -33130 0 0 {name=p151423 lab=_41421_/X }
C {devices/lab_pin.sym} 152500 -33090 0 0 {name=p151424 lab=_82325_/Q }
C {devices/lab_pin.sym} 152500 -33050 0 0 {name=p151425 lab=_41518_/X }
C {devices/lab_pin.sym} 152660 -33090 0 1 {name=p151426 lab=_41519_/X }
C {sky130_stdcells/o21a_4.sym} 152580 -33090 0 0 {name=X_41519_ }
C {devices/lab_pin.sym} 152540 -32950 0 0 {name=p151427 lab=_48914_/A }
C {devices/lab_pin.sym} 152620 -32950 0 1 {name=p151428 lab=_48075_/X }
C {sky130_stdcells/buf_2.sym} 152580 -32950 0 0 {name=X_48075_ }
C {devices/lab_pin.sym} 152520 -32850 0 0 {name=p151429 lab=_60414_/B }
C {devices/lab_pin.sym} 152520 -32810 0 0 {name=p151430 lab=_60353_/B }
C {devices/lab_pin.sym} 152520 -32770 0 0 {name=p151431 lab=_59716_/B }
C {devices/lab_pin.sym} 152640 -32810 0 1 {name=p151432 lab=_60353_/Y }
C {sky130_stdcells/nand3_4.sym} 152580 -32810 0 0 {name=X_60353_ }
C {devices/lab_pin.sym} 152540 -32670 0 0 {name=p151433 lab=_59345_/X }
C {devices/lab_pin.sym} 152620 -32670 0 1 {name=p151434 lab=_72339_/X }
C {sky130_stdcells/buf_2.sym} 152580 -32670 0 0 {name=X_72339_ }
C {devices/lab_pin.sym} 152540 -32550 0 0 {name=p151435 lab=_45212_/A }
C {devices/lab_pin.sym} 152620 -32550 0 1 {name=p151436 lab=_45287_/X }
C {sky130_stdcells/buf_2.sym} 152580 -32550 0 0 {name=X_45287_ }
C {devices/lab_pin.sym} 152540 -32430 0 0 {name=p151437 lab=_42499_/A }
C {devices/lab_pin.sym} 152620 -32430 0 1 {name=p151438 lab=_68746_/B }
C {sky130_stdcells/inv_2.sym} 152580 -32430 0 0 {name=X_42499_ }
C {devices/lab_pin.sym} 152500 -32330 0 0 {name=p151439 lab=_59131_/A }
C {devices/lab_pin.sym} 152500 -32290 0 0 {name=p151440 lab=_47004_/X }
C {devices/lab_pin.sym} 152500 -32250 0 0 {name=p151441 lab=_47025_/Y }
C {devices/lab_pin.sym} 152660 -32290 0 1 {name=p151442 lab=_47026_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -32290 0 0 {name=X_47026_ }
C {devices/lab_pin.sym} 152540 -32150 0 0 {name=p151443 lab=_57126_/A }
C {devices/lab_pin.sym} 152620 -32150 0 1 {name=p151444 lab=_44239_/A }
C {sky130_stdcells/buf_2.sym} 152580 -32150 0 0 {name=X_44238_ }
C {devices/lab_pin.sym} 152540 -32030 0 0 {name=p151445 lab=_63130_/A }
C {devices/lab_pin.sym} 152620 -32030 0 1 {name=p151446 lab=_63072_/X }
C {sky130_stdcells/buf_2.sym} 152580 -32030 0 0 {name=X_63072_ }
C {devices/lab_pin.sym} 152500 -31930 0 0 {name=p151447 lab=_75053_/B }
C {devices/lab_pin.sym} 152500 -31890 0 0 {name=p151448 lab=_75056_/X }
C {devices/lab_pin.sym} 152500 -31850 0 0 {name=p151449 lab=_75057_/Y }
C {devices/lab_pin.sym} 152660 -31890 0 1 {name=p151450 lab=_75059_/B }
C {sky130_stdcells/a21boi_4.sym} 152580 -31890 0 0 {name=X_75058_ }
C {devices/lab_pin.sym} 152540 -31750 0 0 {name=p151451 lab=_79937_/B }
C {devices/lab_pin.sym} 152620 -31750 0 1 {name=p151452 lab=_79935_/Y }
C {sky130_stdcells/inv_2.sym} 152580 -31750 0 0 {name=X_79935_ }
C {devices/lab_pin.sym} 152520 -31650 0 0 {name=p151453 lab=_60284_/A }
C {devices/lab_pin.sym} 152520 -31610 0 0 {name=p151454 lab=_60284_/B }
C {devices/lab_pin.sym} 152520 -31570 0 0 {name=p151455 lab=_60300_/C }
C {devices/lab_pin.sym} 152640 -31610 0 1 {name=p151456 lab=_60284_/Y }
C {sky130_stdcells/nand3_4.sym} 152580 -31610 0 0 {name=X_60284_ }
C {devices/lab_pin.sym} 152520 -31480 0 0 {name=p151457 lab=_66851_/X }
C {devices/lab_pin.sym} 152520 -31440 0 0 {name=p151458 lab=_66900_/B }
C {devices/lab_pin.sym} 152640 -31460 0 1 {name=p151459 lab=_66900_/X }
C {sky130_stdcells/and2_4.sym} 152580 -31460 0 0 {name=X_66900_ }
C {devices/lab_pin.sym} 152500 -31360 0 0 {name=p151460 lab=_63598_/A }
C {devices/lab_pin.sym} 152500 -31320 0 0 {name=p151461 lab=_59841_/X }
C {devices/lab_pin.sym} 152500 -31280 0 0 {name=p151462 lab=_61561_/A }
C {devices/lab_pin.sym} 152500 -31240 0 0 {name=p151463 lab=_61981_/X }
C {devices/lab_pin.sym} 152660 -31300 0 1 {name=p151464 lab=_62023_/X }
C {sky130_stdcells/a2bb2o_4.sym} 152580 -31300 0 0 {name=X_62023_ }
C {devices/lab_pin.sym} 152500 -31170 0 0 {name=p151465 lab=_74006_/X }
C {devices/lab_pin.sym} 152500 -31130 0 0 {name=p151466 lab=_74008_/X }
C {devices/lab_pin.sym} 152500 -31090 0 0 {name=p151467 lab=_73944_/X }
C {devices/lab_pin.sym} 152660 -31130 0 1 {name=p151468 lab=_74028_/B }
C {sky130_stdcells/a21o_4.sym} 152580 -31130 0 0 {name=X_74009_ }
C {devices/lab_pin.sym} 152540 -30990 0 0 {name=p151469 lab=_44244_/A }
C {devices/lab_pin.sym} 152620 -30990 0 1 {name=p151470 lab=_44170_/A }
C {sky130_stdcells/buf_2.sym} 152580 -30990 0 0 {name=X_44169_ }
C {devices/lab_pin.sym} 152520 -30880 0 0 {name=p151471 lab=_67901_/A }
C {devices/lab_pin.sym} 152520 -30840 0 0 {name=p151472 lab=_87644_/Q }
C {devices/lab_pin.sym} 152640 -30860 0 1 {name=p151473 lab=_67880_/X }
C {sky130_stdcells/and2_4.sym} 152580 -30860 0 0 {name=X_67880_ }
C {devices/lab_pin.sym} 152520 -30740 0 0 {name=p151474 lab=_79844_/X }
C {devices/lab_pin.sym} 152520 -30700 0 0 {name=p151475 lab=_79866_/B }
C {devices/lab_pin.sym} 152640 -30720 0 1 {name=p151476 lab=_79866_/X }
C {sky130_stdcells/or2_4.sym} 152580 -30720 0 0 {name=X_79866_ }
C {devices/lab_pin.sym} 152500 -30620 0 0 {name=p151477 lab=_87432_/Q }
C {devices/lab_pin.sym} 152500 -30580 0 0 {name=p151478 lab=_66762_/X }
C {devices/lab_pin.sym} 152500 -30540 0 0 {name=p151479 lab=_66764_/X }
C {devices/lab_pin.sym} 152500 -30500 0 0 {name=p151480 lab=_66830_/X }
C {devices/lab_pin.sym} 152660 -30560 0 1 {name=p151481 lab=_66831_/X }
C {sky130_stdcells/a211o_4.sym} 152580 -30560 0 0 {name=X_66831_ }
C {devices/lab_pin.sym} 152540 -30410 0 0 {name=p151482 lab=_78816_/Y }
C {devices/lab_pin.sym} 152620 -30410 0 1 {name=p151483 lab=_78817_/Y }
C {sky130_stdcells/inv_2.sym} 152580 -30410 0 0 {name=X_78817_ }
C {devices/lab_pin.sym} 152500 -30310 0 0 {name=p151484 lab=_48606_/X }
C {devices/lab_pin.sym} 152500 -30270 0 0 {name=p151485 lab=_81208_/Q }
C {devices/lab_pin.sym} 152500 -30230 0 0 {name=p151486 lab=_48976_/Y }
C {devices/lab_pin.sym} 152660 -30270 0 1 {name=p151487 lab=_48978_/A }
C {sky130_stdcells/o21ai_4.sym} 152580 -30270 0 0 {name=X_48977_ }
C {devices/lab_pin.sym} 152520 -30140 0 0 {name=p151488 lab=_79797_/A }
C {devices/lab_pin.sym} 152520 -30100 0 0 {name=p151489 lab=_79797_/B }
C {devices/lab_pin.sym} 152640 -30120 0 1 {name=p151490 lab=_79798_/B }
C {sky130_stdcells/xor2_4.sym} 152580 -30120 0 0 {name=X_79797_ }
C {devices/lab_pin.sym} 152540 -29990 0 0 {name=p151491 lab=clkbuf_9_320_0_CLK/X }
C {devices/lab_pin.sym} 152620 -29990 0 1 {name=p151492 lab=_86934_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 152580 -29990 0 0 {name=Xclkbuf_10_641_0_CLK }
C {devices/lab_pin.sym} 152500 -29890 0 0 {name=p151493 lab=_69102_/X }
C {devices/lab_pin.sym} 152500 -29850 0 0 {name=p151494 lab=_69105_/X }
C {devices/lab_pin.sym} 152500 -29810 0 0 {name=p151495 lab=_69500_/X }
C {devices/lab_pin.sym} 152660 -29850 0 1 {name=p151496 lab=_69550_/Y }
C {sky130_stdcells/a21oi_4.sym} 152580 -29850 0 0 {name=X_69550_ }
C {devices/lab_pin.sym} 152520 -29720 0 0 {name=p151497 lab=_47887_/A }
C {devices/lab_pin.sym} 152520 -29680 0 0 {name=p151498 lab=_48221_/A }
C {devices/lab_pin.sym} 152640 -29700 0 1 {name=p151499 lab=_47928_/X }
C {sky130_stdcells/and2_4.sym} 152580 -29700 0 0 {name=X_47928_ }
C {devices/lab_pin.sym} 152540 -29570 0 0 {name=p151500 lab=_66642_/A }
C {devices/lab_pin.sym} 152620 -29570 0 1 {name=p151501 lab=_66762_/X }
C {sky130_stdcells/buf_2.sym} 152580 -29570 0 0 {name=X_66762_ }
C {devices/lab_pin.sym} 152520 -29460 0 0 {name=p151502 lab=_78748_/A }
C {devices/lab_pin.sym} 152520 -29420 0 0 {name=p151503 lab=_82782_/D }
C {devices/lab_pin.sym} 152640 -29440 0 1 {name=p151504 lab=_82494_/D }
C {sky130_stdcells/xor2_4.sym} 152580 -29440 0 0 {name=X_78748_ }
C {devices/lab_pin.sym} 152520 -29330 0 0 {name=p151505 lab=_63942_/A }
C {devices/lab_pin.sym} 152520 -29290 0 0 {name=p151506 lab=_59415_/A }
C {devices/lab_pin.sym} 152520 -29250 0 0 {name=p151507 lab=_63958_/C }
C {devices/lab_pin.sym} 152640 -29290 0 1 {name=p151508 lab=_63974_/X }
C {sky130_stdcells/and3_4.sym} 152580 -29290 0 0 {name=X_63974_ }
C {devices/lab_pin.sym} 152540 -29150 0 0 {name=p151509 lab=_68651_/A }
C {devices/lab_pin.sym} 152620 -29150 0 1 {name=p151510 lab=_68501_/X }
C {sky130_stdcells/buf_2.sym} 152580 -29150 0 0 {name=X_68501_ }
C {devices/lab_pin.sym} 152520 -29050 0 0 {name=p151511 lab=_65621_/A }
C {devices/lab_pin.sym} 152520 -29010 0 0 {name=p151512 lab=_65775_/B }
C {devices/lab_pin.sym} 152520 -28970 0 0 {name=p151513 lab=_65713_/C }
C {devices/lab_pin.sym} 152640 -29010 0 1 {name=p151514 lab=_65713_/X }
C {sky130_stdcells/and3_4.sym} 152580 -29010 0 0 {name=X_65713_ }
C {devices/lab_pin.sym} 152540 -28870 0 0 {name=p151515 lab=clkbuf_8_66_0_CLK/X }
C {devices/lab_pin.sym} 152620 -28870 0 1 {name=p151516 lab=clkbuf_9_132_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 152580 -28870 0 0 {name=Xclkbuf_9_132_0_CLK }
C {devices/lab_pin.sym} 152540 -28750 0 0 {name=p151517 lab=_62646_/B }
C {devices/lab_pin.sym} 152620 -28750 0 1 {name=p151518 lab=_62926_/B }
C {sky130_stdcells/buf_2.sym} 152580 -28750 0 0 {name=X_62925_ }
C {devices/lab_pin.sym} 152500 -28660 0 0 {name=p151519 lab=_88026_/Q }
C {devices/lab_pin.sym} 152500 -28620 0 0 {name=p151520 lab=_69368_/X }
C {devices/lab_pin.sym} 152500 -28580 0 0 {name=p151521 lab=_69478_/X }
C {devices/lab_pin.sym} 152500 -28540 0 0 {name=p151522 lab=_69480_/X }
C {devices/lab_pin.sym} 152660 -28600 0 1 {name=p151523 lab=_69481_/X }
C {sky130_stdcells/a211o_4.sym} 152580 -28600 0 0 {name=X_69481_ }
C {devices/lab_pin.sym} 152520 -28460 0 0 {name=p151524 lab=_82367_/Q }
C {devices/lab_pin.sym} 152520 -28420 0 0 {name=p151525 lab=_46579_/X }
C {devices/lab_pin.sym} 152640 -28440 0 1 {name=p151526 lab=_47859_/X }
C {sky130_stdcells/or2_4.sym} 152580 -28440 0 0 {name=X_47859_ }
C {devices/lab_pin.sym} 152500 -28330 0 0 {name=p151527 lab=_66690_/X }
C {devices/lab_pin.sym} 152500 -28290 0 0 {name=p151528 lab=_66692_/X }
C {devices/lab_pin.sym} 152500 -28250 0 0 {name=p151529 lab=_66667_/X }
C {devices/lab_pin.sym} 152660 -28290 0 1 {name=p151530 lab=_66693_/X }
C {sky130_stdcells/a21o_4.sym} 152580 -28290 0 0 {name=X_66693_ }
C {devices/lab_pin.sym} 152520 -28160 0 0 {name=p151531 lab=_78680_/A }
C {devices/lab_pin.sym} 152520 -28120 0 0 {name=p151532 lab=_78680_/B }
C {devices/lab_pin.sym} 152640 -28140 0 1 {name=p151533 lab=_78682_/B }
C {sky130_stdcells/nor2_4.sym} 152580 -28140 0 0 {name=X_78679_ }
C {devices/lab_pin.sym} 152500 -28040 0 0 {name=p151534 lab=_87101_/Q }
C {devices/lab_pin.sym} 152500 -28000 0 0 {name=p151535 lab=_68059_/X }
C {devices/lab_pin.sym} 152500 -27960 0 0 {name=p151536 lab=_68370_/X }
C {devices/lab_pin.sym} 152500 -27920 0 0 {name=p151537 lab=_68431_/X }
C {devices/lab_pin.sym} 152660 -27980 0 1 {name=p151538 lab=_68432_/X }
C {sky130_stdcells/a211o_4.sym} 152580 -27980 0 0 {name=X_68432_ }
C {devices/lab_pin.sym} 152490 -27830 0 0 {name=p151539 lab=_80679_/CLK }
C {devices/lab_pin.sym} 152490 -27810 0 0 {name=p151540 lab=_75896_/X }
C {devices/lab_pin.sym} 152670 -27830 0 1 {name=p151541 lab=_80710_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -27820 0 0 {name=X_80710_ }
C {devices/lab_pin.sym} 152520 -27700 0 0 {name=p151542 lab=_65474_/X }
C {devices/lab_pin.sym} 152520 -27660 0 0 {name=p151543 lab=_86515_/Q }
C {devices/lab_pin.sym} 152640 -27680 0 1 {name=p151544 lab=_65644_/X }
C {sky130_stdcells/and2_4.sym} 152580 -27680 0 0 {name=X_65644_ }
C {devices/lab_pin.sym} 152520 -27560 0 0 {name=p151545 lab=_50857_/X }
C {devices/lab_pin.sym} 152520 -27520 0 0 {name=p151546 lab=_50870_/B }
C {devices/lab_pin.sym} 152640 -27540 0 1 {name=p151547 lab=_50870_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -27540 0 0 {name=X_50870_ }
C {devices/lab_pin.sym} 152500 -27430 0 0 {name=p151548 lab=_63573_/A }
C {devices/lab_pin.sym} 152500 -27390 0 0 {name=p151549 lab=_60337_/D }
C {devices/lab_pin.sym} 152500 -27350 0 0 {name=p151550 lab=_62855_/Y }
C {devices/lab_pin.sym} 152660 -27390 0 1 {name=p151551 lab=_62856_/X }
C {sky130_stdcells/o21a_4.sym} 152580 -27390 0 0 {name=X_62856_ }
C {devices/lab_pin.sym} 152490 -27250 0 0 {name=p151552 lab=_81689_/CLK }
C {devices/lab_pin.sym} 152490 -27230 0 0 {name=p151553 lab=_80182_/X }
C {devices/lab_pin.sym} 152670 -27250 0 1 {name=p151554 lab=_81690_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -27240 0 0 {name=X_81690_ }
C {devices/lab_pin.sym} 152540 -27110 0 0 {name=p151555 lab=clkbuf_9_328_0_CLK/X }
C {devices/lab_pin.sym} 152620 -27110 0 1 {name=p151556 lab=_87926_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 152580 -27110 0 0 {name=Xclkbuf_10_656_0_CLK }
C {devices/lab_pin.sym} 152500 -27030 0 0 {name=p151557 lab=_58237_/X }
C {devices/lab_pin.sym} 152500 -26990 0 0 {name=p151558 lab=_61728_/X }
C {devices/lab_pin.sym} 152500 -26950 0 0 {name=p151559 lab=_61756_/X }
C {devices/lab_pin.sym} 152500 -26910 0 0 {name=p151560 lab=_61790_/X }
C {devices/lab_pin.sym} 152500 -26880 0 0 {name=p151561 lab=_61806_/X }
C {devices/lab_pin.sym} 152660 -26950 0 1 {name=p151562 lab=_61807_/X }
C {sky130_stdcells/a41o_4.sym} 152580 -26950 0 0 {name=X_61807_ }
C {devices/lab_pin.sym} 152500 -26810 0 0 {name=p151563 lab=_49527_/Y }
C {devices/lab_pin.sym} 152500 -26770 0 0 {name=p151564 lab=_49514_/X }
C {devices/lab_pin.sym} 152500 -26730 0 0 {name=p151565 lab=_49528_/X }
C {devices/lab_pin.sym} 152660 -26770 0 1 {name=p151566 lab=_49529_/Y }
C {sky130_stdcells/a21oi_4.sym} 152580 -26770 0 0 {name=X_49529_ }
C {devices/lab_pin.sym} 152640 -26640 0 1 {name=p151567 lab=_80641_/HI }
C {devices/lab_pin.sym} 152640 -26600 0 1 {name=p151568 lab=THREAD_COUNT[0] }
C {sky130_stdcells/conb_1.sym} 152580 -26620 0 0 {name=X_80641_ }
C {devices/lab_pin.sym} 152500 -26520 0 0 {name=p151569 lab=_73552_/A }
C {devices/lab_pin.sym} 152500 -26480 0 0 {name=p151570 lab=_68006_/X }
C {devices/lab_pin.sym} 152500 -26440 0 0 {name=p151571 lab=_68359_/X }
C {devices/lab_pin.sym} 152500 -26400 0 0 {name=p151572 lab=_68362_/Y }
C {devices/lab_pin.sym} 152660 -26460 0 1 {name=p151573 lab=_68363_/X }
C {sky130_stdcells/a211o_4.sym} 152580 -26460 0 0 {name=X_68363_ }
C {devices/lab_pin.sym} 152520 -26330 0 0 {name=p151574 lab=_64885_/X }
C {devices/lab_pin.sym} 152520 -26290 0 0 {name=p151575 lab=_65548_/B }
C {devices/lab_pin.sym} 152520 -26250 0 0 {name=p151576 lab=_64887_/X }
C {devices/lab_pin.sym} 152640 -26290 0 1 {name=p151577 lab=_65587_/A }
C {sky130_stdcells/nand3_4.sym} 152580 -26290 0 0 {name=X_65575_ }
C {devices/lab_pin.sym} 152520 -26180 0 0 {name=p151578 lab=_61461_/X }
C {devices/lab_pin.sym} 152520 -26140 0 0 {name=p151579 lab=_62743_/B }
C {devices/lab_pin.sym} 152520 -26100 0 0 {name=p151580 lab=_62742_/X }
C {devices/lab_pin.sym} 152520 -26060 0 0 {name=p151581 lab=_62834_/D }
C {devices/lab_pin.sym} 152640 -26120 0 1 {name=p151582 lab=_62787_/Y }
C {sky130_stdcells/nand4_4.sym} 152580 -26120 0 0 {name=X_62787_ }
C {devices/lab_pin.sym} 152540 -25970 0 0 {name=p151583 lab=clkbuf_8_73_0_CLK/X }
C {devices/lab_pin.sym} 152620 -25970 0 1 {name=p151584 lab=clkbuf_9_147_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 152580 -25970 0 0 {name=Xclkbuf_9_147_0_CLK }
C {devices/lab_pin.sym} 152520 -25860 0 0 {name=p151585 lab=_67266_/A }
C {devices/lab_pin.sym} 152520 -25820 0 0 {name=p151586 lab=_88116_/Q }
C {devices/lab_pin.sym} 152640 -25840 0 1 {name=p151587 lab=_67314_/X }
C {sky130_stdcells/and2_4.sym} 152580 -25840 0 0 {name=X_67314_ }
C {devices/lab_pin.sym} 152500 -25730 0 0 {name=p151588 lab=_65234_/B }
C {devices/lab_pin.sym} 152500 -25690 0 0 {name=p151589 lab=_52500_/X }
C {devices/lab_pin.sym} 152500 -25650 0 0 {name=p151590 lab=_52539_/Y }
C {devices/lab_pin.sym} 152660 -25690 0 1 {name=p151591 lab=_52540_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -25690 0 0 {name=X_52540_ }
C {devices/lab_pin.sym} 152520 -25570 0 0 {name=p151592 lab=_64455_/X }
C {devices/lab_pin.sym} 152520 -25530 0 0 {name=p151593 lab=_64526_/B }
C {devices/lab_pin.sym} 152520 -25490 0 0 {name=p151594 lab=_61102_/X }
C {devices/lab_pin.sym} 152640 -25530 0 1 {name=p151595 lab=_64526_/Y }
C {sky130_stdcells/nand3_4.sym} 152580 -25530 0 0 {name=X_64526_ }
C {devices/lab_pin.sym} 152490 -25390 0 0 {name=p151596 lab=_83421_/CLK }
C {devices/lab_pin.sym} 152490 -25370 0 0 {name=p151597 lab=_83360_/D }
C {devices/lab_pin.sym} 152670 -25390 0 1 {name=p151598 lab=_83360_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -25380 0 0 {name=X_83360_ }
C {devices/lab_pin.sym} 152540 -25250 0 0 {name=p151599 lab=clkbuf_8_37_0_CLK/X }
C {devices/lab_pin.sym} 152620 -25250 0 1 {name=p151600 lab=clkbuf_9_74_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 152580 -25250 0 0 {name=Xclkbuf_9_74_0_CLK }
C {devices/lab_pin.sym} 152540 -25130 0 0 {name=p151601 lab=_59692_/Y }
C {devices/lab_pin.sym} 152620 -25130 0 1 {name=p151602 lab=_61842_/A }
C {sky130_stdcells/buf_2.sym} 152580 -25130 0 0 {name=X_61738_ }
C {devices/lab_pin.sym} 152500 -25040 0 0 {name=p151603 lab=_80550_/A }
C {devices/lab_pin.sym} 152500 -25000 0 0 {name=p151604 lab=_80549_/Y }
C {devices/lab_pin.sym} 152500 -24960 0 0 {name=p151605 lab=_80557_/X }
C {devices/lab_pin.sym} 152500 -24920 0 0 {name=p151606 lab=_80561_/B }
C {devices/lab_pin.sym} 152660 -24980 0 1 {name=p151607 lab=_80572_/X }
C {sky130_stdcells/o22a_4.sym} 152580 -24980 0 0 {name=X_80572_ }
C {devices/lab_pin.sym} 152540 -24830 0 0 {name=p151608 lab=_67013_/X }
C {devices/lab_pin.sym} 152620 -24830 0 1 {name=p151609 lab=_68737_/A }
C {sky130_stdcells/buf_2.sym} 152580 -24830 0 0 {name=X_68294_ }
C {sky130_stdcells/decap_3.sym} 152580 -24680 0 0 {name=XPHY_209 }
C {devices/lab_pin.sym} 152490 -24530 0 0 {name=p151610 lab=_82317_/CLK }
C {devices/lab_pin.sym} 152490 -24510 0 0 {name=p151611 lab=_77033_/B }
C {devices/lab_pin.sym} 152670 -24530 0 1 {name=p151612 lab=_82311_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -24520 0 0 {name=X_82311_ }
C {devices/lab_pin.sym} 152520 -24400 0 0 {name=p151613 lab=_67266_/A }
C {devices/lab_pin.sym} 152520 -24360 0 0 {name=p151614 lab=_67245_/B }
C {devices/lab_pin.sym} 152640 -24380 0 1 {name=p151615 lab=_67245_/X }
C {sky130_stdcells/and2_4.sym} 152580 -24380 0 0 {name=X_67245_ }
C {devices/lab_pin.sym} 152540 -24250 0 0 {name=p151616 lab=_52177_/A }
C {devices/lab_pin.sym} 152620 -24250 0 1 {name=p151617 lab=_52476_/A }
C {sky130_stdcells/buf_2.sym} 152580 -24250 0 0 {name=X_52471_ }
C {devices/lab_pin.sym} 152520 -24150 0 0 {name=p151618 lab=_64456_/Y }
C {devices/lab_pin.sym} 152520 -24110 0 0 {name=p151619 lab=_64457_/B }
C {devices/lab_pin.sym} 152520 -24070 0 0 {name=p151620 lab=_64457_/C }
C {devices/lab_pin.sym} 152640 -24110 0 1 {name=p151621 lab=_64457_/Y }
C {sky130_stdcells/nand3_4.sym} 152580 -24110 0 0 {name=X_64457_ }
C {devices/lab_pin.sym} 152490 -23970 0 0 {name=p151622 lab=_83304_/CLK }
C {devices/lab_pin.sym} 152490 -23950 0 0 {name=p151623 lab=_72071_/Y }
C {devices/lab_pin.sym} 152670 -23970 0 1 {name=p151624 lab=_83291_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -23960 0 0 {name=X_83291_ }
C {devices/lab_pin.sym} 152540 -23830 0 0 {name=p151625 lab=_61669_/A }
C {devices/lab_pin.sym} 152620 -23830 0 1 {name=p151626 lab=_61669_/Y }
C {sky130_stdcells/inv_2.sym} 152580 -23830 0 0 {name=X_61669_ }
C {devices/lab_pin.sym} 152500 -23730 0 0 {name=p151627 lab=_54206_/Y }
C {devices/lab_pin.sym} 152500 -23690 0 0 {name=p151628 lab=_54197_/X }
C {devices/lab_pin.sym} 152500 -23650 0 0 {name=p151629 lab=_54209_/X }
C {devices/lab_pin.sym} 152660 -23690 0 1 {name=p151630 lab=_85484_/D }
C {sky130_stdcells/a21oi_4.sym} 152580 -23690 0 0 {name=X_54210_ }
C {devices/lab_pin.sym} 152490 -23550 0 0 {name=p151631 lab=_85039_/CLK }
C {devices/lab_pin.sym} 152490 -23530 0 0 {name=p151632 lab=_85030_/D }
C {devices/lab_pin.sym} 152670 -23550 0 1 {name=p151633 lab=_45811_/A }
C {sky130_stdcells/dfxtp_4.sym} 152580 -23540 0 0 {name=X_85030_ }
C {devices/lab_pin.sym} 152520 -23440 0 0 {name=p151634 lab=_51410_/X }
C {devices/lab_pin.sym} 152520 -23400 0 0 {name=p151635 lab=_51421_/X }
C {devices/lab_pin.sym} 152520 -23360 0 0 {name=p151636 lab=_51438_/C }
C {devices/lab_pin.sym} 152520 -23320 0 0 {name=p151637 lab=_52948_/D }
C {devices/lab_pin.sym} 152640 -23380 0 1 {name=p151638 lab=_51422_/X }
C {sky130_stdcells/and4_4.sym} 152580 -23380 0 0 {name=X_51422_ }
C {devices/lab_pin.sym} 152500 -23250 0 0 {name=p151639 lab=_63403_/Y }
C {devices/lab_pin.sym} 152500 -23210 0 0 {name=p151640 lab=_63391_/X }
C {devices/lab_pin.sym} 152500 -23170 0 0 {name=p151641 lab=_63407_/Y }
C {devices/lab_pin.sym} 152660 -23210 0 1 {name=p151642 lab=_63408_/Y }
C {sky130_stdcells/a21oi_4.sym} 152580 -23210 0 0 {name=X_63408_ }
C {devices/lab_pin.sym} 152490 -23070 0 0 {name=p151643 lab=_84441_/CLK }
C {devices/lab_pin.sym} 152490 -23050 0 0 {name=p151644 lab=_80636_/Y }
C {devices/lab_pin.sym} 152670 -23070 0 1 {name=p151645 lab=_82242_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -23060 0 0 {name=X_82242_ }
C {devices/lab_pin.sym} 152540 -22930 0 0 {name=p151646 lab=_55710_/B }
C {devices/lab_pin.sym} 152620 -22930 0 1 {name=p151647 lab=_55190_/X }
C {sky130_stdcells/buf_2.sym} 152580 -22930 0 0 {name=X_55190_ }
C {devices/lab_pin.sym} 152540 -22810 0 0 {name=p151648 lab=_67055_/X }
C {devices/lab_pin.sym} 152620 -22810 0 1 {name=p151649 lab=_67176_/X }
C {sky130_stdcells/buf_2.sym} 152580 -22810 0 0 {name=X_67176_ }
C {devices/lab_pin.sym} 152500 -22710 0 0 {name=p151650 lab=_79733_/B }
C {devices/lab_pin.sym} 152500 -22670 0 0 {name=p151651 lab=_64373_/X }
C {devices/lab_pin.sym} 152500 -22630 0 0 {name=p151652 lab=_64387_/X }
C {devices/lab_pin.sym} 152660 -22670 0 1 {name=p151653 lab=_64388_/X }
C {sky130_stdcells/a21o_4.sym} 152580 -22670 0 0 {name=X_64388_ }
C {devices/lab_pin.sym} 152540 -22530 0 0 {name=p151654 lab=_54194_/A }
C {devices/lab_pin.sym} 152620 -22530 0 1 {name=p151655 lab=_54149_/A }
C {sky130_stdcells/buf_2.sym} 152580 -22530 0 0 {name=X_54141_ }
C {devices/lab_pin.sym} 152540 -22410 0 0 {name=p151656 lab=clkbuf_9_88_0_CLK/A }
C {devices/lab_pin.sym} 152620 -22410 0 1 {name=p151657 lab=clkbuf_9_89_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 152580 -22410 0 0 {name=Xclkbuf_9_89_0_CLK }
C {devices/lab_pin.sym} 152520 -22300 0 0 {name=p151658 lab=_66181_/A }
C {devices/lab_pin.sym} 152520 -22260 0 0 {name=p151659 lab=_85906_/Q }
C {devices/lab_pin.sym} 152640 -22280 0 1 {name=p151660 lab=_66127_/X }
C {sky130_stdcells/and2_4.sym} 152580 -22280 0 0 {name=X_66127_ }
C {devices/lab_pin.sym} 152500 -22170 0 0 {name=p151661 lab=_51351_/Y }
C {devices/lab_pin.sym} 152500 -22130 0 0 {name=p151662 lab=_51339_/X }
C {devices/lab_pin.sym} 152500 -22090 0 0 {name=p151663 lab=_51352_/X }
C {devices/lab_pin.sym} 152660 -22130 0 1 {name=p151664 lab=_86027_/D }
C {sky130_stdcells/a21oi_4.sym} 152580 -22130 0 0 {name=X_51353_ }
C {devices/lab_pin.sym} 152500 -22030 0 0 {name=p151665 lab=_59445_/A }
C {devices/lab_pin.sym} 152500 -21990 0 0 {name=p151666 lab=_60417_/A }
C {devices/lab_pin.sym} 152500 -21950 0 0 {name=p151667 lab=_60523_/A }
C {devices/lab_pin.sym} 152500 -21910 0 0 {name=p151668 lab=_58990_/Y }
C {devices/lab_pin.sym} 152500 -21870 0 0 {name=p151669 lab=_63060_/A }
C {devices/lab_pin.sym} 152660 -21950 0 1 {name=p151670 lab=_63339_/Y }
C {sky130_stdcells/o32ai_4.sym} 152580 -21950 0 0 {name=X_63339_ }
C {devices/lab_pin.sym} 152490 -21790 0 0 {name=p151671 lab=_82047_/CLK }
C {devices/lab_pin.sym} 152490 -21770 0 0 {name=p151672 lab=_65970_/C }
C {devices/lab_pin.sym} 152670 -21790 0 1 {name=p151673 lab=_77983_/B }
C {sky130_stdcells/dfxtp_4.sym} 152580 -21780 0 0 {name=X_82173_ }
C {devices/lab_pin.sym} 152520 -21660 0 0 {name=p151674 lab=_50279_/X }
C {devices/lab_pin.sym} 152520 -21620 0 0 {name=p151675 lab=_48257_/B }
C {devices/lab_pin.sym} 152640 -21640 0 1 {name=p151676 lab=_50304_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -21640 0 0 {name=X_50304_ }
C {devices/lab_pin.sym} 152490 -21510 0 0 {name=p151677 lab=_81195_/CLK }
C {devices/lab_pin.sym} 152490 -21490 0 0 {name=p151678 lab=_81124_/D }
C {devices/lab_pin.sym} 152670 -21510 0 1 {name=p151679 lab=_81124_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -21500 0 0 {name=X_81124_ }
C {devices/lab_pin.sym} 152500 -21390 0 0 {name=p151680 lab=_54070_/Y }
C {devices/lab_pin.sym} 152500 -21350 0 0 {name=p151681 lab=_54060_/X }
C {devices/lab_pin.sym} 152500 -21310 0 0 {name=p151682 lab=_54071_/Y }
C {devices/lab_pin.sym} 152660 -21350 0 1 {name=p151683 lab=_54072_/Y }
C {sky130_stdcells/a21boi_4.sym} 152580 -21350 0 0 {name=X_54072_ }
C {devices/lab_pin.sym} 152500 -21230 0 0 {name=p151684 lab=_66051_/X }
C {devices/lab_pin.sym} 152500 -21190 0 0 {name=p151685 lab=_66056_/X }
C {devices/lab_pin.sym} 152500 -21150 0 0 {name=p151686 lab=_66057_/X }
C {devices/lab_pin.sym} 152660 -21190 0 1 {name=p151687 lab=_66061_/A }
C {sky130_stdcells/a21o_4.sym} 152580 -21190 0 0 {name=X_66058_ }
C {devices/lab_pin.sym} 152500 -21070 0 0 {name=p151688 lab=_51281_/Y }
C {devices/lab_pin.sym} 152500 -21030 0 0 {name=p151689 lab=_51263_/X }
C {devices/lab_pin.sym} 152500 -20990 0 0 {name=p151690 lab=_51283_/X }
C {devices/lab_pin.sym} 152660 -21030 0 1 {name=p151691 lab=_86040_/D }
C {sky130_stdcells/a21oi_4.sym} 152580 -21030 0 0 {name=X_51284_ }
C {devices/lab_pin.sym} 152490 -20890 0 0 {name=p151692 lab=_82538_/CLK }
C {devices/lab_pin.sym} 152490 -20870 0 0 {name=p151693 lab=_44737_/Y }
C {devices/lab_pin.sym} 152670 -20890 0 1 {name=p151694 lab=_86981_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -20880 0 0 {name=X_86981_ }
C {devices/lab_pin.sym} 152540 -20750 0 0 {name=p151695 lab=_58876_/A }
C {devices/lab_pin.sym} 152620 -20750 0 1 {name=p151696 lab=_65009_/X }
C {sky130_stdcells/buf_2.sym} 152580 -20750 0 0 {name=X_65009_ }
C {devices/lab_pin.sym} 152520 -20660 0 0 {name=p151697 lab=_53019_/A }
C {devices/lab_pin.sym} 152520 -20620 0 0 {name=p151698 lab=_53036_/B }
C {devices/lab_pin.sym} 152520 -20580 0 0 {name=p151699 lab=_53019_/C }
C {devices/lab_pin.sym} 152520 -20540 0 0 {name=p151700 lab=_53023_/D }
C {devices/lab_pin.sym} 152640 -20600 0 1 {name=p151701 lab=_53023_/X }
C {sky130_stdcells/and4_4.sym} 152580 -20600 0 0 {name=X_53023_ }
C {devices/lab_pin.sym} 152500 -20490 0 0 {name=p151702 lab=_57868_/X }
C {devices/lab_pin.sym} 152500 -20450 0 0 {name=p151703 lab=_57897_/Y }
C {devices/lab_pin.sym} 152500 -20410 0 0 {name=p151704 lab=_57898_/Y }
C {devices/lab_pin.sym} 152500 -20370 0 0 {name=p151705 lab=_57899_/X }
C {devices/lab_pin.sym} 152500 -20330 0 0 {name=p151706 lab=_57872_/X }
C {devices/lab_pin.sym} 152660 -20410 0 1 {name=p151707 lab=_57900_/X }
C {sky130_stdcells/o32a_4.sym} 152580 -20410 0 0 {name=X_57900_ }
C {devices/lab_pin.sym} 152500 -20270 0 0 {name=p151708 lab=_50233_/Y }
C {devices/lab_pin.sym} 152500 -20230 0 0 {name=p151709 lab=_50227_/X }
C {devices/lab_pin.sym} 152500 -20190 0 0 {name=p151710 lab=_50234_/Y }
C {devices/lab_pin.sym} 152660 -20230 0 1 {name=p151711 lab=_50235_/Y }
C {sky130_stdcells/a21boi_4.sym} 152580 -20230 0 0 {name=X_50235_ }
C {devices/lab_pin.sym} 152490 -20090 0 0 {name=p151712 lab=_86091_/CLK }
C {devices/lab_pin.sym} 152490 -20070 0 0 {name=p151713 lab=_51866_/Y }
C {devices/lab_pin.sym} 152670 -20090 0 1 {name=p151714 lab=_85932_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -20080 0 0 {name=X_85932_ }
C {devices/lab_pin.sym} 152490 -19950 0 0 {name=p151715 lab=_85335_/CLK }
C {devices/lab_pin.sym} 152490 -19930 0 0 {name=p151716 lab=_75528_/X }
C {devices/lab_pin.sym} 152670 -19950 0 1 {name=p151717 lab=_81055_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -19940 0 0 {name=X_81055_ }
C {devices/lab_pin.sym} 152500 -19830 0 0 {name=p151718 lab=_58813_/X }
C {devices/lab_pin.sym} 152500 -19790 0 0 {name=p151719 lab=_85769_/Q }
C {devices/lab_pin.sym} 152500 -19750 0 0 {name=p151720 lab=_58838_/X }
C {devices/lab_pin.sym} 152660 -19790 0 1 {name=p151721 lab=_58880_/X }
C {sky130_stdcells/o21a_4.sym} 152580 -19790 0 0 {name=X_58880_ }
C {devices/lab_pin.sym} 152540 -19650 0 0 {name=p151722 lab=clkbuf_8_6_0_CLK/X }
C {devices/lab_pin.sym} 152620 -19650 0 1 {name=p151723 lab=clkbuf_9_12_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 152580 -19650 0 0 {name=Xclkbuf_9_12_0_CLK }
C {devices/lab_pin.sym} 152520 -19540 0 0 {name=p151724 lab=_84658_/Q }
C {devices/lab_pin.sym} 152520 -19500 0 0 {name=p151725 lab=_64108_/C }
C {devices/lab_pin.sym} 152640 -19520 0 1 {name=p151726 lab=_80006_/X }
C {sky130_stdcells/xor2_4.sym} 152580 -19520 0 0 {name=X_80006_ }
C {devices/lab_pin.sym} 152500 -19420 0 0 {name=p151727 lab=_84947_/Q }
C {devices/lab_pin.sym} 152500 -19380 0 0 {name=p151728 lab=_57819_/X }
C {devices/lab_pin.sym} 152500 -19340 0 0 {name=p151729 lab=_57823_/X }
C {devices/lab_pin.sym} 152500 -19300 0 0 {name=p151730 lab=_57830_/X }
C {devices/lab_pin.sym} 152660 -19360 0 1 {name=p151731 lab=_57831_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 152580 -19360 0 0 {name=X_57831_ }
C {devices/lab_pin.sym} 152500 -19230 0 0 {name=p151732 lab=_69386_/X }
C {devices/lab_pin.sym} 152500 -19190 0 0 {name=p151733 lab=_69388_/X }
C {devices/lab_pin.sym} 152500 -19150 0 0 {name=p151734 lab=_69816_/X }
C {devices/lab_pin.sym} 152660 -19190 0 1 {name=p151735 lab=_69817_/Y }
C {sky130_stdcells/a21oi_4.sym} 152580 -19190 0 0 {name=X_69817_ }
C {devices/lab_pin.sym} 152540 -19050 0 0 {name=p151736 lab=_50092_/A }
C {devices/lab_pin.sym} 152620 -19050 0 1 {name=p151737 lab=_50166_/X }
C {sky130_stdcells/buf_2.sym} 152580 -19050 0 0 {name=X_50166_ }
C {devices/lab_pin.sym} 152490 -18930 0 0 {name=p151738 lab=_86500_/CLK }
C {devices/lab_pin.sym} 152490 -18910 0 0 {name=p151739 lab=_85863_/D }
C {devices/lab_pin.sym} 152670 -18930 0 1 {name=p151740 lab=_85863_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -18920 0 0 {name=X_85863_ }
C {devices/lab_pin.sym} 152540 -18790 0 0 {name=p151741 lab=clkbuf_9_304_0_CLK/X }
C {devices/lab_pin.sym} 152620 -18790 0 1 {name=p151742 lab=_81125_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 152580 -18790 0 0 {name=Xclkbuf_10_609_0_CLK }
C {devices/lab_pin.sym} 152490 -18670 0 0 {name=p151743 lab=_88108_/CLK }
C {devices/lab_pin.sym} 152490 -18650 0 0 {name=p151744 lab=_43027_/Y }
C {devices/lab_pin.sym} 152670 -18670 0 1 {name=p151745 lab=_73577_/A }
C {sky130_stdcells/dfxtp_4.sym} 152580 -18660 0 0 {name=X_87602_ }
C {devices/lab_pin.sym} 152490 -18530 0 0 {name=p151746 lab=_82394_/CLK }
C {devices/lab_pin.sym} 152490 -18510 0 0 {name=p151747 lab=_84814_/D }
C {devices/lab_pin.sym} 152670 -18530 0 1 {name=p151748 lab=_84814_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -18520 0 0 {name=X_84814_ }
C {devices/lab_pin.sym} 152540 -18390 0 0 {name=p151749 lab=_57848_/A }
C {devices/lab_pin.sym} 152620 -18390 0 1 {name=p151750 lab=_58793_/A }
C {sky130_stdcells/buf_2.sym} 152580 -18390 0 0 {name=X_57762_ }
C {devices/lab_pin.sym} 152540 -18270 0 0 {name=p151751 lab=_87813_/Q }
C {devices/lab_pin.sym} 152620 -18270 0 1 {name=p151752 lab=_69749_/B }
C {sky130_stdcells/inv_2.sym} 152580 -18270 0 0 {name=X_69748_ }
C {devices/lab_pin.sym} 152520 -18160 0 0 {name=p151753 lab=_50069_/A }
C {devices/lab_pin.sym} 152520 -18120 0 0 {name=p151754 lab=_71998_/B }
C {devices/lab_pin.sym} 152640 -18140 0 1 {name=p151755 lab=_50097_/X }
C {sky130_stdcells/and2_4.sym} 152580 -18140 0 0 {name=X_50097_ }
C {devices/lab_pin.sym} 152520 -18040 0 0 {name=p151756 lab=_54964_/A }
C {devices/lab_pin.sym} 152520 -18000 0 0 {name=p151757 lab=_54955_/B }
C {devices/lab_pin.sym} 152520 -17960 0 0 {name=p151758 lab=_54974_/C }
C {devices/lab_pin.sym} 152520 -17920 0 0 {name=p151759 lab=_47548_/A }
C {devices/lab_pin.sym} 152640 -17980 0 1 {name=p151760 lab=_54974_/X }
C {sky130_stdcells/and4_4.sym} 152580 -17980 0 0 {name=X_54974_ }
C {devices/lab_pin.sym} 152490 -17830 0 0 {name=p151761 lab=_86122_/CLK }
C {devices/lab_pin.sym} 152490 -17810 0 0 {name=p151762 lab=_85794_/D }
C {devices/lab_pin.sym} 152670 -17830 0 1 {name=p151763 lab=_65411_/B }
C {sky130_stdcells/dfxtp_4.sym} 152580 -17820 0 0 {name=X_85794_ }
C {devices/lab_pin.sym} 152540 -17690 0 0 {name=p151764 lab=clkbuf_8_0_0_CLK/X }
C {devices/lab_pin.sym} 152620 -17690 0 1 {name=p151765 lab=clkbuf_9_0_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 152580 -17690 0 0 {name=Xclkbuf_9_0_0_CLK }
C {devices/lab_pin.sym} 152540 -17570 0 0 {name=p151766 lab=_64286_/C }
C {devices/lab_pin.sym} 152620 -17570 0 1 {name=p151767 lab=_59501_/X }
C {sky130_stdcells/buf_2.sym} 152580 -17570 0 0 {name=X_59501_ }
C {devices/lab_pin.sym} 152520 -17480 0 0 {name=p151768 lab=_56713_/A }
C {devices/lab_pin.sym} 152520 -17440 0 0 {name=p151769 lab=_56684_/C }
C {devices/lab_pin.sym} 152520 -17400 0 0 {name=p151770 lab=_56682_/X }
C {devices/lab_pin.sym} 152520 -17360 0 0 {name=p151771 lab=_56674_/X }
C {devices/lab_pin.sym} 152640 -17420 0 1 {name=p151772 lab=_56713_/X }
C {sky130_stdcells/and4_4.sym} 152580 -17420 0 0 {name=X_56713_ }
C {devices/lab_pin.sym} 152540 -17270 0 0 {name=p151773 lab=clkbuf_9_27_0_CLK/A }
C {devices/lab_pin.sym} 152620 -17270 0 1 {name=p151774 lab=clkbuf_9_27_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 152580 -17270 0 0 {name=Xclkbuf_9_27_0_CLK }
C {devices/lab_pin.sym} 152490 -17150 0 0 {name=p151775 lab=_87533_/CLK }
C {devices/lab_pin.sym} 152490 -17130 0 0 {name=p151776 lab=_43219_/X }
C {devices/lab_pin.sym} 152670 -17150 0 1 {name=p151777 lab=_87533_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -17140 0 0 {name=X_87533_ }
C {devices/lab_pin.sym} 152520 -17020 0 0 {name=p151778 lab=_53902_/A }
C {devices/lab_pin.sym} 152520 -16980 0 0 {name=p151779 lab=_50710_/B }
C {devices/lab_pin.sym} 152640 -17000 0 1 {name=p151780 lab=_53925_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -17000 0 0 {name=X_53925_ }
C {devices/lab_pin.sym} 152490 -16870 0 0 {name=p151781 lab=_83438_/CLK }
C {devices/lab_pin.sym} 152490 -16850 0 0 {name=p151782 lab=_59389_/X }
C {devices/lab_pin.sym} 152670 -16870 0 1 {name=p151783 lab=_84745_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -16860 0 0 {name=X_84745_ }
C {devices/lab_pin.sym} 152540 -16730 0 0 {name=p151784 lab=_64717_/A }
C {devices/lab_pin.sym} 152620 -16730 0 1 {name=p151785 lab=_64601_/A }
C {sky130_stdcells/buf_2.sym} 152580 -16730 0 0 {name=X_57693_ }
C {devices/lab_pin.sym} 152490 -16610 0 0 {name=p151786 lab=_82339_/CLK }
C {devices/lab_pin.sym} 152490 -16590 0 0 {name=p151787 lab=_81957_/D }
C {devices/lab_pin.sym} 152670 -16610 0 1 {name=p151788 lab=_81957_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -16600 0 0 {name=X_81957_ }
C {devices/lab_pin.sym} 152500 -16490 0 0 {name=p151789 lab=_69674_/X }
C {devices/lab_pin.sym} 152500 -16450 0 0 {name=p151790 lab=_69677_/X }
C {devices/lab_pin.sym} 152500 -16410 0 0 {name=p151791 lab=_69678_/X }
C {devices/lab_pin.sym} 152660 -16450 0 1 {name=p151792 lab=_69679_/X }
C {sky130_stdcells/a21o_4.sym} 152580 -16450 0 0 {name=X_69679_ }
C {devices/lab_pin.sym} 152540 -16310 0 0 {name=p151793 lab=_70500_/D }
C {devices/lab_pin.sym} 152620 -16310 0 1 {name=p151794 lab=_71711_/A }
C {sky130_stdcells/buf_2.sym} 152580 -16310 0 0 {name=X_71710_ }
C {devices/lab_pin.sym} 152500 -16210 0 0 {name=p151795 lab=_59417_/X }
C {devices/lab_pin.sym} 152500 -16170 0 0 {name=p151796 lab=_83343_/Q }
C {devices/lab_pin.sym} 152500 -16130 0 0 {name=p151797 lab=_59431_/Y }
C {devices/lab_pin.sym} 152660 -16170 0 1 {name=p151798 lab=_84735_/D }
C {sky130_stdcells/o21a_4.sym} 152580 -16170 0 0 {name=X_59432_ }
C {devices/lab_pin.sym} 152500 -16060 0 0 {name=p151799 lab=_56636_/X }
C {devices/lab_pin.sym} 152500 -16020 0 0 {name=p151800 lab=_56643_/X }
C {devices/lab_pin.sym} 152500 -15980 0 0 {name=p151801 lab=_85139_/Q }
C {devices/lab_pin.sym} 152500 -15940 0 0 {name=p151802 lab=_56753_/A }
C {devices/lab_pin.sym} 152660 -16000 0 1 {name=p151803 lab=_85139_/D }
C {sky130_stdcells/a2bb2o_4.sym} 152580 -16000 0 0 {name=X_56644_ }
C {devices/lab_pin.sym} 152490 -15850 0 0 {name=p151804 lab=_83918_/CLK }
C {devices/lab_pin.sym} 152490 -15830 0 0 {name=p151805 lab=_84084_/Q }
C {devices/lab_pin.sym} 152670 -15850 0 1 {name=p151806 lab=_75656_/A }
C {sky130_stdcells/dfxtp_4.sym} 152580 -15840 0 0 {name=X_80908_ }
C {devices/lab_pin.sym} 152490 -15710 0 0 {name=p151807 lab=_87720_/CLK }
C {devices/lab_pin.sym} 152490 -15690 0 0 {name=p151808 lab=_87464_/D }
C {devices/lab_pin.sym} 152670 -15710 0 1 {name=p151809 lab=_87464_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -15700 0 0 {name=X_87464_ }
C {devices/lab_pin.sym} 152520 -15580 0 0 {name=p151810 lab=_53848_/A }
C {devices/lab_pin.sym} 152520 -15540 0 0 {name=p151811 lab=_53856_/B }
C {devices/lab_pin.sym} 152640 -15560 0 1 {name=p151812 lab=_53856_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -15560 0 0 {name=X_53856_ }
C {devices/lab_pin.sym} 152500 -15450 0 0 {name=p151813 lab=_40361_/A }
C {devices/lab_pin.sym} 152500 -15410 0 0 {name=p151814 lab=_41902_/A }
C {devices/lab_pin.sym} 152500 -15370 0 0 {name=p151815 lab=_41870_/B1 }
C {devices/lab_pin.sym} 152660 -15410 0 1 {name=p151816 lab=_41880_/A }
C {sky130_stdcells/a21o_4.sym} 152580 -15410 0 0 {name=X_41870_ }
C {devices/lab_pin.sym} 152500 -15290 0 0 {name=p151817 lab=_70229_/C }
C {devices/lab_pin.sym} 152500 -15250 0 0 {name=p151818 lab=_72686_/X }
C {devices/lab_pin.sym} 152500 -15210 0 0 {name=p151819 lab=_72689_/Y }
C {devices/lab_pin.sym} 152660 -15250 0 1 {name=p151820 lab=_83189_/D }
C {sky130_stdcells/a21bo_4.sym} 152580 -15250 0 0 {name=X_72690_ }
C {devices/lab_pin.sym} 152490 -15110 0 0 {name=p151821 lab=_84672_/CLK }
C {devices/lab_pin.sym} 152490 -15090 0 0 {name=p151822 lab=_84676_/D }
C {devices/lab_pin.sym} 152670 -15110 0 1 {name=p151823 lab=_80195_/A }
C {sky130_stdcells/dfxtp_4.sym} 152580 -15100 0 0 {name=X_84676_ }
C {devices/lab_pin.sym} 152490 -14970 0 0 {name=p151824 lab=_82531_/CLK }
C {devices/lab_pin.sym} 152490 -14950 0 0 {name=p151825 lab=_78079_/X }
C {devices/lab_pin.sym} 152670 -14970 0 1 {name=p151826 lab=_81888_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -14960 0 0 {name=X_81888_ }
C {devices/lab_pin.sym} 152490 -14830 0 0 {name=p151827 lab=_86127_/CLK }
C {devices/lab_pin.sym} 152490 -14810 0 0 {name=p151828 lab=_86415_/D }
C {devices/lab_pin.sym} 152670 -14830 0 1 {name=p151829 lab=_86415_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -14820 0 0 {name=X_86415_ }
C {devices/lab_pin.sym} 152540 -14690 0 0 {name=p151830 lab=_40793_/A }
C {devices/lab_pin.sym} 152620 -14690 0 1 {name=p151831 lab=_40821_/X }
C {sky130_stdcells/buf_2.sym} 152580 -14690 0 0 {name=X_40821_ }
C {devices/lab_pin.sym} 152520 -14580 0 0 {name=p151832 lab=_52803_/A }
C {devices/lab_pin.sym} 152520 -14540 0 0 {name=p151833 lab=_52807_/B }
C {devices/lab_pin.sym} 152640 -14560 0 1 {name=p151834 lab=_52807_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -14560 0 0 {name=X_52807_ }
C {devices/lab_pin.sym} 152540 -14430 0 0 {name=p151835 lab=_71641_/A }
C {devices/lab_pin.sym} 152620 -14430 0 1 {name=p151836 lab=_71644_/C }
C {sky130_stdcells/buf_2.sym} 152580 -14430 0 0 {name=X_71641_ }
C {devices/lab_pin.sym} 152490 -14310 0 0 {name=p151837 lab=_83627_/CLK }
C {devices/lab_pin.sym} 152490 -14290 0 0 {name=p151838 lab=_71040_/Y }
C {devices/lab_pin.sym} 152670 -14310 0 1 {name=p151839 lab=_47657_/A }
C {sky130_stdcells/dfxtp_4.sym} 152580 -14300 0 0 {name=X_83627_ }
C {devices/lab_pin.sym} 152500 -14200 0 0 {name=p151840 lab=_59354_/Y }
C {devices/lab_pin.sym} 152500 -14160 0 0 {name=p151841 lab=_59230_/X }
C {devices/lab_pin.sym} 152500 -14120 0 0 {name=p151842 lab=_59359_/X }
C {devices/lab_pin.sym} 152500 -14080 0 0 {name=p151843 lab=_59362_/X }
C {devices/lab_pin.sym} 152660 -14140 0 1 {name=p151844 lab=_59363_/Y }
C {sky130_stdcells/a22oi_4.sym} 152580 -14140 0 0 {name=X_59363_ }
C {devices/lab_pin.sym} 152540 -13990 0 0 {name=p151845 lab=_56574_/Y }
C {devices/lab_pin.sym} 152620 -13990 0 1 {name=p151846 lab=_56575_/X }
C {sky130_stdcells/buf_2.sym} 152580 -13990 0 0 {name=X_56575_ }
C {devices/lab_pin.sym} 152490 -13870 0 0 {name=p151847 lab=_80746_/CLK }
C {devices/lab_pin.sym} 152490 -13850 0 0 {name=p151848 lab=_80871_/Q }
C {devices/lab_pin.sym} 152670 -13870 0 1 {name=p151849 lab=_74875_/B }
C {sky130_stdcells/dfxtp_4.sym} 152580 -13860 0 0 {name=X_80839_ }
C {devices/lab_pin.sym} 152490 -13730 0 0 {name=p151850 lab=_87150_/CLK }
C {devices/lab_pin.sym} 152490 -13710 0 0 {name=p151851 lab=_87395_/D }
C {devices/lab_pin.sym} 152670 -13730 0 1 {name=p151852 lab=_87395_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -13720 0 0 {name=X_87395_ }
C {devices/lab_pin.sym} 152500 -13610 0 0 {name=p151853 lab=_85568_/Q }
C {devices/lab_pin.sym} 152500 -13570 0 0 {name=p151854 lab=_53784_/X }
C {devices/lab_pin.sym} 152500 -13530 0 0 {name=p151855 lab=_53786_/Y }
C {devices/lab_pin.sym} 152660 -13570 0 1 {name=p151856 lab=_53787_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -13570 0 0 {name=X_53787_ }
C {devices/lab_pin.sym} 152500 -13450 0 0 {name=p151857 lab=_86092_/Q }
C {devices/lab_pin.sym} 152500 -13410 0 0 {name=p151858 lab=_50992_/X }
C {devices/lab_pin.sym} 152500 -13370 0 0 {name=p151859 lab=_50998_/Y }
C {devices/lab_pin.sym} 152660 -13410 0 1 {name=p151860 lab=_50999_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -13410 0 0 {name=X_50999_ }
C {devices/lab_pin.sym} 152520 -13280 0 0 {name=p151861 lab=_58314_/A }
C {devices/lab_pin.sym} 152520 -13240 0 0 {name=p151862 lab=_58326_/B }
C {devices/lab_pin.sym} 152640 -13260 0 1 {name=p151863 lab=_58314_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -13260 0 0 {name=X_58314_ }
C {devices/lab_pin.sym} 152500 -13170 0 0 {name=p151864 lab=_43518_/X }
C {devices/lab_pin.sym} 152500 -13130 0 0 {name=p151865 lab=_43523_/X }
C {devices/lab_pin.sym} 152500 -13090 0 0 {name=p151866 lab=_40432_/X }
C {devices/lab_pin.sym} 152500 -13050 0 0 {name=p151867 lab=_87368_/Q }
C {devices/lab_pin.sym} 152500 -13010 0 0 {name=p151868 lab=_43528_/X }
C {devices/lab_pin.sym} 152660 -13090 0 1 {name=p151869 lab=_43540_/Y }
C {sky130_stdcells/o32ai_4.sym} 152580 -13090 0 0 {name=X_43540_ }
C {devices/lab_pin.sym} 152500 -12950 0 0 {name=p151870 lab=_55521_/X }
C {devices/lab_pin.sym} 152500 -12910 0 0 {name=p151871 lab=_55525_/X }
C {devices/lab_pin.sym} 152500 -12870 0 0 {name=p151872 lab=_44113_/X }
C {devices/lab_pin.sym} 152660 -12910 0 1 {name=p151873 lab=_55526_/X }
C {sky130_stdcells/a21o_4.sym} 152580 -12910 0 0 {name=X_55526_ }
C {devices/lab_pin.sym} 152500 -12790 0 0 {name=p151874 lab=_83083_/Q }
C {devices/lab_pin.sym} 152500 -12750 0 0 {name=p151875 lab=_72699_/X }
C {devices/lab_pin.sym} 152500 -12710 0 0 {name=p151876 lab=_74359_/Y }
C {devices/lab_pin.sym} 152660 -12750 0 1 {name=p151877 lab=_83083_/D }
C {sky130_stdcells/a21bo_4.sym} 152580 -12750 0 0 {name=X_74360_ }
C {devices/lab_pin.sym} 152490 -12610 0 0 {name=p151878 lab=_82381_/CLK }
C {devices/lab_pin.sym} 152490 -12590 0 0 {name=p151879 lab=_49665_/Y }
C {devices/lab_pin.sym} 152670 -12610 0 1 {name=p151880 lab=_86346_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -12600 0 0 {name=X_86346_ }
C {devices/lab_pin.sym} 152500 -12490 0 0 {name=p151881 lab=_40731_/X }
C {devices/lab_pin.sym} 152500 -12450 0 0 {name=p151882 lab=_40923_/A }
C {devices/lab_pin.sym} 152500 -12410 0 0 {name=p151883 lab=_40751_/X }
C {devices/lab_pin.sym} 152660 -12450 0 1 {name=p151884 lab=_40753_/A }
C {sky130_stdcells/o21ai_4.sym} 152580 -12450 0 0 {name=X_40752_ }
C {devices/lab_pin.sym} 152540 -12310 0 0 {name=p151885 lab=_52657_/A }
C {devices/lab_pin.sym} 152620 -12310 0 1 {name=p151886 lab=_52744_/A }
C {sky130_stdcells/buf_2.sym} 152580 -12310 0 0 {name=X_52738_ }
C {devices/lab_pin.sym} 152500 -12210 0 0 {name=p151887 lab=_59231_/X }
C {devices/lab_pin.sym} 152500 -12170 0 0 {name=p151888 lab=_85417_/Q }
C {devices/lab_pin.sym} 152500 -12130 0 0 {name=p151889 lab=_59293_/X }
C {devices/lab_pin.sym} 152660 -12170 0 1 {name=p151890 lab=_59294_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -12170 0 0 {name=X_59294_ }
C {devices/lab_pin.sym} 152520 -12050 0 0 {name=p151891 lab=_71570_/X }
C {devices/lab_pin.sym} 152520 -12010 0 0 {name=p151892 lab=_71583_/B }
C {devices/lab_pin.sym} 152520 -11970 0 0 {name=p151893 lab=_71574_/C }
C {devices/lab_pin.sym} 152640 -12010 0 1 {name=p151894 lab=_71572_/Y }
C {sky130_stdcells/nor3_4.sym} 152580 -12010 0 0 {name=X_71572_ }
C {devices/lab_pin.sym} 152490 -11870 0 0 {name=p151895 lab=_86558_/CLK }
C {devices/lab_pin.sym} 152490 -11850 0 0 {name=p151896 lab=_83558_/D }
C {devices/lab_pin.sym} 152670 -11870 0 1 {name=p151897 lab=_83558_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -11860 0 0 {name=X_83558_ }
C {devices/lab_pin.sym} 152500 -11760 0 0 {name=p151898 lab=_73214_/X }
C {devices/lab_pin.sym} 152500 -11720 0 0 {name=p151899 lab=_83060_/Q }
C {devices/lab_pin.sym} 152500 -11680 0 0 {name=p151900 lab=_73238_/X }
C {devices/lab_pin.sym} 152500 -11640 0 0 {name=p151901 lab=_73310_/X }
C {devices/lab_pin.sym} 152660 -11700 0 1 {name=p151902 lab=_73311_/X }
C {sky130_stdcells/a211o_4.sym} 152580 -11700 0 0 {name=X_73311_ }
C {devices/lab_pin.sym} 152500 -11570 0 0 {name=p151903 lab=_57674_/Y }
C {devices/lab_pin.sym} 152500 -11530 0 0 {name=p151904 lab=_70500_/Y }
C {devices/lab_pin.sym} 152500 -11490 0 0 {name=p151905 lab=_70522_/Y }
C {devices/lab_pin.sym} 152660 -11530 0 1 {name=p151906 lab=_83756_/D }
C {sky130_stdcells/o21ai_4.sym} 152580 -11530 0 0 {name=X_70523_ }
C {devices/lab_pin.sym} 152500 -11410 0 0 {name=p151907 lab=_58219_/X }
C {devices/lab_pin.sym} 152500 -11370 0 0 {name=p151908 lab=_58240_/Y }
C {devices/lab_pin.sym} 152500 -11330 0 0 {name=p151909 lab=_58244_/Y }
C {devices/lab_pin.sym} 152660 -11370 0 1 {name=p151910 lab=_84899_/D }
C {sky130_stdcells/a21oi_4.sym} 152580 -11370 0 0 {name=X_58245_ }
C {sky130_stdcells/decap_3.sym} 152580 -11200 0 0 {name=XPHY_710 }
C {devices/lab_pin.sym} 152490 -11050 0 0 {name=p151911 lab=_82702_/CLK }
C {devices/lab_pin.sym} 152490 -11030 0 0 {name=p151912 lab=_82509_/D }
C {devices/lab_pin.sym} 152670 -11050 0 1 {name=p151913 lab=_78469_/A }
C {sky130_stdcells/dfxtp_4.sym} 152580 -11040 0 0 {name=X_82509_ }
C {devices/lab_pin.sym} 152540 -10910 0 0 {name=p151914 lab=_55301_/X }
C {devices/lab_pin.sym} 152620 -10910 0 1 {name=p151915 lab=_55457_/X }
C {sky130_stdcells/buf_2.sym} 152580 -10910 0 0 {name=X_55457_ }
C {devices/lab_pin.sym} 152500 -10820 0 0 {name=p151916 lab=_41663_/X }
C {devices/lab_pin.sym} 152500 -10780 0 0 {name=p151917 lab=_43465_/X }
C {devices/lab_pin.sym} 152500 -10740 0 0 {name=p151918 lab=_87405_/Q }
C {devices/lab_pin.sym} 152500 -10700 0 0 {name=p151919 lab=_43467_/X }
C {devices/lab_pin.sym} 152660 -10760 0 1 {name=p151920 lab=_87405_/D }
C {sky130_stdcells/a2bb2o_4.sym} 152580 -10760 0 0 {name=X_43471_ }
C {devices/lab_pin.sym} 152520 -10630 0 0 {name=p151921 lab=_74297_/A }
C {devices/lab_pin.sym} 152520 -10590 0 0 {name=p151922 lab=_74297_/B }
C {devices/lab_pin.sym} 152520 -10550 0 0 {name=p151923 lab=_55975_/X }
C {devices/lab_pin.sym} 152640 -10590 0 1 {name=p151924 lab=_74291_/Y }
C {sky130_stdcells/nand3_4.sym} 152580 -10590 0 0 {name=X_74291_ }
C {devices/lab_pin.sym} 152490 -10450 0 0 {name=p151925 lab=_85957_/CLK }
C {devices/lab_pin.sym} 152490 -10430 0 0 {name=p151926 lab=_86277_/D }
C {devices/lab_pin.sym} 152670 -10450 0 1 {name=p151927 lab=_86277_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -10440 0 0 {name=X_86277_ }
C {devices/lab_pin.sym} 152540 -10310 0 0 {name=p151928 lab=_40832_/A }
C {devices/lab_pin.sym} 152620 -10310 0 1 {name=p151929 lab=_40683_/X }
C {sky130_stdcells/buf_2.sym} 152580 -10310 0 0 {name=X_40683_ }
C {devices/lab_pin.sym} 152520 -10220 0 0 {name=p151930 lab=_52648_/X }
C {devices/lab_pin.sym} 152520 -10180 0 0 {name=p151931 lab=_52661_/B }
C {devices/lab_pin.sym} 152520 -10140 0 0 {name=p151932 lab=_52654_/C }
C {devices/lab_pin.sym} 152520 -10100 0 0 {name=p151933 lab=_46783_/X }
C {devices/lab_pin.sym} 152640 -10160 0 1 {name=p151934 lab=_52669_/X }
C {sky130_stdcells/and4_4.sym} 152580 -10160 0 0 {name=X_52669_ }
C {devices/lab_pin.sym} 152490 -10010 0 0 {name=p151935 lab=_83756_/CLK }
C {devices/lab_pin.sym} 152490 -9990 0 0 {name=p151936 lab=_83489_/D }
C {devices/lab_pin.sym} 152670 -10010 0 1 {name=p151937 lab=_83489_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -10000 0 0 {name=X_83489_ }
C {devices/lab_pin.sym} 152500 -9890 0 0 {name=p151938 lab=_56518_/C }
C {devices/lab_pin.sym} 152500 -9850 0 0 {name=p151939 lab=_45209_/X }
C {devices/lab_pin.sym} 152500 -9810 0 0 {name=p151940 lab=_45189_/X }
C {devices/lab_pin.sym} 152660 -9850 0 1 {name=p151941 lab=_45210_/X }
C {sky130_stdcells/o21a_4.sym} 152580 -9850 0 0 {name=X_45210_ }
C {devices/lab_pin.sym} 152500 -9730 0 0 {name=p151942 lab=_81712_/D }
C {devices/lab_pin.sym} 152500 -9690 0 0 {name=p151943 lab=_76036_/C }
C {devices/lab_pin.sym} 152500 -9650 0 0 {name=p151944 lab=_76029_/Y }
C {devices/lab_pin.sym} 152660 -9690 0 1 {name=p151945 lab=_76030_/Y }
C {sky130_stdcells/a21oi_4.sym} 152580 -9690 0 0 {name=X_76030_ }
C {devices/lab_pin.sym} 152490 -9550 0 0 {name=p151946 lab=_87260_/CLK }
C {devices/lab_pin.sym} 152490 -9530 0 0 {name=p151947 lab=_88016_/D }
C {devices/lab_pin.sym} 152670 -9550 0 1 {name=p151948 lab=_88016_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -9540 0 0 {name=X_88016_ }
C {devices/lab_pin.sym} 152500 -9440 0 0 {name=p151949 lab=_40485_/X }
C {devices/lab_pin.sym} 152500 -9400 0 0 {name=p151950 lab=_42414_/X }
C {devices/lab_pin.sym} 152500 -9360 0 0 {name=p151951 lab=_87872_/Q }
C {devices/lab_pin.sym} 152500 -9320 0 0 {name=p151952 lab=_42415_/X }
C {devices/lab_pin.sym} 152660 -9380 0 1 {name=p151953 lab=_87872_/D }
C {sky130_stdcells/a2bb2o_4.sym} 152580 -9380 0 0 {name=X_42422_ }
C {devices/lab_pin.sym} 152520 -9260 0 0 {name=p151954 lab=_54399_/X }
C {devices/lab_pin.sym} 152520 -9220 0 0 {name=p151955 lab=_54395_/B }
C {devices/lab_pin.sym} 152520 -9180 0 0 {name=p151956 lab=_54402_/C }
C {devices/lab_pin.sym} 152520 -9140 0 0 {name=p151957 lab=_46856_/A }
C {devices/lab_pin.sym} 152640 -9200 0 1 {name=p151958 lab=_54408_/X }
C {sky130_stdcells/and4_4.sym} 152580 -9200 0 0 {name=X_54408_ }
C {devices/lab_pin.sym} 152520 -9060 0 0 {name=p151959 lab=_48559_/Y }
C {devices/lab_pin.sym} 152520 -9020 0 0 {name=p151960 lab=_73241_/Y }
C {devices/lab_pin.sym} 152640 -9040 0 1 {name=p151961 lab=_73242_/X }
C {sky130_stdcells/xor2_4.sym} 152580 -9040 0 0 {name=X_73242_ }
C {devices/lab_pin.sym} 152490 -8910 0 0 {name=p151962 lab=_85192_/CLK }
C {devices/lab_pin.sym} 152490 -8890 0 0 {name=p151963 lab=_56344_/Y }
C {devices/lab_pin.sym} 152670 -8910 0 1 {name=p151964 lab=_85228_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -8900 0 0 {name=X_85228_ }
C {devices/lab_pin.sym} 152520 -8790 0 0 {name=p151965 lab=_46186_/X }
C {devices/lab_pin.sym} 152520 -8750 0 0 {name=p151966 lab=_74842_/B }
C {devices/lab_pin.sym} 152520 -8710 0 0 {name=p151967 lab=_46189_/Y }
C {devices/lab_pin.sym} 152640 -8750 0 1 {name=p151968 lab=_86763_/D }
C {sky130_stdcells/and3_4.sym} 152580 -8750 0 0 {name=X_46190_ }
C {devices/lab_pin.sym} 152520 -8640 0 0 {name=p151969 lab=_70758_/A }
C {devices/lab_pin.sym} 152520 -8600 0 0 {name=p151970 lab=_70827_/B }
C {devices/lab_pin.sym} 152520 -8560 0 0 {name=p151971 lab=_71287_/C }
C {devices/lab_pin.sym} 152520 -8520 0 0 {name=p151972 lab=_70609_/A }
C {devices/lab_pin.sym} 152640 -8580 0 1 {name=p151973 lab=_70454_/Y }
C {sky130_stdcells/nand4_4.sym} 152580 -8580 0 0 {name=X_70454_ }
C {devices/lab_pin.sym} 152500 -8450 0 0 {name=p151974 lab=_58171_/X }
C {devices/lab_pin.sym} 152500 -8410 0 0 {name=p151975 lab=_83491_/Q }
C {devices/lab_pin.sym} 152500 -8370 0 0 {name=p151976 lab=_58175_/Y }
C {devices/lab_pin.sym} 152660 -8410 0 1 {name=p151977 lab=_84915_/D }
C {sky130_stdcells/o21a_4.sym} 152580 -8410 0 0 {name=X_58176_ }
C {devices/lab_pin.sym} 152540 -8270 0 0 {name=p151978 lab=_55387_/X }
C {devices/lab_pin.sym} 152620 -8270 0 1 {name=p151979 lab=_55388_/Y }
C {sky130_stdcells/inv_2.sym} 152580 -8270 0 0 {name=X_55388_ }
C {devices/lab_pin.sym} 152520 -8160 0 0 {name=p151980 lab=_45141_/A }
C {devices/lab_pin.sym} 152520 -8120 0 0 {name=p151981 lab=_45182_/B }
C {devices/lab_pin.sym} 152640 -8140 0 1 {name=p151982 lab=_45141_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -8140 0 0 {name=X_45141_ }
C {devices/lab_pin.sym} 152540 -8010 0 0 {name=p151983 lab=_57158_/C }
C {devices/lab_pin.sym} 152620 -8010 0 1 {name=p151984 lab=_57153_/B }
C {sky130_stdcells/buf_2.sym} 152580 -8010 0 0 {name=X_57127_ }
C {devices/lab_pin.sym} 152500 -7920 0 0 {name=p151985 lab=_41715_/X }
C {devices/lab_pin.sym} 152500 -7880 0 0 {name=p151986 lab=_42342_/X }
C {devices/lab_pin.sym} 152500 -7840 0 0 {name=p151987 lab=_87907_/Q }
C {devices/lab_pin.sym} 152500 -7800 0 0 {name=p151988 lab=_42343_/X }
C {devices/lab_pin.sym} 152660 -7860 0 1 {name=p151989 lab=_87907_/D }
C {sky130_stdcells/a2bb2o_4.sym} 152580 -7860 0 0 {name=X_42353_ }
C {devices/lab_pin.sym} 152520 -7740 0 0 {name=p151990 lab=_54325_/A }
C {devices/lab_pin.sym} 152520 -7700 0 0 {name=p151991 lab=_54353_/B }
C {devices/lab_pin.sym} 152520 -7660 0 0 {name=p151992 lab=_54317_/X }
C {devices/lab_pin.sym} 152520 -7620 0 0 {name=p151993 lab=_46743_/Y }
C {devices/lab_pin.sym} 152640 -7680 0 1 {name=p151994 lab=_54339_/X }
C {sky130_stdcells/and4_4.sym} 152580 -7680 0 0 {name=X_54339_ }
C {devices/lab_pin.sym} 152520 -7540 0 0 {name=p151995 lab=_87055_/Q }
C {devices/lab_pin.sym} 152520 -7500 0 0 {name=p151996 lab=_73104_/B }
C {devices/lab_pin.sym} 152640 -7520 0 1 {name=p151997 lab=_73173_/Y }
C {sky130_stdcells/nor2_4.sym} 152580 -7520 0 0 {name=X_73173_ }
C {devices/lab_pin.sym} 152490 -7390 0 0 {name=p151998 lab=_83016_/CLK }
C {devices/lab_pin.sym} 152490 -7370 0 0 {name=p151999 lab=_56534_/Y }
C {devices/lab_pin.sym} 152670 -7390 0 1 {name=p152000 lab=_85159_/Q }
C {sky130_stdcells/dfxtp_4.sym} 152580 -7380 0 0 {name=X_85159_ }
C {devices/lab_pin.sym} 152500 -7270 0 0 {name=p152001 lab=_50862_/B }
C {devices/lab_pin.sym} 152500 -7230 0 0 {name=p152002 lab=_70364_/X }
C {devices/lab_pin.sym} 152500 -7190 0 0 {name=p152003 lab=_70384_/Y }
C {devices/lab_pin.sym} 152660 -7230 0 1 {name=p152004 lab=_70385_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -7230 0 0 {name=X_70385_ }
C {devices/lab_pin.sym} 152520 -7100 0 0 {name=p152005 lab=_41304_/A }
C {devices/lab_pin.sym} 152520 -7060 0 0 {name=p152006 lab=_41292_/B }
C {devices/lab_pin.sym} 152640 -7080 0 1 {name=p152007 lab=_41304_/X }
C {sky130_stdcells/or2_4.sym} 152580 -7080 0 0 {name=X_41304_ }
C {devices/lab_pin.sym} 152500 -6970 0 0 {name=p152008 lab=_72123_/X }
C {devices/lab_pin.sym} 152500 -6930 0 0 {name=p152009 lab=_85697_/Q }
C {devices/lab_pin.sym} 152500 -6890 0 0 {name=p152010 lab=_59334_/X }
C {devices/lab_pin.sym} 152660 -6930 0 1 {name=p152011 lab=_72124_/X }
C {sky130_stdcells/o21a_4.sym} 152580 -6930 0 0 {name=X_72124_ }
C {devices/lab_pin.sym} 152500 -6810 0 0 {name=p152012 lab=_45064_/X }
C {devices/lab_pin.sym} 152500 -6770 0 0 {name=p152013 lab=_45068_/Y }
C {devices/lab_pin.sym} 152500 -6730 0 0 {name=p152014 lab=_45071_/Y }
C {devices/lab_pin.sym} 152660 -6770 0 1 {name=p152015 lab=_45072_/Y }
C {sky130_stdcells/a21oi_4.sym} 152580 -6770 0 0 {name=X_45072_ }
C {devices/lab_pin.sym} 152520 -6640 0 0 {name=p152016 lab=_56671_/X }
C {devices/lab_pin.sym} 152520 -6600 0 0 {name=p152017 lab=_57058_/B }
C {devices/lab_pin.sym} 152640 -6620 0 1 {name=p152018 lab=_57058_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -6620 0 0 {name=X_57058_ }
C {devices/lab_pin.sym} 152500 -6530 0 0 {name=p152019 lab=_42279_/X }
C {devices/lab_pin.sym} 152500 -6490 0 0 {name=p152020 lab=_42275_/X }
C {devices/lab_pin.sym} 152500 -6450 0 0 {name=p152021 lab=_41536_/X }
C {devices/lab_pin.sym} 152500 -6410 0 0 {name=p152022 lab=_87940_/Q }
C {devices/lab_pin.sym} 152500 -6370 0 0 {name=p152023 lab=_42276_/X }
C {devices/lab_pin.sym} 152660 -6450 0 1 {name=p152024 lab=_42284_/Y }
C {sky130_stdcells/o32ai_4.sym} 152580 -6450 0 0 {name=X_42284_ }
C {devices/lab_pin.sym} 152520 -6300 0 0 {name=p152025 lab=_77983_/A }
C {devices/lab_pin.sym} 152520 -6260 0 0 {name=p152026 lab=_77983_/C }
C {devices/lab_pin.sym} 152640 -6280 0 1 {name=p152027 lab=_77981_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -6280 0 0 {name=X_77981_ }
C {devices/lab_pin.sym} 152540 -6150 0 0 {name=p152028 lab=_48899_/Y }
C {devices/lab_pin.sym} 152620 -6150 0 1 {name=p152029 lab=_48901_/B }
C {sky130_stdcells/buf_2.sym} 152580 -6150 0 0 {name=X_48900_ }
C {devices/lab_pin.sym} 152540 -6030 0 0 {name=p152030 lab=_44022_/X }
C {devices/lab_pin.sym} 152620 -6030 0 1 {name=p152031 lab=_58834_/A }
C {sky130_stdcells/buf_2.sym} 152580 -6030 0 0 {name=X_44023_ }
C {devices/lab_pin.sym} 152540 -5910 0 0 {name=p152032 lab=_55928_/B }
C {devices/lab_pin.sym} 152620 -5910 0 1 {name=p152033 lab=_74310_/C }
C {sky130_stdcells/buf_2.sym} 152580 -5910 0 0 {name=X_56009_ }
C {devices/lab_pin.sym} 152500 -5810 0 0 {name=p152034 lab=_65047_/C }
C {devices/lab_pin.sym} 152500 -5770 0 0 {name=p152035 lab=_72313_/Y }
C {devices/lab_pin.sym} 152500 -5730 0 0 {name=p152036 lab=_79719_/Y }
C {devices/lab_pin.sym} 152660 -5770 0 1 {name=p152037 lab=_79720_/X }
C {sky130_stdcells/o21a_4.sym} 152580 -5770 0 0 {name=X_79720_ }
C {devices/lab_pin.sym} 152540 -5630 0 0 {name=p152038 lab=_40568_/A }
C {devices/lab_pin.sym} 152620 -5630 0 1 {name=p152039 lab=_41235_/X }
C {sky130_stdcells/buf_2.sym} 152580 -5630 0 0 {name=X_41235_ }
C {devices/lab_pin.sym} 152520 -5520 0 0 {name=p152040 lab=_72025_/A }
C {devices/lab_pin.sym} 152520 -5480 0 0 {name=p152041 lab=_53879_/B }
C {devices/lab_pin.sym} 152640 -5500 0 1 {name=p152042 lab=_72055_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -5500 0 0 {name=X_72055_ }
C {devices/lab_pin.sym} 152540 -5370 0 0 {name=p152043 lab=_76932_/A }
C {devices/lab_pin.sym} 152620 -5370 0 1 {name=p152044 lab=_76932_/Y }
C {sky130_stdcells/inv_2.sym} 152580 -5370 0 0 {name=X_76932_ }
C {devices/lab_pin.sym} 152540 -5250 0 0 {name=p152045 lab=_49906_/A }
C {devices/lab_pin.sym} 152620 -5250 0 1 {name=p152046 lab=_49880_/X }
C {sky130_stdcells/buf_2.sym} 152580 -5250 0 0 {name=X_49880_ }
C {devices/lab_pin.sym} 152520 -5150 0 0 {name=p152047 lab=_71055_/A }
C {devices/lab_pin.sym} 152520 -5110 0 0 {name=p152048 lab=_71064_/B }
C {devices/lab_pin.sym} 152520 -5070 0 0 {name=p152049 lab=_71001_/C }
C {devices/lab_pin.sym} 152640 -5110 0 1 {name=p152050 lab=_71006_/Y }
C {sky130_stdcells/nand3_4.sym} 152580 -5110 0 0 {name=X_71006_ }
C {devices/lab_pin.sym} 152520 -4980 0 0 {name=p152051 lab=_48831_/A }
C {devices/lab_pin.sym} 152520 -4940 0 0 {name=p152052 lab=_52216_/B }
C {devices/lab_pin.sym} 152640 -4960 0 1 {name=p152053 lab=_48831_/Y }
C {sky130_stdcells/nand2_4.sym} 152580 -4960 0 0 {name=X_48831_ }
C {devices/lab_pin.sym} 152520 -4840 0 0 {name=p152054 lab=_79647_/X }
C {devices/lab_pin.sym} 152520 -4800 0 0 {name=p152055 lab=_79664_/A }
C {devices/lab_pin.sym} 152640 -4820 0 1 {name=p152056 lab=_79651_/X }
C {sky130_stdcells/xor2_4.sym} 152580 -4820 0 0 {name=X_79651_ }
C {devices/lab_pin.sym} 152500 -4720 0 0 {name=p152057 lab=_41165_/X }
C {devices/lab_pin.sym} 152500 -4680 0 0 {name=p152058 lab=_41152_/X }
C {devices/lab_pin.sym} 152500 -4640 0 0 {name=p152059 lab=_68631_/B }
C {devices/lab_pin.sym} 152500 -4600 0 0 {name=p152060 lab=_41153_/X }
C {devices/lab_pin.sym} 152660 -4660 0 1 {name=p152061 lab=_88265_/D }
C {sky130_stdcells/a2bb2o_4.sym} 152580 -4660 0 0 {name=X_41166_ }
C {devices/lab_pin.sym} 152520 -4520 0 0 {name=p152062 lab=_81593_/Q }
C {devices/lab_pin.sym} 152520 -4480 0 0 {name=p152063 lab=_81465_/D }
C {devices/lab_pin.sym} 152640 -4500 0 1 {name=p152064 lab=_81561_/D }
C {sky130_stdcells/xor2_4.sym} 152580 -4500 0 0 {name=X_76863_ }
C {devices/lab_pin.sym} 152540 -4370 0 0 {name=p152065 lab=_78602_/A }
C {devices/lab_pin.sym} 152620 -4370 0 1 {name=p152066 lab=_78602_/Y }
C {sky130_stdcells/inv_2.sym} 152580 -4370 0 0 {name=X_78602_ }
C {devices/lab_pin.sym} 152520 -4260 0 0 {name=p152067 lab=_80796_/D }
C {devices/lab_pin.sym} 152520 -4220 0 0 {name=p152068 lab=_75807_/A }
C {devices/lab_pin.sym} 152640 -4240 0 1 {name=p152069 lab=_75815_/A }
C {sky130_stdcells/and2_4.sym} 152580 -4240 0 0 {name=X_75814_ }
C {devices/lab_pin.sym} 152500 -4130 0 0 {name=p152070 lab=_48758_/Y }
C {devices/lab_pin.sym} 152500 -4090 0 0 {name=p152071 lab=_48760_/X }
C {devices/lab_pin.sym} 152500 -4050 0 0 {name=p152072 lab=_48761_/X }
C {devices/lab_pin.sym} 152660 -4090 0 1 {name=p152073 lab=_86488_/D }
C {sky130_stdcells/a21oi_4.sym} 152580 -4090 0 0 {name=X_48762_ }
C {devices/lab_pin.sym} 152540 -3950 0 0 {name=p152074 lab=_79588_/A }
C {devices/lab_pin.sym} 152620 -3950 0 1 {name=p152075 lab=_79587_/A }
C {sky130_stdcells/inv_2.sym} 152580 -3950 0 0 {name=X_79582_ }
C {devices/lab_pin.sym} 152540 -3830 0 0 {name=p152076 lab=_45962_/X }
C {devices/lab_pin.sym} 152620 -3830 0 1 {name=p152077 lab=_45974_/X }
C {sky130_stdcells/buf_2.sym} 152580 -3830 0 0 {name=X_45974_ }
C {devices/lab_pin.sym} 152500 -3730 0 0 {name=p152078 lab=_41061_/X }
C {devices/lab_pin.sym} 152500 -3690 0 0 {name=p152079 lab=_40919_/B }
C {devices/lab_pin.sym} 152500 -3650 0 0 {name=p152080 lab=_41096_/X }
C {devices/lab_pin.sym} 152660 -3690 0 1 {name=p152081 lab=_41098_/A }
C {sky130_stdcells/o21ai_4.sym} 152580 -3690 0 0 {name=X_41097_ }
C {devices/lab_pin.sym} 152520 -3560 0 0 {name=p152082 lab=_76774_/X }
C {devices/lab_pin.sym} 152520 -3520 0 0 {name=p152083 lab=_76786_/X }
C {devices/lab_pin.sym} 152640 -3540 0 1 {name=p152084 lab=_76794_/X }
C {sky130_stdcells/and2_4.sym} 152580 -3540 0 0 {name=X_76794_ }
C {devices/lab_pin.sym} 152540 -3410 0 0 {name=p152085 lab=_47003_/A }
C {devices/lab_pin.sym} 152620 -3410 0 1 {name=p152086 lab=_47714_/A }
C {sky130_stdcells/buf_2.sym} 152580 -3410 0 0 {name=X_47713_ }
C {devices/lab_pin.sym} 152500 -3310 0 0 {name=p152087 lab=_78522_/Y }
C {devices/lab_pin.sym} 152500 -3270 0 0 {name=p152088 lab=_78526_/B }
C {devices/lab_pin.sym} 152500 -3230 0 0 {name=p152089 lab=_78525_/A }
C {devices/lab_pin.sym} 152660 -3270 0 1 {name=p152090 lab=_78533_/X }
C {sky130_stdcells/o21a_4.sym} 152580 -3270 0 0 {name=X_78533_ }
C {devices/lab_pin.sym} 152540 -3130 0 0 {name=p152091 lab=_80671_/Q }
C {devices/lab_pin.sym} 152620 -3130 0 1 {name=p152092 lab=_45237_/A }
C {sky130_stdcells/buf_2.sym} 152580 -3130 0 0 {name=X_44925_ }
C {devices/lab_pin.sym} 152520 -3020 0 0 {name=p152093 lab=_75735_/Y }
C {devices/lab_pin.sym} 152520 -2980 0 0 {name=p152094 lab=_75740_/B }
C {devices/lab_pin.sym} 152640 -3000 0 1 {name=p152095 lab=_75745_/X }
C {sky130_stdcells/or2_4.sym} 152580 -3000 0 0 {name=X_75745_ }
C {devices/lab_pin.sym} 152540 -2870 0 0 {name=p152096 lab=_48693_/A }
C {devices/lab_pin.sym} 152620 -2870 0 1 {name=p152097 lab=_48694_/A }
C {sky130_stdcells/inv_2.sym} 152580 -2870 0 0 {name=X_48693_ }
C {devices/lab_pin.sym} 152500 -2790 0 0 {name=p152098 lab=_60961_/X }
C {devices/lab_pin.sym} 152500 -2750 0 0 {name=p152099 lab=_60963_/X }
C {devices/lab_pin.sym} 152500 -2710 0 0 {name=p152100 lab=_60940_/Y }
C {devices/lab_pin.sym} 152500 -2670 0 0 {name=p152101 lab=_60968_/X }
C {devices/lab_pin.sym} 152500 -2630 0 0 {name=p152102 lab=_60970_/X }
C {devices/lab_pin.sym} 152660 -2710 0 1 {name=p152103 lab=_84547_/D }
C {sky130_stdcells/o41a_4.sym} 152580 -2710 0 0 {name=X_60971_ }
C {devices/lab_pin.sym} 152520 -2560 0 0 {name=p152104 lab=_73132_/A }
C {devices/lab_pin.sym} 152520 -2520 0 0 {name=p152105 lab=_72957_/B }
C {devices/lab_pin.sym} 152640 -2540 0 1 {name=p152106 lab=_72957_/X }
C {sky130_stdcells/and2_4.sym} 152580 -2540 0 0 {name=X_72957_ }
C {devices/lab_pin.sym} 152540 -2410 0 0 {name=p152107 lab=_62979_/A }
C {devices/lab_pin.sym} 152620 -2410 0 1 {name=p152108 lab=_62711_/A }
C {sky130_stdcells/buf_2.sym} 152580 -2410 0 0 {name=X_62710_ }
C {devices/lab_pin.sym} 152540 -2290 0 0 {name=p152109 lab=_55026_/D }
C {devices/lab_pin.sym} 152620 -2290 0 1 {name=p152110 lab=_53165_/D }
C {sky130_stdcells/buf_2.sym} 152580 -2290 0 0 {name=X_47644_ }
C {devices/lab_pin.sym} 152520 -2200 0 0 {name=p152111 lab=_74529_/A }
C {devices/lab_pin.sym} 152520 -2160 0 0 {name=p152112 lab=_70710_/C }
C {devices/lab_pin.sym} 152520 -2120 0 0 {name=p152113 lab=_71902_/X }
C {devices/lab_pin.sym} 152520 -2080 0 0 {name=p152114 lab=_71928_/D }
C {devices/lab_pin.sym} 152640 -2140 0 1 {name=p152115 lab=_71908_/Y }
C {sky130_stdcells/nand4_4.sym} 152580 -2140 0 0 {name=X_71908_ }
C {devices/lab_pin.sym} 152540 -1990 0 0 {name=p152116 lab=_78464_/A }
C {devices/lab_pin.sym} 152620 -1990 0 1 {name=p152117 lab=_78464_/X }
C {sky130_stdcells/buf_2.sym} 152580 -1990 0 0 {name=X_78464_ }
C {devices/lab_pin.sym} 152500 -1900 0 0 {name=p152118 lab=_41767_/Y }
C {devices/lab_pin.sym} 152500 -1860 0 0 {name=p152119 lab=_44848_/X }
C {devices/lab_pin.sym} 152500 -1820 0 0 {name=p152120 lab=_67964_/B }
C {devices/lab_pin.sym} 152500 -1780 0 0 {name=p152121 lab=_44849_/X }
C {devices/lab_pin.sym} 152660 -1840 0 1 {name=p152122 lab=_86917_/D }
C {sky130_stdcells/a2bb2o_4.sym} 152580 -1840 0 0 {name=X_44856_ }
C {devices/lab_pin.sym} 152540 -1690 0 0 {name=p152123 lab=_80910_/Q }
C {devices/lab_pin.sym} 152620 -1690 0 1 {name=p152124 lab=_75678_/A }
C {sky130_stdcells/inv_2.sym} 152580 -1690 0 0 {name=X_75676_ }
C {devices/lab_pin.sym} 152540 -1570 0 0 {name=p152125 lab=_60422_/A }
C {devices/lab_pin.sym} 152620 -1570 0 1 {name=p152126 lab=_63849_/A }
C {sky130_stdcells/buf_2.sym} 152580 -1570 0 0 {name=X_63690_ }
C {devices/lab_pin.sym} 152540 -1450 0 0 {name=p152127 lab=_44189_/X }
C {devices/lab_pin.sym} 152620 -1450 0 1 {name=p152128 lab=_72888_/X }
C {sky130_stdcells/buf_2.sym} 152580 -1450 0 0 {name=X_72888_ }
C {devices/lab_pin.sym} 152540 -1330 0 0 {name=p152129 lab=_77415_/A }
C {devices/lab_pin.sym} 152620 -1330 0 1 {name=p152130 lab=_77415_/X }
C {sky130_stdcells/buf_2.sym} 152580 -1330 0 0 {name=X_77415_ }
C {devices/lab_pin.sym} 152500 -1250 0 0 {name=p152131 lab=_43790_/X }
C {devices/lab_pin.sym} 152500 -1210 0 0 {name=p152132 lab=_43797_/X }
C {devices/lab_pin.sym} 152500 -1170 0 0 {name=p152133 lab=_41082_/X }
C {devices/lab_pin.sym} 152500 -1130 0 0 {name=p152134 lab=_69494_/B }
C {devices/lab_pin.sym} 152500 -1090 0 0 {name=p152135 lab=_43791_/X }
C {devices/lab_pin.sym} 152660 -1170 0 1 {name=p152136 lab=_43808_/A }
C {sky130_stdcells/o32ai_4.sym} 152580 -1170 0 0 {name=X_43807_ }
C {devices/lab_pin.sym} 152540 -1010 0 0 {name=p152137 lab=_62886_/A }
C {devices/lab_pin.sym} 152620 -1010 0 1 {name=p152138 lab=_62642_/B }
C {sky130_stdcells/buf_2.sym} 152580 -1010 0 0 {name=X_62641_ }
C {devices/lab_pin.sym} 152500 -910 0 0 {name=p152139 lab=_44196_/A }
C {devices/lab_pin.sym} 152500 -870 0 0 {name=p152140 lab=_45933_/Y }
C {devices/lab_pin.sym} 152500 -830 0 0 {name=p152141 lab=_44037_/X }
C {devices/lab_pin.sym} 152660 -870 0 1 {name=p152142 lab=_74627_/Y }
C {sky130_stdcells/a21oi_4.sym} 152580 -870 0 0 {name=X_74627_ }
C {devices/lab_pin.sym} 152500 -750 0 0 {name=p152143 lab=_72188_/A }
C {devices/lab_pin.sym} 152500 -710 0 0 {name=p152144 lab=_47570_/X }
C {devices/lab_pin.sym} 152500 -670 0 0 {name=p152145 lab=_47574_/Y }
C {devices/lab_pin.sym} 152660 -710 0 1 {name=p152146 lab=_47575_/Y }
C {sky130_stdcells/o21ai_4.sym} 152580 -710 0 0 {name=X_47575_ }
C {devices/lab_pin.sym} 153440 -42180 0 0 {name=p152147 lab=_71829_/X }
C {devices/lab_pin.sym} 153440 -42140 0 0 {name=p152148 lab=_71839_/B }
C {devices/lab_pin.sym} 153440 -42100 0 0 {name=p152149 lab=_70786_/A }
C {devices/lab_pin.sym} 153440 -42060 0 0 {name=p152150 lab=_70721_/A }
C {devices/lab_pin.sym} 153560 -42120 0 1 {name=p152151 lab=_71839_/X }
C {sky130_stdcells/and4_4.sym} 153500 -42120 0 0 {name=X_71839_ }
C {devices/lab_pin.sym} 153440 -41980 0 0 {name=p152152 lab=_78426_/C }
C {devices/lab_pin.sym} 153440 -41940 0 0 {name=p152153 lab=_78426_/B }
C {devices/lab_pin.sym} 153560 -41960 0 1 {name=p152154 lab=_78395_/X }
C {sky130_stdcells/and2_4.sym} 153500 -41960 0 0 {name=X_78395_ }
C {devices/lab_pin.sym} 153460 -41830 0 0 {name=p152155 lab=_46298_/A }
C {devices/lab_pin.sym} 153540 -41830 0 1 {name=p152156 lab=_44803_/A }
C {sky130_stdcells/buf_2.sym} 153500 -41830 0 0 {name=X_44787_ }
C {devices/lab_pin.sym} 153460 -41710 0 0 {name=p152157 lab=_88076_/Q }
C {devices/lab_pin.sym} 153540 -41710 0 1 {name=p152158 lab=_41999_/Y }
C {sky130_stdcells/inv_2.sym} 153500 -41710 0 0 {name=X_41999_ }
C {devices/lab_pin.sym} 153440 -41600 0 0 {name=p152159 lab=_49302_/A }
C {devices/lab_pin.sym} 153440 -41560 0 0 {name=p152160 lab=_51350_/B }
C {devices/lab_pin.sym} 153560 -41580 0 1 {name=p152161 lab=_49314_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -41580 0 0 {name=X_49314_ }
C {devices/lab_pin.sym} 153460 -41450 0 0 {name=p152162 lab=_46526_/A }
C {devices/lab_pin.sym} 153540 -41450 0 1 {name=p152163 lab=_47972_/A }
C {sky130_stdcells/buf_2.sym} 153500 -41450 0 0 {name=X_46526_ }
C {devices/lab_pin.sym} 153440 -41340 0 0 {name=p152164 lab=_65258_/A }
C {devices/lab_pin.sym} 153440 -41300 0 0 {name=p152165 lab=_65360_/B }
C {devices/lab_pin.sym} 153560 -41320 0 1 {name=p152166 lab=_65360_/X }
C {sky130_stdcells/and2_4.sym} 153500 -41320 0 0 {name=X_65360_ }
C {devices/lab_pin.sym} 153440 -41220 0 0 {name=p152167 lab=_77318_/A }
C {devices/lab_pin.sym} 153440 -41180 0 0 {name=p152168 lab=_77318_/B }
C {devices/lab_pin.sym} 153440 -41140 0 0 {name=p152169 lab=_77317_/X }
C {devices/lab_pin.sym} 153440 -41100 0 0 {name=p152170 lab=_77334_/Y }
C {devices/lab_pin.sym} 153560 -41160 0 1 {name=p152171 lab=_77346_/Y }
C {sky130_stdcells/nand4_4.sym} 153500 -41160 0 0 {name=X_77346_ }
C {devices/lab_pin.sym} 153420 -41040 0 0 {name=p152172 lab=_40903_/X }
C {devices/lab_pin.sym} 153420 -41000 0 0 {name=p152173 lab=_43736_/X }
C {devices/lab_pin.sym} 153420 -40960 0 0 {name=p152174 lab=_87289_/Q }
C {devices/lab_pin.sym} 153420 -40920 0 0 {name=p152175 lab=_43737_/X }
C {devices/lab_pin.sym} 153580 -40980 0 1 {name=p152176 lab=_43738_/X }
C {sky130_stdcells/a2bb2o_4.sym} 153500 -40980 0 0 {name=X_43738_ }
C {devices/lab_pin.sym} 153460 -40830 0 0 {name=p152177 lab=_62572_/A }
C {devices/lab_pin.sym} 153540 -40830 0 1 {name=p152178 lab=_62572_/X }
C {sky130_stdcells/buf_2.sym} 153500 -40830 0 0 {name=X_62572_ }
C {devices/lab_pin.sym} 153420 -40730 0 0 {name=p152179 lab=_44990_/A }
C {devices/lab_pin.sym} 153420 -40690 0 0 {name=p152180 lab=_74551_/X }
C {devices/lab_pin.sym} 153420 -40650 0 0 {name=p152181 lab=_74557_/X }
C {devices/lab_pin.sym} 153580 -40690 0 1 {name=p152182 lab=_74558_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -40690 0 0 {name=X_74558_ }
C {devices/lab_pin.sym} 153420 -40590 0 0 {name=p152183 lab=_64304_/X }
C {devices/lab_pin.sym} 153420 -40550 0 0 {name=p152184 lab=_64305_/X }
C {devices/lab_pin.sym} 153420 -40510 0 0 {name=p152185 lab=_64307_/X }
C {devices/lab_pin.sym} 153420 -40470 0 0 {name=p152186 lab=_64310_/Y }
C {devices/lab_pin.sym} 153420 -40430 0 0 {name=p152187 lab=_64267_/X }
C {devices/lab_pin.sym} 153580 -40510 0 1 {name=p152188 lab=_64311_/X }
C {sky130_stdcells/o41a_4.sym} 153500 -40510 0 0 {name=X_64311_ }
C {devices/lab_pin.sym} 153460 -40350 0 0 {name=p152189 lab=_61400_/X }
C {devices/lab_pin.sym} 153540 -40350 0 1 {name=p152190 lab=_61541_/C }
C {sky130_stdcells/buf_2.sym} 153500 -40350 0 0 {name=X_61523_ }
C {devices/lab_pin.sym} 153440 -40240 0 0 {name=p152191 lab=_49241_/A }
C {devices/lab_pin.sym} 153440 -40200 0 0 {name=p152192 lab=_49245_/B }
C {devices/lab_pin.sym} 153560 -40220 0 1 {name=p152193 lab=_49245_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -40220 0 0 {name=X_49245_ }
C {devices/lab_pin.sym} 153440 -40100 0 0 {name=p152194 lab=_73509_/A }
C {devices/lab_pin.sym} 153440 -40060 0 0 {name=p152195 lab=_73530_/B }
C {devices/lab_pin.sym} 153560 -40080 0 1 {name=p152196 lab=_73509_/Y }
C {sky130_stdcells/nor2_4.sym} 153500 -40080 0 0 {name=X_73509_ }
C {devices/lab_pin.sym} 153440 -39960 0 0 {name=p152197 lab=_46434_/A }
C {devices/lab_pin.sym} 153440 -39920 0 0 {name=p152198 lab=_51324_/B }
C {devices/lab_pin.sym} 153560 -39940 0 1 {name=p152199 lab=_46457_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -39940 0 0 {name=X_46457_ }
C {devices/lab_pin.sym} 153440 -39830 0 0 {name=p152200 lab=_65288_/X }
C {devices/lab_pin.sym} 153440 -39790 0 0 {name=p152201 lab=_65631_/B }
C {devices/lab_pin.sym} 153440 -39750 0 0 {name=p152202 lab=_65290_/X }
C {devices/lab_pin.sym} 153560 -39790 0 1 {name=p152203 lab=_65291_/Y }
C {sky130_stdcells/nand3_4.sym} 153500 -39790 0 0 {name=X_65291_ }
C {devices/lab_pin.sym} 153440 -39660 0 0 {name=p152204 lab=_77277_/A }
C {devices/lab_pin.sym} 153440 -39620 0 0 {name=p152205 lab=_77277_/B }
C {devices/lab_pin.sym} 153560 -39640 0 1 {name=p152206 lab=_81893_/D }
C {sky130_stdcells/xnor2_4.sym} 153500 -39640 0 0 {name=X_77277_ }
C {devices/lab_pin.sym} 153460 -39510 0 0 {name=p152207 lab=_43668_/X }
C {devices/lab_pin.sym} 153540 -39510 0 1 {name=p152208 lab=_87319_/D }
C {sky130_stdcells/inv_2.sym} 153500 -39510 0 0 {name=X_43669_ }
C {devices/lab_pin.sym} 153420 -39410 0 0 {name=p152209 lab=_74486_/Y }
C {devices/lab_pin.sym} 153420 -39370 0 0 {name=p152210 lab=_74463_/X }
C {devices/lab_pin.sym} 153420 -39330 0 0 {name=p152211 lab=_74488_/X }
C {devices/lab_pin.sym} 153580 -39370 0 1 {name=p152212 lab=_83056_/D }
C {sky130_stdcells/a21oi_4.sym} 153500 -39370 0 0 {name=X_74489_ }
C {devices/lab_pin.sym} 153440 -39240 0 0 {name=p152213 lab=_67027_/X }
C {devices/lab_pin.sym} 153440 -39200 0 0 {name=p152214 lab=_67030_/B }
C {devices/lab_pin.sym} 153560 -39220 0 1 {name=p152215 lab=_67030_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -39220 0 0 {name=X_67030_ }
C {devices/lab_pin.sym} 153440 -39100 0 0 {name=p152216 lab=_79010_/A }
C {devices/lab_pin.sym} 153440 -39060 0 0 {name=p152217 lab=_79010_/B }
C {devices/lab_pin.sym} 153560 -39080 0 1 {name=p152218 lab=_79016_/Y }
C {sky130_stdcells/nor2_4.sym} 153500 -39080 0 0 {name=X_79016_ }
C {devices/lab_pin.sym} 153460 -38950 0 0 {name=p152219 lab=_45408_/A }
C {devices/lab_pin.sym} 153540 -38950 0 1 {name=p152220 lab=_55625_/B }
C {sky130_stdcells/inv_2.sym} 153500 -38950 0 0 {name=X_45408_ }
C {devices/lab_pin.sym} 153440 -38840 0 0 {name=p152221 lab=_61368_/A }
C {devices/lab_pin.sym} 153440 -38800 0 0 {name=p152222 lab=_64219_/B }
C {devices/lab_pin.sym} 153560 -38820 0 1 {name=p152223 lab=_64242_/Y }
C {sky130_stdcells/nor2_4.sym} 153500 -38820 0 0 {name=X_64242_ }
C {devices/lab_pin.sym} 153440 -38700 0 0 {name=p152224 lab=_81256_/Q }
C {devices/lab_pin.sym} 153440 -38660 0 0 {name=p152225 lab=_81512_/D }
C {devices/lab_pin.sym} 153560 -38680 0 1 {name=p152226 lab=_76233_/C }
C {sky130_stdcells/nand2_4.sym} 153500 -38680 0 0 {name=X_76228_ }
C {devices/lab_pin.sym} 153460 -38550 0 0 {name=p152227 lab=_49176_/A }
C {devices/lab_pin.sym} 153540 -38550 0 1 {name=p152228 lab=_50712_/B }
C {sky130_stdcells/buf_2.sym} 153500 -38550 0 0 {name=X_49176_ }
C {devices/lab_pin.sym} 153420 -38470 0 0 {name=p152229 lab=_61447_/Y }
C {devices/lab_pin.sym} 153420 -38430 0 0 {name=p152230 lab=_61449_/Y }
C {devices/lab_pin.sym} 153420 -38390 0 0 {name=p152231 lab=_61403_/X }
C {devices/lab_pin.sym} 153420 -38350 0 0 {name=p152232 lab=_61451_/Y }
C {devices/lab_pin.sym} 153420 -38320 0 0 {name=p152233 lab=_61453_/Y }
C {devices/lab_pin.sym} 153580 -38390 0 1 {name=p152234 lab=_61454_/X }
C {sky130_stdcells/a41o_4.sym} 153500 -38390 0 0 {name=X_61454_ }
C {devices/lab_pin.sym} 153420 -38250 0 0 {name=p152235 lab=_86741_/Q }
C {devices/lab_pin.sym} 153420 -38210 0 0 {name=p152236 lab=_46364_/X }
C {devices/lab_pin.sym} 153420 -38170 0 0 {name=p152237 lab=_46387_/Y }
C {devices/lab_pin.sym} 153580 -38210 0 1 {name=p152238 lab=_46388_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -38210 0 0 {name=X_46388_ }
C {devices/lab_pin.sym} 153420 -38090 0 0 {name=p152239 lab=_48075_/X }
C {devices/lab_pin.sym} 153420 -38050 0 0 {name=p152240 lab=_46567_/A }
C {devices/lab_pin.sym} 153420 -38010 0 0 {name=p152241 lab=_48126_/X }
C {devices/lab_pin.sym} 153580 -38050 0 1 {name=p152242 lab=_48337_/A }
C {sky130_stdcells/o21ai_4.sym} 153500 -38050 0 0 {name=X_48127_ }
C {devices/lab_pin.sym} 153460 -37910 0 0 {name=p152243 lab=_60404_/Y }
C {devices/lab_pin.sym} 153540 -37910 0 1 {name=p152244 lab=_60410_/B }
C {sky130_stdcells/inv_2.sym} 153500 -37910 0 0 {name=X_60405_ }
C {devices/lab_pin.sym} 153460 -37790 0 0 {name=p152245 lab=_45265_/A }
C {devices/lab_pin.sym} 153540 -37790 0 1 {name=p152246 lab=_45339_/X }
C {sky130_stdcells/buf_2.sym} 153500 -37790 0 0 {name=X_45339_ }
C {devices/lab_pin.sym} 153440 -37690 0 0 {name=p152247 lab=_64184_/A }
C {devices/lab_pin.sym} 153440 -37650 0 0 {name=p152248 lab=_58364_/A }
C {devices/lab_pin.sym} 153440 -37610 0 0 {name=p152249 lab=_64173_/C }
C {devices/lab_pin.sym} 153560 -37650 0 1 {name=p152250 lab=_64173_/X }
C {sky130_stdcells/and3_4.sym} 153500 -37650 0 0 {name=X_64173_ }
C {devices/lab_pin.sym} 153440 -37520 0 0 {name=p152251 lab=_76159_/A }
C {devices/lab_pin.sym} 153440 -37480 0 0 {name=p152252 lab=_76158_/B }
C {devices/lab_pin.sym} 153560 -37500 0 1 {name=p152253 lab=_76159_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -37500 0 0 {name=X_76159_ }
C {devices/lab_pin.sym} 153420 -37390 0 0 {name=p152254 lab=_61383_/X }
C {devices/lab_pin.sym} 153420 -37350 0 0 {name=p152255 lab=_61349_/X }
C {devices/lab_pin.sym} 153420 -37310 0 0 {name=p152256 lab=_61384_/Y }
C {devices/lab_pin.sym} 153580 -37350 0 1 {name=p152257 lab=_61385_/Y }
C {sky130_stdcells/a21oi_4.sym} 153500 -37350 0 0 {name=X_61385_ }
C {devices/lab_pin.sym} 153440 -37240 0 0 {name=p152258 lab=_63100_/A }
C {devices/lab_pin.sym} 153440 -37200 0 0 {name=p152259 lab=_63124_/B }
C {devices/lab_pin.sym} 153440 -37160 0 0 {name=p152260 lab=_63079_/C }
C {devices/lab_pin.sym} 153440 -37120 0 0 {name=p152261 lab=_63124_/D }
C {devices/lab_pin.sym} 153560 -37180 0 1 {name=p152262 lab=_63124_/X }
C {sky130_stdcells/and4_4.sym} 153500 -37180 0 0 {name=X_63124_ }
C {devices/lab_pin.sym} 153440 -37040 0 0 {name=p152263 lab=_47981_/X }
C {devices/lab_pin.sym} 153440 -37000 0 0 {name=p152264 lab=_48058_/B }
C {devices/lab_pin.sym} 153560 -37020 0 1 {name=p152265 lab=_48058_/X }
C {sky130_stdcells/and2_4.sym} 153500 -37020 0 0 {name=X_48058_ }
C {devices/lab_pin.sym} 153460 -36890 0 0 {name=p152266 lab=_60335_/Y }
C {devices/lab_pin.sym} 153540 -36890 0 1 {name=p152267 lab=_60337_/D }
C {sky130_stdcells/buf_2.sym} 153500 -36890 0 0 {name=X_60336_ }
C {devices/lab_pin.sym} 153420 -36800 0 0 {name=p152268 lab=_87482_/Q }
C {devices/lab_pin.sym} 153420 -36760 0 0 {name=p152269 lab=_68792_/X }
C {devices/lab_pin.sym} 153420 -36720 0 0 {name=p152270 lab=_68979_/X }
C {devices/lab_pin.sym} 153420 -36680 0 0 {name=p152271 lab=_68980_/X }
C {devices/lab_pin.sym} 153580 -36740 0 1 {name=p152272 lab=_68981_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -36740 0 0 {name=X_68981_ }
C {devices/lab_pin.sym} 153420 -36610 0 0 {name=p152273 lab=_86680_/Q }
C {devices/lab_pin.sym} 153420 -36570 0 0 {name=p152274 lab=_47004_/X }
C {devices/lab_pin.sym} 153420 -36530 0 0 {name=p152275 lab=_47008_/Y }
C {devices/lab_pin.sym} 153580 -36570 0 1 {name=p152276 lab=_47009_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -36570 0 0 {name=X_47009_ }
C {devices/lab_pin.sym} 153440 -36440 0 0 {name=p152277 lab=_67909_/A }
C {devices/lab_pin.sym} 153440 -36400 0 0 {name=p152278 lab=_67932_/B }
C {devices/lab_pin.sym} 153560 -36420 0 1 {name=p152279 lab=_67932_/X }
C {sky130_stdcells/and2_4.sym} 153500 -36420 0 0 {name=X_67932_ }
C {devices/lab_pin.sym} 153460 -36290 0 0 {name=p152280 lab=_63055_/A }
C {devices/lab_pin.sym} 153540 -36290 0 1 {name=p152281 lab=_63231_/A }
C {sky130_stdcells/buf_2.sym} 153500 -36290 0 0 {name=X_63055_ }
C {devices/lab_pin.sym} 153440 -36180 0 0 {name=p152282 lab=_58108_/Y }
C {devices/lab_pin.sym} 153440 -36140 0 0 {name=p152283 lab=_65872_/C }
C {devices/lab_pin.sym} 153560 -36160 0 1 {name=p152284 lab=_79918_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -36160 0 0 {name=X_79918_ }
C {devices/lab_pin.sym} 153460 -36030 0 0 {name=p152285 lab=_60267_/A }
C {devices/lab_pin.sym} 153540 -36030 0 1 {name=p152286 lab=_60267_/X }
C {sky130_stdcells/buf_2.sym} 153500 -36030 0 0 {name=X_60267_ }
C {devices/lab_pin.sym} 153460 -35910 0 0 {name=p152287 lab=_49915_/A }
C {devices/lab_pin.sym} 153540 -35910 0 1 {name=p152288 lab=_50040_/B }
C {sky130_stdcells/buf_2.sym} 153500 -35910 0 0 {name=X_50020_ }
C {devices/lab_pin.sym} 153420 -35820 0 0 {name=p152289 lab=_63586_/A }
C {devices/lab_pin.sym} 153420 -35780 0 0 {name=p152290 lab=_59841_/X }
C {devices/lab_pin.sym} 153420 -35740 0 0 {name=p152291 lab=_61551_/A }
C {devices/lab_pin.sym} 153420 -35700 0 0 {name=p152292 lab=_61981_/X }
C {devices/lab_pin.sym} 153580 -35760 0 1 {name=p152293 lab=_62006_/X }
C {sky130_stdcells/a2bb2o_4.sym} 153500 -35760 0 0 {name=X_62006_ }
C {devices/lab_pin.sym} 153460 -35610 0 0 {name=p152294 lab=clkbuf_9_290_0_CLK/X }
C {devices/lab_pin.sym} 153540 -35610 0 1 {name=p152295 lab=_83944_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 153500 -35610 0 0 {name=Xclkbuf_10_580_0_CLK }
C {devices/lab_pin.sym} 153460 -35490 0 0 {name=p152296 lab=_67863_/A }
C {devices/lab_pin.sym} 153540 -35490 0 1 {name=p152297 lab=_67863_/X }
C {sky130_stdcells/buf_2.sym} 153500 -35490 0 0 {name=X_67863_ }
C {devices/lab_pin.sym} 153460 -35370 0 0 {name=p152298 lab=_79875_/A }
C {devices/lab_pin.sym} 153540 -35370 0 1 {name=p152299 lab=_79859_/A }
C {sky130_stdcells/inv_2.sym} 153500 -35370 0 0 {name=X_79849_ }
C {devices/lab_pin.sym} 153460 -35250 0 0 {name=p152300 lab=_60198_/A }
C {devices/lab_pin.sym} 153540 -35250 0 1 {name=p152301 lab=_60198_/Y }
C {sky130_stdcells/inv_2.sym} 153500 -35250 0 0 {name=X_60198_ }
C {devices/lab_pin.sym} 153420 -35150 0 0 {name=p152302 lab=_81983_/D }
C {devices/lab_pin.sym} 153420 -35110 0 0 {name=p152303 lab=_69564_/X }
C {devices/lab_pin.sym} 153420 -35070 0 0 {name=p152304 lab=_69601_/X }
C {devices/lab_pin.sym} 153580 -35110 0 1 {name=p152305 lab=_83911_/D }
C {sky130_stdcells/a21bo_4.sym} 153500 -35110 0 0 {name=X_69602_ }
C {devices/lab_pin.sym} 153420 -35000 0 0 {name=p152306 lab=_88393_/Q }
C {devices/lab_pin.sym} 153420 -34960 0 0 {name=p152307 lab=_66715_/X }
C {devices/lab_pin.sym} 153420 -34920 0 0 {name=p152308 lab=_66717_/X }
C {devices/lab_pin.sym} 153420 -34880 0 0 {name=p152309 lab=_66813_/X }
C {devices/lab_pin.sym} 153580 -34940 0 1 {name=p152310 lab=_66814_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -34940 0 0 {name=X_66814_ }
C {devices/lab_pin.sym} 153410 -34790 0 0 {name=p152311 lab=_82860_/CLK }
C {devices/lab_pin.sym} 153410 -34770 0 0 {name=p152312 lab=_82860_/D }
C {devices/lab_pin.sym} 153590 -34790 0 1 {name=p152313 lab=_82860_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -34780 0 0 {name=X_82860_ }
C {devices/lab_pin.sym} 153420 -34680 0 0 {name=p152314 lab=_87968_/Q }
C {devices/lab_pin.sym} 153420 -34640 0 0 {name=p152315 lab=_67770_/X }
C {devices/lab_pin.sym} 153420 -34600 0 0 {name=p152316 lab=_67748_/X }
C {devices/lab_pin.sym} 153420 -34560 0 0 {name=p152317 lab=_67793_/X }
C {devices/lab_pin.sym} 153580 -34620 0 1 {name=p152318 lab=_67794_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -34620 0 0 {name=X_67794_ }
C {devices/lab_pin.sym} 153410 -34470 0 0 {name=p152319 lab=_81811_/CLK }
C {devices/lab_pin.sym} 153410 -34450 0 0 {name=p152320 lab=_81619_/Q }
C {devices/lab_pin.sym} 153590 -34470 0 1 {name=p152321 lab=_47355_/A }
C {sky130_stdcells/dfxtp_4.sym} 153500 -34460 0 0 {name=X_81811_ }
C {devices/lab_pin.sym} 153440 -34340 0 0 {name=p152322 lab=_69626_/A }
C {devices/lab_pin.sym} 153440 -34300 0 0 {name=p152323 lab=_87254_/Q }
C {devices/lab_pin.sym} 153560 -34320 0 1 {name=p152324 lab=_69533_/X }
C {sky130_stdcells/and2_4.sym} 153500 -34320 0 0 {name=X_69533_ }
C {devices/lab_pin.sym} 153440 -34200 0 0 {name=p152325 lab=_66795_/A }
C {devices/lab_pin.sym} 153440 -34160 0 0 {name=p152326 lab=_66745_/B }
C {devices/lab_pin.sym} 153560 -34180 0 1 {name=p152327 lab=_66745_/X }
C {sky130_stdcells/and2_4.sym} 153500 -34180 0 0 {name=X_66745_ }
C {devices/lab_pin.sym} 153420 -34070 0 0 {name=p152328 lab=_66006_/B }
C {devices/lab_pin.sym} 153420 -34030 0 0 {name=p152329 lab=_51945_/X }
C {devices/lab_pin.sym} 153420 -33990 0 0 {name=p152330 lab=_51970_/Y }
C {devices/lab_pin.sym} 153580 -34030 0 1 {name=p152331 lab=_51971_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -34030 0 0 {name=X_51971_ }
C {devices/lab_pin.sym} 153440 -33920 0 0 {name=p152332 lab=_61490_/X }
C {devices/lab_pin.sym} 153440 -33880 0 0 {name=p152333 lab=_63908_/B }
C {devices/lab_pin.sym} 153440 -33840 0 0 {name=p152334 lab=_63894_/C }
C {devices/lab_pin.sym} 153440 -33800 0 0 {name=p152335 lab=_63908_/D }
C {devices/lab_pin.sym} 153560 -33860 0 1 {name=p152336 lab=_63957_/Y }
C {sky130_stdcells/nand4_4.sym} 153500 -33860 0 0 {name=X_63957_ }
C {devices/lab_pin.sym} 153410 -33710 0 0 {name=p152337 lab=_82792_/CLK }
C {devices/lab_pin.sym} 153410 -33690 0 0 {name=p152338 lab=_82823_/Q }
C {devices/lab_pin.sym} 153590 -33710 0 1 {name=p152339 lab=_78375_/B }
C {sky130_stdcells/dfxtp_4.sym} 153500 -33700 0 0 {name=X_82791_ }
C {devices/lab_pin.sym} 153460 -33570 0 0 {name=p152340 lab=clkbuf_9_297_0_CLK/X }
C {devices/lab_pin.sym} 153540 -33570 0 1 {name=p152341 lab=_81933_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 153500 -33570 0 0 {name=Xclkbuf_10_595_0_CLK }
C {devices/lab_pin.sym} 153420 -33470 0 0 {name=p152342 lab=_85583_/Q }
C {devices/lab_pin.sym} 153420 -33430 0 0 {name=p152343 lab=_53687_/X }
C {devices/lab_pin.sym} 153420 -33390 0 0 {name=p152344 lab=_53709_/Y }
C {devices/lab_pin.sym} 153580 -33430 0 1 {name=p152345 lab=_53710_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -33430 0 0 {name=X_53710_ }
C {devices/lab_pin.sym} 153410 -33290 0 0 {name=p152346 lab=_84292_/CLK }
C {devices/lab_pin.sym} 153410 -33270 0 0 {name=p152347 lab=_61043_/X }
C {devices/lab_pin.sym} 153590 -33290 0 1 {name=p152348 lab=_84530_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -33280 0 0 {name=X_84530_ }
C {devices/lab_pin.sym} 153420 -33170 0 0 {name=p152349 lab=_86106_/Q }
C {devices/lab_pin.sym} 153420 -33130 0 0 {name=p152350 lab=_50910_/X }
C {devices/lab_pin.sym} 153420 -33090 0 0 {name=p152351 lab=_50921_/Y }
C {devices/lab_pin.sym} 153580 -33130 0 1 {name=p152352 lab=_50922_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -33130 0 0 {name=X_50922_ }
C {devices/lab_pin.sym} 153460 -32990 0 0 {name=p152353 lab=_60274_/X }
C {devices/lab_pin.sym} 153540 -32990 0 1 {name=p152354 lab=_62908_/X }
C {sky130_stdcells/buf_2.sym} 153500 -32990 0 0 {name=X_62908_ }
C {devices/lab_pin.sym} 153410 -32870 0 0 {name=p152355 lab=_88175_/CLK }
C {devices/lab_pin.sym} 153410 -32850 0 0 {name=p152356 lab=_81742_/D }
C {devices/lab_pin.sym} 153590 -32870 0 1 {name=p152357 lab=_81742_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -32860 0 0 {name=X_81742_ }
C {devices/lab_pin.sym} 153420 -32750 0 0 {name=p152358 lab=_83922_/Q }
C {devices/lab_pin.sym} 153420 -32710 0 0 {name=p152359 lab=_69439_/X }
C {devices/lab_pin.sym} 153420 -32670 0 0 {name=p152360 lab=_69463_/X }
C {devices/lab_pin.sym} 153580 -32710 0 1 {name=p152361 lab=_69464_/X }
C {sky130_stdcells/a21bo_4.sym} 153500 -32710 0 0 {name=X_69464_ }
C {devices/lab_pin.sym} 153420 -32590 0 0 {name=p152362 lab=_54688_/Y }
C {devices/lab_pin.sym} 153420 -32550 0 0 {name=p152363 lab=_54666_/X }
C {devices/lab_pin.sym} 153420 -32510 0 0 {name=p152364 lab=_54689_/X }
C {devices/lab_pin.sym} 153580 -32550 0 1 {name=p152365 lab=_54690_/Y }
C {sky130_stdcells/a21oi_4.sym} 153500 -32550 0 0 {name=X_54690_ }
C {devices/lab_pin.sym} 153440 -32420 0 0 {name=p152366 lab=_66651_/A }
C {devices/lab_pin.sym} 153440 -32380 0 0 {name=p152367 lab=_66676_/B }
C {devices/lab_pin.sym} 153560 -32400 0 1 {name=p152368 lab=_66676_/X }
C {sky130_stdcells/and2_4.sym} 153500 -32400 0 0 {name=X_66676_ }
C {devices/lab_pin.sym} 153440 -32300 0 0 {name=p152369 lab=_57656_/X }
C {devices/lab_pin.sym} 153440 -32260 0 0 {name=p152370 lab=_63902_/B }
C {devices/lab_pin.sym} 153440 -32220 0 0 {name=p152371 lab=_63902_/C }
C {devices/lab_pin.sym} 153440 -32180 0 0 {name=p152372 lab=_63902_/D }
C {devices/lab_pin.sym} 153560 -32240 0 1 {name=p152373 lab=_63888_/Y }
C {sky130_stdcells/nand4_4.sym} 153500 -32240 0 0 {name=X_63888_ }
C {devices/lab_pin.sym} 153460 -32090 0 0 {name=p152374 lab=_87857_/Q }
C {devices/lab_pin.sym} 153540 -32090 0 1 {name=p152375 lab=_68415_/Y }
C {sky130_stdcells/inv_2.sym} 153500 -32090 0 0 {name=X_68415_ }
C {devices/lab_pin.sym} 153440 -31980 0 0 {name=p152376 lab=_53778_/A }
C {devices/lab_pin.sym} 153440 -31940 0 0 {name=p152377 lab=_52119_/B }
C {devices/lab_pin.sym} 153560 -31960 0 1 {name=p152378 lab=_53641_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -31960 0 0 {name=X_53641_ }
C {devices/lab_pin.sym} 153420 -31860 0 0 {name=p152379 lab=_65362_/X }
C {devices/lab_pin.sym} 153420 -31820 0 0 {name=p152380 lab=_85588_/Q }
C {devices/lab_pin.sym} 153420 -31780 0 0 {name=p152381 lab=_65363_/X }
C {devices/lab_pin.sym} 153420 -31740 0 0 {name=p152382 lab=_65626_/X }
C {devices/lab_pin.sym} 153580 -31800 0 1 {name=p152383 lab=_65627_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -31800 0 0 {name=X_65627_ }
C {devices/lab_pin.sym} 153410 -31650 0 0 {name=p152384 lab=_82452_/CLK }
C {devices/lab_pin.sym} 153410 -31630 0 0 {name=p152385 lab=_61672_/Y }
C {devices/lab_pin.sym} 153590 -31650 0 1 {name=p152386 lab=_79129_/B }
C {sky130_stdcells/dfxtp_4.sym} 153500 -31640 0 0 {name=X_84461_ }
C {devices/lab_pin.sym} 153420 -31530 0 0 {name=p152387 lab=_86120_/Q }
C {devices/lab_pin.sym} 153420 -31490 0 0 {name=p152388 lab=_50804_/X }
C {devices/lab_pin.sym} 153420 -31450 0 0 {name=p152389 lab=_50852_/Y }
C {devices/lab_pin.sym} 153580 -31490 0 1 {name=p152390 lab=_50853_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -31490 0 0 {name=X_50853_ }
C {devices/lab_pin.sym} 153440 -31370 0 0 {name=p152391 lab=_62792_/X }
C {devices/lab_pin.sym} 153440 -31330 0 0 {name=p152392 lab=_62839_/B }
C {devices/lab_pin.sym} 153440 -31290 0 0 {name=p152393 lab=_84378_/Q }
C {devices/lab_pin.sym} 153560 -31330 0 1 {name=p152394 lab=_62839_/Y }
C {sky130_stdcells/nor3_4.sym} 153500 -31330 0 0 {name=X_62839_ }
C {devices/lab_pin.sym} 153410 -31190 0 0 {name=p152395 lab=_81671_/CLK }
C {devices/lab_pin.sym} 153410 -31170 0 0 {name=p152396 lab=_80002_/X }
C {devices/lab_pin.sym} 153590 -31190 0 1 {name=p152397 lab=_81673_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -31180 0 0 {name=X_81673_ }
C {devices/lab_pin.sym} 153420 -31080 0 0 {name=p152398 lab=_88032_/Q }
C {devices/lab_pin.sym} 153420 -31040 0 0 {name=p152399 lab=_69315_/X }
C {devices/lab_pin.sym} 153420 -31000 0 0 {name=p152400 lab=_69393_/X }
C {devices/lab_pin.sym} 153420 -30960 0 0 {name=p152401 lab=_69394_/X }
C {devices/lab_pin.sym} 153580 -31020 0 1 {name=p152402 lab=_69395_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -31020 0 0 {name=X_69395_ }
C {devices/lab_pin.sym} 153410 -30870 0 0 {name=p152403 lab=_85879_/CLK }
C {devices/lab_pin.sym} 153410 -30850 0 0 {name=p152404 lab=_86200_/D }
C {devices/lab_pin.sym} 153590 -30870 0 1 {name=p152405 lab=_86200_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -30860 0 0 {name=X_86200_ }
C {devices/lab_pin.sym} 153410 -30730 0 0 {name=p152406 lab=_83380_/CLK }
C {devices/lab_pin.sym} 153410 -30710 0 0 {name=p152407 lab=_71684_/X }
C {devices/lab_pin.sym} 153590 -30730 0 1 {name=p152408 lab=_83412_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -30720 0 0 {name=X_83412_ }
C {devices/lab_pin.sym} 153440 -30610 0 0 {name=p152409 lab=_56360_/A }
C {devices/lab_pin.sym} 153440 -30570 0 0 {name=p152410 lab=_56358_/B }
C {devices/lab_pin.sym} 153440 -30530 0 0 {name=p152411 lab=_55730_/B }
C {devices/lab_pin.sym} 153560 -30570 0 1 {name=p152412 lab=_56360_/Y }
C {sky130_stdcells/nand3_4.sym} 153500 -30570 0 0 {name=X_56360_ }
C {devices/lab_pin.sym} 153440 -30440 0 0 {name=p152413 lab=_80624_/A }
C {devices/lab_pin.sym} 153440 -30400 0 0 {name=p152414 lab=_80623_/X }
C {devices/lab_pin.sym} 153560 -30420 0 1 {name=p152415 lab=_80632_/A }
C {sky130_stdcells/nand2_4.sym} 153500 -30420 0 0 {name=X_80624_ }
C {devices/lab_pin.sym} 153460 -30290 0 0 {name=p152416 lab=_69645_/A }
C {devices/lab_pin.sym} 153540 -30290 0 1 {name=p152417 lab=_68472_/A }
C {sky130_stdcells/buf_2.sym} 153500 -30290 0 0 {name=X_68346_ }
C {devices/lab_pin.sym} 153410 -30170 0 0 {name=p152418 lab=_87183_/CLK }
C {devices/lab_pin.sym} 153410 -30150 0 0 {name=p152419 lab=_44220_/Y }
C {devices/lab_pin.sym} 153590 -30170 0 1 {name=p152420 lab=_87180_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -30160 0 0 {name=X_87180_ }
C {devices/lab_pin.sym} 153440 -30040 0 0 {name=p152421 lab=_53548_/A }
C {devices/lab_pin.sym} 153440 -30000 0 0 {name=p152422 lab=_57605_/B }
C {devices/lab_pin.sym} 153560 -30020 0 1 {name=p152423 lab=_53572_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -30020 0 0 {name=X_53572_ }
C {devices/lab_pin.sym} 153460 -29890 0 0 {name=p152424 lab=_65929_/A }
C {devices/lab_pin.sym} 153540 -29890 0 1 {name=p152425 lab=_65559_/B }
C {sky130_stdcells/buf_2.sym} 153500 -29890 0 0 {name=X_65558_ }
C {devices/lab_pin.sym} 153410 -29770 0 0 {name=p152426 lab=_84392_/CLK }
C {devices/lab_pin.sym} 153410 -29750 0 0 {name=p152427 lab=_62674_/Y }
C {devices/lab_pin.sym} 153590 -29770 0 1 {name=p152428 lab=_84392_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -29760 0 0 {name=X_84392_ }
C {devices/lab_pin.sym} 153420 -29650 0 0 {name=p152429 lab=_50782_/Y }
C {devices/lab_pin.sym} 153420 -29610 0 0 {name=p152430 lab=_50768_/X }
C {devices/lab_pin.sym} 153420 -29570 0 0 {name=p152431 lab=_50783_/Y }
C {devices/lab_pin.sym} 153580 -29610 0 1 {name=p152432 lab=_86134_/D }
C {sky130_stdcells/a21boi_4.sym} 153500 -29610 0 0 {name=X_50784_ }
C {devices/lab_pin.sym} 153460 -29470 0 0 {name=p152433 lab=_55305_/X }
C {devices/lab_pin.sym} 153540 -29470 0 1 {name=p152434 lab=_55311_/X }
C {sky130_stdcells/buf_2.sym} 153500 -29470 0 0 {name=X_55311_ }
C {devices/lab_pin.sym} 153410 -29350 0 0 {name=p152435 lab=_86424_/CLK }
C {devices/lab_pin.sym} 153410 -29330 0 0 {name=p152436 lab=_50798_/Y }
C {devices/lab_pin.sym} 153590 -29350 0 1 {name=p152437 lab=_86131_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -29340 0 0 {name=X_86131_ }
C {devices/lab_pin.sym} 153420 -29230 0 0 {name=p152438 lab=_65115_/B }
C {devices/lab_pin.sym} 153420 -29190 0 0 {name=p152439 lab=_52516_/X }
C {devices/lab_pin.sym} 153420 -29150 0 0 {name=p152440 lab=_52522_/Y }
C {devices/lab_pin.sym} 153580 -29190 0 1 {name=p152441 lab=_52523_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -29190 0 0 {name=X_52523_ }
C {devices/lab_pin.sym} 153440 -29070 0 0 {name=p152442 lab=_64689_/A }
C {devices/lab_pin.sym} 153440 -29030 0 0 {name=p152443 lab=_64741_/B }
C {devices/lab_pin.sym} 153440 -28990 0 0 {name=p152444 lab=_79605_/B }
C {devices/lab_pin.sym} 153560 -29030 0 1 {name=p152445 lab=_64509_/Y }
C {sky130_stdcells/nor3_4.sym} 153500 -29030 0 0 {name=X_64509_ }
C {devices/lab_pin.sym} 153410 -28890 0 0 {name=p152446 lab=_83338_/CLK }
C {devices/lab_pin.sym} 153410 -28870 0 0 {name=p152447 lab=_71880_/X }
C {devices/lab_pin.sym} 153590 -28890 0 1 {name=p152448 lab=_83343_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -28880 0 0 {name=X_83343_ }
C {devices/lab_pin.sym} 153440 -28760 0 0 {name=p152449 lab=_80562_/B }
C {devices/lab_pin.sym} 153440 -28720 0 0 {name=p152450 lab=_80554_/Y }
C {devices/lab_pin.sym} 153560 -28740 0 1 {name=p152451 lab=_82266_/D }
C {sky130_stdcells/xor2_4.sym} 153500 -28740 0 0 {name=X_80555_ }
C {devices/lab_pin.sym} 153440 -28630 0 0 {name=p152452 lab=_56368_/A }
C {devices/lab_pin.sym} 153440 -28590 0 0 {name=p152453 lab=_56270_/B }
C {devices/lab_pin.sym} 153440 -28550 0 0 {name=p152454 lab=_55976_/B }
C {devices/lab_pin.sym} 153560 -28590 0 1 {name=p152455 lab=_56291_/Y }
C {sky130_stdcells/nand3_4.sym} 153500 -28590 0 0 {name=X_56291_ }
C {devices/lab_pin.sym} 153420 -28480 0 0 {name=p152456 lab=_68254_/X }
C {devices/lab_pin.sym} 153420 -28440 0 0 {name=p152457 lab=_67698_/Y }
C {devices/lab_pin.sym} 153420 -28400 0 0 {name=p152458 lab=_68268_/X }
C {devices/lab_pin.sym} 153420 -28360 0 0 {name=p152459 lab=_68276_/Y }
C {devices/lab_pin.sym} 153580 -28420 0 1 {name=p152460 lab=_68277_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -28420 0 0 {name=X_68277_ }
C {devices/lab_pin.sym} 153440 -28280 0 0 {name=p152461 lab=_65592_/A }
C {devices/lab_pin.sym} 153440 -28240 0 0 {name=p152462 lab=_65489_/B }
C {devices/lab_pin.sym} 153560 -28260 0 1 {name=p152463 lab=_65489_/X }
C {sky130_stdcells/and2_4.sym} 153500 -28260 0 0 {name=X_65489_ }
C {devices/lab_pin.sym} 153460 -28130 0 0 {name=p152464 lab=_58605_/A }
C {devices/lab_pin.sym} 153540 -28130 0 1 {name=p152465 lab=_58030_/X }
C {sky130_stdcells/buf_2.sym} 153500 -28130 0 0 {name=X_58030_ }
C {devices/lab_pin.sym} 153440 -28030 0 0 {name=p152466 lab=_72712_/C }
C {devices/lab_pin.sym} 153440 -27990 0 0 {name=p152467 lab=_83317_/Q }
C {devices/lab_pin.sym} 153440 -27950 0 0 {name=p152468 lab=_55209_/X }
C {devices/lab_pin.sym} 153560 -27990 0 1 {name=p152469 lab=_56889_/B }
C {sky130_stdcells/nand3_4.sym} 153500 -27990 0 0 {name=X_55242_ }
C {devices/lab_pin.sym} 153420 -27880 0 0 {name=p152470 lab=_87416_/Q }
C {devices/lab_pin.sym} 153420 -27840 0 0 {name=p152471 lab=_67156_/X }
C {devices/lab_pin.sym} 153420 -27800 0 0 {name=p152472 lab=_67226_/X }
C {devices/lab_pin.sym} 153420 -27760 0 0 {name=p152473 lab=_67227_/X }
C {devices/lab_pin.sym} 153580 -27820 0 1 {name=p152474 lab=_67228_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -27820 0 0 {name=X_67228_ }
C {devices/lab_pin.sym} 153410 -27670 0 0 {name=p152475 lab=_85745_/CLK }
C {devices/lab_pin.sym} 153410 -27650 0 0 {name=p152476 lab=_51166_/Y }
C {devices/lab_pin.sym} 153590 -27670 0 1 {name=p152477 lab=_86062_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -27660 0 0 {name=X_86062_ }
C {devices/lab_pin.sym} 153440 -27540 0 0 {name=p152478 lab=_52436_/A }
C {devices/lab_pin.sym} 153440 -27500 0 0 {name=p152479 lab=_52454_/B }
C {devices/lab_pin.sym} 153560 -27520 0 1 {name=p152480 lab=_52454_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -27520 0 0 {name=X_52454_ }
C {devices/lab_pin.sym} 153410 -27390 0 0 {name=p152481 lab=_86297_/CLK }
C {devices/lab_pin.sym} 153410 -27370 0 0 {name=p152482 lab=_72213_/Y }
C {devices/lab_pin.sym} 153590 -27390 0 1 {name=p152483 lab=_83274_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -27380 0 0 {name=X_83274_ }
C {devices/lab_pin.sym} 153440 -27260 0 0 {name=p152484 lab=_80482_/Y }
C {devices/lab_pin.sym} 153440 -27220 0 0 {name=p152485 lab=_80485_/Y }
C {devices/lab_pin.sym} 153560 -27240 0 1 {name=p152486 lab=_80487_/A }
C {sky130_stdcells/xor2_4.sym} 153500 -27240 0 0 {name=X_80486_ }
C {devices/lab_pin.sym} 153410 -27110 0 0 {name=p152487 lab=_85013_/CLK }
C {devices/lab_pin.sym} 153410 -27090 0 0 {name=p152488 lab=_85013_/D }
C {devices/lab_pin.sym} 153590 -27110 0 1 {name=p152489 lab=_45584_/A }
C {sky130_stdcells/dfxtp_4.sym} 153500 -27100 0 0 {name=X_85013_ }
C {devices/lab_pin.sym} 153460 -26970 0 0 {name=p152490 lab=clkbuf_9_266_0_CLK/X }
C {devices/lab_pin.sym} 153540 -26970 0 1 {name=p152491 lab=_83918_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 153500 -26970 0 0 {name=Xclkbuf_10_533_0_CLK }
C {devices/lab_pin.sym} 153420 -26870 0 0 {name=p152492 lab=_86016_/Q }
C {devices/lab_pin.sym} 153420 -26830 0 0 {name=p152493 lab=_51402_/X }
C {devices/lab_pin.sym} 153420 -26790 0 0 {name=p152494 lab=_51404_/Y }
C {devices/lab_pin.sym} 153580 -26830 0 1 {name=p152495 lab=_51405_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -26830 0 0 {name=X_51405_ }
C {devices/lab_pin.sym} 153410 -26690 0 0 {name=p152496 lab=_82786_/CLK }
C {devices/lab_pin.sym} 153410 -26670 0 0 {name=p152497 lab=_82257_/Q }
C {devices/lab_pin.sym} 153590 -26690 0 1 {name=p152498 lab=_77443_/A }
C {sky130_stdcells/dfxtp_4.sym} 153500 -26680 0 0 {name=X_82225_ }
C {devices/lab_pin.sym} 153460 -26550 0 0 {name=p152499 lab=clkbuf_6_25_0_CLK/A }
C {devices/lab_pin.sym} 153540 -26550 0 1 {name=p152500 lab=clkbuf_6_24_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 153500 -26550 0 0 {name=Xclkbuf_6_24_0_CLK }
C {devices/lab_pin.sym} 153460 -26430 0 0 {name=p152501 lab=_55125_/A }
C {devices/lab_pin.sym} 153540 -26430 0 1 {name=p152502 lab=_55244_/A }
C {sky130_stdcells/buf_2.sym} 153500 -26430 0 0 {name=X_55173_ }
C {devices/lab_pin.sym} 153420 -26330 0 0 {name=p152503 lab=_67155_/X }
C {devices/lab_pin.sym} 153420 -26290 0 0 {name=p152504 lab=_67158_/X }
C {devices/lab_pin.sym} 153420 -26250 0 0 {name=p152505 lab=_67085_/X }
C {devices/lab_pin.sym} 153580 -26290 0 1 {name=p152506 lab=_67159_/X }
C {sky130_stdcells/a21o_4.sym} 153500 -26290 0 0 {name=X_67159_ }
C {devices/lab_pin.sym} 153440 -26160 0 0 {name=p152507 lab=_52385_/A }
C {devices/lab_pin.sym} 153440 -26120 0 0 {name=p152508 lab=_52385_/B }
C {devices/lab_pin.sym} 153560 -26140 0 1 {name=p152509 lab=_52385_/X }
C {sky130_stdcells/and2_4.sym} 153500 -26140 0 0 {name=X_52385_ }
C {devices/lab_pin.sym} 153420 -26030 0 0 {name=p152510 lab=_54122_/Y }
C {devices/lab_pin.sym} 153420 -25990 0 0 {name=p152511 lab=_54117_/X }
C {devices/lab_pin.sym} 153420 -25950 0 0 {name=p152512 lab=_54123_/X }
C {devices/lab_pin.sym} 153580 -25990 0 1 {name=p152513 lab=_85500_/D }
C {sky130_stdcells/a21oi_4.sym} 153500 -25990 0 0 {name=X_54124_ }
C {devices/lab_pin.sym} 153420 -25870 0 0 {name=p152514 lab=_65120_/B }
C {devices/lab_pin.sym} 153420 -25830 0 0 {name=p152515 lab=_51332_/X }
C {devices/lab_pin.sym} 153420 -25790 0 0 {name=p152516 lab=_51335_/Y }
C {devices/lab_pin.sym} 153580 -25830 0 1 {name=p152517 lab=_51336_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -25830 0 0 {name=X_51336_ }
C {devices/lab_pin.sym} 153460 -25690 0 0 {name=p152518 lab=_70127_/X }
C {devices/lab_pin.sym} 153540 -25690 0 1 {name=p152519 lab=_70231_/A }
C {sky130_stdcells/buf_2.sym} 153500 -25690 0 0 {name=X_70170_ }
C {devices/lab_pin.sym} 153410 -25570 0 0 {name=p152520 lab=_84220_/CLK }
C {devices/lab_pin.sym} 153410 -25550 0 0 {name=p152521 lab=_84148_/Q }
C {devices/lab_pin.sym} 153590 -25570 0 1 {name=p152522 lab=_82156_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -25560 0 0 {name=X_82156_ }
C {devices/lab_pin.sym} 153440 -25450 0 0 {name=p152523 lab=_59980_/X }
C {devices/lab_pin.sym} 153440 -25410 0 0 {name=p152524 lab=_59570_/A }
C {devices/lab_pin.sym} 153440 -25370 0 0 {name=p152525 lab=_59905_/B }
C {devices/lab_pin.sym} 153560 -25410 0 1 {name=p152526 lab=_59981_/Y }
C {sky130_stdcells/nor3_4.sym} 153500 -25410 0 0 {name=X_59981_ }
C {devices/lab_pin.sym} 153410 -25270 0 0 {name=p152527 lab=_81087_/CLK }
C {devices/lab_pin.sym} 153410 -25250 0 0 {name=p152528 lab=_79738_/Y }
C {devices/lab_pin.sym} 153590 -25270 0 1 {name=p152529 lab=_81107_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -25260 0 0 {name=X_81107_ }
C {devices/lab_pin.sym} 153420 -25160 0 0 {name=p152530 lab=_84789_/Q }
C {devices/lab_pin.sym} 153420 -25120 0 0 {name=p152531 lab=_58871_/X }
C {devices/lab_pin.sym} 153420 -25080 0 0 {name=p152532 lab=_58924_/X }
C {devices/lab_pin.sym} 153420 -25040 0 0 {name=p152533 lab=_58931_/X }
C {devices/lab_pin.sym} 153580 -25100 0 1 {name=p152534 lab=_84789_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 153500 -25100 0 0 {name=X_58932_ }
C {devices/lab_pin.sym} 153420 -24970 0 0 {name=p152535 lab=_85514_/Q }
C {devices/lab_pin.sym} 153420 -24930 0 0 {name=p152536 lab=_54018_/X }
C {devices/lab_pin.sym} 153420 -24890 0 0 {name=p152537 lab=_54054_/Y }
C {devices/lab_pin.sym} 153580 -24930 0 1 {name=p152538 lab=_54055_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -24930 0 0 {name=X_54055_ }
C {devices/lab_pin.sym} 153420 -24810 0 0 {name=p152539 lab=_51262_/Y }
C {devices/lab_pin.sym} 153420 -24770 0 0 {name=p152540 lab=_51263_/X }
C {devices/lab_pin.sym} 153420 -24730 0 0 {name=p152541 lab=_51266_/X }
C {devices/lab_pin.sym} 153580 -24770 0 1 {name=p152542 lab=_51267_/Y }
C {sky130_stdcells/a21oi_4.sym} 153500 -24770 0 0 {name=X_51267_ }
C {devices/lab_pin.sym} 153410 -24630 0 0 {name=p152543 lab=_88224_/CLK }
C {devices/lab_pin.sym} 153410 -24610 0 0 {name=p152544 lab=_86964_/D }
C {devices/lab_pin.sym} 153590 -24630 0 1 {name=p152545 lab=_86964_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -24620 0 0 {name=X_86964_ }
C {devices/lab_pin.sym} 153410 -24490 0 0 {name=p152546 lab=_82133_/CLK }
C {devices/lab_pin.sym} 153410 -24470 0 0 {name=p152547 lab=_77294_/B }
C {devices/lab_pin.sym} 153590 -24490 0 1 {name=p152548 lab=_82087_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -24480 0 0 {name=X_82087_ }
C {devices/lab_pin.sym} 153460 -24350 0 0 {name=p152549 lab=clkbuf_9_274_0_CLK/X }
C {devices/lab_pin.sym} 153540 -24350 0 1 {name=p152550 lab=_81756_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 153500 -24350 0 0 {name=Xclkbuf_10_548_0_CLK }
C {devices/lab_pin.sym} 153460 -24230 0 0 {name=p152551 lab=clkbuf_6_39_0_CLK/A }
C {devices/lab_pin.sym} 153540 -24230 0 1 {name=p152552 lab=clkbuf_7_78_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 153500 -24230 0 0 {name=Xclkbuf_6_39_0_CLK }
C {devices/lab_pin.sym} 153420 -24130 0 0 {name=p152553 lab=_85714_/Q }
C {devices/lab_pin.sym} 153420 -24090 0 0 {name=p152554 lab=_52984_/X }
C {devices/lab_pin.sym} 153420 -24050 0 0 {name=p152555 lab=_53005_/Y }
C {devices/lab_pin.sym} 153580 -24090 0 1 {name=p152556 lab=_53006_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -24090 0 0 {name=X_53006_ }
C {devices/lab_pin.sym} 153420 -23970 0 0 {name=p152557 lab=_40991_/X }
C {devices/lab_pin.sym} 153420 -23930 0 0 {name=p152558 lab=_81714_/Q }
C {devices/lab_pin.sym} 153420 -23890 0 0 {name=p152559 lab=_41019_/X }
C {devices/lab_pin.sym} 153580 -23930 0 1 {name=p152560 lab=_41021_/A }
C {sky130_stdcells/o21a_4.sym} 153500 -23930 0 0 {name=X_41020_ }
C {devices/lab_pin.sym} 153460 -23790 0 0 {name=p152561 lab=_50218_/A }
C {devices/lab_pin.sym} 153540 -23790 0 1 {name=p152562 lab=_50655_/A }
C {sky130_stdcells/buf_2.sym} 153500 -23790 0 0 {name=X_50218_ }
C {devices/lab_pin.sym} 153410 -23670 0 0 {name=p152563 lab=_85915_/CLK }
C {devices/lab_pin.sym} 153410 -23650 0 0 {name=p152564 lab=_85915_/D }
C {devices/lab_pin.sym} 153590 -23670 0 1 {name=p152565 lab=_73707_/B }
C {sky130_stdcells/dfxtp_4.sym} 153500 -23660 0 0 {name=X_85915_ }
C {devices/lab_pin.sym} 153410 -23530 0 0 {name=p152566 lab=_81038_/CLK }
C {devices/lab_pin.sym} 153410 -23510 0 0 {name=p152567 lab=_75249_/Y }
C {devices/lab_pin.sym} 153590 -23530 0 1 {name=p152568 lab=_81038_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -23520 0 0 {name=X_81038_ }
C {devices/lab_pin.sym} 153420 -23410 0 0 {name=p152569 lab=_58860_/Y }
C {devices/lab_pin.sym} 153420 -23370 0 0 {name=p152570 lab=_58862_/Y }
C {devices/lab_pin.sym} 153420 -23330 0 0 {name=p152571 lab=_58761_/X }
C {devices/lab_pin.sym} 153580 -23370 0 1 {name=p152572 lab=_58863_/X }
C {sky130_stdcells/a21o_4.sym} 153500 -23370 0 0 {name=X_58863_ }
C {devices/lab_pin.sym} 153420 -23250 0 0 {name=p152573 lab=_51195_/Y }
C {devices/lab_pin.sym} 153420 -23210 0 0 {name=p152574 lab=_51175_/X }
C {devices/lab_pin.sym} 153420 -23170 0 0 {name=p152575 lab=_51197_/X }
C {devices/lab_pin.sym} 153580 -23210 0 1 {name=p152576 lab=_86056_/D }
C {sky130_stdcells/a21oi_4.sym} 153500 -23210 0 0 {name=X_51198_ }
C {devices/lab_pin.sym} 153410 -23070 0 0 {name=p152577 lab=_86896_/CLK }
C {devices/lab_pin.sym} 153410 -23050 0 0 {name=p152578 lab=_45160_/Y }
C {devices/lab_pin.sym} 153590 -23070 0 1 {name=p152579 lab=_64401_/B }
C {sky130_stdcells/dfxtp_4.sym} 153500 -23060 0 0 {name=X_86895_ }
C {devices/lab_pin.sym} 153460 -22930 0 0 {name=p152580 lab=_58020_/A }
C {devices/lab_pin.sym} 153540 -22930 0 1 {name=p152581 lab=_57814_/X }
C {sky130_stdcells/buf_2.sym} 153500 -22930 0 0 {name=X_57814_ }
C {devices/lab_pin.sym} 153440 -22820 0 0 {name=p152582 lab=_50153_/A }
C {devices/lab_pin.sym} 153440 -22780 0 0 {name=p152583 lab=_49073_/X }
C {devices/lab_pin.sym} 153560 -22800 0 1 {name=p152584 lab=_50149_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -22800 0 0 {name=X_50149_ }
C {devices/lab_pin.sym} 153460 -22670 0 0 {name=p152585 lab=_72874_/A }
C {devices/lab_pin.sym} 153540 -22670 0 1 {name=p152586 lab=_73954_/A }
C {sky130_stdcells/buf_2.sym} 153500 -22670 0 0 {name=X_73860_ }
C {devices/lab_pin.sym} 153410 -22550 0 0 {name=p152587 lab=_83303_/CLK }
C {devices/lab_pin.sym} 153410 -22530 0 0 {name=p152588 lab=_52321_/Y }
C {devices/lab_pin.sym} 153590 -22550 0 1 {name=p152589 lab=_64904_/B }
C {sky130_stdcells/dfxtp_4.sym} 153500 -22540 0 0 {name=X_85846_ }
C {devices/lab_pin.sym} 153420 -22430 0 0 {name=p152590 lab=_58756_/X }
C {devices/lab_pin.sym} 153420 -22390 0 0 {name=p152591 lab=_85935_/Q }
C {devices/lab_pin.sym} 153420 -22350 0 0 {name=p152592 lab=_58793_/X }
C {devices/lab_pin.sym} 153580 -22390 0 1 {name=p152593 lab=_58794_/X }
C {sky130_stdcells/o21a_4.sym} 153500 -22390 0 0 {name=X_58794_ }
C {devices/lab_pin.sym} 153460 -22250 0 0 {name=p152594 lab=_44131_/A }
C {devices/lab_pin.sym} 153540 -22250 0 1 {name=p152595 lab=_73067_/A }
C {sky130_stdcells/buf_2.sym} 153500 -22250 0 0 {name=X_72811_ }
C {devices/lab_pin.sym} 153440 -22140 0 0 {name=p152596 lab=_86654_/Q }
C {devices/lab_pin.sym} 153440 -22100 0 0 {name=p152597 lab=_57833_/B }
C {devices/lab_pin.sym} 153560 -22120 0 1 {name=p152598 lab=_57745_/Y }
C {sky130_stdcells/nor2_4.sym} 153500 -22120 0 0 {name=X_57745_ }
C {devices/lab_pin.sym} 153440 -22000 0 0 {name=p152599 lab=_54961_/A }
C {devices/lab_pin.sym} 153440 -21960 0 0 {name=p152600 lab=_47526_/Y }
C {devices/lab_pin.sym} 153560 -21980 0 1 {name=p152601 lab=_54957_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -21980 0 0 {name=X_54957_ }
C {devices/lab_pin.sym} 153460 -21850 0 0 {name=p152602 lab=_41992_/A }
C {devices/lab_pin.sym} 153540 -21850 0 1 {name=p152603 lab=_42971_/X }
C {sky130_stdcells/buf_2.sym} 153500 -21850 0 0 {name=X_42971_ }
C {devices/lab_pin.sym} 153420 -21750 0 0 {name=p152604 lab=_73792_/B }
C {devices/lab_pin.sym} 153420 -21710 0 0 {name=p152605 lab=_73779_/Y }
C {devices/lab_pin.sym} 153420 -21670 0 0 {name=p152606 lab=_73790_/X }
C {devices/lab_pin.sym} 153580 -21710 0 1 {name=p152607 lab=_73791_/X }
C {sky130_stdcells/a21o_4.sym} 153500 -21710 0 0 {name=X_73791_ }
C {devices/lab_pin.sym} 153410 -21570 0 0 {name=p152608 lab=_85778_/CLK }
C {devices/lab_pin.sym} 153410 -21550 0 0 {name=p152609 lab=_52666_/Y }
C {devices/lab_pin.sym} 153590 -21570 0 1 {name=p152610 lab=_85777_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -21560 0 0 {name=X_85777_ }
C {devices/lab_pin.sym} 153410 -21430 0 0 {name=p152611 lab=_83012_/CLK }
C {devices/lab_pin.sym} 153410 -21410 0 0 {name=p152612 lab=_74674_/X }
C {devices/lab_pin.sym} 153590 -21430 0 1 {name=p152613 lab=_82989_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -21420 0 0 {name=X_82989_ }
C {devices/lab_pin.sym} 153460 -21290 0 0 {name=p152614 lab=_44533_/A }
C {devices/lab_pin.sym} 153540 -21290 0 1 {name=p152615 lab=_44710_/X }
C {sky130_stdcells/buf_2.sym} 153500 -21290 0 0 {name=X_44710_ }
C {devices/lab_pin.sym} 153440 -21180 0 0 {name=p152616 lab=_75530_/A }
C {devices/lab_pin.sym} 153440 -21140 0 0 {name=p152617 lab=_75525_/X }
C {devices/lab_pin.sym} 153560 -21160 0 1 {name=p152618 lab=_75530_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -21160 0 0 {name=X_75530_ }
C {devices/lab_pin.sym} 153410 -21030 0 0 {name=p152619 lab=_87767_/CLK }
C {devices/lab_pin.sym} 153410 -21010 0 0 {name=p152620 lab=_87516_/D }
C {devices/lab_pin.sym} 153590 -21030 0 1 {name=p152621 lab=_87516_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -21020 0 0 {name=X_87516_ }
C {devices/lab_pin.sym} 153460 -20890 0 0 {name=p152622 lab=_41922_/A }
C {devices/lab_pin.sym} 153540 -20890 0 1 {name=p152623 lab=_41922_/Y }
C {sky130_stdcells/inv_2.sym} 153500 -20890 0 0 {name=X_41922_ }
C {devices/lab_pin.sym} 153440 -20780 0 0 {name=p152624 lab=_53898_/A }
C {devices/lab_pin.sym} 153440 -20740 0 0 {name=p152625 lab=_49135_/A }
C {devices/lab_pin.sym} 153560 -20760 0 1 {name=p152626 lab=_53908_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -20760 0 0 {name=X_53908_ }
C {devices/lab_pin.sym} 153410 -20630 0 0 {name=p152627 lab=_83402_/CLK }
C {devices/lab_pin.sym} 153410 -20610 0 0 {name=p152628 lab=_59455_/X }
C {devices/lab_pin.sym} 153590 -20630 0 1 {name=p152629 lab=_84728_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -20620 0 0 {name=X_84728_ }
C {devices/lab_pin.sym} 153420 -20510 0 0 {name=p152630 lab=_88339_/Q }
C {devices/lab_pin.sym} 153420 -20470 0 0 {name=p152631 lab=_56939_/X }
C {devices/lab_pin.sym} 153420 -20430 0 0 {name=p152632 lab=_72741_/X }
C {devices/lab_pin.sym} 153580 -20470 0 1 {name=p152633 lab=_72742_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -20470 0 0 {name=X_72742_ }
C {devices/lab_pin.sym} 153420 -20360 0 0 {name=p152634 lab=_45688_/Y }
C {devices/lab_pin.sym} 153420 -20320 0 0 {name=p152635 lab=_45627_/X }
C {devices/lab_pin.sym} 153420 -20280 0 0 {name=p152636 lab=_45644_/X }
C {devices/lab_pin.sym} 153420 -20240 0 0 {name=p152637 lab=_45689_/Y }
C {devices/lab_pin.sym} 153580 -20300 0 1 {name=p152638 lab=_45690_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -20300 0 0 {name=X_45690_ }
C {devices/lab_pin.sym} 153420 -20170 0 0 {name=p152639 lab=_45909_/X }
C {devices/lab_pin.sym} 153420 -20130 0 0 {name=p152640 lab=_57672_/X }
C {devices/lab_pin.sym} 153420 -20090 0 0 {name=p152641 lab=_57675_/Y }
C {devices/lab_pin.sym} 153580 -20130 0 1 {name=p152642 lab=_57676_/X }
C {sky130_stdcells/o21a_4.sym} 153500 -20130 0 0 {name=X_57676_ }
C {devices/lab_pin.sym} 153460 -19990 0 0 {name=p152643 lab=_54888_/A }
C {devices/lab_pin.sym} 153540 -19990 0 1 {name=p152644 lab=_54910_/A }
C {sky130_stdcells/buf_2.sym} 153500 -19990 0 0 {name=X_54888_ }
C {devices/lab_pin.sym} 153440 -19880 0 0 {name=p152645 lab=_59415_/A }
C {devices/lab_pin.sym} 153440 -19840 0 0 {name=p152646 lab=_59399_/B }
C {devices/lab_pin.sym} 153560 -19860 0 1 {name=p152647 lab=_59415_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -19860 0 0 {name=X_59415_ }
C {devices/lab_pin.sym} 153420 -19770 0 0 {name=p152648 lab=_44638_/X }
C {devices/lab_pin.sym} 153420 -19730 0 0 {name=p152649 lab=_44639_/X }
C {devices/lab_pin.sym} 153420 -19690 0 0 {name=p152650 lab=_41035_/X }
C {devices/lab_pin.sym} 153420 -19650 0 0 {name=p152651 lab=_87021_/Q }
C {devices/lab_pin.sym} 153420 -19610 0 0 {name=p152652 lab=_44640_/X }
C {devices/lab_pin.sym} 153580 -19690 0 1 {name=p152653 lab=_44642_/A }
C {sky130_stdcells/o32ai_4.sym} 153500 -19690 0 0 {name=X_44641_ }
C {devices/lab_pin.sym} 153440 -19550 0 0 {name=p152654 lab=_56602_/X }
C {devices/lab_pin.sym} 153440 -19510 0 0 {name=p152655 lab=_56627_/B }
C {devices/lab_pin.sym} 153440 -19470 0 0 {name=p152656 lab=_56696_/B }
C {devices/lab_pin.sym} 153560 -19510 0 1 {name=p152657 lab=_56627_/Y }
C {sky130_stdcells/nor3_4.sym} 153500 -19510 0 0 {name=X_56627_ }
C {devices/lab_pin.sym} 153460 -19370 0 0 {name=p152658 lab=_75461_/A }
C {devices/lab_pin.sym} 153540 -19370 0 1 {name=p152659 lab=_75509_/A }
C {sky130_stdcells/inv_2.sym} 153500 -19370 0 0 {name=X_75461_ }
C {devices/lab_pin.sym} 153420 -19280 0 0 {name=p152660 lab=_40524_/X }
C {devices/lab_pin.sym} 153420 -19240 0 0 {name=p152661 lab=_41847_/X }
C {devices/lab_pin.sym} 153420 -19200 0 0 {name=p152662 lab=_67206_/B }
C {devices/lab_pin.sym} 153420 -19160 0 0 {name=p152663 lab=_41848_/X }
C {devices/lab_pin.sym} 153580 -19220 0 1 {name=p152664 lab=_88121_/D }
C {sky130_stdcells/a2bb2o_4.sym} 153500 -19220 0 0 {name=X_41853_ }
C {devices/lab_pin.sym} 153410 -19070 0 0 {name=p152665 lab=_87382_/CLK }
C {devices/lab_pin.sym} 153410 -19050 0 0 {name=p152666 lab=_43389_/X }
C {devices/lab_pin.sym} 153590 -19070 0 1 {name=p152667 lab=_87447_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -19060 0 0 {name=X_87447_ }
C {devices/lab_pin.sym} 153440 -18940 0 0 {name=p152668 lab=_53825_/A }
C {devices/lab_pin.sym} 153440 -18900 0 0 {name=p152669 lab=_72014_/B }
C {devices/lab_pin.sym} 153560 -18920 0 1 {name=p152670 lab=_53839_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -18920 0 0 {name=X_53839_ }
C {devices/lab_pin.sym} 153460 -18790 0 0 {name=p152671 lab=_72687_/A }
C {devices/lab_pin.sym} 153540 -18790 0 1 {name=p152672 lab=_72683_/A }
C {sky130_stdcells/buf_2.sym} 153500 -18790 0 0 {name=X_72673_ }
C {devices/lab_pin.sym} 153410 -18670 0 0 {name=p152673 lab=_84660_/CLK }
C {devices/lab_pin.sym} 153410 -18650 0 0 {name=p152674 lab=_84659_/D }
C {devices/lab_pin.sym} 153590 -18670 0 1 {name=p152675 lab=_84659_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -18660 0 0 {name=X_84659_ }
C {devices/lab_pin.sym} 153440 -18540 0 0 {name=p152676 lab=_77200_/A }
C {devices/lab_pin.sym} 153440 -18500 0 0 {name=p152677 lab=_82302_/D }
C {devices/lab_pin.sym} 153560 -18520 0 1 {name=p152678 lab=_77200_/X }
C {sky130_stdcells/xor2_4.sym} 153500 -18520 0 0 {name=X_77200_ }
C {devices/lab_pin.sym} 153460 -18390 0 0 {name=p152679 lab=_72001_/A }
C {devices/lab_pin.sym} 153540 -18390 0 1 {name=p152680 lab=_74412_/X }
C {sky130_stdcells/buf_2.sym} 153500 -18390 0 0 {name=X_74412_ }
C {devices/lab_pin.sym} 153440 -18280 0 0 {name=p152681 lab=_82873_/Q }
C {devices/lab_pin.sym} 153440 -18240 0 0 {name=p152682 lab=_40779_/B }
C {devices/lab_pin.sym} 153560 -18260 0 1 {name=p152683 lab=_40804_/X }
C {sky130_stdcells/or2_4.sym} 153500 -18260 0 0 {name=X_40804_ }
C {devices/lab_pin.sym} 153460 -18130 0 0 {name=p152684 lab=_59345_/X }
C {devices/lab_pin.sym} 153540 -18130 0 1 {name=p152685 lab=_59346_/X }
C {sky130_stdcells/buf_2.sym} 153500 -18130 0 0 {name=X_59346_ }
C {devices/lab_pin.sym} 153460 -18010 0 0 {name=p152686 lab=_47360_/A }
C {devices/lab_pin.sym} 153540 -18010 0 1 {name=p152687 lab=_53005_/B }
C {sky130_stdcells/buf_2.sym} 153500 -18010 0 0 {name=X_47360_ }
C {devices/lab_pin.sym} 153440 -17900 0 0 {name=p152688 lab=_71528_/X }
C {devices/lab_pin.sym} 153440 -17860 0 0 {name=p152689 lab=_71446_/X }
C {devices/lab_pin.sym} 153560 -17880 0 1 {name=p152690 lab=_71628_/A }
C {sky130_stdcells/nor2_4.sym} 153500 -17880 0 0 {name=X_71624_ }
C {devices/lab_pin.sym} 153440 -17760 0 0 {name=p152691 lab=_78176_/Y }
C {devices/lab_pin.sym} 153440 -17720 0 0 {name=p152692 lab=_78179_/X }
C {devices/lab_pin.sym} 153560 -17740 0 1 {name=p152693 lab=_78192_/A }
C {sky130_stdcells/nand2_4.sym} 153500 -17740 0 0 {name=X_78180_ }
C {devices/lab_pin.sym} 153460 -17610 0 0 {name=p152694 lab=_44571_/Y }
C {devices/lab_pin.sym} 153540 -17610 0 1 {name=p152695 lab=_44572_/Y }
C {sky130_stdcells/inv_2.sym} 153500 -17610 0 0 {name=X_44572_ }
C {devices/lab_pin.sym} 153460 -17490 0 0 {name=p152696 lab=_56557_/X }
C {devices/lab_pin.sym} 153540 -17490 0 1 {name=p152697 lab=_56558_/X }
C {sky130_stdcells/buf_2.sym} 153500 -17490 0 0 {name=X_56558_ }
C {devices/lab_pin.sym} 153460 -17370 0 0 {name=p152698 lab=_75392_/A }
C {devices/lab_pin.sym} 153540 -17370 0 1 {name=p152699 lab=_75396_/A }
C {sky130_stdcells/inv_2.sym} 153500 -17370 0 0 {name=X_75392_ }
C {devices/lab_pin.sym} 153410 -17250 0 0 {name=p152700 lab=_87995_/CLK }
C {devices/lab_pin.sym} 153410 -17230 0 0 {name=p152701 lab=_87378_/D }
C {devices/lab_pin.sym} 153590 -17250 0 1 {name=p152702 lab=_87378_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -17240 0 0 {name=X_87378_ }
C {devices/lab_pin.sym} 153440 -17120 0 0 {name=p152703 lab=_40414_/X }
C {devices/lab_pin.sym} 153440 -17080 0 0 {name=p152704 lab=_41784_/B }
C {devices/lab_pin.sym} 153560 -17100 0 1 {name=p152705 lab=_41784_/X }
C {sky130_stdcells/or2_4.sym} 153500 -17100 0 0 {name=X_41784_ }
C {devices/lab_pin.sym} 153440 -16990 0 0 {name=p152706 lab=_51256_/A }
C {devices/lab_pin.sym} 153440 -16950 0 0 {name=p152707 lab=_46428_/B }
C {devices/lab_pin.sym} 153440 -16910 0 0 {name=p152708 lab=_46428_/C }
C {devices/lab_pin.sym} 153560 -16950 0 1 {name=p152709 lab=_46311_/X }
C {sky130_stdcells/and3_4.sym} 153500 -16950 0 0 {name=X_46311_ }
C {devices/lab_pin.sym} 153440 -16820 0 0 {name=p152710 lab=_77141_/A }
C {devices/lab_pin.sym} 153440 -16780 0 0 {name=p152711 lab=_77142_/A }
C {devices/lab_pin.sym} 153560 -16800 0 1 {name=p152712 lab=_77132_/B }
C {sky130_stdcells/xor2_4.sym} 153500 -16800 0 0 {name=X_77131_ }
C {devices/lab_pin.sym} 153460 -16670 0 0 {name=p152713 lab=_43425_/X }
C {devices/lab_pin.sym} 153540 -16670 0 1 {name=p152714 lab=_43523_/X }
C {sky130_stdcells/buf_2.sym} 153500 -16670 0 0 {name=X_43523_ }
C {devices/lab_pin.sym} 153420 -16580 0 0 {name=p152715 lab=_45572_/A }
C {devices/lab_pin.sym} 153420 -16540 0 0 {name=p152716 lab=_55505_/X }
C {devices/lab_pin.sym} 153420 -16500 0 0 {name=p152717 lab=_55506_/X }
C {devices/lab_pin.sym} 153420 -16460 0 0 {name=p152718 lab=_55508_/Y }
C {devices/lab_pin.sym} 153580 -16520 0 1 {name=p152719 lab=_55509_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -16520 0 0 {name=X_55509_ }
C {devices/lab_pin.sym} 153410 -16370 0 0 {name=p152720 lab=_86647_/CLK }
C {devices/lab_pin.sym} 153410 -16350 0 0 {name=p152721 lab=_86329_/D }
C {devices/lab_pin.sym} 153590 -16370 0 1 {name=p152722 lab=_86329_/Q }
C {sky130_stdcells/dfxtp_4.sym} 153500 -16360 0 0 {name=X_86329_ }
C {devices/lab_pin.sym} 153440 -16250 0 0 {name=p152723 lab=_74351_/A }
C {devices/lab_pin.sym} 153440 -16210 0 0 {name=p152724 lab=_74342_/X }
C {devices/lab_pin.sym} 153440 -16170 0 0 {name=p152725 lab=_55801_/C }
C {devices/lab_pin.sym} 153560 -16210 0 1 {name=p152726 lab=_74343_/Y }
C {sky130_stdcells/nand3_4.sym} 153500 -16210 0 0 {name=X_74343_ }
C {devices/lab_pin.sym} 153420 -16100 0 0 {name=p152727 lab=_40734_/X }
C {devices/lab_pin.sym} 153420 -16060 0 0 {name=p152728 lab=_40719_/X }
C {devices/lab_pin.sym} 153420 -16020 0 0 {name=p152729 lab=_69004_/B }
C {devices/lab_pin.sym} 153420 -15980 0 0 {name=p152730 lab=_40720_/X }
C {devices/lab_pin.sym} 153580 -16040 0 1 {name=p152731 lab=_40735_/X }
C {sky130_stdcells/a2bb2o_4.sym} 153500 -16040 0 0 {name=X_40735_ }
C {devices/lab_pin.sym} 153420 -15910 0 0 {name=p152732 lab=_86650_/Q }
C {devices/lab_pin.sym} 153420 -15870 0 0 {name=p152733 lab=_47286_/X }
C {devices/lab_pin.sym} 153420 -15830 0 0 {name=p152734 lab=_47290_/Y }
C {devices/lab_pin.sym} 153580 -15870 0 1 {name=p152735 lab=_47291_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -15870 0 0 {name=X_47291_ }
C {devices/lab_pin.sym} 153420 -15750 0 0 {name=p152736 lab=_59177_/X }
C {devices/lab_pin.sym} 153420 -15710 0 0 {name=p152737 lab=_86059_/Q }
C {devices/lab_pin.sym} 153420 -15670 0 0 {name=p152738 lab=_59276_/X }
C {devices/lab_pin.sym} 153580 -15710 0 1 {name=p152739 lab=_59277_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -15710 0 0 {name=X_59277_ }
C {devices/lab_pin.sym} 153440 -15580 0 0 {name=p152740 lab=_71602_/C }
C {devices/lab_pin.sym} 153440 -15540 0 0 {name=p152741 lab=_71164_/B }
C {devices/lab_pin.sym} 153560 -15560 0 1 {name=p152742 lab=_71556_/A }
C {sky130_stdcells/nor2_4.sym} 153500 -15560 0 0 {name=X_71555_ }
C {devices/lab_pin.sym} 153420 -15450 0 0 {name=p152743 lab=_56462_/X }
C {devices/lab_pin.sym} 153420 -15410 0 0 {name=p152744 lab=_56049_/Y }
C {devices/lab_pin.sym} 153420 -15370 0 0 {name=p152745 lab=_56488_/Y }
C {devices/lab_pin.sym} 153580 -15410 0 1 {name=p152746 lab=_85177_/D }
C {sky130_stdcells/o21ai_4.sym} 153500 -15410 0 0 {name=X_56489_ }
C {devices/lab_pin.sym} 153420 -15290 0 0 {name=p152747 lab=_49018_/X }
C {devices/lab_pin.sym} 153420 -15250 0 0 {name=p152748 lab=_48520_/A }
C {devices/lab_pin.sym} 153420 -15210 0 0 {name=p152749 lab=_49029_/Y }
C {devices/lab_pin.sym} 153580 -15250 0 1 {name=p152750 lab=_49031_/A }
C {sky130_stdcells/a21o_4.sym} 153500 -15250 0 0 {name=X_49030_ }
C {devices/lab_pin.sym} 153460 -15110 0 0 {name=p152751 lab=_46242_/A }
C {devices/lab_pin.sym} 153540 -15110 0 1 {name=p152752 lab=_46242_/Y }
C {sky130_stdcells/inv_2.sym} 153500 -15110 0 0 {name=X_46242_ }
C {sky130_stdcells/decap_3.sym} 153500 -14960 0 0 {name=XPHY_540 }
C {devices/lab_pin.sym} 153460 -14810 0 0 {name=p152753 lab=_70506_/A }
C {devices/lab_pin.sym} 153540 -14810 0 1 {name=p152754 lab=_71170_/A }
C {sky130_stdcells/buf_2.sym} 153500 -14810 0 0 {name=X_70506_ }
C {devices/lab_pin.sym} 153460 -14690 0 0 {name=p152755 lab=_63400_/B }
C {devices/lab_pin.sym} 153540 -14690 0 1 {name=p152756 lab=_58228_/X }
C {sky130_stdcells/buf_2.sym} 153500 -14690 0 0 {name=X_58228_ }
C {devices/lab_pin.sym} 153440 -14580 0 0 {name=p152757 lab=_77050_/A }
C {devices/lab_pin.sym} 153440 -14540 0 0 {name=p152758 lab=_81906_/Q }
C {devices/lab_pin.sym} 153560 -14560 0 1 {name=p152759 lab=_77062_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -14560 0 0 {name=X_77062_ }
C {devices/lab_pin.sym} 153460 -14430 0 0 {name=p152760 lab=_43454_/A }
C {devices/lab_pin.sym} 153540 -14430 0 1 {name=p152761 lab=_43454_/Y }
C {sky130_stdcells/inv_2.sym} 153500 -14430 0 0 {name=X_43454_ }
C {devices/lab_pin.sym} 153420 -14340 0 0 {name=p152762 lab=_74016_/X }
C {devices/lab_pin.sym} 153420 -14300 0 0 {name=p152763 lab=_85602_/Q }
C {devices/lab_pin.sym} 153420 -14260 0 0 {name=p152764 lab=_56933_/X }
C {devices/lab_pin.sym} 153420 -14220 0 0 {name=p152765 lab=_74273_/X }
C {devices/lab_pin.sym} 153580 -14280 0 1 {name=p152766 lab=_74274_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -14280 0 0 {name=X_74274_ }
C {sky130_stdcells/decap_3.sym} 153500 -14100 0 0 {name=XPHY_551 }
C {devices/lab_pin.sym} 153420 -13970 0 0 {name=p152767 lab=_40601_/X }
C {devices/lab_pin.sym} 153420 -13930 0 0 {name=p152768 lab=_81139_/Q }
C {devices/lab_pin.sym} 153420 -13890 0 0 {name=p152769 lab=_40665_/X }
C {devices/lab_pin.sym} 153580 -13930 0 1 {name=p152770 lab=_40667_/A }
C {sky130_stdcells/o21a_4.sym} 153500 -13930 0 0 {name=X_40666_ }
C {devices/lab_pin.sym} 153460 -13790 0 0 {name=p152771 lab=_71486_/A }
C {devices/lab_pin.sym} 153540 -13790 0 1 {name=p152772 lab=_71487_/A }
C {sky130_stdcells/inv_2.sym} 153500 -13790 0 0 {name=X_71486_ }
C {sky130_stdcells/decap_3.sym} 153500 -13640 0 0 {name=XPHY_562 }
C {sky130_stdcells/decap_3.sym} 153500 -13460 0 0 {name=XPHY_573 }
C {devices/lab_pin.sym} 153440 -13320 0 0 {name=p152773 lab=_81710_/D }
C {devices/lab_pin.sym} 153440 -13280 0 0 {name=p152774 lab=_76013_/B }
C {devices/lab_pin.sym} 153560 -13300 0 1 {name=p152775 lab=_76013_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -13300 0 0 {name=X_76013_ }
C {devices/lab_pin.sym} 153460 -13170 0 0 {name=p152776 lab=_42405_/A }
C {devices/lab_pin.sym} 153540 -13170 0 1 {name=p152777 lab=_42405_/Y }
C {sky130_stdcells/inv_2.sym} 153500 -13170 0 0 {name=X_42405_ }
C {sky130_stdcells/decap_3.sym} 153500 -13020 0 0 {name=XPHY_584 }
C {devices/lab_pin.sym} 153440 -12880 0 0 {name=p152778 lab=_73225_/A }
C {devices/lab_pin.sym} 153440 -12840 0 0 {name=p152779 lab=_73196_/B }
C {devices/lab_pin.sym} 153560 -12860 0 1 {name=p152780 lab=_73225_/Y }
C {sky130_stdcells/nor2_4.sym} 153500 -12860 0 0 {name=X_73225_ }
C {devices/lab_pin.sym} 153460 -12730 0 0 {name=p152781 lab=_70994_/A }
C {devices/lab_pin.sym} 153540 -12730 0 1 {name=p152782 lab=_70947_/B }
C {sky130_stdcells/buf_2.sym} 153500 -12730 0 0 {name=X_70437_ }
C {devices/lab_pin.sym} 153460 -12610 0 0 {name=p152783 lab=_45904_/X }
C {devices/lab_pin.sym} 153540 -12610 0 1 {name=p152784 lab=_46173_/X }
C {sky130_stdcells/buf_2.sym} 153500 -12610 0 0 {name=X_46173_ }
C {devices/lab_pin.sym} 153460 -12490 0 0 {name=p152785 lab=_63044_/A }
C {devices/lab_pin.sym} 153540 -12490 0 1 {name=p152786 lab=_61368_/A }
C {sky130_stdcells/buf_2.sym} 153500 -12490 0 0 {name=X_58159_ }
C {sky130_stdcells/decap_3.sym} 153500 -12340 0 0 {name=XPHY_595 }
C {devices/lab_pin.sym} 153420 -12220 0 0 {name=p152787 lab=_41433_/X }
C {devices/lab_pin.sym} 153420 -12180 0 0 {name=p152788 lab=_43371_/X }
C {devices/lab_pin.sym} 153420 -12140 0 0 {name=p152789 lab=_87448_/Q }
C {devices/lab_pin.sym} 153420 -12100 0 0 {name=p152790 lab=_43372_/X }
C {devices/lab_pin.sym} 153580 -12160 0 1 {name=p152791 lab=_43385_/X }
C {sky130_stdcells/a2bb2o_4.sym} 153500 -12160 0 0 {name=X_43385_ }
C {devices/lab_pin.sym} 153460 -12010 0 0 {name=p152792 lab=_40565_/Y }
C {devices/lab_pin.sym} 153540 -12010 0 1 {name=p152793 lab=_40755_/A }
C {sky130_stdcells/buf_2.sym} 153500 -12010 0 0 {name=X_40597_ }
C {devices/lab_pin.sym} 153440 -11900 0 0 {name=p152794 lab=_45124_/A }
C {devices/lab_pin.sym} 153440 -11860 0 0 {name=p152795 lab=_45182_/B }
C {devices/lab_pin.sym} 153560 -11880 0 1 {name=p152796 lab=_45124_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -11880 0 0 {name=X_45124_ }
C {devices/lab_pin.sym} 153420 -11790 0 0 {name=p152797 lab=_42330_/X }
C {devices/lab_pin.sym} 153420 -11750 0 0 {name=p152798 lab=_42319_/X }
C {devices/lab_pin.sym} 153420 -11710 0 0 {name=p152799 lab=_41676_/X }
C {devices/lab_pin.sym} 153420 -11670 0 0 {name=p152800 lab=_87915_/Q }
C {devices/lab_pin.sym} 153420 -11630 0 0 {name=p152801 lab=_42320_/X }
C {devices/lab_pin.sym} 153580 -11710 0 1 {name=p152802 lab=_42337_/A }
C {sky130_stdcells/o32ai_4.sym} 153500 -11710 0 0 {name=X_42336_ }
C {devices/lab_pin.sym} 153420 -11570 0 0 {name=p152803 lab=_61117_/X }
C {devices/lab_pin.sym} 153420 -11530 0 0 {name=p152804 lab=_61169_/X }
C {devices/lab_pin.sym} 153420 -11490 0 0 {name=p152805 lab=_59512_/X }
C {devices/lab_pin.sym} 153580 -11530 0 1 {name=p152806 lab=_61170_/Y }
C {sky130_stdcells/a21oi_4.sym} 153500 -11530 0 0 {name=X_61170_ }
C {devices/lab_pin.sym} 153440 -11400 0 0 {name=p152807 lab=_73156_/A }
C {devices/lab_pin.sym} 153440 -11360 0 0 {name=p152808 lab=_73155_/X }
C {devices/lab_pin.sym} 153560 -11380 0 1 {name=p152809 lab=_73156_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -11380 0 0 {name=X_73156_ }
C {devices/lab_pin.sym} 153460 -11250 0 0 {name=p152810 lab=_70984_/A }
C {devices/lab_pin.sym} 153540 -11250 0 1 {name=p152811 lab=_70368_/X }
C {sky130_stdcells/buf_2.sym} 153500 -11250 0 0 {name=X_70368_ }
C {devices/lab_pin.sym} 153460 -11130 0 0 {name=p152812 lab=_57689_/A }
C {devices/lab_pin.sym} 153540 -11130 0 1 {name=p152813 lab=_60267_/A }
C {sky130_stdcells/buf_2.sym} 153500 -11130 0 0 {name=X_60121_ }
C {devices/lab_pin.sym} 153460 -11010 0 0 {name=p152814 lab=_72083_/A }
C {devices/lab_pin.sym} 153540 -11010 0 1 {name=p152815 lab=_72107_/X }
C {sky130_stdcells/buf_2.sym} 153500 -11010 0 0 {name=X_72107_ }
C {devices/lab_pin.sym} 153440 -10920 0 0 {name=p152816 lab=_49925_/X }
C {devices/lab_pin.sym} 153440 -10880 0 0 {name=p152817 lab=_49915_/X }
C {devices/lab_pin.sym} 153440 -10840 0 0 {name=p152818 lab=_49953_/C }
C {devices/lab_pin.sym} 153440 -10800 0 0 {name=p152819 lab=_53144_/D }
C {devices/lab_pin.sym} 153560 -10860 0 1 {name=p152820 lab=_49932_/X }
C {sky130_stdcells/and4_4.sym} 153500 -10860 0 0 {name=X_49932_ }
C {devices/lab_pin.sym} 153420 -10730 0 0 {name=p152821 lab=_45043_/X }
C {devices/lab_pin.sym} 153420 -10690 0 0 {name=p152822 lab=_45050_/Y }
C {devices/lab_pin.sym} 153420 -10650 0 0 {name=p152823 lab=_45054_/Y }
C {devices/lab_pin.sym} 153580 -10690 0 1 {name=p152824 lab=_45055_/Y }
C {sky130_stdcells/a21oi_4.sym} 153500 -10690 0 0 {name=X_45055_ }
C {devices/lab_pin.sym} 153460 -10550 0 0 {name=p152825 lab=_42266_/Y }
C {devices/lab_pin.sym} 153540 -10550 0 1 {name=p152826 lab=_87949_/D }
C {sky130_stdcells/inv_2.sym} 153500 -10550 0 0 {name=X_42267_ }
C {devices/lab_pin.sym} 153440 -10440 0 0 {name=p152827 lab=_77964_/A }
C {devices/lab_pin.sym} 153440 -10400 0 0 {name=p152828 lab=_81948_/D }
C {devices/lab_pin.sym} 153560 -10420 0 1 {name=p152829 lab=_77965_/A }
C {sky130_stdcells/xor2_4.sym} 153500 -10420 0 0 {name=X_77964_ }
C {devices/lab_pin.sym} 153460 -10290 0 0 {name=p152830 lab=_73704_/A }
C {devices/lab_pin.sym} 153540 -10290 0 1 {name=p152831 lab=_73087_/X }
C {sky130_stdcells/buf_2.sym} 153500 -10290 0 0 {name=X_73087_ }
C {devices/lab_pin.sym} 153440 -10200 0 0 {name=p152832 lab=_70296_/X }
C {devices/lab_pin.sym} 153440 -10160 0 0 {name=p152833 lab=_70297_/X }
C {devices/lab_pin.sym} 153440 -10120 0 0 {name=p152834 lab=_83102_/Q }
C {devices/lab_pin.sym} 153440 -10080 0 0 {name=p152835 lab=_70301_/D }
C {devices/lab_pin.sym} 153560 -10140 0 1 {name=p152836 lab=_70299_/X }
C {sky130_stdcells/and4_4.sym} 153500 -10140 0 0 {name=X_70299_ }
C {devices/lab_pin.sym} 153460 -9990 0 0 {name=p152837 lab=_44005_/X }
C {devices/lab_pin.sym} 153540 -9990 0 1 {name=p152838 lab=_44006_/X }
C {sky130_stdcells/buf_2.sym} 153500 -9990 0 0 {name=X_44006_ }
C {devices/lab_pin.sym} 153460 -9870 0 0 {name=p152839 lab=_79702_/X }
C {devices/lab_pin.sym} 153540 -9870 0 1 {name=p152840 lab=_79703_/Y }
C {sky130_stdcells/inv_2.sym} 153500 -9870 0 0 {name=X_79703_ }
C {devices/lab_pin.sym} 153440 -9760 0 0 {name=p152841 lab=_41513_/A }
C {devices/lab_pin.sym} 153440 -9720 0 0 {name=p152842 lab=_40700_/A }
C {devices/lab_pin.sym} 153560 -9740 0 1 {name=p152843 lab=_41218_/X }
C {sky130_stdcells/or2_4.sym} 153500 -9740 0 0 {name=X_41218_ }
C {devices/lab_pin.sym} 153440 -9620 0 0 {name=p152844 lab=_72025_/A }
C {devices/lab_pin.sym} 153440 -9580 0 0 {name=p152845 lab=_53863_/A }
C {devices/lab_pin.sym} 153560 -9600 0 1 {name=p152846 lab=_72038_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -9600 0 0 {name=X_72038_ }
C {devices/lab_pin.sym} 153440 -9480 0 0 {name=p152847 lab=_76915_/A }
C {devices/lab_pin.sym} 153440 -9440 0 0 {name=p152848 lab=_81470_/D }
C {devices/lab_pin.sym} 153560 -9460 0 1 {name=p152849 lab=_81566_/D }
C {sky130_stdcells/xor2_4.sym} 153500 -9460 0 0 {name=X_76915_ }
C {devices/lab_pin.sym} 153420 -9370 0 0 {name=p152850 lab=_59971_/X }
C {devices/lab_pin.sym} 153420 -9330 0 0 {name=p152851 lab=_60049_/Y }
C {devices/lab_pin.sym} 153420 -9290 0 0 {name=p152852 lab=_60015_/Y }
C {devices/lab_pin.sym} 153420 -9250 0 0 {name=p152853 lab=_62203_/A }
C {devices/lab_pin.sym} 153420 -9220 0 0 {name=p152854 lab=_60051_/Y }
C {devices/lab_pin.sym} 153580 -9290 0 1 {name=p152855 lab=_84670_/D }
C {sky130_stdcells/a41oi_4.sym} 153500 -9290 0 0 {name=X_60052_ }
C {devices/lab_pin.sym} 153420 -9150 0 0 {name=p152856 lab=_49860_/Y }
C {devices/lab_pin.sym} 153420 -9110 0 0 {name=p152857 lab=_49844_/X }
C {devices/lab_pin.sym} 153420 -9070 0 0 {name=p152858 lab=_49862_/X }
C {devices/lab_pin.sym} 153580 -9110 0 1 {name=p152859 lab=_49863_/Y }
C {sky130_stdcells/a21oi_4.sym} 153500 -9110 0 0 {name=X_49863_ }
C {devices/lab_pin.sym} 153460 -8970 0 0 {name=p152860 lab=clkbuf_8_7_0_CLK/A }
C {devices/lab_pin.sym} 153540 -8970 0 1 {name=p152861 lab=clkbuf_8_7_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 153500 -8970 0 0 {name=Xclkbuf_8_7_0_CLK }
C {devices/lab_pin.sym} 153420 -8880 0 0 {name=p152862 lab=_41312_/X }
C {devices/lab_pin.sym} 153420 -8840 0 0 {name=p152863 lab=_42192_/X }
C {devices/lab_pin.sym} 153420 -8800 0 0 {name=p152864 lab=_87982_/Q }
C {devices/lab_pin.sym} 153420 -8760 0 0 {name=p152865 lab=_42193_/X }
C {devices/lab_pin.sym} 153580 -8820 0 1 {name=p152866 lab=_42198_/X }
C {sky130_stdcells/a2bb2o_4.sym} 153500 -8820 0 0 {name=X_42198_ }
C {devices/lab_pin.sym} 153420 -8690 0 0 {name=p152867 lab=_77884_/A }
C {devices/lab_pin.sym} 153420 -8650 0 0 {name=p152868 lab=_77883_/Y }
C {devices/lab_pin.sym} 153420 -8610 0 0 {name=p152869 lab=_77894_/X }
C {devices/lab_pin.sym} 153580 -8650 0 1 {name=p152870 lab=_77895_/Y }
C {sky130_stdcells/a21oi_4.sym} 153500 -8650 0 0 {name=X_77895_ }
C {devices/lab_pin.sym} 153440 -8530 0 0 {name=p152871 lab=_52199_/A }
C {devices/lab_pin.sym} 153440 -8490 0 0 {name=p152872 lab=_48829_/B }
C {devices/lab_pin.sym} 153440 -8450 0 0 {name=p152873 lab=_48814_/C }
C {devices/lab_pin.sym} 153560 -8490 0 1 {name=p152874 lab=_48814_/X }
C {sky130_stdcells/and3_4.sym} 153500 -8490 0 0 {name=X_48814_ }
C {devices/lab_pin.sym} 153440 -8360 0 0 {name=p152875 lab=_84209_/Q }
C {devices/lab_pin.sym} 153440 -8320 0 0 {name=p152876 lab=_83257_/Q }
C {devices/lab_pin.sym} 153560 -8340 0 1 {name=p152877 lab=_79634_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -8340 0 0 {name=X_79634_ }
C {devices/lab_pin.sym} 153440 -8220 0 0 {name=p152878 lab=_41149_/A }
C {devices/lab_pin.sym} 153440 -8180 0 0 {name=p152879 lab=_41145_/B }
C {devices/lab_pin.sym} 153560 -8200 0 1 {name=p152880 lab=_41149_/X }
C {sky130_stdcells/or2_4.sym} 153500 -8200 0 0 {name=X_41149_ }
C {devices/lab_pin.sym} 153440 -8080 0 0 {name=p152881 lab=_64804_/A }
C {devices/lab_pin.sym} 153440 -8040 0 0 {name=p152882 lab=_64860_/B }
C {devices/lab_pin.sym} 153560 -8060 0 1 {name=p152883 lab=_64860_/X }
C {sky130_stdcells/and2_4.sym} 153500 -8060 0 0 {name=X_64860_ }
C {devices/lab_pin.sym} 153460 -7930 0 0 {name=p152884 lab=_81496_/Q }
C {devices/lab_pin.sym} 153540 -7930 0 1 {name=p152885 lab=_76846_/Y }
C {sky130_stdcells/inv_2.sym} 153500 -7930 0 0 {name=X_76846_ }
C {devices/lab_pin.sym} 153460 -7810 0 0 {name=p152886 lab=_52679_/A }
C {devices/lab_pin.sym} 153540 -7810 0 1 {name=p152887 lab=_49794_/X }
C {sky130_stdcells/buf_2.sym} 153500 -7810 0 0 {name=X_49794_ }
C {devices/lab_pin.sym} 153460 -7690 0 0 {name=p152888 lab=_60984_/A }
C {devices/lab_pin.sym} 153540 -7690 0 1 {name=p152889 lab=_63860_/D }
C {sky130_stdcells/buf_2.sym} 153500 -7690 0 0 {name=X_63811_ }
C {devices/lab_pin.sym} 153420 -7590 0 0 {name=p152890 lab=_48742_/Y }
C {devices/lab_pin.sym} 153420 -7550 0 0 {name=p152891 lab=_48734_/X }
C {devices/lab_pin.sym} 153420 -7510 0 0 {name=p152892 lab=_48744_/X }
C {devices/lab_pin.sym} 153580 -7550 0 1 {name=p152893 lab=_86491_/D }
C {sky130_stdcells/a21oi_4.sym} 153500 -7550 0 0 {name=X_48745_ }
C {devices/lab_pin.sym} 153460 -7410 0 0 {name=p152894 lab=_79564_/Y }
C {devices/lab_pin.sym} 153540 -7410 0 1 {name=p152895 lab=_79565_/Y }
C {sky130_stdcells/inv_2.sym} 153500 -7410 0 0 {name=X_79565_ }
C {devices/lab_pin.sym} 153460 -7290 0 0 {name=p152896 lab=_45957_/A }
C {devices/lab_pin.sym} 153540 -7290 0 1 {name=p152897 lab=_74831_/A }
C {sky130_stdcells/buf_2.sym} 153500 -7290 0 0 {name=X_45957_ }
C {devices/lab_pin.sym} 153420 -7190 0 0 {name=p152898 lab=_64787_/Y }
C {devices/lab_pin.sym} 153420 -7150 0 0 {name=p152899 lab=_64662_/X }
C {devices/lab_pin.sym} 153420 -7110 0 0 {name=p152900 lab=_64790_/X }
C {devices/lab_pin.sym} 153580 -7150 0 1 {name=p152901 lab=_84227_/D }
C {sky130_stdcells/a21o_4.sym} 153500 -7150 0 0 {name=X_64791_ }
C {devices/lab_pin.sym} 153460 -7010 0 0 {name=p152902 lab=_76766_/Y }
C {devices/lab_pin.sym} 153540 -7010 0 1 {name=p152903 lab=_81359_/D }
C {sky130_stdcells/inv_2.sym} 153500 -7010 0 0 {name=X_76777_ }
C {devices/lab_pin.sym} 153440 -6900 0 0 {name=p152904 lab=_73989_/A }
C {devices/lab_pin.sym} 153440 -6860 0 0 {name=p152905 lab=_73250_/A }
C {devices/lab_pin.sym} 153560 -6880 0 1 {name=p152906 lab=_73989_/Y }
C {sky130_stdcells/nor2_4.sym} 153500 -6880 0 0 {name=X_73989_ }
C {devices/lab_pin.sym} 153460 -6750 0 0 {name=p152907 lab=_66563_/A }
C {devices/lab_pin.sym} 153540 -6750 0 1 {name=p152908 lab=_69245_/A }
C {sky130_stdcells/buf_2.sym} 153500 -6750 0 0 {name=X_66530_ }
C {devices/lab_pin.sym} 153420 -6650 0 0 {name=p152909 lab=_78491_/X }
C {devices/lab_pin.sym} 153420 -6610 0 0 {name=p152910 lab=_78492_/Y }
C {devices/lab_pin.sym} 153420 -6570 0 0 {name=p152911 lab=_78486_/Y }
C {devices/lab_pin.sym} 153580 -6610 0 1 {name=p152912 lab=_78516_/Y }
C {sky130_stdcells/a21boi_4.sym} 153500 -6610 0 0 {name=X_78516_ }
C {devices/lab_pin.sym} 153420 -6490 0 0 {name=p152913 lab=_61298_/B }
C {devices/lab_pin.sym} 153420 -6450 0 0 {name=p152914 lab=_44905_/X }
C {devices/lab_pin.sym} 153420 -6410 0 0 {name=p152915 lab=_44907_/X }
C {devices/lab_pin.sym} 153580 -6450 0 1 {name=p152916 lab=_44908_/Y }
C {sky130_stdcells/o21ai_4.sym} 153500 -6450 0 0 {name=X_44908_ }
C {devices/lab_pin.sym} 153440 -6320 0 0 {name=p152917 lab=_61323_/A }
C {devices/lab_pin.sym} 153440 -6280 0 0 {name=p152918 lab=_63741_/X }
C {devices/lab_pin.sym} 153560 -6300 0 1 {name=p152919 lab=_63742_/Y }
C {sky130_stdcells/nor2_4.sym} 153500 -6300 0 0 {name=X_63742_ }
C {devices/lab_pin.sym} 153440 -6180 0 0 {name=p152920 lab=_75715_/A }
C {devices/lab_pin.sym} 153440 -6140 0 0 {name=p152921 lab=_75714_/Y }
C {devices/lab_pin.sym} 153560 -6160 0 1 {name=p152922 lab=_75728_/Y }
C {sky130_stdcells/nor2_4.sym} 153500 -6160 0 0 {name=X_75728_ }
C {devices/lab_pin.sym} 153440 -6040 0 0 {name=p152923 lab=_48676_/A }
C {devices/lab_pin.sym} 153440 -6000 0 0 {name=p152924 lab=_48632_/B }
C {devices/lab_pin.sym} 153560 -6020 0 1 {name=p152925 lab=_48676_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -6020 0 0 {name=X_48676_ }
C {devices/lab_pin.sym} 153460 -5890 0 0 {name=p152926 lab=_60901_/A }
C {devices/lab_pin.sym} 153540 -5890 0 1 {name=p152927 lab=_60954_/X }
C {sky130_stdcells/buf_2.sym} 153500 -5890 0 0 {name=X_60954_ }
C {devices/lab_pin.sym} 153440 -5780 0 0 {name=p152928 lab=_79474_/Y }
C {devices/lab_pin.sym} 153440 -5740 0 0 {name=p152929 lab=_79496_/B }
C {devices/lab_pin.sym} 153560 -5760 0 1 {name=p152930 lab=_79496_/X }
C {sky130_stdcells/or2_4.sym} 153500 -5760 0 0 {name=X_79496_ }
C {devices/lab_pin.sym} 153460 -5630 0 0 {name=p152931 lab=_45888_/A }
C {devices/lab_pin.sym} 153540 -5630 0 1 {name=p152932 lab=_58517_/A }
C {sky130_stdcells/buf_2.sym} 153500 -5630 0 0 {name=X_45888_ }
C {devices/lab_pin.sym} 153460 -5510 0 0 {name=p152933 lab=_81239_/Q }
C {devices/lab_pin.sym} 153540 -5510 0 1 {name=p152934 lab=_55013_/D }
C {sky130_stdcells/inv_2.sym} 153500 -5510 0 0 {name=X_47627_ }
C {devices/lab_pin.sym} 153420 -5410 0 0 {name=p152935 lab=_66457_/Y }
C {devices/lab_pin.sym} 153420 -5370 0 0 {name=p152936 lab=_64532_/X }
C {devices/lab_pin.sym} 153420 -5330 0 0 {name=p152937 lab=_66460_/X }
C {devices/lab_pin.sym} 153580 -5370 0 1 {name=p152938 lab=_84119_/D }
C {sky130_stdcells/o21ai_4.sym} 153500 -5370 0 0 {name=X_66461_ }
C {devices/lab_pin.sym} 153440 -5240 0 0 {name=p152939 lab=_82796_/Q }
C {devices/lab_pin.sym} 153440 -5200 0 0 {name=p152940 lab=_78447_/B }
C {devices/lab_pin.sym} 153560 -5220 0 1 {name=p152941 lab=_78466_/B }
C {sky130_stdcells/xnor2_4.sym} 153500 -5220 0 0 {name=X_78447_ }
C {devices/lab_pin.sym} 153460 -5090 0 0 {name=p152942 lab=_45964_/A }
C {devices/lab_pin.sym} 153540 -5090 0 1 {name=p152943 lab=_44839_/X }
C {sky130_stdcells/buf_2.sym} 153500 -5090 0 0 {name=X_44839_ }
C {devices/lab_pin.sym} 153420 -5000 0 0 {name=p152944 lab=_59433_/Y }
C {devices/lab_pin.sym} 153420 -4960 0 0 {name=p152945 lab=_63626_/X }
C {devices/lab_pin.sym} 153420 -4920 0 0 {name=p152946 lab=_61655_/A }
C {devices/lab_pin.sym} 153420 -4880 0 0 {name=p152947 lab=_63627_/X }
C {devices/lab_pin.sym} 153580 -4940 0 1 {name=p152948 lab=_63673_/X }
C {sky130_stdcells/a2bb2o_4.sym} 153500 -4940 0 0 {name=X_63673_ }
C {devices/lab_pin.sym} 153440 -4800 0 0 {name=p152949 lab=_75659_/A }
C {devices/lab_pin.sym} 153440 -4760 0 0 {name=p152950 lab=_75659_/B }
C {devices/lab_pin.sym} 153560 -4780 0 1 {name=p152951 lab=_75660_/B }
C {sky130_stdcells/and2_4.sym} 153500 -4780 0 0 {name=X_75659_ }
C {devices/lab_pin.sym} 153460 -4650 0 0 {name=p152952 lab=_60879_/D }
C {devices/lab_pin.sym} 153540 -4650 0 1 {name=p152953 lab=_60996_/B }
C {sky130_stdcells/buf_2.sym} 153500 -4650 0 0 {name=X_60885_ }
C {devices/lab_pin.sym} 153460 -4530 0 0 {name=p152954 lab=_68160_/A }
C {devices/lab_pin.sym} 153540 -4530 0 1 {name=p152955 lab=_68200_/X }
C {sky130_stdcells/buf_2.sym} 153500 -4530 0 0 {name=X_68200_ }
C {devices/lab_pin.sym} 153420 -4440 0 0 {name=p152956 lab=_65334_/X }
C {devices/lab_pin.sym} 153420 -4400 0 0 {name=p152957 lab=_86114_/Q }
C {devices/lab_pin.sym} 153420 -4360 0 0 {name=p152958 lab=_65256_/X }
C {devices/lab_pin.sym} 153420 -4320 0 0 {name=p152959 lab=_65411_/X }
C {devices/lab_pin.sym} 153580 -4380 0 1 {name=p152960 lab=_65412_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -4380 0 0 {name=X_65412_ }
C {devices/lab_pin.sym} 153420 -4270 0 0 {name=p152961 lab=_61682_/B }
C {devices/lab_pin.sym} 153420 -4230 0 0 {name=p152962 lab=_62548_/C }
C {devices/lab_pin.sym} 153420 -4190 0 0 {name=p152963 lab=_59987_/X }
C {devices/lab_pin.sym} 153420 -4150 0 0 {name=p152964 lab=_62548_/B }
C {devices/lab_pin.sym} 153420 -4120 0 0 {name=p152965 lab=_62623_/X }
C {devices/lab_pin.sym} 153580 -4190 0 1 {name=p152966 lab=_62624_/X }
C {sky130_stdcells/a41o_4.sym} 153500 -4190 0 0 {name=X_62624_ }
C {devices/lab_pin.sym} 153420 -4060 0 0 {name=p152967 lab=_87536_/Q }
C {devices/lab_pin.sym} 153420 -4020 0 0 {name=p152968 lab=_69044_/X }
C {devices/lab_pin.sym} 153420 -3980 0 0 {name=p152969 lab=_68979_/X }
C {devices/lab_pin.sym} 153420 -3940 0 0 {name=p152970 lab=_69179_/X }
C {devices/lab_pin.sym} 153580 -4000 0 1 {name=p152971 lab=_69180_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -4000 0 0 {name=X_69180_ }
C {devices/lab_pin.sym} 153460 -3850 0 0 {name=p152972 lab=_47558_/A }
C {devices/lab_pin.sym} 153540 -3850 0 1 {name=p152973 lab=_53118_/D }
C {sky130_stdcells/buf_2.sym} 153500 -3850 0 0 {name=X_47558_ }
C {devices/lab_pin.sym} 153440 -3750 0 0 {name=p152974 lab=_64782_/X }
C {devices/lab_pin.sym} 153440 -3710 0 0 {name=p152975 lab=_66417_/B }
C {devices/lab_pin.sym} 153440 -3670 0 0 {name=p152976 lab=_64785_/X }
C {devices/lab_pin.sym} 153560 -3710 0 1 {name=p152977 lab=_66392_/Y }
C {sky130_stdcells/nand3_4.sym} 153500 -3710 0 0 {name=X_66392_ }
C {devices/lab_pin.sym} 153440 -3590 0 0 {name=p152978 lab=_78378_/A }
C {devices/lab_pin.sym} 153440 -3550 0 0 {name=p152979 lab=_78374_/X }
C {devices/lab_pin.sym} 153440 -3510 0 0 {name=p152980 lab=_78375_/Y }
C {devices/lab_pin.sym} 153560 -3550 0 1 {name=p152981 lab=_78379_/A }
C {sky130_stdcells/nand3_4.sym} 153500 -3550 0 0 {name=X_78378_ }
C {devices/lab_pin.sym} 153420 -3440 0 0 {name=p152982 lab=_68097_/X }
C {devices/lab_pin.sym} 153420 -3400 0 0 {name=p152983 lab=_66815_/Y }
C {devices/lab_pin.sym} 153420 -3360 0 0 {name=p152984 lab=_68128_/X }
C {devices/lab_pin.sym} 153420 -3320 0 0 {name=p152985 lab=_68130_/Y }
C {devices/lab_pin.sym} 153580 -3380 0 1 {name=p152986 lab=_68131_/X }
C {sky130_stdcells/a211o_4.sym} 153500 -3380 0 0 {name=X_68131_ }
C {devices/lab_pin.sym} 153420 -3250 0 0 {name=p152987 lab=_46503_/Y }
C {devices/lab_pin.sym} 153420 -3210 0 0 {name=p152988 lab=_46445_/X }
C {devices/lab_pin.sym} 153420 -3170 0 0 {name=p152989 lab=_46508_/X }
C {devices/lab_pin.sym} 153580 -3210 0 1 {name=p152990 lab=_86731_/D }
C {sky130_stdcells/a21oi_4.sym} 153500 -3210 0 0 {name=X_46509_ }
C {devices/lab_pin.sym} 153440 -3080 0 0 {name=p152991 lab=_65289_/A }
C {devices/lab_pin.sym} 153440 -3040 0 0 {name=p152992 lab=_65343_/B }
C {devices/lab_pin.sym} 153560 -3060 0 1 {name=p152993 lab=_65343_/X }
C {sky130_stdcells/and2_4.sym} 153500 -3060 0 0 {name=X_65343_ }
C {devices/lab_pin.sym} 153440 -2950 0 0 {name=p152994 lab=_77328_/Y }
C {devices/lab_pin.sym} 153440 -2910 0 0 {name=p152995 lab=_82217_/Q }
C {devices/lab_pin.sym} 153440 -2870 0 0 {name=p152996 lab=_77325_/A }
C {devices/lab_pin.sym} 153560 -2910 0 1 {name=p152997 lab=_77329_/Y }
C {sky130_stdcells/nand3_4.sym} 153500 -2910 0 0 {name=X_77329_ }
C {devices/lab_pin.sym} 153420 -2790 0 0 {name=p152998 lab=_62550_/Y }
C {devices/lab_pin.sym} 153420 -2750 0 0 {name=p152999 lab=_62540_/X }
C {devices/lab_pin.sym} 153420 -2710 0 0 {name=p153000 lab=_62554_/Y }
C {devices/lab_pin.sym} 153580 -2750 0 1 {name=p153001 lab=_62555_/Y }
C {sky130_stdcells/a21oi_4.sym} 153500 -2750 0 0 {name=X_62555_ }
C {devices/lab_pin.sym} 153460 -2610 0 0 {name=p153002 lab=_47489_/A }
C {devices/lab_pin.sym} 153540 -2610 0 1 {name=p153003 lab=_47490_/A }
C {sky130_stdcells/inv_2.sym} 153500 -2610 0 0 {name=X_47489_ }
C {devices/lab_pin.sym} 153440 -2500 0 0 {name=p153004 lab=_49232_/A }
C {devices/lab_pin.sym} 153440 -2460 0 0 {name=p153005 lab=_46295_/X }
C {devices/lab_pin.sym} 153560 -2480 0 1 {name=p153006 lab=_49228_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -2480 0 0 {name=X_49228_ }
C {devices/lab_pin.sym} 153420 -2390 0 0 {name=p153007 lab=_61499_/Y }
C {devices/lab_pin.sym} 153420 -2350 0 0 {name=p153008 lab=_61501_/Y }
C {devices/lab_pin.sym} 153420 -2310 0 0 {name=p153009 lab=_61464_/X }
C {devices/lab_pin.sym} 153420 -2270 0 0 {name=p153010 lab=_61502_/Y }
C {devices/lab_pin.sym} 153420 -2240 0 0 {name=p153011 lab=_61505_/Y }
C {devices/lab_pin.sym} 153580 -2310 0 1 {name=p153012 lab=_61506_/X }
C {sky130_stdcells/a41o_4.sym} 153500 -2310 0 0 {name=X_61506_ }
C {devices/lab_pin.sym} 153460 -2150 0 0 {name=p153013 lab=_68129_/A }
C {devices/lab_pin.sym} 153540 -2150 0 1 {name=p153014 lab=_68062_/X }
C {sky130_stdcells/buf_2.sym} 153500 -2150 0 0 {name=X_68062_ }
C {devices/lab_pin.sym} 153460 -2030 0 0 {name=p153015 lab=_80339_/X }
C {devices/lab_pin.sym} 153540 -2030 0 1 {name=p153016 lab=_82246_/D }
C {sky130_stdcells/inv_2.sym} 153500 -2030 0 0 {name=X_80340_ }
C {devices/lab_pin.sym} 153460 -1910 0 0 {name=p153017 lab=_65877_/A }
C {devices/lab_pin.sym} 153540 -1910 0 1 {name=p153018 lab=_65403_/A }
C {sky130_stdcells/buf_2.sym} 153500 -1910 0 0 {name=X_65274_ }
C {devices/lab_pin.sym} 153420 -1810 0 0 {name=p153019 lab=_62481_/Y }
C {devices/lab_pin.sym} 153420 -1770 0 0 {name=p153020 lab=_62467_/X }
C {devices/lab_pin.sym} 153420 -1730 0 0 {name=p153021 lab=_62485_/Y }
C {devices/lab_pin.sym} 153580 -1770 0 1 {name=p153022 lab=_84407_/D }
C {sky130_stdcells/a21oi_4.sym} 153500 -1770 0 0 {name=X_62486_ }
C {devices/lab_pin.sym} 153460 -1630 0 0 {name=p153023 lab=_45943_/A }
C {devices/lab_pin.sym} 153540 -1630 0 1 {name=p153024 lab=_67013_/X }
C {sky130_stdcells/buf_2.sym} 153500 -1630 0 0 {name=X_67013_ }
C {devices/lab_pin.sym} 153440 -1530 0 0 {name=p153025 lab=_64248_/A }
C {devices/lab_pin.sym} 153440 -1490 0 0 {name=p153026 lab=_64225_/B }
C {devices/lab_pin.sym} 153440 -1450 0 0 {name=p153027 lab=_64225_/C }
C {devices/lab_pin.sym} 153560 -1490 0 1 {name=p153028 lab=_64225_/X }
C {sky130_stdcells/and3_4.sym} 153500 -1490 0 0 {name=X_64225_ }
C {devices/lab_pin.sym} 153440 -1360 0 0 {name=p153029 lab=_49156_/X }
C {devices/lab_pin.sym} 153440 -1320 0 0 {name=p153030 lab=_50188_/B }
C {devices/lab_pin.sym} 153560 -1340 0 1 {name=p153031 lab=_49159_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -1340 0 0 {name=X_49159_ }
C {devices/lab_pin.sym} 153440 -1230 0 0 {name=p153032 lab=_61437_/A }
C {devices/lab_pin.sym} 153440 -1190 0 0 {name=p153033 lab=_61437_/B }
C {devices/lab_pin.sym} 153440 -1150 0 0 {name=p153034 lab=_61398_/C }
C {devices/lab_pin.sym} 153560 -1190 0 1 {name=p153035 lab=_61437_/Y }
C {sky130_stdcells/nand3_4.sym} 153500 -1190 0 0 {name=X_61437_ }
C {devices/lab_pin.sym} 153440 -1060 0 0 {name=p153036 lab=_84746_/Q }
C {devices/lab_pin.sym} 153440 -1020 0 0 {name=p153037 lab=_84138_/Q }
C {devices/lab_pin.sym} 153560 -1040 0 1 {name=p153038 lab=_80271_/Y }
C {sky130_stdcells/nand2_4.sym} 153500 -1040 0 0 {name=X_80271_ }
C {devices/lab_pin.sym} 153410 -910 0 0 {name=p153039 lab=_82139_/CLK }
C {devices/lab_pin.sym} 153410 -890 0 0 {name=p153040 lab=_82042_/Q }
C {devices/lab_pin.sym} 153590 -910 0 1 {name=p153041 lab=_77170_/A }
C {sky130_stdcells/dfxtp_4.sym} 153500 -900 0 0 {name=X_82010_ }
C {devices/lab_pin.sym} 153460 -770 0 0 {name=p153042 lab=_52203_/A }
C {devices/lab_pin.sym} 153540 -770 0 1 {name=p153043 lab=_52170_/X }
C {sky130_stdcells/buf_2.sym} 153500 -770 0 0 {name=X_52170_ }
C {devices/lab_pin.sym} 154360 -42180 0 0 {name=p153044 lab=_58296_/A }
C {devices/lab_pin.sym} 154360 -42140 0 0 {name=p153045 lab=_64190_/B }
C {devices/lab_pin.sym} 154360 -42100 0 0 {name=p153046 lab=_64178_/C }
C {devices/lab_pin.sym} 154360 -42060 0 0 {name=p153047 lab=_64190_/D }
C {devices/lab_pin.sym} 154480 -42120 0 1 {name=p153048 lab=_64159_/B }
C {sky130_stdcells/nand4_4.sym} 154420 -42120 0 0 {name=X_64156_ }
C {devices/lab_pin.sym} 154360 -42000 0 0 {name=p153049 lab=_61368_/A }
C {devices/lab_pin.sym} 154360 -41960 0 0 {name=p153050 lab=_61368_/B }
C {devices/lab_pin.sym} 154360 -41920 0 0 {name=p153051 lab=_61368_/C }
C {devices/lab_pin.sym} 154360 -41880 0 0 {name=p153052 lab=_61368_/D }
C {devices/lab_pin.sym} 154480 -41940 0 1 {name=p153053 lab=_61368_/Y }
C {sky130_stdcells/nand4_4.sym} 154420 -41940 0 0 {name=X_61368_ }
C {devices/lab_pin.sym} 154360 -41820 0 0 {name=p153054 lab=_51115_/A }
C {devices/lab_pin.sym} 154360 -41780 0 0 {name=p153055 lab=_51121_/B }
C {devices/lab_pin.sym} 154360 -41740 0 0 {name=p153056 lab=_51115_/C }
C {devices/lab_pin.sym} 154360 -41700 0 0 {name=p153057 lab=_52811_/D }
C {devices/lab_pin.sym} 154480 -41760 0 1 {name=p153058 lab=_51121_/X }
C {sky130_stdcells/and4_4.sym} 154420 -41760 0 0 {name=X_51121_ }
C {devices/lab_pin.sym} 154380 -41610 0 0 {name=p153059 lab=_60466_/X }
C {devices/lab_pin.sym} 154460 -41610 0 1 {name=p153060 lab=_63108_/C }
C {sky130_stdcells/buf_2.sym} 154420 -41610 0 0 {name=X_63107_ }
C {devices/lab_pin.sym} 154380 -41490 0 0 {name=p153061 lab=_60525_/A }
C {devices/lab_pin.sym} 154460 -41490 0 1 {name=p153062 lab=_60319_/X }
C {sky130_stdcells/buf_2.sym} 154420 -41490 0 0 {name=X_60319_ }
C {devices/lab_pin.sym} 154340 -41390 0 0 {name=p153063 lab=_68961_/X }
C {devices/lab_pin.sym} 154340 -41350 0 0 {name=p153064 lab=_68963_/X }
C {devices/lab_pin.sym} 154340 -41310 0 0 {name=p153065 lab=_68846_/X }
C {devices/lab_pin.sym} 154500 -41350 0 1 {name=p153066 lab=_68964_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -41350 0 0 {name=X_68964_ }
C {devices/lab_pin.sym} 154380 -41210 0 0 {name=p153067 lab=_64508_/A }
C {devices/lab_pin.sym} 154460 -41210 0 1 {name=p153068 lab=_64087_/X }
C {sky130_stdcells/buf_2.sym} 154420 -41210 0 0 {name=X_64087_ }
C {devices/lab_pin.sym} 154380 -41090 0 0 {name=p153069 lab=_61290_/X }
C {devices/lab_pin.sym} 154460 -41090 0 1 {name=p153070 lab=_61355_/A }
C {sky130_stdcells/buf_2.sym} 154420 -41090 0 0 {name=X_61299_ }
C {devices/lab_pin.sym} 154340 -40990 0 0 {name=p153071 lab=_51050_/Y }
C {devices/lab_pin.sym} 154340 -40950 0 0 {name=p153072 lab=_51039_/X }
C {devices/lab_pin.sym} 154340 -40910 0 0 {name=p153073 lab=_51051_/X }
C {devices/lab_pin.sym} 154500 -40950 0 1 {name=p153074 lab=_51052_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -40950 0 0 {name=X_51052_ }
C {devices/lab_pin.sym} 154360 -40820 0 0 {name=p153075 lab=_67914_/X }
C {devices/lab_pin.sym} 154360 -40780 0 0 {name=p153076 lab=_67915_/B }
C {devices/lab_pin.sym} 154480 -40800 0 1 {name=p153077 lab=_67915_/X }
C {sky130_stdcells/and2_4.sym} 154420 -40800 0 0 {name=X_67915_ }
C {devices/lab_pin.sym} 154360 -40700 0 0 {name=p153078 lab=_63038_/A }
C {devices/lab_pin.sym} 154360 -40660 0 0 {name=p153079 lab=_64246_/B }
C {devices/lab_pin.sym} 154360 -40620 0 0 {name=p153080 lab=_63347_/C }
C {devices/lab_pin.sym} 154360 -40580 0 0 {name=p153081 lab=_60541_/B }
C {devices/lab_pin.sym} 154480 -40640 0 1 {name=p153082 lab=_63038_/X }
C {sky130_stdcells/and4_4.sym} 154420 -40640 0 0 {name=X_63038_ }
C {devices/lab_pin.sym} 154330 -40490 0 0 {name=p153083 lab=_83967_/CLK }
C {devices/lab_pin.sym} 154330 -40470 0 0 {name=p153084 lab=_83961_/D }
C {devices/lab_pin.sym} 154510 -40490 0 1 {name=p153085 lab=_83961_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -40480 0 0 {name=X_83961_ }
C {devices/lab_pin.sym} 154380 -40350 0 0 {name=p153086 lab=_69007_/A }
C {devices/lab_pin.sym} 154460 -40350 0 1 {name=p153087 lab=_68895_/X }
C {sky130_stdcells/buf_2.sym} 154420 -40350 0 0 {name=X_68895_ }
C {devices/lab_pin.sym} 154380 -40230 0 0 {name=p153088 lab=_40595_/X }
C {devices/lab_pin.sym} 154460 -40230 0 1 {name=p153089 lab=_50003_/X }
C {sky130_stdcells/buf_2.sym} 154420 -40230 0 0 {name=X_50003_ }
C {devices/lab_pin.sym} 154330 -40110 0 0 {name=p153090 lab=_85700_/CLK }
C {devices/lab_pin.sym} 154330 -40090 0 0 {name=p153091 lab=_85700_/D }
C {devices/lab_pin.sym} 154510 -40110 0 1 {name=p153092 lab=_85700_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -40100 0 0 {name=X_85700_ }
C {devices/lab_pin.sym} 154330 -39970 0 0 {name=p153093 lab=_87416_/CLK }
C {devices/lab_pin.sym} 154330 -39950 0 0 {name=p153094 lab=_78299_/B }
C {devices/lab_pin.sym} 154510 -39970 0 1 {name=p153095 lab=_82912_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -39960 0 0 {name=X_82912_ }
C {devices/lab_pin.sym} 154360 -39840 0 0 {name=p153096 lab=_55477_/A }
C {devices/lab_pin.sym} 154360 -39800 0 0 {name=p153097 lab=_56080_/C }
C {devices/lab_pin.sym} 154480 -39820 0 1 {name=p153098 lab=_55860_/X }
C {sky130_stdcells/and2_4.sym} 154420 -39820 0 0 {name=X_55860_ }
C {devices/lab_pin.sym} 154340 -39720 0 0 {name=p153099 lab=_87454_/Q }
C {devices/lab_pin.sym} 154340 -39680 0 0 {name=p153100 lab=_67751_/X }
C {devices/lab_pin.sym} 154340 -39640 0 0 {name=p153101 lab=_67821_/X }
C {devices/lab_pin.sym} 154340 -39600 0 0 {name=p153102 lab=_67845_/X }
C {devices/lab_pin.sym} 154500 -39660 0 1 {name=p153103 lab=_67846_/X }
C {sky130_stdcells/a211o_4.sym} 154420 -39660 0 0 {name=X_67846_ }
C {devices/lab_pin.sym} 154330 -39510 0 0 {name=p153104 lab=_86361_/CLK }
C {devices/lab_pin.sym} 154330 -39490 0 0 {name=p153105 lab=_86680_/D }
C {devices/lab_pin.sym} 154510 -39510 0 1 {name=p153106 lab=_86680_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -39500 0 0 {name=X_86680_ }
C {devices/lab_pin.sym} 154330 -39370 0 0 {name=p153107 lab=_87345_/CLK }
C {devices/lab_pin.sym} 154330 -39350 0 0 {name=p153108 lab=_83892_/D }
C {devices/lab_pin.sym} 154510 -39370 0 1 {name=p153109 lab=_81964_/D }
C {sky130_stdcells/dfxtp_4.sym} 154420 -39360 0 0 {name=X_83892_ }
C {devices/lab_pin.sym} 154340 -39250 0 0 {name=p153110 lab=_54806_/Y }
C {devices/lab_pin.sym} 154340 -39210 0 0 {name=p153111 lab=_54802_/X }
C {devices/lab_pin.sym} 154340 -39170 0 0 {name=p153112 lab=_54810_/X }
C {devices/lab_pin.sym} 154500 -39210 0 1 {name=p153113 lab=_54811_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -39210 0 0 {name=X_54811_ }
C {devices/lab_pin.sym} 154330 -39070 0 0 {name=p153114 lab=_86592_/CLK }
C {devices/lab_pin.sym} 154330 -39050 0 0 {name=p153115 lab=_53463_/Y }
C {devices/lab_pin.sym} 154510 -39070 0 1 {name=p153116 lab=_85631_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -39060 0 0 {name=X_85631_ }
C {devices/lab_pin.sym} 154330 -38930 0 0 {name=p153117 lab=_82748_/CLK }
C {devices/lab_pin.sym} 154330 -38910 0 0 {name=p153118 lab=_82843_/D }
C {devices/lab_pin.sym} 154510 -38930 0 1 {name=p153119 lab=_82843_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -38920 0 0 {name=X_82843_ }
C {devices/lab_pin.sym} 154380 -38790 0 0 {name=p153120 lab=_55790_/X }
C {devices/lab_pin.sym} 154460 -38790 0 1 {name=p153121 lab=_55801_/C }
C {sky130_stdcells/buf_2.sym} 154420 -38790 0 0 {name=X_55791_ }
C {devices/lab_pin.sym} 154360 -38680 0 0 {name=p153122 lab=_67873_/A }
C {devices/lab_pin.sym} 154360 -38640 0 0 {name=p153123 lab=_88161_/Q }
C {devices/lab_pin.sym} 154480 -38660 0 1 {name=p153124 lab=_67777_/X }
C {sky130_stdcells/and2_4.sym} 154420 -38660 0 0 {name=X_67777_ }
C {devices/lab_pin.sym} 154380 -38530 0 0 {name=p153125 lab=_64729_/A }
C {devices/lab_pin.sym} 154460 -38530 0 1 {name=p153126 lab=_64989_/X }
C {sky130_stdcells/buf_2.sym} 154420 -38530 0 0 {name=X_64989_ }
C {devices/lab_pin.sym} 154340 -38430 0 0 {name=p153127 lab=_84985_/Q }
C {devices/lab_pin.sym} 154340 -38390 0 0 {name=p153128 lab=_57527_/X }
C {devices/lab_pin.sym} 154340 -38350 0 0 {name=p153129 lab=_57529_/Y }
C {devices/lab_pin.sym} 154500 -38390 0 1 {name=p153130 lab=_57530_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -38390 0 0 {name=X_57530_ }
C {devices/lab_pin.sym} 154380 -38250 0 0 {name=p153131 lab=_69733_/A }
C {devices/lab_pin.sym} 154460 -38250 0 1 {name=p153132 lab=_69516_/X }
C {sky130_stdcells/buf_2.sym} 154420 -38250 0 0 {name=X_69516_ }
C {devices/lab_pin.sym} 154330 -38130 0 0 {name=p153133 lab=_87859_/CLK }
C {devices/lab_pin.sym} 154330 -38110 0 0 {name=p153134 lab=_40709_/Y }
C {devices/lab_pin.sym} 154510 -38130 0 1 {name=p153135 lab=_68892_/B }
C {sky130_stdcells/dfxtp_4.sym} 154420 -38120 0 0 {name=X_88350_ }
C {devices/lab_pin.sym} 154340 -38010 0 0 {name=p153136 lab=_85386_/Q }
C {devices/lab_pin.sym} 154340 -37970 0 0 {name=p153137 lab=_54729_/X }
C {devices/lab_pin.sym} 154340 -37930 0 0 {name=p153138 lab=_54741_/Y }
C {devices/lab_pin.sym} 154500 -37970 0 1 {name=p153139 lab=_54742_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -37970 0 0 {name=X_54742_ }
C {devices/lab_pin.sym} 154360 -37840 0 0 {name=p153140 lab=_66728_/A }
C {devices/lab_pin.sym} 154360 -37800 0 0 {name=p153141 lab=_88141_/Q }
C {devices/lab_pin.sym} 154480 -37820 0 1 {name=p153142 lab=_66728_/X }
C {sky130_stdcells/and2_4.sym} 154420 -37820 0 0 {name=X_66728_ }
C {devices/lab_pin.sym} 154330 -37690 0 0 {name=p153143 lab=_85562_/CLK }
C {devices/lab_pin.sym} 154330 -37670 0 0 {name=p153144 lab=_53822_/Y }
C {devices/lab_pin.sym} 154510 -37690 0 1 {name=p153145 lab=_85562_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -37680 0 0 {name=X_85562_ }
C {devices/lab_pin.sym} 154360 -37560 0 0 {name=p153146 lab=_51947_/A }
C {devices/lab_pin.sym} 154360 -37520 0 0 {name=p153147 lab=_51954_/B }
C {devices/lab_pin.sym} 154480 -37540 0 1 {name=p153148 lab=_51954_/Y }
C {sky130_stdcells/nand2_4.sym} 154420 -37540 0 0 {name=X_51954_ }
C {devices/lab_pin.sym} 154330 -37410 0 0 {name=p153149 lab=_82774_/CLK }
C {devices/lab_pin.sym} 154330 -37390 0 0 {name=p153150 lab=_82774_/D }
C {devices/lab_pin.sym} 154510 -37410 0 1 {name=p153151 lab=_82966_/D }
C {sky130_stdcells/dfxtp_4.sym} 154420 -37400 0 0 {name=X_82774_ }
C {devices/lab_pin.sym} 154330 -37270 0 0 {name=p153152 lab=_87553_/CLK }
C {devices/lab_pin.sym} 154330 -37250 0 0 {name=p153153 lab=_87301_/D }
C {devices/lab_pin.sym} 154510 -37270 0 1 {name=p153154 lab=_87301_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -37260 0 0 {name=X_87301_ }
C {devices/lab_pin.sym} 154330 -37130 0 0 {name=p153155 lab=_84649_/CLK }
C {devices/lab_pin.sym} 154330 -37110 0 0 {name=p153156 lab=_84513_/D }
C {devices/lab_pin.sym} 154510 -37130 0 1 {name=p153157 lab=_84513_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -37120 0 0 {name=X_84513_ }
C {devices/lab_pin.sym} 154340 -37010 0 0 {name=p153158 lab=_50901_/Y }
C {devices/lab_pin.sym} 154340 -36970 0 0 {name=p153159 lab=_50902_/X }
C {devices/lab_pin.sym} 154340 -36930 0 0 {name=p153160 lab=_50904_/X }
C {devices/lab_pin.sym} 154500 -36970 0 1 {name=p153161 lab=_50905_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -36970 0 0 {name=X_50905_ }
C {devices/lab_pin.sym} 154340 -36850 0 0 {name=p153162 lab=_57440_/X }
C {devices/lab_pin.sym} 154340 -36810 0 0 {name=p153163 lab=_57459_/X }
C {devices/lab_pin.sym} 154340 -36770 0 0 {name=p153164 lab=_57460_/Y }
C {devices/lab_pin.sym} 154500 -36810 0 1 {name=p153165 lab=_57461_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -36810 0 0 {name=X_57461_ }
C {devices/lab_pin.sym} 154330 -36670 0 0 {name=p153166 lab=_80928_/CLK }
C {devices/lab_pin.sym} 154330 -36650 0 0 {name=p153167 lab=_81725_/D }
C {devices/lab_pin.sym} 154510 -36670 0 1 {name=p153168 lab=_81725_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -36660 0 0 {name=X_81725_ }
C {devices/lab_pin.sym} 154340 -36560 0 0 {name=p153169 lab=_87017_/Q }
C {devices/lab_pin.sym} 154340 -36520 0 0 {name=p153170 lab=_69277_/X }
C {devices/lab_pin.sym} 154340 -36480 0 0 {name=p153171 lab=_69278_/X }
C {devices/lab_pin.sym} 154340 -36440 0 0 {name=p153172 lab=_69446_/X }
C {devices/lab_pin.sym} 154500 -36500 0 1 {name=p153173 lab=_69448_/B }
C {sky130_stdcells/a211o_4.sym} 154420 -36500 0 0 {name=X_69447_ }
C {devices/lab_pin.sym} 154330 -36350 0 0 {name=p153174 lab=_88288_/CLK }
C {devices/lab_pin.sym} 154330 -36330 0 0 {name=p153175 lab=_41084_/Y }
C {devices/lab_pin.sym} 154510 -36350 0 1 {name=p153176 lab=_88281_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -36340 0 0 {name=X_88281_ }
C {devices/lab_pin.sym} 154380 -36210 0 0 {name=p153177 lab=_54672_/X }
C {devices/lab_pin.sym} 154460 -36210 0 1 {name=p153178 lab=_54674_/C }
C {sky130_stdcells/buf_2.sym} 154420 -36210 0 0 {name=X_54673_ }
C {devices/lab_pin.sym} 154340 -36110 0 0 {name=p153179 lab=_66655_/X }
C {devices/lab_pin.sym} 154340 -36070 0 0 {name=p153180 lab=_66657_/X }
C {devices/lab_pin.sym} 154340 -36030 0 0 {name=p153181 lab=_66658_/X }
C {devices/lab_pin.sym} 154500 -36070 0 1 {name=p153182 lab=_66659_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -36070 0 0 {name=X_66659_ }
C {devices/lab_pin.sym} 154330 -35930 0 0 {name=p153183 lab=_85492_/CLK }
C {devices/lab_pin.sym} 154330 -35910 0 0 {name=p153184 lab=_85493_/D }
C {devices/lab_pin.sym} 154510 -35930 0 1 {name=p153185 lab=_85493_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -35920 0 0 {name=X_85493_ }
C {devices/lab_pin.sym} 154340 -35810 0 0 {name=p153186 lab=_85928_/Q }
C {devices/lab_pin.sym} 154340 -35770 0 0 {name=p153187 lab=_51873_/X }
C {devices/lab_pin.sym} 154340 -35730 0 0 {name=p153188 lab=_51884_/Y }
C {devices/lab_pin.sym} 154500 -35770 0 1 {name=p153189 lab=_51885_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -35770 0 0 {name=X_51885_ }
C {devices/lab_pin.sym} 154340 -35650 0 0 {name=p153190 lab=_59199_/X }
C {devices/lab_pin.sym} 154340 -35610 0 0 {name=p153191 lab=_85745_/Q }
C {devices/lab_pin.sym} 154340 -35570 0 0 {name=p153192 lab=_59124_/X }
C {devices/lab_pin.sym} 154500 -35610 0 1 {name=p153193 lab=_59200_/X }
C {sky130_stdcells/o21a_4.sym} 154420 -35610 0 0 {name=X_59200_ }
C {devices/lab_pin.sym} 154360 -35490 0 0 {name=p153194 lab=_56418_/A }
C {devices/lab_pin.sym} 154360 -35450 0 0 {name=p153195 lab=_56418_/B }
C {devices/lab_pin.sym} 154360 -35410 0 0 {name=p153196 lab=_85204_/Q }
C {devices/lab_pin.sym} 154480 -35450 0 1 {name=p153197 lab=_56412_/Y }
C {sky130_stdcells/nand3_4.sym} 154420 -35450 0 0 {name=X_56412_ }
C {devices/lab_pin.sym} 154330 -35310 0 0 {name=p153198 lab=_87758_/CLK }
C {devices/lab_pin.sym} 154330 -35290 0 0 {name=p153199 lab=_43856_/Y }
C {devices/lab_pin.sym} 154510 -35310 0 1 {name=p153200 lab=_87232_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -35300 0 0 {name=X_87232_ }
C {devices/lab_pin.sym} 154360 -35190 0 0 {name=p153201 lab=_52103_/A }
C {devices/lab_pin.sym} 154360 -35150 0 0 {name=p153202 lab=_53620_/B }
C {devices/lab_pin.sym} 154360 -35110 0 0 {name=p153203 lab=_53620_/C }
C {devices/lab_pin.sym} 154480 -35150 0 1 {name=p153204 lab=_53624_/X }
C {sky130_stdcells/and3_4.sym} 154420 -35150 0 0 {name=X_53624_ }
C {devices/lab_pin.sym} 154330 -35010 0 0 {name=p153205 lab=_84452_/CLK }
C {devices/lab_pin.sym} 154330 -34990 0 0 {name=p153206 lab=_84444_/D }
C {devices/lab_pin.sym} 154510 -35010 0 1 {name=p153207 lab=_78067_/B }
C {sky130_stdcells/dfxtp_4.sym} 154420 -35000 0 0 {name=X_84444_ }
C {devices/lab_pin.sym} 154360 -34880 0 0 {name=p153208 lab=_50822_/A }
C {devices/lab_pin.sym} 154360 -34840 0 0 {name=p153209 lab=_51350_/B }
C {devices/lab_pin.sym} 154480 -34860 0 1 {name=p153210 lab=_50836_/Y }
C {sky130_stdcells/nand2_4.sym} 154420 -34860 0 0 {name=X_50836_ }
C {devices/lab_pin.sym} 154360 -34750 0 0 {name=p153211 lab=_57359_/A }
C {devices/lab_pin.sym} 154360 -34710 0 0 {name=p153212 lab=_57392_/B }
C {devices/lab_pin.sym} 154360 -34670 0 0 {name=p153213 lab=_57372_/X }
C {devices/lab_pin.sym} 154480 -34710 0 1 {name=p153214 lab=_57392_/Y }
C {sky130_stdcells/nor3_4.sym} 154420 -34710 0 0 {name=X_57392_ }
C {devices/lab_pin.sym} 154330 -34570 0 0 {name=p153215 lab=_81697_/CLK }
C {devices/lab_pin.sym} 154330 -34550 0 0 {name=p153216 lab=_81688_/Q }
C {devices/lab_pin.sym} 154510 -34570 0 1 {name=p153217 lab=_76470_/A }
C {sky130_stdcells/dfxtp_4.sym} 154420 -34560 0 0 {name=X_81656_ }
C {devices/lab_pin.sym} 154340 -34450 0 0 {name=p153218 lab=_69374_/X }
C {devices/lab_pin.sym} 154340 -34410 0 0 {name=p153219 lab=_69377_/X }
C {devices/lab_pin.sym} 154340 -34370 0 0 {name=p153220 lab=_69142_/X }
C {devices/lab_pin.sym} 154500 -34410 0 1 {name=p153221 lab=_69378_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -34410 0 0 {name=X_69378_ }
C {devices/lab_pin.sym} 154360 -34280 0 0 {name=p153222 lab=_59131_/A }
C {devices/lab_pin.sym} 154360 -34240 0 0 {name=p153223 lab=_59068_/B }
C {devices/lab_pin.sym} 154480 -34260 0 1 {name=p153224 lab=_59131_/Y }
C {sky130_stdcells/nor2_4.sym} 154420 -34260 0 0 {name=X_59131_ }
C {devices/lab_pin.sym} 154360 -34150 0 0 {name=p153225 lab=_56345_/A }
C {devices/lab_pin.sym} 154360 -34110 0 0 {name=p153226 lab=_56345_/B }
C {devices/lab_pin.sym} 154360 -34070 0 0 {name=p153227 lab=_85228_/Q }
C {devices/lab_pin.sym} 154480 -34110 0 1 {name=p153228 lab=_56343_/Y }
C {sky130_stdcells/nand3_4.sym} 154420 -34110 0 0 {name=X_56343_ }
C {devices/lab_pin.sym} 154360 -33980 0 0 {name=p153229 lab=_80607_/A }
C {devices/lab_pin.sym} 154360 -33940 0 0 {name=p153230 lab=_80607_/B }
C {devices/lab_pin.sym} 154480 -33960 0 1 {name=p153231 lab=_80607_/X }
C {sky130_stdcells/xor2_4.sym} 154420 -33960 0 0 {name=X_80607_ }
C {devices/lab_pin.sym} 154340 -33860 0 0 {name=p153232 lab=_68319_/X }
C {devices/lab_pin.sym} 154340 -33820 0 0 {name=p153233 lab=_68005_/Y }
C {devices/lab_pin.sym} 154340 -33780 0 0 {name=p153234 lab=_68326_/X }
C {devices/lab_pin.sym} 154340 -33740 0 0 {name=p153235 lab=_68328_/Y }
C {devices/lab_pin.sym} 154500 -33800 0 1 {name=p153236 lab=_68329_/X }
C {sky130_stdcells/a211o_4.sym} 154420 -33800 0 0 {name=X_68329_ }
C {devices/lab_pin.sym} 154330 -33650 0 0 {name=p153237 lab=_88175_/CLK }
C {devices/lab_pin.sym} 154330 -33630 0 0 {name=p153238 lab=_87163_/D }
C {devices/lab_pin.sym} 154510 -33650 0 1 {name=p153239 lab=_87163_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -33640 0 0 {name=X_87163_ }
C {devices/lab_pin.sym} 154340 -33530 0 0 {name=p153240 lab=_53553_/Y }
C {devices/lab_pin.sym} 154340 -33490 0 0 {name=p153241 lab=_53537_/X }
C {devices/lab_pin.sym} 154340 -33450 0 0 {name=p153242 lab=_53554_/X }
C {devices/lab_pin.sym} 154500 -33490 0 1 {name=p153243 lab=_85614_/D }
C {sky130_stdcells/a21oi_4.sym} 154420 -33490 0 0 {name=X_53555_ }
C {devices/lab_pin.sym} 154330 -33350 0 0 {name=p153244 lab=_84375_/CLK }
C {devices/lab_pin.sym} 154330 -33330 0 0 {name=p153245 lab=_84375_/D }
C {devices/lab_pin.sym} 154510 -33350 0 1 {name=p153246 lab=_62873_/C }
C {sky130_stdcells/dfxtp_4.sym} 154420 -33340 0 0 {name=X_84375_ }
C {devices/lab_pin.sym} 154340 -33230 0 0 {name=p153247 lab=_86137_/Q }
C {devices/lab_pin.sym} 154340 -33190 0 0 {name=p153248 lab=_50742_/X }
C {devices/lab_pin.sym} 154340 -33150 0 0 {name=p153249 lab=_50766_/Y }
C {devices/lab_pin.sym} 154500 -33190 0 1 {name=p153250 lab=_50767_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -33190 0 0 {name=X_50767_ }
C {devices/lab_pin.sym} 154330 -33050 0 0 {name=p153251 lab=_81587_/CLK }
C {devices/lab_pin.sym} 154330 -33030 0 0 {name=p153252 lab=_84187_/Q }
C {devices/lab_pin.sym} 154510 -33050 0 1 {name=p153253 lab=_76809_/A }
C {sky130_stdcells/dfxtp_4.sym} 154420 -33040 0 0 {name=X_81587_ }
C {devices/lab_pin.sym} 154330 -32910 0 0 {name=p153254 lab=_86121_/CLK }
C {devices/lab_pin.sym} 154330 -32890 0 0 {name=p153255 lab=_86114_/D }
C {devices/lab_pin.sym} 154510 -32910 0 1 {name=p153256 lab=_86114_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -32900 0 0 {name=X_86114_ }
C {devices/lab_pin.sym} 154380 -32770 0 0 {name=p153257 lab=_40519_/Y }
C {devices/lab_pin.sym} 154460 -32770 0 1 {name=p153258 lab=_40520_/X }
C {sky130_stdcells/buf_2.sym} 154420 -32770 0 0 {name=X_40520_ }
C {devices/lab_pin.sym} 154360 -32660 0 0 {name=p153259 lab=_52448_/A }
C {devices/lab_pin.sym} 154360 -32620 0 0 {name=p153260 lab=_46441_/Y }
C {devices/lab_pin.sym} 154480 -32640 0 1 {name=p153261 lab=_52506_/Y }
C {sky130_stdcells/nand2_4.sym} 154420 -32640 0 0 {name=X_52506_ }
C {devices/lab_pin.sym} 154340 -32530 0 0 {name=p153262 lab=_59013_/X }
C {devices/lab_pin.sym} 154340 -32490 0 0 {name=p153263 lab=_85756_/Q }
C {devices/lab_pin.sym} 154340 -32450 0 0 {name=p153264 lab=_59037_/X }
C {devices/lab_pin.sym} 154500 -32490 0 1 {name=p153265 lab=_59062_/X }
C {sky130_stdcells/o21a_4.sym} 154420 -32490 0 0 {name=X_59062_ }
C {devices/lab_pin.sym} 154380 -32350 0 0 {name=p153266 lab=clkbuf_9_236_0_CLK/X }
C {devices/lab_pin.sym} 154460 -32350 0 1 {name=p153267 lab=_86697_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 154420 -32350 0 0 {name=Xclkbuf_10_472_0_CLK }
C {devices/lab_pin.sym} 154380 -32230 0 0 {name=p153268 lab=_71462_/B }
C {devices/lab_pin.sym} 154460 -32230 0 1 {name=p153269 lab=_71485_/B }
C {sky130_stdcells/inv_2.sym} 154420 -32230 0 0 {name=X_71340_ }
C {devices/lab_pin.sym} 154330 -32110 0 0 {name=p153270 lab=_83322_/CLK }
C {devices/lab_pin.sym} 154330 -32090 0 0 {name=p153271 lab=_83326_/D }
C {devices/lab_pin.sym} 154510 -32110 0 1 {name=p153272 lab=_56682_/A }
C {sky130_stdcells/dfxtp_4.sym} 154420 -32100 0 0 {name=X_83326_ }
C {devices/lab_pin.sym} 154360 -31980 0 0 {name=p153273 lab=_84769_/Q }
C {devices/lab_pin.sym} 154360 -31940 0 0 {name=p153274 lab=_84161_/Q }
C {devices/lab_pin.sym} 154480 -31960 0 1 {name=p153275 lab=_80538_/X }
C {sky130_stdcells/xor2_4.sym} 154420 -31960 0 0 {name=X_80538_ }
C {devices/lab_pin.sym} 154380 -31830 0 0 {name=p153276 lab=_56273_/X }
C {devices/lab_pin.sym} 154460 -31830 0 1 {name=p153277 lab=_56274_/X }
C {sky130_stdcells/buf_2.sym} 154420 -31830 0 0 {name=X_56274_ }
C {devices/lab_pin.sym} 154330 -31710 0 0 {name=p153278 lab=_88268_/CLK }
C {devices/lab_pin.sym} 154330 -31690 0 0 {name=p153279 lab=_44468_/X }
C {devices/lab_pin.sym} 154510 -31710 0 1 {name=p153280 lab=_87094_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -31700 0 0 {name=X_87094_ }
C {devices/lab_pin.sym} 154360 -31580 0 0 {name=p153281 lab=_53478_/A }
C {devices/lab_pin.sym} 154360 -31540 0 0 {name=p153282 lab=_73717_/A }
C {devices/lab_pin.sym} 154480 -31560 0 1 {name=p153283 lab=_53486_/Y }
C {sky130_stdcells/nand2_4.sym} 154420 -31560 0 0 {name=X_53486_ }
C {devices/lab_pin.sym} 154340 -31450 0 0 {name=p153284 lab=_86151_/Q }
C {devices/lab_pin.sym} 154340 -31410 0 0 {name=p153285 lab=_50680_/X }
C {devices/lab_pin.sym} 154340 -31370 0 0 {name=p153286 lab=_50697_/Y }
C {devices/lab_pin.sym} 154500 -31410 0 1 {name=p153287 lab=_50698_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -31410 0 0 {name=X_50698_ }
C {devices/lab_pin.sym} 154360 -31280 0 0 {name=p153288 lab=_86636_/Q }
C {devices/lab_pin.sym} 154360 -31240 0 0 {name=p153289 lab=_58039_/B }
C {devices/lab_pin.sym} 154480 -31260 0 1 {name=p153290 lab=_58013_/Y }
C {sky130_stdcells/nor2_4.sym} 154420 -31260 0 0 {name=X_58013_ }
C {devices/lab_pin.sym} 154340 -31160 0 0 {name=p153291 lab=_45861_/A }
C {devices/lab_pin.sym} 154340 -31120 0 0 {name=p153292 lab=_44058_/A }
C {devices/lab_pin.sym} 154340 -31080 0 0 {name=p153293 lab=_55140_/A }
C {devices/lab_pin.sym} 154340 -31040 0 0 {name=p153294 lab=_55224_/X }
C {devices/lab_pin.sym} 154500 -31100 0 1 {name=p153295 lab=_55225_/X }
C {sky130_stdcells/a211o_4.sym} 154420 -31100 0 0 {name=X_55225_ }
C {devices/lab_pin.sym} 154330 -30950 0 0 {name=p153296 lab=_86045_/CLK }
C {devices/lab_pin.sym} 154330 -30930 0 0 {name=p153297 lab=_51257_/Y }
C {devices/lab_pin.sym} 154510 -30950 0 1 {name=p153298 lab=_86045_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -30940 0 0 {name=X_86045_ }
C {devices/lab_pin.sym} 154340 -30830 0 0 {name=p153299 lab=_40421_/X }
C {devices/lab_pin.sym} 154340 -30790 0 0 {name=p153300 lab=_81171_/Q }
C {devices/lab_pin.sym} 154340 -30750 0 0 {name=p153301 lab=_40450_/X }
C {devices/lab_pin.sym} 154500 -30790 0 1 {name=p153302 lab=_40451_/X }
C {sky130_stdcells/o21a_4.sym} 154420 -30790 0 0 {name=X_40451_ }
C {devices/lab_pin.sym} 154340 -30670 0 0 {name=p153303 lab=_52435_/Y }
C {devices/lab_pin.sym} 154340 -30630 0 0 {name=p153304 lab=_52430_/X }
C {devices/lab_pin.sym} 154340 -30590 0 0 {name=p153305 lab=_52436_/Y }
C {devices/lab_pin.sym} 154500 -30630 0 1 {name=p153306 lab=_85823_/D }
C {sky130_stdcells/a21boi_4.sym} 154420 -30630 0 0 {name=X_52437_ }
C {devices/lab_pin.sym} 154360 -30520 0 0 {name=p153307 lab=_71171_/A }
C {devices/lab_pin.sym} 154360 -30480 0 0 {name=p153308 lab=_71276_/B }
C {devices/lab_pin.sym} 154360 -30440 0 0 {name=p153309 lab=_71276_/C }
C {devices/lab_pin.sym} 154360 -30400 0 0 {name=p153310 lab=_70656_/D }
C {devices/lab_pin.sym} 154480 -30460 0 1 {name=p153311 lab=_71271_/Y }
C {sky130_stdcells/nand4_4.sym} 154420 -30460 0 0 {name=X_71271_ }
C {devices/lab_pin.sym} 154330 -30310 0 0 {name=p153312 lab=_86282_/CLK }
C {devices/lab_pin.sym} 154330 -30290 0 0 {name=p153313 lab=_83257_/D }
C {devices/lab_pin.sym} 154510 -30310 0 1 {name=p153314 lab=_83257_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -30300 0 0 {name=X_83257_ }
C {devices/lab_pin.sym} 154340 -30190 0 0 {name=p153315 lab=_80457_/A }
C {devices/lab_pin.sym} 154340 -30150 0 0 {name=p153316 lab=_80456_/Y }
C {devices/lab_pin.sym} 154340 -30110 0 0 {name=p153317 lab=_80468_/X }
C {devices/lab_pin.sym} 154500 -30150 0 1 {name=p153318 lab=_80469_/X }
C {sky130_stdcells/a21o_4.sym} 154420 -30150 0 0 {name=X_80469_ }
C {devices/lab_pin.sym} 154360 -30020 0 0 {name=p153319 lab=_73132_/A }
C {devices/lab_pin.sym} 154360 -29980 0 0 {name=p153320 lab=_85880_/Q }
C {devices/lab_pin.sym} 154480 -30000 0 1 {name=p153321 lab=_73010_/X }
C {sky130_stdcells/and2_4.sym} 154420 -30000 0 0 {name=X_73010_ }
C {devices/lab_pin.sym} 154340 -29890 0 0 {name=p153322 lab=_70209_/X }
C {devices/lab_pin.sym} 154340 -29850 0 0 {name=p153323 lab=_83832_/Q }
C {devices/lab_pin.sym} 154340 -29810 0 0 {name=p153324 lab=_70221_/X }
C {devices/lab_pin.sym} 154500 -29850 0 1 {name=p153325 lab=_70222_/X }
C {sky130_stdcells/a21o_4.sym} 154420 -29850 0 0 {name=X_70222_ }
C {devices/lab_pin.sym} 154330 -29710 0 0 {name=p153326 lab=_82965_/CLK }
C {devices/lab_pin.sym} 154330 -29690 0 0 {name=p153327 lab=_82208_/D }
C {devices/lab_pin.sym} 154510 -29710 0 1 {name=p153328 lab=_82208_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -29700 0 0 {name=X_82208_ }
C {devices/lab_pin.sym} 154380 -29570 0 0 {name=p153329 lab=_43170_/A }
C {devices/lab_pin.sym} 154460 -29570 0 1 {name=p153330 lab=_43170_/Y }
C {sky130_stdcells/inv_2.sym} 154420 -29570 0 0 {name=X_43170_ }
C {devices/lab_pin.sym} 154340 -29470 0 0 {name=p153331 lab=_55151_/X }
C {devices/lab_pin.sym} 154340 -29430 0 0 {name=p153332 lab=_55155_/X }
C {devices/lab_pin.sym} 154340 -29390 0 0 {name=p153333 lab=_44108_/X }
C {devices/lab_pin.sym} 154500 -29430 0 1 {name=p153334 lab=_55156_/X }
C {sky130_stdcells/a21o_4.sym} 154420 -29430 0 0 {name=X_55156_ }
C {devices/lab_pin.sym} 154340 -29310 0 0 {name=p153335 lab=_65155_/B }
C {devices/lab_pin.sym} 154340 -29270 0 0 {name=p153336 lab=_52347_/X }
C {devices/lab_pin.sym} 154340 -29230 0 0 {name=p153337 lab=_52367_/Y }
C {devices/lab_pin.sym} 154500 -29270 0 1 {name=p153338 lab=_52368_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -29270 0 0 {name=X_52368_ }
C {devices/lab_pin.sym} 154380 -29130 0 0 {name=p153339 lab=_40321_/A }
C {devices/lab_pin.sym} 154460 -29130 0 1 {name=p153340 lab=_40586_/A }
C {sky130_stdcells/buf_2.sym} 154420 -29130 0 0 {name=X_40382_ }
C {devices/lab_pin.sym} 154330 -29010 0 0 {name=p153341 lab=_83188_/CLK }
C {devices/lab_pin.sym} 154330 -28990 0 0 {name=p153342 lab=_72692_/X }
C {devices/lab_pin.sym} 154510 -29010 0 1 {name=p153343 lab=_83188_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -29000 0 0 {name=X_83188_ }
C {devices/lab_pin.sym} 154380 -28870 0 0 {name=p153344 lab=clkbuf_9_243_0_CLK/X }
C {devices/lab_pin.sym} 154460 -28870 0 1 {name=p153345 lab=_86713_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 154420 -28870 0 0 {name=Xclkbuf_10_487_0_CLK }
C {devices/lab_pin.sym} 154340 -28770 0 0 {name=p153346 lab=_85502_/Q }
C {devices/lab_pin.sym} 154340 -28730 0 0 {name=p153347 lab=_53431_/X }
C {devices/lab_pin.sym} 154340 -28690 0 0 {name=p153348 lab=_54106_/Y }
C {devices/lab_pin.sym} 154500 -28730 0 1 {name=p153349 lab=_54107_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -28730 0 0 {name=X_54107_ }
C {devices/lab_pin.sym} 154340 -28630 0 0 {name=p153350 lab=_42120_/X }
C {devices/lab_pin.sym} 154340 -28590 0 0 {name=p153351 lab=_42116_/X }
C {devices/lab_pin.sym} 154340 -28550 0 0 {name=p153352 lab=_41082_/X }
C {devices/lab_pin.sym} 154340 -28510 0 0 {name=p153353 lab=_88025_/Q }
C {devices/lab_pin.sym} 154340 -28470 0 0 {name=p153354 lab=_42117_/X }
C {devices/lab_pin.sym} 154500 -28550 0 1 {name=p153355 lab=_42122_/A }
C {sky130_stdcells/o32ai_4.sym} 154420 -28550 0 0 {name=X_42121_ }
C {devices/lab_pin.sym} 154340 -28410 0 0 {name=p153356 lab=_51317_/Y }
C {devices/lab_pin.sym} 154340 -28370 0 0 {name=p153357 lab=_51313_/X }
C {devices/lab_pin.sym} 154340 -28330 0 0 {name=p153358 lab=_51318_/X }
C {devices/lab_pin.sym} 154500 -28370 0 1 {name=p153359 lab=_51319_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -28370 0 0 {name=X_51319_ }
C {devices/lab_pin.sym} 154380 -28230 0 0 {name=p153360 lab=_70153_/A }
C {devices/lab_pin.sym} 154460 -28230 0 1 {name=p153361 lab=_70153_/Y }
C {sky130_stdcells/inv_2.sym} 154420 -28230 0 0 {name=X_70153_ }
C {devices/lab_pin.sym} 154330 -28110 0 0 {name=p153362 lab=_82139_/CLK }
C {devices/lab_pin.sym} 154330 -28090 0 0 {name=p153363 lab=_77958_/X }
C {devices/lab_pin.sym} 154510 -28110 0 1 {name=p153364 lab=_82095_/D }
C {sky130_stdcells/dfxtp_4.sym} 154420 -28100 0 0 {name=X_82139_ }
C {devices/lab_pin.sym} 154360 -28000 0 0 {name=p153365 lab=_55083_/A }
C {devices/lab_pin.sym} 154360 -27960 0 0 {name=p153366 lab=_55104_/B }
C {devices/lab_pin.sym} 154360 -27920 0 0 {name=p153367 lab=_55083_/C }
C {devices/lab_pin.sym} 154360 -27880 0 0 {name=p153368 lab=_47757_/A }
C {devices/lab_pin.sym} 154480 -27940 0 1 {name=p153369 lab=_55087_/X }
C {sky130_stdcells/and4_4.sym} 154420 -27940 0 0 {name=X_55087_ }
C {devices/lab_pin.sym} 154380 -27790 0 0 {name=p153370 lab=_59964_/A }
C {devices/lab_pin.sym} 154460 -27790 0 1 {name=p153371 lab=_59964_/Y }
C {sky130_stdcells/inv_2.sym} 154420 -27790 0 0 {name=X_59964_ }
C {devices/lab_pin.sym} 154360 -27680 0 0 {name=p153372 lab=_52299_/A }
C {devices/lab_pin.sym} 154360 -27640 0 0 {name=p153373 lab=_48955_/X }
C {devices/lab_pin.sym} 154480 -27660 0 1 {name=p153374 lab=_52299_/Y }
C {sky130_stdcells/nand2_4.sym} 154420 -27660 0 0 {name=X_52299_ }
C {devices/lab_pin.sym} 154330 -27530 0 0 {name=p153375 lab=_87487_/CLK }
C {devices/lab_pin.sym} 154330 -27510 0 0 {name=p153376 lab=_42178_/Y }
C {devices/lab_pin.sym} 154510 -27530 0 1 {name=p153377 lab=_87996_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -27520 0 0 {name=X_87996_ }
C {devices/lab_pin.sym} 154380 -27390 0 0 {name=p153378 lab=_42013_/A }
C {devices/lab_pin.sym} 154460 -27390 0 1 {name=p153379 lab=_42052_/X }
C {sky130_stdcells/buf_2.sym} 154420 -27390 0 0 {name=X_42052_ }
C {devices/lab_pin.sym} 154340 -27290 0 0 {name=p153380 lab=_58891_/X }
C {devices/lab_pin.sym} 154340 -27250 0 0 {name=p153381 lab=_86086_/Q }
C {devices/lab_pin.sym} 154340 -27210 0 0 {name=p153382 lab=_58914_/X }
C {devices/lab_pin.sym} 154500 -27250 0 1 {name=p153383 lab=_58915_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -27250 0 0 {name=X_58915_ }
C {devices/lab_pin.sym} 154340 -27130 0 0 {name=p153384 lab=_85518_/Q }
C {devices/lab_pin.sym} 154340 -27090 0 0 {name=p153385 lab=_54035_/X }
C {devices/lab_pin.sym} 154340 -27050 0 0 {name=p153386 lab=_54037_/Y }
C {devices/lab_pin.sym} 154500 -27090 0 1 {name=p153387 lab=_54038_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -27090 0 0 {name=X_54038_ }
C {devices/lab_pin.sym} 154360 -26960 0 0 {name=p153388 lab=_74960_/Y }
C {devices/lab_pin.sym} 154360 -26920 0 0 {name=p153389 lab=_74961_/B }
C {devices/lab_pin.sym} 154480 -26940 0 1 {name=p153390 lab=_74962_/B }
C {sky130_stdcells/and2_4.sym} 154420 -26940 0 0 {name=X_74961_ }
C {devices/lab_pin.sym} 154340 -26830 0 0 {name=p153391 lab=_83854_/Q }
C {devices/lab_pin.sym} 154340 -26790 0 0 {name=p153392 lab=_70067_/X }
C {devices/lab_pin.sym} 154340 -26750 0 0 {name=p153393 lab=_70083_/X }
C {devices/lab_pin.sym} 154500 -26790 0 1 {name=p153394 lab=_83854_/D }
C {sky130_stdcells/a21bo_4.sym} 154420 -26790 0 0 {name=X_70084_ }
C {devices/lab_pin.sym} 154330 -26650 0 0 {name=p153395 lab=_88215_/CLK }
C {devices/lab_pin.sym} 154330 -26630 0 0 {name=p153396 lab=_86947_/D }
C {devices/lab_pin.sym} 154510 -26650 0 1 {name=p153397 lab=_86947_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -26640 0 0 {name=X_86947_ }
C {devices/lab_pin.sym} 154340 -26530 0 0 {name=p153398 lab=_59881_/X }
C {devices/lab_pin.sym} 154340 -26490 0 0 {name=p153399 lab=_59884_/X }
C {devices/lab_pin.sym} 154340 -26450 0 0 {name=p153400 lab=_59927_/A }
C {devices/lab_pin.sym} 154500 -26490 0 1 {name=p153401 lab=_62288_/A }
C {sky130_stdcells/a21oi_4.sym} 154420 -26490 0 0 {name=X_59895_ }
C {devices/lab_pin.sym} 154340 -26370 0 0 {name=p153402 lab=_40429_/X }
C {devices/lab_pin.sym} 154340 -26330 0 0 {name=p153403 lab=_82293_/Q }
C {devices/lab_pin.sym} 154340 -26290 0 0 {name=p153404 lab=_41002_/X }
C {devices/lab_pin.sym} 154500 -26330 0 1 {name=p153405 lab=_41003_/X }
C {sky130_stdcells/o21a_4.sym} 154420 -26330 0 0 {name=X_41003_ }
C {devices/lab_pin.sym} 154380 -26190 0 0 {name=p153406 lab=_76692_/Y }
C {devices/lab_pin.sym} 154460 -26190 0 1 {name=p153407 lab=_76700_/Y }
C {sky130_stdcells/inv_2.sym} 154420 -26190 0 0 {name=X_76700_ }
C {devices/lab_pin.sym} 154340 -26090 0 0 {name=p153408 lab=_73913_/B }
C {devices/lab_pin.sym} 154340 -26050 0 0 {name=p153409 lab=_73913_/C }
C {devices/lab_pin.sym} 154340 -26010 0 0 {name=p153410 lab=_73911_/X }
C {devices/lab_pin.sym} 154500 -26050 0 1 {name=p153411 lab=_73912_/X }
C {sky130_stdcells/a21o_4.sym} 154420 -26050 0 0 {name=X_73912_ }
C {devices/lab_pin.sym} 154380 -25910 0 0 {name=p153412 lab=clkbuf_9_205_0_CLK/X }
C {devices/lab_pin.sym} 154460 -25910 0 1 {name=p153413 lab=_83521_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 154420 -25910 0 0 {name=Xclkbuf_10_410_0_CLK }
C {devices/lab_pin.sym} 154380 -25790 0 0 {name=p153414 lab=_58846_/A }
C {devices/lab_pin.sym} 154460 -25790 0 1 {name=p153415 lab=_58846_/X }
C {sky130_stdcells/buf_2.sym} 154420 -25790 0 0 {name=X_58846_ }
C {devices/lab_pin.sym} 154380 -25670 0 0 {name=p153416 lab=_46720_/A }
C {devices/lab_pin.sym} 154460 -25670 0 1 {name=p153417 lab=_46860_/X }
C {sky130_stdcells/buf_2.sym} 154420 -25670 0 0 {name=X_46860_ }
C {devices/lab_pin.sym} 154340 -25570 0 0 {name=p153418 lab=_77676_/X }
C {devices/lab_pin.sym} 154340 -25530 0 0 {name=p153419 lab=_77677_/Y }
C {devices/lab_pin.sym} 154340 -25490 0 0 {name=p153420 lab=_77679_/Y }
C {devices/lab_pin.sym} 154500 -25530 0 1 {name=p153421 lab=_77680_/X }
C {sky130_stdcells/a21o_4.sym} 154420 -25530 0 0 {name=X_77680_ }
C {devices/lab_pin.sym} 154360 -25400 0 0 {name=p153422 lab=_81128_/D }
C {devices/lab_pin.sym} 154360 -25360 0 0 {name=p153423 lab=_80840_/Q }
C {devices/lab_pin.sym} 154480 -25380 0 1 {name=p153424 lab=_74900_/A }
C {sky130_stdcells/nand2_4.sym} 154420 -25380 0 0 {name=X_74892_ }
C {devices/lab_pin.sym} 154330 -25250 0 0 {name=p153425 lab=_86878_/CLK }
C {devices/lab_pin.sym} 154330 -25230 0 0 {name=p153426 lab=_86878_/D }
C {devices/lab_pin.sym} 154510 -25250 0 1 {name=p153427 lab=_63017_/B }
C {sky130_stdcells/dfxtp_4.sym} 154420 -25240 0 0 {name=X_86878_ }
C {devices/lab_pin.sym} 154380 -25110 0 0 {name=p153428 lab=_45811_/A }
C {devices/lab_pin.sym} 154460 -25110 0 1 {name=p153429 lab=_45811_/Y }
C {sky130_stdcells/inv_2.sym} 154420 -25110 0 0 {name=X_45811_ }
C {devices/lab_pin.sym} 154360 -25000 0 0 {name=p153430 lab=_76640_/A }
C {devices/lab_pin.sym} 154360 -24960 0 0 {name=p153431 lab=_76640_/B }
C {devices/lab_pin.sym} 154480 -24980 0 1 {name=p153432 lab=_76639_/A }
C {sky130_stdcells/nand2_4.sym} 154420 -24980 0 0 {name=X_76631_ }
C {devices/lab_pin.sym} 154330 -24850 0 0 {name=p153433 lab=_86749_/CLK }
C {devices/lab_pin.sym} 154330 -24830 0 0 {name=p153434 lab=_52408_/Y }
C {devices/lab_pin.sym} 154510 -24850 0 1 {name=p153435 lab=_65324_/B }
C {sky130_stdcells/dfxtp_4.sym} 154420 -24840 0 0 {name=X_85829_ }
C {devices/lab_pin.sym} 154340 -24740 0 0 {name=p153436 lab=_68669_/B }
C {devices/lab_pin.sym} 154340 -24700 0 0 {name=p153437 lab=_73674_/X }
C {devices/lab_pin.sym} 154340 -24660 0 0 {name=p153438 lab=_73819_/X }
C {devices/lab_pin.sym} 154340 -24620 0 0 {name=p153439 lab=_73842_/Y }
C {devices/lab_pin.sym} 154500 -24680 0 1 {name=p153440 lab=_73843_/X }
C {sky130_stdcells/a211o_4.sym} 154420 -24680 0 0 {name=X_73843_ }
C {devices/lab_pin.sym} 154380 -24530 0 0 {name=p153441 lab=_46790_/Y }
C {devices/lab_pin.sym} 154460 -24530 0 1 {name=p153442 lab=_46791_/X }
C {sky130_stdcells/buf_2.sym} 154420 -24530 0 0 {name=X_46791_ }
C {devices/lab_pin.sym} 154340 -24450 0 0 {name=p153443 lab=_58748_/X }
C {devices/lab_pin.sym} 154340 -24410 0 0 {name=p153444 lab=_58775_/Y }
C {devices/lab_pin.sym} 154340 -24370 0 0 {name=p153445 lab=_58776_/Y }
C {devices/lab_pin.sym} 154340 -24330 0 0 {name=p153446 lab=_58766_/X }
C {devices/lab_pin.sym} 154340 -24290 0 0 {name=p153447 lab=_58752_/X }
C {devices/lab_pin.sym} 154500 -24370 0 1 {name=p153448 lab=_58777_/X }
C {sky130_stdcells/o32a_4.sym} 154420 -24370 0 0 {name=X_58777_ }
C {devices/lab_pin.sym} 154380 -24210 0 0 {name=p153449 lab=_56104_/A }
C {devices/lab_pin.sym} 154460 -24210 0 1 {name=p153450 lab=_56177_/A }
C {sky130_stdcells/buf_2.sym} 154420 -24210 0 0 {name=X_55989_ }
C {devices/lab_pin.sym} 154360 -24100 0 0 {name=p153451 lab=_48914_/A }
C {devices/lab_pin.sym} 154360 -24060 0 0 {name=p153452 lab=_82354_/Q }
C {devices/lab_pin.sym} 154480 -24080 0 1 {name=p153453 lab=_48530_/Y }
C {sky130_stdcells/nor2_4.sym} 154420 -24080 0 0 {name=X_48530_ }
C {devices/lab_pin.sym} 154340 -23970 0 0 {name=p153454 lab=_58769_/Y }
C {devices/lab_pin.sym} 154340 -23930 0 0 {name=p153455 lab=_66450_/Y }
C {devices/lab_pin.sym} 154340 -23890 0 0 {name=p153456 lab=_79349_/Y }
C {devices/lab_pin.sym} 154500 -23930 0 1 {name=p153457 lab=_79350_/X }
C {sky130_stdcells/o21a_4.sym} 154420 -23930 0 0 {name=X_79350_ }
C {devices/lab_pin.sym} 154340 -23810 0 0 {name=p153458 lab=_45737_/X }
C {devices/lab_pin.sym} 154340 -23770 0 0 {name=p153459 lab=_45741_/X }
C {devices/lab_pin.sym} 154340 -23730 0 0 {name=p153460 lab=_45678_/X }
C {devices/lab_pin.sym} 154500 -23770 0 1 {name=p153461 lab=_45742_/X }
C {sky130_stdcells/a21o_4.sym} 154420 -23770 0 0 {name=X_45742_ }
C {devices/lab_pin.sym} 154340 -23650 0 0 {name=p153462 lab=_57726_/X }
C {devices/lab_pin.sym} 154340 -23610 0 0 {name=p153463 lab=_86016_/Q }
C {devices/lab_pin.sym} 154340 -23570 0 0 {name=p153464 lab=_57727_/X }
C {devices/lab_pin.sym} 154500 -23610 0 1 {name=p153465 lab=_57728_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -23610 0 0 {name=X_57728_ }
C {devices/lab_pin.sym} 154380 -23470 0 0 {name=p153466 lab=_76584_/D }
C {devices/lab_pin.sym} 154460 -23470 0 1 {name=p153467 lab=_76562_/Y }
C {sky130_stdcells/inv_2.sym} 154420 -23470 0 0 {name=X_76562_ }
C {devices/lab_pin.sym} 154380 -23350 0 0 {name=p153468 lab=_42488_/A }
C {devices/lab_pin.sym} 154460 -23350 0 1 {name=p153469 lab=_42954_/X }
C {sky130_stdcells/buf_2.sym} 154420 -23350 0 0 {name=X_42954_ }
C {devices/lab_pin.sym} 154340 -23260 0 0 {name=p153470 lab=_43620_/Y }
C {devices/lab_pin.sym} 154340 -23220 0 0 {name=p153471 lab=_73597_/X }
C {devices/lab_pin.sym} 154340 -23180 0 0 {name=p153472 lab=_73772_/X }
C {devices/lab_pin.sym} 154340 -23140 0 0 {name=p153473 lab=_73773_/Y }
C {devices/lab_pin.sym} 154500 -23200 0 1 {name=p153474 lab=_73774_/X }
C {sky130_stdcells/a211o_4.sym} 154420 -23200 0 0 {name=X_73774_ }
C {devices/lab_pin.sym} 154380 -23050 0 0 {name=p153475 lab=_70986_/A }
C {devices/lab_pin.sym} 154460 -23050 0 1 {name=p153476 lab=_70990_/C }
C {sky130_stdcells/buf_2.sym} 154420 -23050 0 0 {name=X_70986_ }
C {devices/lab_pin.sym} 154360 -22940 0 0 {name=p153477 lab=_78301_/A }
C {devices/lab_pin.sym} 154360 -22900 0 0 {name=p153478 lab=_82472_/Q }
C {devices/lab_pin.sym} 154480 -22920 0 1 {name=p153479 lab=_78302_/B }
C {sky130_stdcells/nand2_4.sym} 154420 -22920 0 0 {name=X_78301_ }
C {devices/lab_pin.sym} 154380 -22790 0 0 {name=p153480 lab=clkbuf_9_212_0_CLK/X }
C {devices/lab_pin.sym} 154460 -22790 0 1 {name=p153481 lab=_82425_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 154420 -22790 0 0 {name=Xclkbuf_10_425_0_CLK }
C {devices/lab_pin.sym} 154360 -22680 0 0 {name=p153482 lab=_75505_/Y }
C {devices/lab_pin.sym} 154360 -22640 0 0 {name=p153483 lab=_75538_/B }
C {devices/lab_pin.sym} 154480 -22660 0 1 {name=p153484 lab=_75513_/X }
C {sky130_stdcells/xor2_4.sym} 154420 -22660 0 0 {name=X_75513_ }
C {devices/lab_pin.sym} 154380 -22530 0 0 {name=p153485 lab=_50523_/A }
C {devices/lab_pin.sym} 154460 -22530 0 1 {name=p153486 lab=_51584_/A }
C {sky130_stdcells/buf_2.sym} 154420 -22530 0 0 {name=X_41905_ }
C {devices/lab_pin.sym} 154380 -22410 0 0 {name=p153487 lab=_48461_/A }
C {devices/lab_pin.sym} 154460 -22410 0 1 {name=p153488 lab=_48485_/B }
C {sky130_stdcells/buf_2.sym} 154420 -22410 0 0 {name=X_48461_ }
C {devices/lab_pin.sym} 154380 -22290 0 0 {name=p153489 lab=_72725_/A }
C {devices/lab_pin.sym} 154460 -22290 0 1 {name=p153490 lab=_72725_/X }
C {sky130_stdcells/buf_2.sym} 154420 -22290 0 0 {name=X_72725_ }
C {devices/lab_pin.sym} 154360 -22180 0 0 {name=p153491 lab=_79277_/X }
C {devices/lab_pin.sym} 154360 -22140 0 0 {name=p153492 lab=_79280_/Y }
C {devices/lab_pin.sym} 154480 -22160 0 1 {name=p153493 lab=_79281_/X }
C {sky130_stdcells/xor2_4.sym} 154420 -22160 0 0 {name=X_79281_ }
C {devices/lab_pin.sym} 154360 -22040 0 0 {name=p153494 lab=_45673_/A }
C {devices/lab_pin.sym} 154360 -22000 0 0 {name=p153495 lab=_45793_/B }
C {devices/lab_pin.sym} 154480 -22020 0 1 {name=p153496 lab=_45673_/Y }
C {sky130_stdcells/nor2_4.sym} 154420 -22020 0 0 {name=X_45673_ }
C {devices/lab_pin.sym} 154380 -21890 0 0 {name=p153497 lab=_83759_/Q }
C {devices/lab_pin.sym} 154460 -21890 0 1 {name=p153498 lab=_57659_/Y }
C {sky130_stdcells/inv_2.sym} 154420 -21890 0 0 {name=X_57659_ }
C {devices/lab_pin.sym} 154340 -21790 0 0 {name=p153499 lab=_76474_/A }
C {devices/lab_pin.sym} 154340 -21750 0 0 {name=p153500 lab=_76471_/Y }
C {devices/lab_pin.sym} 154340 -21710 0 0 {name=p153501 lab=_76473_/A }
C {devices/lab_pin.sym} 154500 -21750 0 1 {name=p153502 lab=_76494_/A }
C {sky130_stdcells/o21a_4.sym} 154420 -21750 0 0 {name=X_76493_ }
C {devices/lab_pin.sym} 154380 -21610 0 0 {name=p153503 lab=_42885_/A }
C {devices/lab_pin.sym} 154460 -21610 0 1 {name=p153504 lab=_87669_/D }
C {sky130_stdcells/inv_2.sym} 154420 -21610 0 0 {name=X_42885_ }
C {devices/lab_pin.sym} 154360 -21500 0 0 {name=p153505 lab=_47404_/A }
C {devices/lab_pin.sym} 154360 -21460 0 0 {name=p153506 lab=_53033_/B }
C {devices/lab_pin.sym} 154480 -21480 0 1 {name=p153507 lab=_47412_/Y }
C {sky130_stdcells/nand2_4.sym} 154420 -21480 0 0 {name=X_47412_ }
C {devices/lab_pin.sym} 154360 -21360 0 0 {name=p153508 lab=_78253_/B }
C {devices/lab_pin.sym} 154360 -21320 0 0 {name=p153509 lab=_82496_/Q }
C {devices/lab_pin.sym} 154480 -21340 0 1 {name=p153510 lab=_78252_/A }
C {sky130_stdcells/xor2_4.sym} 154420 -21340 0 0 {name=X_78232_ }
C {devices/lab_pin.sym} 154380 -21210 0 0 {name=p153511 lab=_44624_/A }
C {devices/lab_pin.sym} 154460 -21210 0 1 {name=p153512 lab=_44714_/A }
C {sky130_stdcells/buf_2.sym} 154420 -21210 0 0 {name=X_44624_ }
C {devices/lab_pin.sym} 154360 -21100 0 0 {name=p153513 lab=_75443_/A }
C {devices/lab_pin.sym} 154360 -21060 0 0 {name=p153514 lab=_80955_/D }
C {devices/lab_pin.sym} 154480 -21080 0 1 {name=p153515 lab=_75445_/A }
C {sky130_stdcells/nand2_4.sym} 154420 -21080 0 0 {name=X_75444_ }
C {devices/lab_pin.sym} 154340 -20990 0 0 {name=p153516 lab=_41824_/X }
C {devices/lab_pin.sym} 154340 -20950 0 0 {name=p153517 lab=_41825_/X }
C {devices/lab_pin.sym} 154340 -20910 0 0 {name=p153518 lab=_40480_/X }
C {devices/lab_pin.sym} 154340 -20870 0 0 {name=p153519 lab=_67003_/B }
C {devices/lab_pin.sym} 154340 -20830 0 0 {name=p153520 lab=_41835_/X }
C {devices/lab_pin.sym} 154500 -20910 0 1 {name=p153521 lab=_41837_/A }
C {sky130_stdcells/o32ai_4.sym} 154420 -20910 0 0 {name=X_41836_ }
C {devices/lab_pin.sym} 154360 -20760 0 0 {name=p153522 lab=_48392_/A }
C {devices/lab_pin.sym} 154360 -20720 0 0 {name=p153523 lab=_48391_/X }
C {devices/lab_pin.sym} 154480 -20740 0 1 {name=p153524 lab=_48392_/Y }
C {sky130_stdcells/nand2_4.sym} 154420 -20740 0 0 {name=X_48392_ }
C {devices/lab_pin.sym} 154380 -20610 0 0 {name=p153525 lab=_63398_/A }
C {devices/lab_pin.sym} 154460 -20610 0 1 {name=p153526 lab=_60671_/C }
C {sky130_stdcells/inv_2.sym} 154420 -20610 0 0 {name=X_60670_ }
C {devices/lab_pin.sym} 154360 -20510 0 0 {name=p153527 lab=_72656_/A }
C {devices/lab_pin.sym} 154360 -20470 0 0 {name=p153528 lab=_72656_/B }
C {devices/lab_pin.sym} 154360 -20430 0 0 {name=p153529 lab=_72656_/C }
C {devices/lab_pin.sym} 154480 -20470 0 1 {name=p153530 lab=_72656_/Y }
C {sky130_stdcells/nand3_4.sym} 154420 -20470 0 0 {name=X_72656_ }
C {devices/lab_pin.sym} 154380 -20330 0 0 {name=p153531 lab=_47343_/A }
C {devices/lab_pin.sym} 154460 -20330 0 1 {name=p153532 lab=_47344_/A }
C {sky130_stdcells/inv_2.sym} 154420 -20330 0 0 {name=X_47343_ }
C {devices/lab_pin.sym} 154380 -20210 0 0 {name=p153533 lab=_58923_/A }
C {devices/lab_pin.sym} 154460 -20210 0 1 {name=p153534 lab=_59329_/X }
C {sky130_stdcells/buf_2.sym} 154420 -20210 0 0 {name=X_59329_ }
C {devices/lab_pin.sym} 154360 -20120 0 0 {name=p153535 lab=_71626_/A }
C {devices/lab_pin.sym} 154360 -20080 0 0 {name=p153536 lab=_70573_/B }
C {devices/lab_pin.sym} 154360 -20040 0 0 {name=p153537 lab=_70568_/D }
C {devices/lab_pin.sym} 154360 -20000 0 0 {name=p153538 lab=_71606_/X }
C {devices/lab_pin.sym} 154480 -20060 0 1 {name=p153539 lab=_71607_/Y }
C {sky130_stdcells/nor4_4.sym} 154420 -20060 0 0 {name=X_71607_ }
C {devices/lab_pin.sym} 154360 -19920 0 0 {name=p153540 lab=_78151_/Y }
C {devices/lab_pin.sym} 154360 -19880 0 0 {name=p153541 lab=_78162_/X }
C {devices/lab_pin.sym} 154480 -19900 0 1 {name=p153542 lab=_78166_/A }
C {sky130_stdcells/nand2_4.sym} 154420 -19900 0 0 {name=X_78163_ }
C {devices/lab_pin.sym} 154380 -19770 0 0 {name=p153543 lab=_44530_/A }
C {devices/lab_pin.sym} 154460 -19770 0 1 {name=p153544 lab=_44555_/X }
C {sky130_stdcells/buf_2.sym} 154420 -19770 0 0 {name=X_44555_ }
C {devices/lab_pin.sym} 154360 -19660 0 0 {name=p153545 lab=_75376_/A }
C {devices/lab_pin.sym} 154360 -19620 0 0 {name=p153546 lab=_75376_/B }
C {devices/lab_pin.sym} 154480 -19640 0 1 {name=p153547 lab=_75375_/Y }
C {sky130_stdcells/nor2_4.sym} 154420 -19640 0 0 {name=X_75375_ }
C {devices/lab_pin.sym} 154340 -19530 0 0 {name=p153548 lab=_40621_/X }
C {devices/lab_pin.sym} 154340 -19490 0 0 {name=p153549 lab=_41427_/A }
C {devices/lab_pin.sym} 154340 -19450 0 0 {name=p153550 lab=_41766_/X }
C {devices/lab_pin.sym} 154500 -19490 0 1 {name=p153551 lab=_41767_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -19490 0 0 {name=X_41767_ }
C {devices/lab_pin.sym} 154340 -19390 0 0 {name=p153552 lab=_61260_/X }
C {devices/lab_pin.sym} 154340 -19350 0 0 {name=p153553 lab=_72597_/B }
C {devices/lab_pin.sym} 154340 -19310 0 0 {name=p153554 lab=_61319_/X }
C {devices/lab_pin.sym} 154340 -19270 0 0 {name=p153555 lab=_72607_/C }
C {devices/lab_pin.sym} 154340 -19240 0 0 {name=p153556 lab=_60529_/A }
C {devices/lab_pin.sym} 154500 -19310 0 1 {name=p153557 lab=_72587_/Y }
C {sky130_stdcells/a41oi_4.sym} 154420 -19310 0 0 {name=X_72587_ }
C {devices/lab_pin.sym} 154380 -19150 0 0 {name=p153558 lab=clkbuf_0_CLK/X }
C {devices/lab_pin.sym} 154460 -19150 0 1 {name=p153559 lab=clkbuf_1_1_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 154420 -19150 0 0 {name=Xclkbuf_1_1_0_CLK }
C {devices/lab_pin.sym} 154360 -19050 0 0 {name=p153560 lab=_77106_/A }
C {devices/lab_pin.sym} 154360 -19010 0 0 {name=p153561 lab=_77114_/B }
C {devices/lab_pin.sym} 154360 -18970 0 0 {name=p153562 lab=_82288_/D }
C {devices/lab_pin.sym} 154480 -19010 0 1 {name=p153563 lab=_77115_/A }
C {sky130_stdcells/nand3_4.sym} 154420 -19010 0 0 {name=X_77114_ }
C {devices/lab_pin.sym} 154380 -18870 0 0 {name=p153564 lab=_43528_/A }
C {devices/lab_pin.sym} 154460 -18870 0 1 {name=p153565 lab=_43506_/X }
C {sky130_stdcells/buf_2.sym} 154420 -18870 0 0 {name=X_43506_ }
C {devices/lab_pin.sym} 154380 -18750 0 0 {name=p153566 lab=_62120_/A }
C {devices/lab_pin.sym} 154460 -18750 0 1 {name=p153567 lab=_62342_/A }
C {sky130_stdcells/buf_2.sym} 154420 -18750 0 0 {name=X_62340_ }
C {devices/lab_pin.sym} 154340 -18650 0 0 {name=p153568 lab=_70313_/C }
