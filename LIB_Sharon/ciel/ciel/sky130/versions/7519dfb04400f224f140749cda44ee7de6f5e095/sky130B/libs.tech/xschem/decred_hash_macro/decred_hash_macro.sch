C {devices/lab_pin.sym} 57780 -770 0 0 {name=p57724 lab=_42579_/A }
C {devices/lab_pin.sym} 57860 -770 0 1 {name=p57725 lab=_42580_/A }
C {sky130_stdcells/buf_2.sym} 57820 -770 0 0 {name=X_42579_ }
C {devices/lab_pin.sym} 58660 -42170 0 0 {name=p57726 lab=_88314_/Q }
C {devices/lab_pin.sym} 58660 -42130 0 0 {name=p57727 lab=_73059_/X }
C {devices/lab_pin.sym} 58660 -42090 0 0 {name=p57728 lab=_73007_/X }
C {devices/lab_pin.sym} 58820 -42130 0 1 {name=p57729 lab=_73399_/Y }
C {sky130_stdcells/o21ai_4.sym} 58740 -42130 0 0 {name=X_73399_ }
C {devices/lab_pin.sym} 58660 -42010 0 0 {name=p57730 lab=_47101_/Y }
C {devices/lab_pin.sym} 58660 -41970 0 0 {name=p57731 lab=_47081_/X }
C {devices/lab_pin.sym} 58660 -41930 0 0 {name=p57732 lab=_47105_/X }
C {devices/lab_pin.sym} 58820 -41970 0 1 {name=p57733 lab=_86670_/D }
C {sky130_stdcells/a21oi_4.sym} 58740 -41970 0 0 {name=X_47106_ }
C {devices/lab_pin.sym} 58680 -41840 0 0 {name=p57734 lab=_44318_/A }
C {devices/lab_pin.sym} 58680 -41800 0 0 {name=p57735 lab=_44317_/X }
C {devices/lab_pin.sym} 58800 -41820 0 1 {name=p57736 lab=_87169_/D }
C {sky130_stdcells/nor2_4.sym} 58740 -41820 0 0 {name=X_44318_ }
C {devices/lab_pin.sym} 58660 -41710 0 0 {name=p57737 lab=_79385_/A }
C {devices/lab_pin.sym} 58660 -41670 0 0 {name=p57738 lab=_63130_/X }
C {devices/lab_pin.sym} 58660 -41630 0 0 {name=p57739 lab=_63151_/Y }
C {devices/lab_pin.sym} 58820 -41670 0 1 {name=p57740 lab=_84349_/D }
C {sky130_stdcells/a21o_4.sym} 58740 -41670 0 0 {name=X_63152_ }
C {devices/lab_pin.sym} 58680 -41540 0 0 {name=p57741 lab=_75138_/A }
C {devices/lab_pin.sym} 58680 -41500 0 0 {name=p57742 lab=_75138_/B }
C {devices/lab_pin.sym} 58800 -41520 0 1 {name=p57743 lab=_75138_/Y }
C {sky130_stdcells/nor2_4.sym} 58740 -41520 0 0 {name=X_75138_ }
C {devices/lab_pin.sym} 58700 -41390 0 0 {name=p57744 lab=_60525_/A }
C {devices/lab_pin.sym} 58780 -41390 0 1 {name=p57745 lab=_60519_/B }
C {sky130_stdcells/buf_2.sym} 58740 -41390 0 0 {name=X_60364_ }
C {devices/lab_pin.sym} 58680 -41280 0 0 {name=p57746 lab=_48086_/A }
C {devices/lab_pin.sym} 58680 -41240 0 0 {name=p57747 lab=_48086_/B }
C {devices/lab_pin.sym} 58800 -41260 0 1 {name=p57748 lab=_48086_/X }
C {sky130_stdcells/or2_4.sym} 58740 -41260 0 0 {name=X_48086_ }
C {devices/lab_pin.sym} 58660 -41150 0 0 {name=p57749 lab=_55756_/B }
C {devices/lab_pin.sym} 58660 -41110 0 0 {name=p57750 lab=_45281_/X }
C {devices/lab_pin.sym} 58660 -41070 0 0 {name=p57751 lab=_45237_/X }
C {devices/lab_pin.sym} 58820 -41110 0 1 {name=p57752 lab=_45298_/X }
C {sky130_stdcells/o21a_4.sym} 58740 -41110 0 0 {name=X_45298_ }
C {devices/lab_pin.sym} 58660 -40990 0 0 {name=p57753 lab=_62100_/Y }
C {devices/lab_pin.sym} 58660 -40950 0 0 {name=p57754 lab=_62101_/X }
C {devices/lab_pin.sym} 58660 -40910 0 0 {name=p57755 lab=_62102_/Y }
C {devices/lab_pin.sym} 58820 -40950 0 1 {name=p57756 lab=_62103_/Y }
C {sky130_stdcells/a21oi_4.sym} 58740 -40950 0 0 {name=X_62103_ }
C {devices/lab_pin.sym} 58700 -40810 0 0 {name=p57757 lab=_82389_/Q }
C {devices/lab_pin.sym} 58780 -40810 0 1 {name=p57758 lab=_54509_/D }
C {sky130_stdcells/inv_2.sym} 58740 -40810 0 0 {name=X_47037_ }
C {devices/lab_pin.sym} 58700 -40690 0 0 {name=p57759 lab=_44174_/A }
C {devices/lab_pin.sym} 58780 -40690 0 1 {name=p57760 lab=_68385_/A }
C {sky130_stdcells/buf_2.sym} 58740 -40690 0 0 {name=X_44249_ }
C {devices/lab_pin.sym} 58660 -40590 0 0 {name=p57761 lab=_79447_/A }
C {devices/lab_pin.sym} 58660 -40550 0 0 {name=p57762 lab=_63072_/X }
C {devices/lab_pin.sym} 58660 -40510 0 0 {name=p57763 lab=_63082_/Y }
C {devices/lab_pin.sym} 58820 -40550 0 1 {name=p57764 lab=_84355_/D }
C {sky130_stdcells/a21o_4.sym} 58740 -40550 0 0 {name=X_63083_ }
C {devices/lab_pin.sym} 58660 -40440 0 0 {name=p57765 lab=_86949_/Q }
C {devices/lab_pin.sym} 58660 -40400 0 0 {name=p57766 lab=_67906_/X }
C {devices/lab_pin.sym} 58660 -40360 0 0 {name=p57767 lab=_67908_/X }
C {devices/lab_pin.sym} 58660 -40320 0 0 {name=p57768 lab=_67959_/X }
C {devices/lab_pin.sym} 58820 -40380 0 1 {name=p57769 lab=_67960_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -40380 0 0 {name=X_67960_ }
C {devices/lab_pin.sym} 58680 -40240 0 0 {name=p57770 lab=_75067_/Y }
C {devices/lab_pin.sym} 58680 -40200 0 0 {name=p57771 lab=_75069_/B }
C {devices/lab_pin.sym} 58800 -40220 0 1 {name=p57772 lab=_75069_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -40220 0 0 {name=X_75069_ }
C {devices/lab_pin.sym} 58680 -40100 0 0 {name=p57773 lab=_79946_/A }
C {devices/lab_pin.sym} 58680 -40060 0 0 {name=p57774 lab=_79934_/A }
C {devices/lab_pin.sym} 58800 -40080 0 1 {name=p57775 lab=_79946_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -40080 0 0 {name=X_79946_ }
C {devices/lab_pin.sym} 58660 -39990 0 0 {name=p57776 lab=_60249_/X }
C {devices/lab_pin.sym} 58660 -39950 0 0 {name=p57777 lab=_60325_/B }
C {devices/lab_pin.sym} 58660 -39910 0 0 {name=p57778 lab=_60290_/Y }
C {devices/lab_pin.sym} 58660 -39870 0 0 {name=p57779 lab=_60337_/A }
C {devices/lab_pin.sym} 58660 -39840 0 0 {name=p57780 lab=_60294_/Y }
C {devices/lab_pin.sym} 58820 -39910 0 1 {name=p57781 lab=_60295_/Y }
C {sky130_stdcells/a41oi_4.sym} 58740 -39910 0 0 {name=X_60295_ }
C {devices/lab_pin.sym} 58700 -39750 0 0 {name=p57782 lab=_66794_/A }
C {devices/lab_pin.sym} 58780 -39750 0 1 {name=p57783 lab=_66911_/X }
C {sky130_stdcells/buf_2.sym} 58740 -39750 0 0 {name=X_66911_ }
C {devices/lab_pin.sym} 58680 -39650 0 0 {name=p57784 lab=_62002_/A }
C {devices/lab_pin.sym} 58680 -39610 0 0 {name=p57785 lab=_62002_/B }
C {devices/lab_pin.sym} 58680 -39570 0 0 {name=p57786 lab=_78061_/B }
C {devices/lab_pin.sym} 58800 -39610 0 1 {name=p57787 lab=_62034_/Y }
C {sky130_stdcells/nor3_4.sym} 58740 -39610 0 0 {name=X_62034_ }
C {devices/lab_pin.sym} 58680 -39480 0 0 {name=p57788 lab=_67891_/A }
C {devices/lab_pin.sym} 58680 -39440 0 0 {name=p57789 lab=_67891_/B }
C {devices/lab_pin.sym} 58800 -39460 0 1 {name=p57790 lab=_67891_/X }
C {sky130_stdcells/and2_4.sym} 58740 -39460 0 0 {name=X_67891_ }
C {devices/lab_pin.sym} 58660 -39350 0 0 {name=p57791 lab=_79861_/X }
C {devices/lab_pin.sym} 58660 -39310 0 0 {name=p57792 lab=_79865_/B }
C {devices/lab_pin.sym} 58660 -39270 0 0 {name=p57793 lab=_79876_/X }
C {devices/lab_pin.sym} 58820 -39310 0 1 {name=p57794 lab=_79877_/X }
C {sky130_stdcells/a21o_4.sym} 58740 -39310 0 0 {name=X_79877_ }
C {devices/lab_pin.sym} 58660 -39200 0 0 {name=p57795 lab=_69198_/Y }
C {devices/lab_pin.sym} 58660 -39160 0 0 {name=p57796 lab=_69603_/X }
C {devices/lab_pin.sym} 58660 -39120 0 0 {name=p57797 lab=_69604_/X }
C {devices/lab_pin.sym} 58660 -39080 0 0 {name=p57798 lab=_69629_/Y }
C {devices/lab_pin.sym} 58820 -39140 0 1 {name=p57799 lab=_69630_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -39140 0 0 {name=X_69630_ }
C {devices/lab_pin.sym} 58660 -39020 0 0 {name=p57800 lab=_87368_/Q }
C {devices/lab_pin.sym} 58660 -38980 0 0 {name=p57801 lab=_66797_/X }
C {devices/lab_pin.sym} 58660 -38940 0 0 {name=p57802 lab=_66747_/X }
C {devices/lab_pin.sym} 58660 -38900 0 0 {name=p57803 lab=_66841_/X }
C {devices/lab_pin.sym} 58820 -38960 0 1 {name=p57804 lab=_66842_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -38960 0 0 {name=X_66842_ }
C {devices/lab_pin.sym} 58680 -38830 0 0 {name=p57805 lab=_78828_/A }
C {devices/lab_pin.sym} 58680 -38790 0 0 {name=p57806 lab=_78828_/B }
C {devices/lab_pin.sym} 58680 -38750 0 0 {name=p57807 lab=_78828_/C }
C {devices/lab_pin.sym} 58800 -38790 0 1 {name=p57808 lab=_78828_/Y }
C {sky130_stdcells/nand3_4.sym} 58740 -38790 0 0 {name=X_78828_ }
C {devices/lab_pin.sym} 58700 -38650 0 0 {name=p57809 lab=_48988_/A }
C {devices/lab_pin.sym} 58780 -38650 0 1 {name=p57810 lab=_53834_/B }
C {sky130_stdcells/buf_2.sym} 58740 -38650 0 0 {name=X_48988_ }
C {devices/lab_pin.sym} 58660 -38550 0 0 {name=p57811 lab=_69127_/X }
C {devices/lab_pin.sym} 58660 -38510 0 0 {name=p57812 lab=_69130_/X }
C {devices/lab_pin.sym} 58660 -38470 0 0 {name=p57813 lab=_69500_/X }
C {devices/lab_pin.sym} 58820 -38510 0 1 {name=p57814 lab=_69561_/Y }
C {sky130_stdcells/a21oi_4.sym} 58740 -38510 0 0 {name=X_69561_ }
C {devices/lab_pin.sym} 58700 -38370 0 0 {name=p57815 lab=_83775_/Q }
C {devices/lab_pin.sym} 58780 -38370 0 1 {name=p57816 lab=_57537_/B }
C {sky130_stdcells/inv_2.sym} 58740 -38370 0 0 {name=X_47939_ }
C {devices/lab_pin.sym} 58700 -38250 0 0 {name=p57817 lab=clkbuf_8_75_0_CLK/X }
C {devices/lab_pin.sym} 58780 -38250 0 1 {name=p57818 lab=clkbuf_9_150_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 58740 -38250 0 0 {name=Xclkbuf_9_150_0_CLK }
C {devices/lab_pin.sym} 58660 -38160 0 0 {name=p57819 lab=_87883_/Q }
C {devices/lab_pin.sym} 58660 -38120 0 0 {name=p57820 lab=_66697_/X }
C {devices/lab_pin.sym} 58660 -38080 0 0 {name=p57821 lab=_66675_/X }
C {devices/lab_pin.sym} 58660 -38040 0 0 {name=p57822 lab=_66772_/X }
C {devices/lab_pin.sym} 58820 -38100 0 1 {name=p57823 lab=_66773_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -38100 0 0 {name=X_66773_ }
C {devices/lab_pin.sym} 58680 -37960 0 0 {name=p57824 lab=_78770_/B }
C {devices/lab_pin.sym} 58680 -37920 0 0 {name=p57825 lab=_78770_/D }
C {devices/lab_pin.sym} 58800 -37940 0 1 {name=p57826 lab=_78759_/X }
C {sky130_stdcells/and2_4.sym} 58740 -37940 0 0 {name=X_78759_ }
C {devices/lab_pin.sym} 58680 -37840 0 0 {name=p57827 lab=_63979_/Y }
C {devices/lab_pin.sym} 58680 -37800 0 0 {name=p57828 lab=_63980_/Y }
C {devices/lab_pin.sym} 58680 -37760 0 0 {name=p57829 lab=_63981_/Y }
C {devices/lab_pin.sym} 58680 -37720 0 0 {name=p57830 lab=_63985_/D }
C {devices/lab_pin.sym} 58800 -37780 0 1 {name=p57831 lab=_63985_/X }
C {sky130_stdcells/and4_4.sym} 58740 -37780 0 0 {name=X_63985_ }
C {devices/lab_pin.sym} 58700 -37630 0 0 {name=p57832 lab=_68208_/X }
C {devices/lab_pin.sym} 58780 -37630 0 1 {name=p57833 lab=_68512_/X }
C {sky130_stdcells/buf_2.sym} 58740 -37630 0 0 {name=X_68512_ }
C {devices/lab_pin.sym} 58660 -37540 0 0 {name=p57834 lab=_65660_/X }
C {devices/lab_pin.sym} 58660 -37500 0 0 {name=p57835 lab=_83062_/Q }
C {devices/lab_pin.sym} 58660 -37460 0 0 {name=p57836 lab=_65568_/X }
C {devices/lab_pin.sym} 58660 -37420 0 0 {name=p57837 lab=_65723_/X }
C {devices/lab_pin.sym} 58820 -37480 0 1 {name=p57838 lab=_65724_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -37480 0 0 {name=X_65724_ }
C {devices/lab_pin.sym} 58680 -37340 0 0 {name=p57839 lab=_50938_/X }
C {devices/lab_pin.sym} 58680 -37300 0 0 {name=p57840 lab=_51812_/B }
C {devices/lab_pin.sym} 58800 -37320 0 1 {name=p57841 lab=_50950_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -37320 0 0 {name=X_50950_ }
C {devices/lab_pin.sym} 58700 -37190 0 0 {name=p57842 lab=_62646_/B }
C {devices/lab_pin.sym} 58780 -37190 0 1 {name=p57843 lab=_62936_/X }
C {sky130_stdcells/buf_2.sym} 58740 -37190 0 0 {name=X_62936_ }
C {devices/lab_pin.sym} 58650 -37070 0 0 {name=p57844 lab=_82896_/CLK }
C {devices/lab_pin.sym} 58650 -37050 0 0 {name=p57845 lab=_76032_/X }
C {devices/lab_pin.sym} 58830 -37070 0 1 {name=p57846 lab=_81770_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -37060 0 0 {name=X_81770_ }
C {devices/lab_pin.sym} 58680 -36940 0 0 {name=p57847 lab=_69580_/A }
C {devices/lab_pin.sym} 58680 -36900 0 0 {name=p57848 lab=_87769_/Q }
C {devices/lab_pin.sym} 58800 -36920 0 1 {name=p57849 lab=_69492_/X }
C {sky130_stdcells/and2_4.sym} 58740 -36920 0 0 {name=X_69492_ }
C {devices/lab_pin.sym} 58700 -36790 0 0 {name=p57850 lab=clkbuf_9_337_0_CLK/X }
C {devices/lab_pin.sym} 58780 -36790 0 1 {name=p57851 lab=_87150_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 58740 -36790 0 0 {name=Xclkbuf_10_674_0_CLK }
C {devices/lab_pin.sym} 58660 -36690 0 0 {name=p57852 lab=_59167_/B }
C {devices/lab_pin.sym} 58660 -36650 0 0 {name=p57853 lab=_49606_/X }
C {devices/lab_pin.sym} 58660 -36610 0 0 {name=p57854 lab=_49608_/Y }
C {devices/lab_pin.sym} 58820 -36650 0 1 {name=p57855 lab=_49609_/Y }
C {sky130_stdcells/o21ai_4.sym} 58740 -36650 0 0 {name=X_49609_ }
C {devices/lab_pin.sym} 58650 -36510 0 0 {name=p57856 lab=_80721_/CLK }
C {devices/lab_pin.sym} 58650 -36490 0 0 {name=p57857 lab=_75907_/X }
C {devices/lab_pin.sym} 58830 -36510 0 1 {name=p57858 lab=_80721_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -36500 0 0 {name=X_80721_ }
C {devices/lab_pin.sym} 58660 -36390 0 0 {name=p57859 lab=_68438_/X }
C {devices/lab_pin.sym} 58660 -36350 0 0 {name=p57860 lab=_68441_/X }
C {devices/lab_pin.sym} 58660 -36310 0 0 {name=p57861 lab=_68442_/X }
C {devices/lab_pin.sym} 58820 -36350 0 1 {name=p57862 lab=_68446_/A }
C {sky130_stdcells/a21o_4.sym} 58740 -36350 0 0 {name=X_68443_ }
C {devices/lab_pin.sym} 58680 -36220 0 0 {name=p57863 lab=_65731_/A }
C {devices/lab_pin.sym} 58680 -36180 0 0 {name=p57864 lab=_85874_/Q }
C {devices/lab_pin.sym} 58800 -36200 0 1 {name=p57865 lab=_65655_/X }
C {sky130_stdcells/and2_4.sym} 58740 -36200 0 0 {name=X_65655_ }
C {devices/lab_pin.sym} 58660 -36090 0 0 {name=p57866 lab=_50879_/Y }
C {devices/lab_pin.sym} 58660 -36050 0 0 {name=p57867 lab=_50839_/X }
C {devices/lab_pin.sym} 58660 -36010 0 0 {name=p57868 lab=_50880_/X }
C {devices/lab_pin.sym} 58820 -36050 0 1 {name=p57869 lab=_86114_/D }
C {sky130_stdcells/a21oi_4.sym} 58740 -36050 0 0 {name=X_50881_ }
C {devices/lab_pin.sym} 58660 -35930 0 0 {name=p57870 lab=_63586_/A }
C {devices/lab_pin.sym} 58660 -35890 0 0 {name=p57871 lab=_60337_/D }
C {devices/lab_pin.sym} 58660 -35850 0 0 {name=p57872 lab=_62866_/Y }
C {devices/lab_pin.sym} 58820 -35890 0 1 {name=p57873 lab=_62867_/X }
C {sky130_stdcells/o21a_4.sym} 58740 -35890 0 0 {name=X_62867_ }
C {devices/lab_pin.sym} 58700 -35750 0 0 {name=p57874 lab=_52620_/A }
C {devices/lab_pin.sym} 58780 -35750 0 1 {name=p57875 lab=_52648_/A }
C {sky130_stdcells/buf_2.sym} 58740 -35750 0 0 {name=X_52620_ }
C {devices/lab_pin.sym} 58700 -35630 0 0 {name=p57876 lab=clkbuf_8_82_0_CLK/X }
C {devices/lab_pin.sym} 58780 -35630 0 1 {name=p57877 lab=clkbuf_9_165_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 58740 -35630 0 0 {name=Xclkbuf_9_165_0_CLK }
C {devices/lab_pin.sym} 58660 -35530 0 0 {name=p57878 lab=_64561_/X }
C {devices/lab_pin.sym} 58660 -35490 0 0 {name=p57879 lab=_64582_/Y }
C {devices/lab_pin.sym} 58660 -35450 0 0 {name=p57880 lab=_64605_/Y }
C {devices/lab_pin.sym} 58820 -35490 0 1 {name=p57881 lab=_64606_/Y }
C {sky130_stdcells/o21ai_4.sym} 58740 -35490 0 0 {name=X_64606_ }
C {devices/lab_pin.sym} 58650 -35350 0 0 {name=p57882 lab=_83491_/CLK }
C {devices/lab_pin.sym} 58650 -35330 0 0 {name=p57883 lab=_83440_/D }
C {devices/lab_pin.sym} 58830 -35350 0 1 {name=p57884 lab=_83440_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -35340 0 0 {name=X_83440_ }
C {devices/lab_pin.sym} 58700 -35210 0 0 {name=p57885 lab=_59770_/A }
C {devices/lab_pin.sym} 58780 -35210 0 1 {name=p57886 lab=_62851_/A }
C {sky130_stdcells/buf_2.sym} 58740 -35210 0 0 {name=X_61818_ }
C {devices/lab_pin.sym} 58650 -35090 0 0 {name=p57887 lab=_80657_/CLK }
C {devices/lab_pin.sym} 58650 -35070 0 0 {name=p57888 lab=_80652_/D }
C {devices/lab_pin.sym} 58830 -35090 0 1 {name=p57889 lab=_46094_/A }
C {sky130_stdcells/dfxtp_4.sym} 58740 -35080 0 0 {name=X_80652_ }
C {devices/lab_pin.sym} 58660 -34980 0 0 {name=p57890 lab=_68357_/Y }
C {devices/lab_pin.sym} 58660 -34940 0 0 {name=p57891 lab=_68358_/X }
C {devices/lab_pin.sym} 58660 -34900 0 0 {name=p57892 lab=_68326_/X }
C {devices/lab_pin.sym} 58660 -34860 0 0 {name=p57893 lab=_68373_/Y }
C {devices/lab_pin.sym} 58820 -34920 0 1 {name=p57894 lab=_68374_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -34920 0 0 {name=X_68374_ }
C {devices/lab_pin.sym} 58680 -34790 0 0 {name=p57895 lab=_65582_/X }
C {devices/lab_pin.sym} 58680 -34750 0 0 {name=p57896 lab=_65663_/B }
C {devices/lab_pin.sym} 58680 -34710 0 0 {name=p57897 lab=_65585_/X }
C {devices/lab_pin.sym} 58800 -34750 0 1 {name=p57898 lab=_65587_/B }
C {sky130_stdcells/nand3_4.sym} 58740 -34750 0 0 {name=X_65586_ }
C {devices/lab_pin.sym} 58700 -34610 0 0 {name=p57899 lab=clkbuf_9_93_0_CLK/A }
C {devices/lab_pin.sym} 58780 -34610 0 1 {name=p57900 lab=clkbuf_9_92_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 58740 -34610 0 0 {name=Xclkbuf_9_92_0_CLK }
C {devices/lab_pin.sym} 58660 -34530 0 0 {name=p57901 lab=_57670_/A }
C {devices/lab_pin.sym} 58660 -34490 0 0 {name=p57902 lab=_62749_/X }
C {devices/lab_pin.sym} 58660 -34450 0 0 {name=p57903 lab=_62768_/X }
C {devices/lab_pin.sym} 58660 -34410 0 0 {name=p57904 lab=_62759_/X }
C {devices/lab_pin.sym} 58660 -34380 0 0 {name=p57905 lab=_62797_/X }
C {devices/lab_pin.sym} 58820 -34450 0 1 {name=p57906 lab=_62798_/Y }
C {sky130_stdcells/a41oi_4.sym} 58740 -34450 0 0 {name=X_62798_ }
C {devices/lab_pin.sym} 58660 -34320 0 0 {name=p57907 lab=_87104_/Q }
C {devices/lab_pin.sym} 58660 -34280 0 0 {name=p57908 lab=_67230_/X }
C {devices/lab_pin.sym} 58660 -34240 0 0 {name=p57909 lab=_67278_/X }
C {devices/lab_pin.sym} 58660 -34200 0 0 {name=p57910 lab=_67324_/X }
C {devices/lab_pin.sym} 58820 -34260 0 1 {name=p57911 lab=_67325_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -34260 0 0 {name=X_67325_ }
C {devices/lab_pin.sym} 58680 -34120 0 0 {name=p57912 lab=_52567_/A }
C {devices/lab_pin.sym} 58680 -34080 0 0 {name=p57913 lab=_54069_/B }
C {devices/lab_pin.sym} 58800 -34100 0 1 {name=p57914 lab=_52551_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -34100 0 0 {name=X_52551_ }
C {devices/lab_pin.sym} 58680 -33990 0 0 {name=p57915 lab=_64455_/X }
C {devices/lab_pin.sym} 58680 -33950 0 0 {name=p57916 lab=_84732_/Q }
C {devices/lab_pin.sym} 58680 -33910 0 0 {name=p57917 lab=_61102_/X }
C {devices/lab_pin.sym} 58800 -33950 0 1 {name=p57918 lab=_64537_/Y }
C {sky130_stdcells/nand3_4.sym} 58740 -33950 0 0 {name=X_64537_ }
C {devices/lab_pin.sym} 58650 -33810 0 0 {name=p57919 lab=_83372_/CLK }
C {devices/lab_pin.sym} 58650 -33790 0 0 {name=p57920 lab=_83371_/D }
C {devices/lab_pin.sym} 58830 -33810 0 1 {name=p57921 lab=_83371_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -33800 0 0 {name=X_83371_ }
C {devices/lab_pin.sym} 58680 -33700 0 0 {name=p57922 lab=_61744_/X }
C {devices/lab_pin.sym} 58680 -33660 0 0 {name=p57923 lab=_61749_/B }
C {devices/lab_pin.sym} 58680 -33620 0 0 {name=p57924 lab=_61765_/C }
C {devices/lab_pin.sym} 58680 -33580 0 0 {name=p57925 lab=_61748_/X }
C {devices/lab_pin.sym} 58800 -33640 0 1 {name=p57926 lab=_61749_/Y }
C {sky130_stdcells/nand4_4.sym} 58740 -33640 0 0 {name=X_61749_ }
C {devices/lab_pin.sym} 58660 -33510 0 0 {name=p57927 lab=_80570_/Y }
C {devices/lab_pin.sym} 58660 -33470 0 0 {name=p57928 lab=_80574_/Y }
C {devices/lab_pin.sym} 58660 -33430 0 0 {name=p57929 lab=_80582_/X }
C {devices/lab_pin.sym} 58820 -33470 0 1 {name=p57930 lab=_80584_/B }
C {sky130_stdcells/o21ai_4.sym} 58740 -33470 0 0 {name=X_80583_ }
C {sky130_stdcells/decap_3.sym} 58740 -33300 0 0 {name=XPHY_308 }
C {devices/lab_pin.sym} 58700 -33150 0 0 {name=p57931 lab=clkbuf_9_344_0_CLK/X }
C {devices/lab_pin.sym} 58780 -33150 0 1 {name=p57932 lab=_87436_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 58740 -33150 0 0 {name=Xclkbuf_10_689_0_CLK }
C {devices/lab_pin.sym} 58650 -33030 0 0 {name=p57933 lab=_85114_/CLK }
C {devices/lab_pin.sym} 58650 -33010 0 0 {name=p57934 lab=_85110_/D }
C {devices/lab_pin.sym} 58830 -33030 0 1 {name=p57935 lab=_45572_/A }
C {sky130_stdcells/dfxtp_4.sym} 58740 -33020 0 0 {name=X_85110_ }
C {sky130_stdcells/decap_3.sym} 58740 -32860 0 0 {name=XPHY_319 }
C {devices/lab_pin.sym} 58660 -32730 0 0 {name=p57936 lab=_85998_/Q }
C {devices/lab_pin.sym} 58660 -32690 0 0 {name=p57937 lab=_51485_/X }
C {devices/lab_pin.sym} 58660 -32650 0 0 {name=p57938 lab=_51501_/Y }
C {devices/lab_pin.sym} 58820 -32690 0 1 {name=p57939 lab=_51502_/Y }
C {sky130_stdcells/o21ai_4.sym} 58740 -32690 0 0 {name=X_51502_ }
C {devices/lab_pin.sym} 58650 -32550 0 0 {name=p57940 lab=_82327_/CLK }
C {devices/lab_pin.sym} 58650 -32530 0 0 {name=p57941 lab=_77118_/B }
C {devices/lab_pin.sym} 58830 -32550 0 1 {name=p57942 lab=_82322_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -32540 0 0 {name=X_82322_ }
C {devices/lab_pin.sym} 58660 -32440 0 0 {name=p57943 lab=_45808_/A }
C {devices/lab_pin.sym} 58660 -32400 0 0 {name=p57944 lab=_55272_/A }
C {devices/lab_pin.sym} 58660 -32360 0 0 {name=p57945 lab=_44044_/X }
C {devices/lab_pin.sym} 58660 -32320 0 0 {name=p57946 lab=_55269_/X }
C {devices/lab_pin.sym} 58820 -32380 0 1 {name=p57947 lab=_55270_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -32380 0 0 {name=X_55270_ }
C {devices/lab_pin.sym} 58660 -32250 0 0 {name=p57948 lab=_67252_/X }
C {devices/lab_pin.sym} 58660 -32210 0 0 {name=p57949 lab=_67254_/X }
C {devices/lab_pin.sym} 58660 -32170 0 0 {name=p57950 lab=_67255_/X }
C {devices/lab_pin.sym} 58820 -32210 0 1 {name=p57951 lab=_67256_/Y }
C {sky130_stdcells/a21oi_4.sym} 58740 -32210 0 0 {name=X_67256_ }
C {devices/lab_pin.sym} 58650 -32070 0 0 {name=p57952 lab=_85770_/CLK }
C {devices/lab_pin.sym} 58650 -32050 0 0 {name=p57953 lab=_86090_/D }
C {devices/lab_pin.sym} 58830 -32070 0 1 {name=p57954 lab=_86090_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -32060 0 0 {name=X_86090_ }
C {devices/lab_pin.sym} 58680 -31940 0 0 {name=p57955 lab=_52468_/A }
C {devices/lab_pin.sym} 58680 -31900 0 0 {name=p57956 lab=_52482_/B }
C {devices/lab_pin.sym} 58800 -31920 0 1 {name=p57957 lab=_52482_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -31920 0 0 {name=X_52482_ }
C {devices/lab_pin.sym} 58680 -31810 0 0 {name=p57958 lab=_64515_/A }
C {devices/lab_pin.sym} 58680 -31770 0 0 {name=p57959 lab=_84859_/Q }
C {devices/lab_pin.sym} 58680 -31730 0 0 {name=p57960 lab=_64515_/C }
C {devices/lab_pin.sym} 58800 -31770 0 1 {name=p57961 lab=_64468_/Y }
C {sky130_stdcells/nand3_4.sym} 58740 -31770 0 0 {name=X_64468_ }
C {devices/lab_pin.sym} 58700 -31630 0 0 {name=p57962 lab=_47832_/X }
C {devices/lab_pin.sym} 58780 -31630 0 1 {name=p57963 lab=_54250_/A }
C {sky130_stdcells/buf_2.sym} 58740 -31630 0 0 {name=X_54221_ }
C {devices/lab_pin.sym} 58660 -31530 0 0 {name=p57964 lab=_66204_/Y }
C {devices/lab_pin.sym} 58660 -31490 0 0 {name=p57965 lab=_66205_/X }
C {devices/lab_pin.sym} 58660 -31450 0 0 {name=p57966 lab=_66206_/X }
C {devices/lab_pin.sym} 58820 -31490 0 1 {name=p57967 lab=_84149_/D }
C {sky130_stdcells/a21o_4.sym} 58740 -31490 0 0 {name=X_66207_ }
C {devices/lab_pin.sym} 58650 -31350 0 0 {name=p57968 lab=_85041_/CLK }
C {devices/lab_pin.sym} 58650 -31330 0 0 {name=p57969 lab=_85041_/D }
C {devices/lab_pin.sym} 58830 -31350 0 1 {name=p57970 lab=_45647_/A }
C {sky130_stdcells/dfxtp_4.sym} 58740 -31340 0 0 {name=X_85041_ }
C {devices/lab_pin.sym} 58680 -31240 0 0 {name=p57971 lab=_51410_/X }
C {devices/lab_pin.sym} 58680 -31200 0 0 {name=p57972 lab=_51421_/X }
C {devices/lab_pin.sym} 58680 -31160 0 0 {name=p57973 lab=_51438_/C }
C {devices/lab_pin.sym} 58680 -31120 0 0 {name=p57974 lab=_52963_/D }
C {devices/lab_pin.sym} 58800 -31180 0 1 {name=p57975 lab=_51433_/X }
C {sky130_stdcells/and4_4.sym} 58740 -31180 0 0 {name=X_51433_ }
C {devices/lab_pin.sym} 58660 -31070 0 0 {name=p57976 lab=_63368_/X }
C {devices/lab_pin.sym} 58660 -31030 0 0 {name=p57977 lab=_63410_/X }
C {devices/lab_pin.sym} 58660 -30990 0 0 {name=p57978 lab=_63411_/X }
C {devices/lab_pin.sym} 58660 -30950 0 0 {name=p57979 lab=_63415_/X }
C {devices/lab_pin.sym} 58660 -30910 0 0 {name=p57980 lab=_63418_/Y }
C {devices/lab_pin.sym} 58820 -30990 0 1 {name=p57981 lab=_63419_/Y }
C {sky130_stdcells/o41ai_4.sym} 58740 -30990 0 0 {name=X_63419_ }
C {devices/lab_pin.sym} 58650 -30830 0 0 {name=p57982 lab=_82253_/CLK }
C {devices/lab_pin.sym} 58650 -30810 0 0 {name=p57983 lab=_80418_/X }
C {devices/lab_pin.sym} 58830 -30830 0 1 {name=p57984 lab=_82253_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -30820 0 0 {name=X_82253_ }
C {devices/lab_pin.sym} 58660 -30710 0 0 {name=p57985 lab=_84080_/Q }
C {devices/lab_pin.sym} 58660 -30670 0 0 {name=p57986 lab=_67092_/X }
C {devices/lab_pin.sym} 58660 -30630 0 0 {name=p57987 lab=_67186_/X }
C {devices/lab_pin.sym} 58820 -30670 0 1 {name=p57988 lab=_84080_/D }
C {sky130_stdcells/a21bo_4.sym} 58740 -30670 0 0 {name=X_67187_ }
C {devices/lab_pin.sym} 58680 -30540 0 0 {name=p57989 lab=_58434_/A }
C {devices/lab_pin.sym} 58680 -30500 0 0 {name=p57990 lab=_64418_/B }
C {devices/lab_pin.sym} 58800 -30520 0 1 {name=p57991 lab=_64399_/Y }
C {sky130_stdcells/nor2_4.sym} 58740 -30520 0 0 {name=X_64399_ }
C {devices/lab_pin.sym} 58650 -30390 0 0 {name=p57992 lab=_81211_/CLK }
C {devices/lab_pin.sym} 58650 -30370 0 0 {name=p57993 lab=_75028_/X }
C {devices/lab_pin.sym} 58830 -30390 0 1 {name=p57994 lab=_49019_/A }
C {sky130_stdcells/dfxtp_4.sym} 58740 -30380 0 0 {name=X_81204_ }
C {devices/lab_pin.sym} 58700 -30250 0 0 {name=p57995 lab=clkbuf_9_306_0_CLK/X }
C {devices/lab_pin.sym} 58780 -30250 0 1 {name=p57996 lab=_80818_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 58740 -30250 0 0 {name=Xclkbuf_10_612_0_CLK }
C {devices/lab_pin.sym} 58660 -30150 0 0 {name=p57997 lab=_54150_/Y }
C {devices/lab_pin.sym} 58660 -30110 0 0 {name=p57998 lab=_54144_/X }
C {devices/lab_pin.sym} 58660 -30070 0 0 {name=p57999 lab=_54151_/X }
C {devices/lab_pin.sym} 58820 -30110 0 1 {name=p58000 lab=_85495_/D }
C {sky130_stdcells/a21oi_4.sym} 58740 -30110 0 0 {name=X_54152_ }
C {devices/lab_pin.sym} 58700 -29970 0 0 {name=p58001 lab=_66138_/A }
C {devices/lab_pin.sym} 58780 -29970 0 1 {name=p58002 lab=_66138_/Y }
C {sky130_stdcells/inv_2.sym} 58740 -29970 0 0 {name=X_66138_ }
C {devices/lab_pin.sym} 58680 -29860 0 0 {name=p58003 lab=_51364_/A }
C {devices/lab_pin.sym} 58680 -29820 0 0 {name=p58004 lab=_50852_/B }
C {devices/lab_pin.sym} 58800 -29840 0 1 {name=p58005 lab=_51364_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -29840 0 0 {name=X_51364_ }
C {devices/lab_pin.sym} 58650 -29710 0 0 {name=p58006 lab=_85407_/CLK }
C {devices/lab_pin.sym} 58650 -29690 0 0 {name=p58007 lab=_82184_/D }
C {devices/lab_pin.sym} 58830 -29710 0 1 {name=p58008 lab=_82184_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -29700 0 0 {name=X_82184_ }
C {devices/lab_pin.sym} 58680 -29600 0 0 {name=p58009 lab=_53107_/A }
C {devices/lab_pin.sym} 58680 -29560 0 0 {name=p58010 lab=_53113_/B }
C {devices/lab_pin.sym} 58680 -29520 0 0 {name=p58011 lab=_53107_/C }
C {devices/lab_pin.sym} 58680 -29480 0 0 {name=p58012 lab=_53103_/D }
C {devices/lab_pin.sym} 58800 -29540 0 1 {name=p58013 lab=_53103_/X }
C {sky130_stdcells/and4_4.sym} 58740 -29540 0 0 {name=X_53103_ }
C {devices/lab_pin.sym} 58660 -29410 0 0 {name=p58014 lab=_50311_/Y }
C {devices/lab_pin.sym} 58660 -29370 0 0 {name=p58015 lab=_50313_/X }
C {devices/lab_pin.sym} 58660 -29330 0 0 {name=p58016 lab=_50314_/X }
C {devices/lab_pin.sym} 58820 -29370 0 1 {name=p58017 lab=_86225_/D }
C {sky130_stdcells/a21oi_4.sym} 58740 -29370 0 0 {name=X_50315_ }
C {devices/lab_pin.sym} 58650 -29230 0 0 {name=p58018 lab=_83957_/CLK }
C {devices/lab_pin.sym} 58650 -29210 0 0 {name=p58019 lab=_81135_/D }
C {devices/lab_pin.sym} 58830 -29230 0 1 {name=p58020 lab=_40689_/A }
C {sky130_stdcells/dfxtp_4.sym} 58740 -29220 0 0 {name=X_81135_ }
C {devices/lab_pin.sym} 58700 -29090 0 0 {name=p58021 lab=clkbuf_8_51_0_CLK/X }
C {devices/lab_pin.sym} 58780 -29090 0 1 {name=p58022 lab=clkbuf_9_103_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 58740 -29090 0 0 {name=Xclkbuf_9_103_0_CLK }
C {devices/lab_pin.sym} 58660 -29010 0 0 {name=p58023 lab=_58918_/X }
C {devices/lab_pin.sym} 58660 -28970 0 0 {name=p58024 lab=_58957_/Y }
C {devices/lab_pin.sym} 58660 -28930 0 0 {name=p58025 lab=_58958_/Y }
C {devices/lab_pin.sym} 58660 -28890 0 0 {name=p58026 lab=_58959_/X }
C {devices/lab_pin.sym} 58660 -28850 0 0 {name=p58027 lab=_58923_/X }
C {devices/lab_pin.sym} 58820 -28930 0 1 {name=p58028 lab=_58960_/X }
C {sky130_stdcells/o32a_4.sym} 58740 -28930 0 0 {name=X_58960_ }
C {devices/lab_pin.sym} 58680 -28780 0 0 {name=p58029 lab=_53801_/B }
C {devices/lab_pin.sym} 58680 -28740 0 0 {name=p58030 lab=_52565_/B }
C {devices/lab_pin.sym} 58800 -28760 0 1 {name=p58031 lab=_54083_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -28760 0 0 {name=X_54083_ }
C {devices/lab_pin.sym} 58680 -28640 0 0 {name=p58032 lab=_64593_/A }
C {devices/lab_pin.sym} 58680 -28600 0 0 {name=p58033 lab=_73827_/B }
C {devices/lab_pin.sym} 58800 -28620 0 1 {name=p58034 lab=_66069_/X }
C {sky130_stdcells/and2_4.sym} 58740 -28620 0 0 {name=X_66069_ }
C {devices/lab_pin.sym} 58660 -28510 0 0 {name=p58035 lab=_51293_/Y }
C {devices/lab_pin.sym} 58660 -28470 0 0 {name=p58036 lab=_51289_/X }
C {devices/lab_pin.sym} 58660 -28430 0 0 {name=p58037 lab=_51294_/X }
C {devices/lab_pin.sym} 58820 -28470 0 1 {name=p58038 lab=_51295_/Y }
C {sky130_stdcells/a21oi_4.sym} 58740 -28470 0 0 {name=X_51295_ }
C {devices/lab_pin.sym} 58650 -28330 0 0 {name=p58039 lab=_82536_/CLK }
C {devices/lab_pin.sym} 58650 -28310 0 0 {name=p58040 lab=_86992_/D }
C {devices/lab_pin.sym} 58830 -28330 0 1 {name=p58041 lab=_44705_/A }
C {sky130_stdcells/dfxtp_4.sym} 58740 -28320 0 0 {name=X_86992_ }
C {devices/lab_pin.sym} 58700 -28190 0 0 {name=p58042 lab=clkbuf_9_31_0_CLK/A }
C {devices/lab_pin.sym} 58780 -28190 0 1 {name=p58043 lab=clkbuf_9_30_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 58740 -28190 0 0 {name=Xclkbuf_9_30_0_CLK }
C {devices/lab_pin.sym} 58660 -28090 0 0 {name=p58044 lab=_85709_/Q }
C {devices/lab_pin.sym} 58660 -28050 0 0 {name=p58045 lab=_53010_/X }
C {devices/lab_pin.sym} 58660 -28010 0 0 {name=p58046 lab=_53033_/Y }
C {devices/lab_pin.sym} 58820 -28050 0 1 {name=p58047 lab=_53034_/Y }
C {sky130_stdcells/o21ai_4.sym} 58740 -28050 0 0 {name=X_53034_ }
C {devices/lab_pin.sym} 58660 -27940 0 0 {name=p58048 lab=_84941_/Q }
C {devices/lab_pin.sym} 58660 -27900 0 0 {name=p58049 lab=_57896_/X }
C {devices/lab_pin.sym} 58660 -27860 0 0 {name=p58050 lab=_57900_/X }
C {devices/lab_pin.sym} 58660 -27820 0 0 {name=p58051 lab=_57910_/X }
C {devices/lab_pin.sym} 58820 -27880 0 1 {name=p58052 lab=_84941_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 58740 -27880 0 0 {name=X_57911_ }
C {devices/lab_pin.sym} 58700 -27730 0 0 {name=p58053 lab=_50537_/A }
C {devices/lab_pin.sym} 58780 -27730 0 1 {name=p58054 lab=_53190_/A }
C {sky130_stdcells/buf_2.sym} 58740 -27730 0 0 {name=X_50246_ }
C {devices/lab_pin.sym} 58650 -27610 0 0 {name=p58055 lab=_82768_/CLK }
C {devices/lab_pin.sym} 58650 -27590 0 0 {name=p58056 lab=_51806_/Y }
C {devices/lab_pin.sym} 58830 -27610 0 1 {name=p58057 lab=_85943_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -27600 0 0 {name=X_85943_ }
C {devices/lab_pin.sym} 58650 -27470 0 0 {name=p58058 lab=_81065_/CLK }
C {devices/lab_pin.sym} 58650 -27450 0 0 {name=p58059 lab=_81098_/Q }
C {devices/lab_pin.sym} 58830 -27470 0 1 {name=p58060 lab=_75186_/B }
C {sky130_stdcells/dfxtp_4.sym} 58740 -27460 0 0 {name=X_81066_ }
C {devices/lab_pin.sym} 58700 -27330 0 0 {name=p58061 lab=_59061_/A }
C {devices/lab_pin.sym} 58780 -27330 0 1 {name=p58062 lab=_58891_/X }
C {sky130_stdcells/buf_2.sym} 58740 -27330 0 0 {name=X_58891_ }
C {devices/lab_pin.sym} 58700 -27210 0 0 {name=p58063 lab=clkbuf_9_313_0_CLK/X }
C {devices/lab_pin.sym} 58780 -27210 0 1 {name=p58064 lab=_81996_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 58740 -27210 0 0 {name=Xclkbuf_10_627_0_CLK }
C {devices/lab_pin.sym} 58680 -27100 0 0 {name=p58065 lab=_84931_/Q }
C {devices/lab_pin.sym} 58680 -27060 0 0 {name=p58066 lab=_84179_/Q }
C {devices/lab_pin.sym} 58800 -27080 0 1 {name=p58067 lab=_80019_/A }
C {sky130_stdcells/xor2_4.sym} 58740 -27080 0 0 {name=X_80017_ }
C {devices/lab_pin.sym} 58660 -26980 0 0 {name=p58068 lab=_84946_/Q }
C {devices/lab_pin.sym} 58660 -26940 0 0 {name=p58069 lab=_57819_/X }
C {devices/lab_pin.sym} 58660 -26900 0 0 {name=p58070 lab=_57834_/X }
C {devices/lab_pin.sym} 58660 -26860 0 0 {name=p58071 lab=_57841_/X }
C {devices/lab_pin.sym} 58820 -26920 0 1 {name=p58072 lab=_84946_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 58740 -26920 0 0 {name=X_57842_ }
C {devices/lab_pin.sym} 58660 -26790 0 0 {name=p58073 lab=_69825_/X }
C {devices/lab_pin.sym} 58660 -26750 0 0 {name=p58074 lab=_69827_/X }
C {devices/lab_pin.sym} 58660 -26710 0 0 {name=p58075 lab=_69742_/X }
C {devices/lab_pin.sym} 58820 -26750 0 1 {name=p58076 lab=_69828_/Y }
C {sky130_stdcells/a21oi_4.sym} 58740 -26750 0 0 {name=X_69828_ }
C {devices/lab_pin.sym} 58680 -26620 0 0 {name=p58077 lab=_50169_/A }
C {devices/lab_pin.sym} 58680 -26580 0 0 {name=p58078 lab=_49135_/X }
C {devices/lab_pin.sym} 58800 -26600 0 1 {name=p58079 lab=_50177_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -26600 0 0 {name=X_50177_ }
C {devices/lab_pin.sym} 58650 -26470 0 0 {name=p58080 lab=_86193_/CLK }
C {devices/lab_pin.sym} 58650 -26450 0 0 {name=p58081 lab=_85874_/D }
C {devices/lab_pin.sym} 58830 -26470 0 1 {name=p58082 lab=_85874_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -26460 0 0 {name=X_85874_ }
C {devices/lab_pin.sym} 58700 -26330 0 0 {name=p58083 lab=clkbuf_8_59_0_CLK/X }
C {devices/lab_pin.sym} 58780 -26330 0 1 {name=p58084 lab=clkbuf_9_118_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 58740 -26330 0 0 {name=Xclkbuf_9_118_0_CLK }
C {devices/lab_pin.sym} 58650 -26210 0 0 {name=p58085 lab=_82888_/CLK }
C {devices/lab_pin.sym} 58650 -26190 0 0 {name=p58086 lab=_87613_/D }
C {devices/lab_pin.sym} 58830 -26210 0 1 {name=p58087 lab=_67104_/B }
C {sky130_stdcells/dfxtp_4.sym} 58740 -26200 0 0 {name=X_87613_ }
C {devices/lab_pin.sym} 58650 -26070 0 0 {name=p58088 lab=_84960_/CLK }
C {devices/lab_pin.sym} 58650 -26050 0 0 {name=p58089 lab=_58537_/X }
C {devices/lab_pin.sym} 58830 -26070 0 1 {name=p58090 lab=_58535_/A }
C {sky130_stdcells/dfxtp_4.sym} 58740 -26060 0 0 {name=X_84825_ }
C {devices/lab_pin.sym} 58700 -25930 0 0 {name=p58091 lab=_57947_/A }
C {devices/lab_pin.sym} 58780 -25930 0 1 {name=p58092 lab=_57773_/X }
C {sky130_stdcells/buf_2.sym} 58740 -25930 0 0 {name=X_57773_ }
C {devices/lab_pin.sym} 58700 -25810 0 0 {name=p58093 lab=clkbuf_8_22_0_CLK/X }
C {devices/lab_pin.sym} 58780 -25810 0 1 {name=p58094 lab=clkbuf_9_45_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 58740 -25810 0 0 {name=Xclkbuf_9_45_0_CLK }
C {devices/lab_pin.sym} 58660 -25710 0 0 {name=p58095 lab=_69334_/X }
C {devices/lab_pin.sym} 58660 -25670 0 0 {name=p58096 lab=_69336_/X }
C {devices/lab_pin.sym} 58660 -25630 0 0 {name=p58097 lab=_69728_/X }
C {devices/lab_pin.sym} 58820 -25670 0 1 {name=p58098 lab=_69759_/Y }
C {sky130_stdcells/a21oi_4.sym} 58740 -25670 0 0 {name=X_69759_ }
C {devices/lab_pin.sym} 58680 -25540 0 0 {name=p58099 lab=_54985_/A }
C {devices/lab_pin.sym} 58680 -25500 0 0 {name=p58100 lab=_47572_/Y }
C {devices/lab_pin.sym} 58800 -25520 0 1 {name=p58101 lab=_54985_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -25520 0 0 {name=X_54985_ }
C {devices/lab_pin.sym} 58700 -25390 0 0 {name=p58102 lab=_59512_/A }
C {devices/lab_pin.sym} 58780 -25390 0 1 {name=p58103 lab=_59512_/X }
C {sky130_stdcells/buf_2.sym} 58740 -25390 0 0 {name=X_59512_ }
C {devices/lab_pin.sym} 58680 -25280 0 0 {name=p58104 lab=_56724_/A }
C {devices/lab_pin.sym} 58680 -25240 0 0 {name=p58105 lab=_56723_/Y }
C {devices/lab_pin.sym} 58800 -25260 0 1 {name=p58106 lab=_57153_/A }
C {sky130_stdcells/nand2_4.sym} 58740 -25260 0 0 {name=X_56724_ }
C {devices/lab_pin.sym} 58650 -25130 0 0 {name=p58107 lab=_87544_/CLK }
C {devices/lab_pin.sym} 58650 -25110 0 0 {name=p58108 lab=_87544_/D }
C {devices/lab_pin.sym} 58830 -25130 0 1 {name=p58109 lab=_73440_/A }
C {sky130_stdcells/dfxtp_4.sym} 58740 -25120 0 0 {name=X_87544_ }
C {devices/lab_pin.sym} 58700 -24990 0 0 {name=p58110 lab=_41950_/A }
C {devices/lab_pin.sym} 58780 -24990 0 1 {name=p58111 lab=_41950_/Y }
C {sky130_stdcells/inv_2.sym} 58740 -24990 0 0 {name=X_41950_ }
C {devices/lab_pin.sym} 58680 -24880 0 0 {name=p58112 lab=_53871_/X }
C {devices/lab_pin.sym} 58680 -24840 0 0 {name=p58113 lab=_53936_/B }
C {devices/lab_pin.sym} 58800 -24860 0 1 {name=p58114 lab=_53936_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -24860 0 0 {name=X_53936_ }
C {devices/lab_pin.sym} 58660 -24760 0 0 {name=p58115 lab=_41983_/Y }
C {devices/lab_pin.sym} 58660 -24720 0 0 {name=p58116 lab=_72723_/X }
C {devices/lab_pin.sym} 58660 -24680 0 0 {name=p58117 lab=_72725_/X }
C {devices/lab_pin.sym} 58660 -24640 0 0 {name=p58118 lab=_72769_/Y }
C {devices/lab_pin.sym} 58820 -24700 0 1 {name=p58119 lab=_72770_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -24700 0 0 {name=X_72770_ }
C {devices/lab_pin.sym} 58650 -24550 0 0 {name=p58120 lab=_84757_/CLK }
C {devices/lab_pin.sym} 58650 -24530 0 0 {name=p58121 lab=_84756_/D }
C {devices/lab_pin.sym} 58830 -24550 0 1 {name=p58122 lab=_84756_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -24540 0 0 {name=X_84756_ }
C {devices/lab_pin.sym} 58650 -24410 0 0 {name=p58123 lab=_82558_/CLK }
C {devices/lab_pin.sym} 58650 -24390 0 0 {name=p58124 lab=_81968_/D }
C {devices/lab_pin.sym} 58830 -24410 0 1 {name=p58125 lab=_81968_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -24400 0 0 {name=X_81968_ }
C {devices/lab_pin.sym} 58700 -24270 0 0 {name=p58126 lab=clkbuf_3_3_0_CLK/A }
C {devices/lab_pin.sym} 58780 -24270 0 1 {name=p58127 lab=clkbuf_3_3_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 58740 -24270 0 0 {name=Xclkbuf_3_3_0_CLK }
C {devices/lab_pin.sym} 58680 -24160 0 0 {name=p58128 lab=_46469_/B }
C {devices/lab_pin.sym} 58680 -24120 0 0 {name=p58129 lab=_40901_/B }
C {devices/lab_pin.sym} 58800 -24140 0 1 {name=p58130 lab=_40901_/X }
C {sky130_stdcells/or2_4.sym} 58740 -24140 0 0 {name=X_40901_ }
C {devices/lab_pin.sym} 58650 -24010 0 0 {name=p58131 lab=_83707_/CLK }
C {devices/lab_pin.sym} 58650 -23990 0 0 {name=p58132 lab=_83707_/D }
C {devices/lab_pin.sym} 58830 -24010 0 1 {name=p58133 lab=_83707_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -24000 0 0 {name=X_83707_ }
C {devices/lab_pin.sym} 58680 -23890 0 0 {name=p58134 lab=_70526_/A }
C {devices/lab_pin.sym} 58680 -23850 0 0 {name=p58135 lab=_71223_/B }
C {devices/lab_pin.sym} 58680 -23810 0 0 {name=p58136 lab=_70954_/C }
C {devices/lab_pin.sym} 58800 -23850 0 1 {name=p58137 lab=_71721_/Y }
C {sky130_stdcells/nand3_4.sym} 58740 -23850 0 0 {name=X_71721_ }
C {devices/lab_pin.sym} 58700 -23710 0 0 {name=p58138 lab=_59443_/A }
C {devices/lab_pin.sym} 58780 -23710 0 1 {name=p58139 lab=_59445_/A }
C {sky130_stdcells/inv_2.sym} 58740 -23710 0 0 {name=X_59443_ }
C {devices/lab_pin.sym} 58700 -23590 0 0 {name=p58140 lab=_56655_/A }
C {devices/lab_pin.sym} 58780 -23590 0 1 {name=p58141 lab=_56655_/Y }
C {sky130_stdcells/inv_2.sym} 58740 -23590 0 0 {name=X_56655_ }
C {devices/lab_pin.sym} 58650 -23470 0 0 {name=p58142 lab=_84105_/CLK }
C {devices/lab_pin.sym} 58650 -23450 0 0 {name=p58143 lab=_80919_/D }
C {devices/lab_pin.sym} 58830 -23470 0 1 {name=p58144 lab=_80919_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -23460 0 0 {name=X_80919_ }
C {devices/lab_pin.sym} 58650 -23330 0 0 {name=p58145 lab=_87675_/CLK }
C {devices/lab_pin.sym} 58650 -23310 0 0 {name=p58146 lab=_87475_/D }
C {devices/lab_pin.sym} 58830 -23330 0 1 {name=p58147 lab=_87475_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -23320 0 0 {name=X_87475_ }
C {devices/lab_pin.sym} 58700 -23190 0 0 {name=p58148 lab=_41881_/A }
C {devices/lab_pin.sym} 58780 -23190 0 1 {name=p58149 lab=_42000_/A }
C {sky130_stdcells/buf_2.sym} 58740 -23190 0 0 {name=X_41881_ }
C {devices/lab_pin.sym} 58680 -23090 0 0 {name=p58150 lab=_50142_/A }
C {devices/lab_pin.sym} 58680 -23050 0 0 {name=p58151 lab=_53806_/B }
C {devices/lab_pin.sym} 58680 -23010 0 0 {name=p58152 lab=_53806_/C }
C {devices/lab_pin.sym} 58800 -23050 0 1 {name=p58153 lab=_53867_/X }
C {sky130_stdcells/and3_4.sym} 58740 -23050 0 0 {name=X_53867_ }
C {devices/lab_pin.sym} 58650 -22910 0 0 {name=p58154 lab=_84329_/CLK }
C {devices/lab_pin.sym} 58650 -22890 0 0 {name=p58155 lab=_84687_/D }
C {devices/lab_pin.sym} 58830 -22910 0 1 {name=p58156 lab=_80347_/A }
C {sky130_stdcells/dfxtp_4.sym} 58740 -22900 0 0 {name=X_84687_ }
C {devices/lab_pin.sym} 58650 -22770 0 0 {name=p58157 lab=_81975_/CLK }
C {devices/lab_pin.sym} 58650 -22750 0 0 {name=p58158 lab=_81899_/D }
C {devices/lab_pin.sym} 58830 -22770 0 1 {name=p58159 lab=_77013_/B }
C {sky130_stdcells/dfxtp_4.sym} 58740 -22760 0 0 {name=X_81899_ }
C {devices/lab_pin.sym} 58700 -22630 0 0 {name=p58160 lab=_87338_/Q }
C {devices/lab_pin.sym} 58780 -22630 0 1 {name=p58161 lab=_43620_/Y }
C {sky130_stdcells/inv_2.sym} 58740 -22630 0 0 {name=X_43620_ }
C {devices/lab_pin.sym} 58700 -22510 0 0 {name=p58162 lab=_44106_/C }
C {devices/lab_pin.sym} 58780 -22510 0 1 {name=p58163 lab=_55607_/A }
C {sky130_stdcells/buf_2.sym} 58740 -22510 0 0 {name=X_55606_ }
C {devices/lab_pin.sym} 58660 -22410 0 0 {name=p58164 lab=_74438_/Y }
C {devices/lab_pin.sym} 58660 -22370 0 0 {name=p58165 lab=_72107_/X }
C {devices/lab_pin.sym} 58660 -22330 0 0 {name=p58166 lab=_74439_/Y }
C {devices/lab_pin.sym} 58820 -22370 0 1 {name=p58167 lab=_83066_/D }
C {sky130_stdcells/a21boi_4.sym} 58740 -22370 0 0 {name=X_74440_ }
C {devices/lab_pin.sym} 58650 -22230 0 0 {name=p58168 lab=_85818_/CLK }
C {devices/lab_pin.sym} 58650 -22210 0 0 {name=p58169 lab=_49244_/Y }
C {devices/lab_pin.sym} 58830 -22230 0 1 {name=p58170 lab=_64798_/B }
C {sky130_stdcells/dfxtp_4.sym} 58740 -22220 0 0 {name=X_86426_ }
C {devices/lab_pin.sym} 58700 -22090 0 0 {name=p58171 lab=_40832_/A }
C {devices/lab_pin.sym} 58780 -22090 0 1 {name=p58172 lab=_40832_/X }
C {sky130_stdcells/buf_2.sym} 58740 -22090 0 0 {name=X_40832_ }
C {devices/lab_pin.sym} 58680 -22000 0 0 {name=p58173 lab=_52818_/A }
C {devices/lab_pin.sym} 58680 -21960 0 0 {name=p58174 lab=_52818_/B }
C {devices/lab_pin.sym} 58680 -21920 0 0 {name=p58175 lab=_52818_/C }
C {devices/lab_pin.sym} 58680 -21880 0 0 {name=p58176 lab=_52818_/D }
C {devices/lab_pin.sym} 58800 -21940 0 1 {name=p58177 lab=_52818_/X }
C {sky130_stdcells/and4_4.sym} 58740 -21940 0 0 {name=X_52818_ }
C {devices/lab_pin.sym} 58660 -21830 0 0 {name=p58178 lab=_59237_/X }
C {devices/lab_pin.sym} 58660 -21790 0 0 {name=p58179 lab=_59372_/Y }
C {devices/lab_pin.sym} 58660 -21750 0 0 {name=p58180 lab=_59373_/Y }
C {devices/lab_pin.sym} 58660 -21710 0 0 {name=p58181 lab=_59301_/X }
C {devices/lab_pin.sym} 58660 -21670 0 0 {name=p58182 lab=_59241_/X }
C {devices/lab_pin.sym} 58820 -21750 0 1 {name=p58183 lab=_59374_/X }
C {sky130_stdcells/o32a_4.sym} 58740 -21750 0 0 {name=X_59374_ }
C {devices/lab_pin.sym} 58680 -21610 0 0 {name=p58184 lab=_71650_/A }
C {devices/lab_pin.sym} 58680 -21570 0 0 {name=p58185 lab=_71246_/B }
C {devices/lab_pin.sym} 58680 -21530 0 0 {name=p58186 lab=_71644_/C }
C {devices/lab_pin.sym} 58800 -21570 0 1 {name=p58187 lab=_71652_/Y }
C {sky130_stdcells/nand3_4.sym} 58740 -21570 0 0 {name=X_71652_ }
C {devices/lab_pin.sym} 58650 -21430 0 0 {name=p58188 lab=_86424_/CLK }
C {devices/lab_pin.sym} 58650 -21410 0 0 {name=p58189 lab=_70996_/Y }
C {devices/lab_pin.sym} 58830 -21430 0 1 {name=p58190 lab=_83638_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -21420 0 0 {name=X_83638_ }
C {devices/lab_pin.sym} 58700 -21290 0 0 {name=p58191 lab=_56567_/Y }
C {devices/lab_pin.sym} 58780 -21290 0 1 {name=p58192 lab=_56764_/B }
C {sky130_stdcells/buf_2.sym} 58740 -21290 0 0 {name=X_56586_ }
C {devices/lab_pin.sym} 58700 -21170 0 0 {name=p58193 lab=_53798_/A }
C {devices/lab_pin.sym} 58780 -21170 0 1 {name=p58194 lab=_53838_/A }
C {sky130_stdcells/buf_2.sym} 58740 -21170 0 0 {name=X_53798_ }
C {devices/lab_pin.sym} 58680 -21080 0 0 {name=p58195 lab=_70714_/A }
C {devices/lab_pin.sym} 58680 -21040 0 0 {name=p58196 lab=_70613_/B }
C {devices/lab_pin.sym} 58680 -21000 0 0 {name=p58197 lab=_74533_/D }
C {devices/lab_pin.sym} 58680 -20960 0 0 {name=p58198 lab=_70594_/X }
C {devices/lab_pin.sym} 58800 -21020 0 1 {name=p58199 lab=_70603_/Y }
C {sky130_stdcells/nand4_4.sym} 58740 -21020 0 0 {name=X_70603_ }
C {devices/lab_pin.sym} 58700 -20870 0 0 {name=p58200 lab=_84877_/Q }
C {devices/lab_pin.sym} 58780 -20870 0 1 {name=p58201 lab=_58326_/A }
C {sky130_stdcells/inv_2.sym} 58740 -20870 0 0 {name=X_58325_ }
C {devices/lab_pin.sym} 58700 -20750 0 0 {name=p58202 lab=_43550_/Y }
C {devices/lab_pin.sym} 58780 -20750 0 1 {name=p58203 lab=_43551_/Y }
C {sky130_stdcells/inv_2.sym} 58740 -20750 0 0 {name=X_43551_ }
C {devices/lab_pin.sym} 58680 -20640 0 0 {name=p58204 lab=_55462_/X }
C {devices/lab_pin.sym} 58680 -20600 0 0 {name=p58205 lab=_45533_/Y }
C {devices/lab_pin.sym} 58800 -20620 0 1 {name=p58206 lab=_55537_/Y }
C {sky130_stdcells/nor2_4.sym} 58740 -20620 0 0 {name=X_55537_ }
C {devices/lab_pin.sym} 58650 -20490 0 0 {name=p58207 lab=_83046_/CLK }
C {devices/lab_pin.sym} 58650 -20470 0 0 {name=p58208 lab=_49604_/Y }
C {devices/lab_pin.sym} 58830 -20490 0 1 {name=p58209 lab=_86357_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -20480 0 0 {name=X_86357_ }
C {devices/lab_pin.sym} 58680 -20370 0 0 {name=p58210 lab=_74371_/A }
C {devices/lab_pin.sym} 58680 -20330 0 0 {name=p58211 lab=_72113_/B }
C {devices/lab_pin.sym} 58680 -20290 0 0 {name=p58212 lab=_74366_/C }
C {devices/lab_pin.sym} 58800 -20330 0 1 {name=p58213 lab=_74371_/X }
C {sky130_stdcells/and3_4.sym} 58740 -20330 0 0 {name=X_74371_ }
C {devices/lab_pin.sym} 58660 -20230 0 0 {name=p58214 lab=_40758_/X }
C {devices/lab_pin.sym} 58660 -20190 0 0 {name=p58215 lab=_40759_/X }
C {devices/lab_pin.sym} 58660 -20150 0 0 {name=p58216 lab=_40762_/X }
C {devices/lab_pin.sym} 58660 -20110 0 0 {name=p58217 lab=_88340_/Q }
C {devices/lab_pin.sym} 58660 -20070 0 0 {name=p58218 lab=_40744_/X }
C {devices/lab_pin.sym} 58820 -20150 0 1 {name=p58219 lab=_40764_/A }
C {sky130_stdcells/o32ai_4.sym} 58740 -20150 0 0 {name=X_40763_ }
C {devices/lab_pin.sym} 58660 -20010 0 0 {name=p58220 lab=_85761_/Q }
C {devices/lab_pin.sym} 58660 -19970 0 0 {name=p58221 lab=_52737_/X }
C {devices/lab_pin.sym} 58660 -19930 0 0 {name=p58222 lab=_52748_/Y }
C {devices/lab_pin.sym} 58820 -19970 0 1 {name=p58223 lab=_52749_/Y }
C {sky130_stdcells/o21ai_4.sym} 58740 -19970 0 0 {name=X_52749_ }
C {devices/lab_pin.sym} 58650 -19830 0 0 {name=p58224 lab=_86500_/CLK }
C {devices/lab_pin.sym} 58650 -19810 0 0 {name=p58225 lab=_71218_/Y }
C {devices/lab_pin.sym} 58830 -19830 0 1 {name=p58226 lab=_83569_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -19820 0 0 {name=X_83569_ }
C {devices/lab_pin.sym} 58680 -19710 0 0 {name=p58227 lab=_71626_/A }
C {devices/lab_pin.sym} 58680 -19670 0 0 {name=p58228 lab=_71583_/B }
C {devices/lab_pin.sym} 58680 -19630 0 0 {name=p58229 lab=_71582_/X }
C {devices/lab_pin.sym} 58800 -19670 0 1 {name=p58230 lab=_71583_/Y }
C {sky130_stdcells/nor3_4.sym} 58740 -19670 0 0 {name=X_71583_ }
C {devices/lab_pin.sym} 58660 -19550 0 0 {name=p58231 lab=_76093_/A }
C {devices/lab_pin.sym} 58660 -19510 0 0 {name=p58232 lab=_76108_/Y }
C {devices/lab_pin.sym} 58660 -19470 0 0 {name=p58233 lab=_76109_/Y }
C {devices/lab_pin.sym} 58820 -19510 0 1 {name=p58234 lab=_76110_/X }
C {sky130_stdcells/a21o_4.sym} 58740 -19510 0 0 {name=X_76110_ }
C {devices/lab_pin.sym} 58700 -19370 0 0 {name=p58235 lab=_73940_/A }
C {devices/lab_pin.sym} 58780 -19370 0 1 {name=p58236 lab=_42502_/Y }
C {sky130_stdcells/inv_2.sym} 58740 -19370 0 0 {name=X_42502_ }
C {devices/lab_pin.sym} 58650 -19250 0 0 {name=p58237 lab=_85213_/CLK }
C {devices/lab_pin.sym} 58650 -19230 0 0 {name=p58238 lab=_56033_/Y }
C {devices/lab_pin.sym} 58830 -19250 0 1 {name=p58239 lab=_55943_/B }
C {sky130_stdcells/dfxtp_4.sym} 58740 -19240 0 0 {name=X_85308_ }
C {devices/lab_pin.sym} 58700 -19110 0 0 {name=p58240 lab=_44305_/X }
C {devices/lab_pin.sym} 58780 -19110 0 1 {name=p58241 lab=_73577_/B }
C {sky130_stdcells/buf_2.sym} 58740 -19110 0 0 {name=X_73322_ }
C {devices/lab_pin.sym} 58700 -18990 0 0 {name=p58242 lab=_46270_/A }
C {devices/lab_pin.sym} 58780 -18990 0 1 {name=p58243 lab=_53951_/B }
C {sky130_stdcells/inv_2.sym} 58740 -18990 0 0 {name=X_46270_ }
C {devices/lab_pin.sym} 58700 -18870 0 0 {name=p58244 lab=DATA_TO_HASH[7] }
C {devices/lab_pin.sym} 58780 -18870 0 1 {name=p58245 lab=_70534_/Y }
C {sky130_stdcells/inv_2.sym} 58740 -18870 0 0 {name=X_70534_ }
C {devices/lab_pin.sym} 58680 -18760 0 0 {name=p58246 lab=_58254_/Y }
C {devices/lab_pin.sym} 58680 -18720 0 0 {name=p58247 lab=_58268_/B }
C {devices/lab_pin.sym} 58800 -18740 0 1 {name=p58248 lab=_58256_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -18740 0 0 {name=X_58256_ }
C {devices/lab_pin.sym} 58680 -18620 0 0 {name=p58249 lab=_77098_/A }
C {devices/lab_pin.sym} 58680 -18580 0 0 {name=p58250 lab=_82287_/D }
C {devices/lab_pin.sym} 58800 -18600 0 1 {name=p58251 lab=_77096_/B }
C {sky130_stdcells/xor2_4.sym} 58740 -18600 0 0 {name=X_77090_ }
C {devices/lab_pin.sym} 58660 -18500 0 0 {name=p58252 lab=_41693_/X }
C {devices/lab_pin.sym} 58660 -18460 0 0 {name=p58253 lab=_43465_/X }
C {devices/lab_pin.sym} 58660 -18420 0 0 {name=p58254 lab=_87400_/Q }
C {devices/lab_pin.sym} 58660 -18380 0 0 {name=p58255 lab=_43467_/X }
C {devices/lab_pin.sym} 58820 -18440 0 1 {name=p58256 lab=_43482_/X }
C {sky130_stdcells/a2bb2o_4.sym} 58740 -18440 0 0 {name=X_43482_ }
C {devices/lab_pin.sym} 58700 -18290 0 0 {name=p58257 lab=_55454_/X }
C {devices/lab_pin.sym} 58780 -18290 0 1 {name=p58258 lab=_55468_/X }
C {sky130_stdcells/buf_2.sym} 58740 -18290 0 0 {name=X_55468_ }
C {devices/lab_pin.sym} 58650 -18170 0 0 {name=p58259 lab=_86289_/CLK }
C {devices/lab_pin.sym} 58650 -18150 0 0 {name=p58260 lab=_86288_/D }
C {devices/lab_pin.sym} 58830 -18170 0 1 {name=p58261 lab=_86288_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -18160 0 0 {name=X_86288_ }
C {devices/lab_pin.sym} 58680 -18040 0 0 {name=p58262 lab=_40694_/A }
C {devices/lab_pin.sym} 58680 -18000 0 0 {name=p58263 lab=_40710_/B }
C {devices/lab_pin.sym} 58800 -18020 0 1 {name=p58264 lab=_40694_/X }
C {sky130_stdcells/or2_4.sym} 58740 -18020 0 0 {name=X_40694_ }
C {devices/lab_pin.sym} 58660 -17910 0 0 {name=p58265 lab=_45213_/X }
C {devices/lab_pin.sym} 58660 -17870 0 0 {name=p58266 lab=_45217_/Y }
C {devices/lab_pin.sym} 58660 -17830 0 0 {name=p58267 lab=_45220_/Y }
C {devices/lab_pin.sym} 58820 -17870 0 1 {name=p58268 lab=_45221_/Y }
C {sky130_stdcells/a21oi_4.sym} 58740 -17870 0 0 {name=X_45221_ }
C {devices/lab_pin.sym} 58660 -17750 0 0 {name=p58269 lab=_56873_/X }
C {devices/lab_pin.sym} 58660 -17710 0 0 {name=p58270 lab=_57153_/B }
C {devices/lab_pin.sym} 58660 -17670 0 0 {name=p58271 lab=_57206_/Y }
C {devices/lab_pin.sym} 58820 -17710 0 1 {name=p58272 lab=_57207_/X }
C {sky130_stdcells/a21o_4.sym} 58740 -17710 0 0 {name=X_57207_ }
C {devices/lab_pin.sym} 58680 -17580 0 0 {name=p58273 lab=_81339_/Q }
C {devices/lab_pin.sym} 58680 -17540 0 0 {name=p58274 lab=_76041_/B }
C {devices/lab_pin.sym} 58800 -17560 0 1 {name=p58275 lab=_76047_/B }
C {sky130_stdcells/xor2_4.sym} 58740 -17560 0 0 {name=X_76041_ }
C {devices/lab_pin.sym} 58660 -17460 0 0 {name=p58276 lab=_40520_/X }
C {devices/lab_pin.sym} 58660 -17420 0 0 {name=p58277 lab=_42414_/X }
C {devices/lab_pin.sym} 58660 -17380 0 0 {name=p58278 lab=_87866_/Q }
C {devices/lab_pin.sym} 58660 -17340 0 0 {name=p58279 lab=_42415_/X }
C {devices/lab_pin.sym} 58820 -17400 0 1 {name=p58280 lab=_87866_/D }
C {sky130_stdcells/a2bb2o_4.sym} 58740 -17400 0 0 {name=X_42433_ }
C {devices/lab_pin.sym} 58650 -17250 0 0 {name=p58281 lab=_87273_/CLK }
C {devices/lab_pin.sym} 58650 -17230 0 0 {name=p58282 lab=_42115_/X }
C {devices/lab_pin.sym} 58830 -17250 0 1 {name=p58283 lab=_88027_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -17240 0 0 {name=X_88027_ }
C {devices/lab_pin.sym} 58680 -17120 0 0 {name=p58284 lab=_54425_/A }
C {devices/lab_pin.sym} 58680 -17080 0 0 {name=p58285 lab=_52726_/B }
C {devices/lab_pin.sym} 58800 -17100 0 1 {name=p58286 lab=_54419_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -17100 0 0 {name=X_54419_ }
C {devices/lab_pin.sym} 58660 -17000 0 0 {name=p58287 lab=_69823_/B }
C {devices/lab_pin.sym} 58660 -16960 0 0 {name=p58288 lab=_73250_/X }
C {devices/lab_pin.sym} 58660 -16920 0 0 {name=p58289 lab=_73251_/X }
C {devices/lab_pin.sym} 58660 -16880 0 0 {name=p58290 lab=_73252_/Y }
C {devices/lab_pin.sym} 58820 -16940 0 1 {name=p58291 lab=_73253_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -16940 0 0 {name=X_73253_ }
C {devices/lab_pin.sym} 58650 -16790 0 0 {name=p58292 lab=_85269_/CLK }
C {devices/lab_pin.sym} 58650 -16770 0 0 {name=p58293 lab=_56316_/Y }
C {devices/lab_pin.sym} 58830 -16790 0 1 {name=p58294 lab=_85239_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -16780 0 0 {name=X_85239_ }
C {devices/lab_pin.sym} 58660 -16670 0 0 {name=p58295 lab=_58342_/Y }
C {devices/lab_pin.sym} 58660 -16630 0 0 {name=p58296 lab=_70458_/X }
C {devices/lab_pin.sym} 58660 -16590 0 0 {name=p58297 lab=_70464_/Y }
C {devices/lab_pin.sym} 58820 -16630 0 1 {name=p58298 lab=_70465_/Y }
C {sky130_stdcells/o21ai_4.sym} 58740 -16630 0 0 {name=X_70465_ }
C {devices/lab_pin.sym} 58700 -16490 0 0 {name=p58299 lab=_58187_/A }
C {devices/lab_pin.sym} 58780 -16490 0 1 {name=p58300 lab=_58187_/X }
C {sky130_stdcells/buf_2.sym} 58740 -16490 0 0 {name=X_58187_ }
C {devices/lab_pin.sym} 58660 -16390 0 0 {name=p58301 lab=_55409_/A }
C {devices/lab_pin.sym} 58660 -16350 0 0 {name=p58302 lab=_55397_/Y }
C {devices/lab_pin.sym} 58660 -16310 0 0 {name=p58303 lab=_55398_/Y }
C {devices/lab_pin.sym} 58820 -16350 0 1 {name=p58304 lab=_55399_/X }
C {sky130_stdcells/a21o_4.sym} 58740 -16350 0 0 {name=X_55399_ }
C {devices/lab_pin.sym} 58680 -16220 0 0 {name=p58305 lab=_72277_/A }
C {devices/lab_pin.sym} 58680 -16180 0 0 {name=p58306 lab=_86298_/Q }
C {devices/lab_pin.sym} 58800 -16200 0 1 {name=p58307 lab=_72204_/Y }
C {sky130_stdcells/nor2_4.sym} 58740 -16200 0 0 {name=X_72204_ }
C {devices/lab_pin.sym} 58660 -16090 0 0 {name=p58308 lab=_45149_/Y }
C {devices/lab_pin.sym} 58660 -16050 0 0 {name=p58309 lab=_45151_/Y }
C {devices/lab_pin.sym} 58660 -16010 0 0 {name=p58310 lab=_45137_/X }
C {devices/lab_pin.sym} 58820 -16050 0 1 {name=p58311 lab=_45152_/X }
C {sky130_stdcells/a21o_4.sym} 58740 -16050 0 0 {name=X_45152_ }
C {devices/lab_pin.sym} 58660 -15930 0 0 {name=p58312 lab=_57136_/Y }
C {devices/lab_pin.sym} 58660 -15890 0 0 {name=p58313 lab=_57137_/X }
C {devices/lab_pin.sym} 58660 -15850 0 0 {name=p58314 lab=_57087_/X }
C {devices/lab_pin.sym} 58820 -15890 0 1 {name=p58315 lab=_57138_/Y }
C {sky130_stdcells/a21oi_4.sym} 58740 -15890 0 0 {name=X_57138_ }
C {devices/lab_pin.sym} 58660 -15790 0 0 {name=p58316 lab=_42350_/X }
C {devices/lab_pin.sym} 58660 -15750 0 0 {name=p58317 lab=_42346_/X }
C {devices/lab_pin.sym} 58660 -15710 0 0 {name=p58318 lab=_41757_/X }
C {devices/lab_pin.sym} 58660 -15670 0 0 {name=p58319 lab=_87899_/Q }
C {devices/lab_pin.sym} 58660 -15630 0 0 {name=p58320 lab=_42347_/X }
C {devices/lab_pin.sym} 58820 -15710 0 1 {name=p58321 lab=_42365_/A }
C {sky130_stdcells/o32ai_4.sym} 58740 -15710 0 0 {name=X_42364_ }
C {devices/lab_pin.sym} 58660 -15580 0 0 {name=p58322 lab=_72988_/X }
C {devices/lab_pin.sym} 58660 -15540 0 0 {name=p58323 lab=_85585_/Q }
C {devices/lab_pin.sym} 58660 -15500 0 0 {name=p58324 lab=_73092_/A }
C {devices/lab_pin.sym} 58660 -15460 0 0 {name=p58325 lab=_73183_/X }
C {devices/lab_pin.sym} 58820 -15520 0 1 {name=p58326 lab=_73184_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -15520 0 0 {name=X_73184_ }
C {devices/lab_pin.sym} 58700 -15370 0 0 {name=p58327 lab=_70370_/A }
C {devices/lab_pin.sym} 58780 -15370 0 1 {name=p58328 lab=_70407_/C }
C {sky130_stdcells/buf_2.sym} 58740 -15370 0 0 {name=X_70396_ }
C {devices/lab_pin.sym} 58700 -15250 0 0 {name=p58329 lab=_86841_/Q }
C {devices/lab_pin.sym} 58780 -15250 0 1 {name=p58330 lab=_45938_/A }
C {sky130_stdcells/inv_2.sym} 58740 -15250 0 0 {name=X_44103_ }
C {devices/lab_pin.sym} 58680 -15140 0 0 {name=p58331 lab=_79782_/X }
C {devices/lab_pin.sym} 58680 -15100 0 0 {name=p58332 lab=_79785_/Y }
C {devices/lab_pin.sym} 58800 -15120 0 1 {name=p58333 lab=_79800_/X }
C {sky130_stdcells/or2_4.sym} 58740 -15120 0 0 {name=X_79800_ }
C {devices/lab_pin.sym} 58660 -15010 0 0 {name=p58334 lab=_41242_/X }
C {devices/lab_pin.sym} 58660 -14970 0 0 {name=p58335 lab=_41661_/A }
C {devices/lab_pin.sym} 58660 -14930 0 0 {name=p58336 lab=_41314_/X }
C {devices/lab_pin.sym} 58820 -14970 0 1 {name=p58337 lab=_41316_/A }
C {sky130_stdcells/o21a_4.sym} 58740 -14970 0 0 {name=X_41315_ }
C {devices/lab_pin.sym} 58660 -14850 0 0 {name=p58338 lab=_72132_/Y }
C {devices/lab_pin.sym} 58660 -14810 0 0 {name=p58339 lab=_72134_/Y }
C {devices/lab_pin.sym} 58660 -14770 0 0 {name=p58340 lab=_59351_/X }
C {devices/lab_pin.sym} 58820 -14810 0 1 {name=p58341 lab=_72135_/X }
C {sky130_stdcells/a21o_4.sym} 58740 -14810 0 0 {name=X_72135_ }
C {devices/lab_pin.sym} 58700 -14670 0 0 {name=p58342 lab=_49906_/A }
C {devices/lab_pin.sym} 58780 -14670 0 1 {name=p58343 lab=_49960_/X }
C {sky130_stdcells/buf_2.sym} 58740 -14670 0 0 {name=X_49960_ }
C {devices/lab_pin.sym} 58660 -14570 0 0 {name=p58344 lab=_45080_/X }
C {devices/lab_pin.sym} 58660 -14530 0 0 {name=p58345 lab=_45082_/Y }
C {devices/lab_pin.sym} 58660 -14490 0 0 {name=p58346 lab=_45049_/X }
C {devices/lab_pin.sym} 58820 -14530 0 1 {name=p58347 lab=_45083_/Y }
C {sky130_stdcells/a21oi_4.sym} 58740 -14530 0 0 {name=X_45083_ }
C {devices/lab_pin.sym} 58680 -14400 0 0 {name=p58348 lab=_56850_/X }
C {devices/lab_pin.sym} 58680 -14360 0 0 {name=p58349 lab=_56976_/X }
C {devices/lab_pin.sym} 58800 -14380 0 1 {name=p58350 lab=_57069_/Y }
C {sky130_stdcells/nor2_4.sym} 58740 -14380 0 0 {name=X_57069_ }
C {devices/lab_pin.sym} 58700 -14250 0 0 {name=p58351 lab=_42294_/Y }
C {devices/lab_pin.sym} 58780 -14250 0 1 {name=p58352 lab=_42295_/Y }
C {sky130_stdcells/inv_2.sym} 58740 -14250 0 0 {name=X_42295_ }
C {devices/lab_pin.sym} 58660 -14150 0 0 {name=p58353 lab=_77950_/B }
C {devices/lab_pin.sym} 58660 -14110 0 0 {name=p58354 lab=_77989_/X }
C {devices/lab_pin.sym} 58660 -14070 0 0 {name=p58355 lab=_77991_/X }
C {devices/lab_pin.sym} 58820 -14110 0 1 {name=p58356 lab=_77993_/B }
C {sky130_stdcells/a21boi_4.sym} 58740 -14110 0 0 {name=X_77992_ }
C {devices/lab_pin.sym} 58700 -13970 0 0 {name=p58357 lab=_71972_/B }
C {devices/lab_pin.sym} 58780 -13970 0 1 {name=p58358 lab=_48912_/B }
C {sky130_stdcells/buf_2.sym} 58740 -13970 0 0 {name=X_48911_ }
C {devices/lab_pin.sym} 58700 -13850 0 0 {name=p58359 lab=_64850_/A }
C {devices/lab_pin.sym} 58780 -13850 0 1 {name=p58360 lab=_65614_/A }
C {sky130_stdcells/buf_2.sym} 58740 -13850 0 0 {name=X_44034_ }
C {devices/lab_pin.sym} 58660 -13750 0 0 {name=p58361 lab=_79721_/X }
C {devices/lab_pin.sym} 58660 -13710 0 0 {name=p58362 lab=_79722_/X }
C {devices/lab_pin.sym} 58660 -13670 0 0 {name=p58363 lab=_79730_/Y }
C {devices/lab_pin.sym} 58820 -13710 0 1 {name=p58364 lab=_79731_/Y }
C {sky130_stdcells/a21boi_4.sym} 58740 -13710 0 0 {name=X_79731_ }
C {devices/lab_pin.sym} 58660 -13610 0 0 {name=p58365 lab=_41239_/X }
C {devices/lab_pin.sym} 58660 -13570 0 0 {name=p58366 lab=_41241_/X }
C {devices/lab_pin.sym} 58660 -13530 0 0 {name=p58367 lab=_41245_/X }
C {devices/lab_pin.sym} 58660 -13490 0 0 {name=p58368 lab=_68970_/B }
C {devices/lab_pin.sym} 58660 -13450 0 0 {name=p58369 lab=_41236_/X }
C {devices/lab_pin.sym} 58820 -13530 0 1 {name=p58370 lab=_41246_/Y }
C {sky130_stdcells/o32ai_4.sym} 58740 -13530 0 0 {name=X_41246_ }
C {devices/lab_pin.sym} 58700 -13370 0 0 {name=p58371 lab=_72001_/A }
C {devices/lab_pin.sym} 58780 -13370 0 1 {name=p58372 lab=_72066_/X }
C {sky130_stdcells/buf_2.sym} 58740 -13370 0 0 {name=X_72066_ }
C {devices/lab_pin.sym} 58700 -13250 0 0 {name=p58373 lab=_76942_/Y }
C {devices/lab_pin.sym} 58780 -13250 0 1 {name=p58374 lab=_76944_/B }
C {sky130_stdcells/inv_2.sym} 58740 -13250 0 0 {name=X_76943_ }
C {devices/lab_pin.sym} 58700 -13130 0 0 {name=p58375 lab=_60162_/A }
C {devices/lab_pin.sym} 58780 -13130 0 1 {name=p58376 lab=_72625_/B }
C {sky130_stdcells/buf_2.sym} 58740 -13130 0 0 {name=X_60080_ }
C {devices/lab_pin.sym} 58680 -13020 0 0 {name=p58377 lab=_49901_/A }
C {devices/lab_pin.sym} 58680 -12980 0 0 {name=p58378 lab=_53105_/B }
C {devices/lab_pin.sym} 58800 -13000 0 1 {name=p58379 lab=_49891_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -13000 0 0 {name=X_49891_ }
C {devices/lab_pin.sym} 58700 -12870 0 0 {name=p58380 lab=_71039_/D }
C {devices/lab_pin.sym} 58780 -12870 0 1 {name=p58381 lab=_71018_/D }
C {sky130_stdcells/buf_2.sym} 58740 -12870 0 0 {name=X_71017_ }
C {devices/lab_pin.sym} 58660 -12770 0 0 {name=p58382 lab=_48839_/Y }
C {devices/lab_pin.sym} 58660 -12730 0 0 {name=p58383 lab=_48840_/X }
C {devices/lab_pin.sym} 58660 -12690 0 0 {name=p58384 lab=_48841_/X }
C {devices/lab_pin.sym} 58820 -12730 0 1 {name=p58385 lab=_86473_/D }
C {sky130_stdcells/a21oi_4.sym} 58740 -12730 0 0 {name=X_48842_ }
C {devices/lab_pin.sym} 58680 -12600 0 0 {name=p58386 lab=_79651_/X }
C {devices/lab_pin.sym} 58680 -12560 0 0 {name=p58387 lab=_79639_/X }
C {devices/lab_pin.sym} 58800 -12580 0 1 {name=p58388 lab=_79662_/X }
C {sky130_stdcells/and2_4.sym} 58740 -12580 0 0 {name=X_79662_ }
C {devices/lab_pin.sym} 58680 -12460 0 0 {name=p58389 lab=_41007_/B }
C {devices/lab_pin.sym} 58680 -12420 0 0 {name=p58390 lab=_41145_/B }
C {devices/lab_pin.sym} 58800 -12440 0 1 {name=p58391 lab=_41177_/X }
C {sky130_stdcells/or2_4.sym} 58740 -12440 0 0 {name=X_41177_ }
C {devices/lab_pin.sym} 58680 -12320 0 0 {name=p58392 lab=_76874_/A }
C {devices/lab_pin.sym} 58680 -12280 0 0 {name=p58393 lab=_76874_/B }
C {devices/lab_pin.sym} 58800 -12300 0 1 {name=p58394 lab=_76874_/Y }
C {sky130_stdcells/xnor2_4.sym} 58740 -12300 0 0 {name=X_76874_ }
C {devices/lab_pin.sym} 58700 -12170 0 0 {name=p58395 lab=_78613_/A }
C {devices/lab_pin.sym} 58780 -12170 0 1 {name=p58396 lab=_78616_/B }
C {sky130_stdcells/inv_2.sym} 58740 -12170 0 0 {name=X_78613_ }
C {devices/lab_pin.sym} 58660 -12070 0 0 {name=p58397 lab=_75824_/A }
C {devices/lab_pin.sym} 58660 -12030 0 0 {name=p58398 lab=_75824_/B }
C {devices/lab_pin.sym} 58660 -11990 0 0 {name=p58399 lab=_81021_/Q }
C {devices/lab_pin.sym} 58820 -12030 0 1 {name=p58400 lab=_75825_/X }
C {sky130_stdcells/a21o_4.sym} 58740 -12030 0 0 {name=X_75825_ }
C {devices/lab_pin.sym} 58680 -11900 0 0 {name=p58401 lab=_48777_/A }
C {devices/lab_pin.sym} 58680 -11860 0 0 {name=p58402 lab=_52158_/B }
C {devices/lab_pin.sym} 58800 -11880 0 1 {name=p58403 lab=_48773_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -11880 0 0 {name=X_48773_ }
C {devices/lab_pin.sym} 58700 -11750 0 0 {name=p58404 lab=_79591_/Y }
C {devices/lab_pin.sym} 58780 -11750 0 1 {name=p58405 lab=_79594_/A }
C {sky130_stdcells/inv_2.sym} 58740 -11750 0 0 {name=X_79593_ }
C {devices/lab_pin.sym} 58660 -11670 0 0 {name=p58406 lab=_45980_/X }
C {devices/lab_pin.sym} 58660 -11630 0 0 {name=p58407 lab=_44865_/X }
C {devices/lab_pin.sym} 58660 -11590 0 0 {name=p58408 lab=_40431_/X }
C {devices/lab_pin.sym} 58660 -11550 0 0 {name=p58409 lab=_86827_/Q }
C {devices/lab_pin.sym} 58660 -11510 0 0 {name=p58410 lab=_45982_/X }
C {devices/lab_pin.sym} 58820 -11590 0 1 {name=p58411 lab=_45985_/Y }
C {sky130_stdcells/o32ai_4.sym} 58740 -11590 0 0 {name=X_45985_ }
C {devices/lab_pin.sym} 58660 -11450 0 0 {name=p58412 lab=_47719_/Y }
C {devices/lab_pin.sym} 58660 -11410 0 0 {name=p58413 lab=_47698_/X }
C {devices/lab_pin.sym} 58660 -11370 0 0 {name=p58414 lab=_47723_/X }
C {devices/lab_pin.sym} 58820 -11410 0 1 {name=p58415 lab=_86605_/D }
C {sky130_stdcells/a21oi_4.sym} 58740 -11410 0 0 {name=X_47724_ }
C {devices/lab_pin.sym} 58680 -11280 0 0 {name=p58416 lab=_78561_/B }
C {devices/lab_pin.sym} 58680 -11240 0 0 {name=p58417 lab=_78561_/A }
C {devices/lab_pin.sym} 58800 -11260 0 1 {name=p58418 lab=_82770_/D }
C {sky130_stdcells/xor2_4.sym} 58740 -11260 0 0 {name=X_78544_ }
C {devices/lab_pin.sym} 58660 -11150 0 0 {name=p58419 lab=_85311_/Q }
C {devices/lab_pin.sym} 58660 -11110 0 0 {name=p58420 lab=_44935_/X }
C {devices/lab_pin.sym} 58660 -11070 0 0 {name=p58421 lab=_45757_/A }
C {devices/lab_pin.sym} 58820 -11110 0 1 {name=p58422 lab=_44936_/X }
C {sky130_stdcells/o21a_4.sym} 58740 -11110 0 0 {name=X_44936_ }
C {devices/lab_pin.sym} 58660 -11000 0 0 {name=p58423 lab=_75742_/Y }
C {devices/lab_pin.sym} 58660 -10960 0 0 {name=p58424 lab=_75743_/Y }
C {devices/lab_pin.sym} 58660 -10920 0 0 {name=p58425 lab=_75732_/A }
C {devices/lab_pin.sym} 58660 -10880 0 0 {name=p58426 lab=_80788_/D }
C {devices/lab_pin.sym} 58820 -10940 0 1 {name=p58427 lab=_75756_/X }
C {sky130_stdcells/a2bb2o_4.sym} 58740 -10940 0 0 {name=X_75756_ }
C {devices/lab_pin.sym} 58660 -10810 0 0 {name=p58428 lab=_63766_/X }
C {devices/lab_pin.sym} 58660 -10770 0 0 {name=p58429 lab=_63744_/X }
C {devices/lab_pin.sym} 58660 -10730 0 0 {name=p58430 lab=_63769_/Y }
C {devices/lab_pin.sym} 58820 -10770 0 1 {name=p58431 lab=_84296_/D }
C {sky130_stdcells/a21oi_4.sym} 58740 -10770 0 0 {name=X_63770_ }
C {devices/lab_pin.sym} 58700 -10630 0 0 {name=p58432 lab=_60982_/A }
C {devices/lab_pin.sym} 58780 -10630 0 1 {name=p58433 lab=_64032_/A }
C {sky130_stdcells/buf_2.sym} 58740 -10630 0 0 {name=X_60982_ }
C {devices/lab_pin.sym} 58660 -10530 0 0 {name=p58434 lab=_72969_/B }
C {devices/lab_pin.sym} 58660 -10490 0 0 {name=p58435 lab=_72969_/C }
C {devices/lab_pin.sym} 58660 -10450 0 0 {name=p58436 lab=_72967_/X }
C {devices/lab_pin.sym} 58820 -10490 0 1 {name=p58437 lab=_72968_/X }
C {sky130_stdcells/a21o_4.sym} 58740 -10490 0 0 {name=X_72968_ }
C {devices/lab_pin.sym} 58700 -10350 0 0 {name=p58438 lab=_62893_/A }
C {devices/lab_pin.sym} 58780 -10350 0 1 {name=p58439 lab=_62721_/X }
C {sky130_stdcells/buf_2.sym} 58740 -10350 0 0 {name=X_62721_ }
C {devices/lab_pin.sym} 58700 -10230 0 0 {name=p58440 lab=MACRO_RD_SELECT }
C {devices/lab_pin.sym} 58780 -10230 0 1 {name=p58441 lab=_74711_/A }
C {sky130_stdcells/buf_2.sym} 58740 -10230 0 0 {name=X_74707_ }
C {devices/lab_pin.sym} 58680 -10140 0 0 {name=p58442 lab=_47655_/A }
C {devices/lab_pin.sym} 58680 -10100 0 0 {name=p58443 lab=_47692_/B }
C {devices/lab_pin.sym} 58680 -10060 0 0 {name=p58444 lab=_47614_/X }
C {devices/lab_pin.sym} 58680 -10020 0 0 {name=p58445 lab=_53170_/D }
C {devices/lab_pin.sym} 58800 -10080 0 1 {name=p58446 lab=_47655_/X }
C {sky130_stdcells/and4_4.sym} 58740 -10080 0 0 {name=X_47655_ }
C {devices/lab_pin.sym} 58660 -9950 0 0 {name=p58447 lab=_56672_/Y }
C {devices/lab_pin.sym} 58660 -9910 0 0 {name=p58448 lab=_71917_/X }
C {devices/lab_pin.sym} 58660 -9870 0 0 {name=p58449 lab=_71918_/Y }
C {devices/lab_pin.sym} 58820 -9910 0 1 {name=p58450 lab=_83329_/D }
C {sky130_stdcells/o21ai_4.sym} 58740 -9910 0 0 {name=X_71919_ }
C {devices/lab_pin.sym} 58680 -9780 0 0 {name=p58451 lab=_78475_/A }
C {devices/lab_pin.sym} 58680 -9740 0 0 {name=p58452 lab=_78475_/B }
C {devices/lab_pin.sym} 58800 -9760 0 1 {name=p58453 lab=_78476_/A }
C {sky130_stdcells/nor2_4.sym} 58740 -9760 0 0 {name=X_78475_ }
C {devices/lab_pin.sym} 58700 -9630 0 0 {name=p58454 lab=_44867_/A }
C {devices/lab_pin.sym} 58780 -9630 0 1 {name=p58455 lab=_86912_/D }
C {sky130_stdcells/inv_2.sym} 58740 -9630 0 0 {name=X_44867_ }
C {devices/lab_pin.sym} 58700 -9510 0 0 {name=p58456 lab=_75687_/A }
C {devices/lab_pin.sym} 58780 -9510 0 1 {name=p58457 lab=_75689_/A }
C {sky130_stdcells/inv_2.sym} 58740 -9510 0 0 {name=X_75687_ }
C {devices/lab_pin.sym} 58700 -9390 0 0 {name=p58458 lab=_72899_/A }
C {devices/lab_pin.sym} 58780 -9390 0 1 {name=p58459 lab=_72899_/X }
C {sky130_stdcells/buf_2.sym} 58740 -9390 0 0 {name=X_72899_ }
C {devices/lab_pin.sym} 58700 -9270 0 0 {name=p58460 lab=_83689_/Q }
C {devices/lab_pin.sym} 58780 -9270 0 1 {name=p58461 lab=_52577_/B }
C {sky130_stdcells/inv_2.sym} 58740 -9270 0 0 {name=X_46606_ }
C {devices/lab_pin.sym} 58660 -9180 0 0 {name=p58462 lab=_65438_/X }
C {devices/lab_pin.sym} 58660 -9140 0 0 {name=p58463 lab=_86208_/Q }
C {devices/lab_pin.sym} 58660 -9100 0 0 {name=p58464 lab=_65182_/X }
C {devices/lab_pin.sym} 58660 -9060 0 0 {name=p58465 lab=_65439_/X }
C {devices/lab_pin.sym} 58820 -9120 0 1 {name=p58466 lab=_65440_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -9120 0 0 {name=X_65440_ }
C {devices/lab_pin.sym} 58680 -8990 0 0 {name=p58467 lab=_77422_/Y }
C {devices/lab_pin.sym} 58680 -8950 0 0 {name=p58468 lab=_77423_/Y }
C {devices/lab_pin.sym} 58680 -8910 0 0 {name=p58469 lab=_77426_/C }
C {devices/lab_pin.sym} 58800 -8950 0 1 {name=p58470 lab=_77426_/X }
C {sky130_stdcells/or3_4.sym} 58740 -8950 0 0 {name=X_77426_ }
C {devices/lab_pin.sym} 58700 -8810 0 0 {name=p58471 lab=_43802_/A }
C {devices/lab_pin.sym} 58780 -8810 0 1 {name=p58472 lab=_43818_/X }
C {sky130_stdcells/buf_2.sym} 58740 -8810 0 0 {name=X_43818_ }
C {devices/lab_pin.sym} 58700 -8690 0 0 {name=p58473 lab=_62395_/X }
C {devices/lab_pin.sym} 58780 -8690 0 1 {name=p58474 lab=_62652_/X }
C {sky130_stdcells/buf_2.sym} 58740 -8690 0 0 {name=X_62652_ }
C {devices/lab_pin.sym} 58700 -8570 0 0 {name=p58475 lab=_45951_/Y }
C {devices/lab_pin.sym} 58780 -8570 0 1 {name=p58476 lab=_74638_/X }
C {sky130_stdcells/buf_2.sym} 58740 -8570 0 0 {name=X_74638_ }
C {devices/lab_pin.sym} 58700 -8450 0 0 {name=p58477 lab=_47586_/A }
C {devices/lab_pin.sym} 58780 -8450 0 1 {name=p58478 lab=_53133_/D }
C {sky130_stdcells/buf_2.sym} 58740 -8450 0 0 {name=X_47586_ }
C {devices/lab_pin.sym} 58660 -8360 0 0 {name=p58479 lab=_41428_/Y }
C {devices/lab_pin.sym} 58660 -8320 0 0 {name=p58480 lab=_44788_/X }
C {devices/lab_pin.sym} 58660 -8280 0 0 {name=p58481 lab=_86949_/Q }
C {devices/lab_pin.sym} 58660 -8240 0 0 {name=p58482 lab=_44789_/X }
C {devices/lab_pin.sym} 58820 -8300 0 1 {name=p58483 lab=_86949_/D }
C {sky130_stdcells/a2bb2o_4.sym} 58740 -8300 0 0 {name=X_44798_ }
C {devices/lab_pin.sym} 58700 -8150 0 0 {name=p58484 lab=_61413_/A }
C {devices/lab_pin.sym} 58780 -8150 0 1 {name=p58485 lab=_61634_/A }
C {sky130_stdcells/buf_2.sym} 58740 -8150 0 0 {name=X_61603_ }
C {devices/lab_pin.sym} 58660 -8050 0 0 {name=p58486 lab=_86409_/Q }
C {devices/lab_pin.sym} 58660 -8010 0 0 {name=p58487 lab=_49285_/X }
C {devices/lab_pin.sym} 58660 -7970 0 0 {name=p58488 lab=_49324_/Y }
C {devices/lab_pin.sym} 58820 -8010 0 1 {name=p58489 lab=_49325_/Y }
C {sky130_stdcells/o21ai_4.sym} 58740 -8010 0 0 {name=X_49325_ }
C {devices/lab_pin.sym} 58680 -7880 0 0 {name=p58490 lab=_82920_/Q }
C {devices/lab_pin.sym} 58680 -7840 0 0 {name=p58491 lab=_46527_/X }
C {devices/lab_pin.sym} 58800 -7860 0 1 {name=p58492 lab=_46537_/X }
C {sky130_stdcells/or2_4.sym} 58740 -7860 0 0 {name=X_46537_ }
C {devices/lab_pin.sym} 58700 -7730 0 0 {name=p58493 lab=_65045_/A }
C {devices/lab_pin.sym} 58780 -7730 0 1 {name=p58494 lab=_65397_/B }
C {sky130_stdcells/buf_2.sym} 58740 -7730 0 0 {name=X_65371_ }
C {devices/lab_pin.sym} 58660 -7630 0 0 {name=p58495 lab=_77339_/B }
C {devices/lab_pin.sym} 58660 -7590 0 0 {name=p58496 lab=_77339_/A }
C {devices/lab_pin.sym} 58660 -7550 0 0 {name=p58497 lab=_77356_/Y }
C {devices/lab_pin.sym} 58820 -7590 0 1 {name=p58498 lab=_77359_/A }
C {sky130_stdcells/a21boi_4.sym} 58740 -7590 0 0 {name=X_77357_ }
C {devices/lab_pin.sym} 58660 -7480 0 0 {name=p58499 lab=_40929_/X }
C {devices/lab_pin.sym} 58660 -7440 0 0 {name=p58500 lab=_43736_/X }
C {devices/lab_pin.sym} 58660 -7400 0 0 {name=p58501 lab=_69967_/B }
C {devices/lab_pin.sym} 58660 -7360 0 0 {name=p58502 lab=_43737_/X }
C {devices/lab_pin.sym} 58820 -7420 0 1 {name=p58503 lab=_87284_/D }
C {sky130_stdcells/a2bb2o_4.sym} 58740 -7420 0 0 {name=X_43749_ }
C {devices/lab_pin.sym} 58680 -7290 0 0 {name=p58504 lab=_62551_/X }
C {devices/lab_pin.sym} 58680 -7250 0 0 {name=p58505 lab=_62553_/X }
C {devices/lab_pin.sym} 58680 -7210 0 0 {name=p58506 lab=_84399_/Q }
C {devices/lab_pin.sym} 58800 -7250 0 1 {name=p58507 lab=_62583_/Y }
C {sky130_stdcells/nor3_4.sym} 58740 -7250 0 0 {name=X_62583_ }
C {devices/lab_pin.sym} 58700 -7110 0 0 {name=p58508 lab=_74552_/X }
C {devices/lab_pin.sym} 58780 -7110 0 1 {name=p58509 lab=_74569_/X }
C {sky130_stdcells/buf_2.sym} 58740 -7110 0 0 {name=X_74569_ }
C {devices/lab_pin.sym} 58700 -6990 0 0 {name=p58510 lab=_66868_/A }
C {devices/lab_pin.sym} 58780 -6990 0 1 {name=p58511 lab=_67110_/X }
C {sky130_stdcells/buf_2.sym} 58740 -6990 0 0 {name=X_67110_ }
C {devices/lab_pin.sym} 58700 -6870 0 0 {name=p58512 lab=_64263_/A }
C {devices/lab_pin.sym} 58780 -6870 0 1 {name=p58513 lab=_64336_/A }
C {sky130_stdcells/buf_2.sym} 58740 -6870 0 0 {name=X_64322_ }
C {devices/lab_pin.sym} 58680 -6760 0 0 {name=p58514 lab=_76299_/Y }
C {devices/lab_pin.sym} 58680 -6720 0 0 {name=p58515 lab=_76321_/A }
C {devices/lab_pin.sym} 58800 -6740 0 1 {name=p58516 lab=_76311_/A }
C {sky130_stdcells/xor2_4.sym} 58740 -6740 0 0 {name=X_76308_ }
C {devices/lab_pin.sym} 58700 -6610 0 0 {name=p58517 lab=_48535_/A }
C {devices/lab_pin.sym} 58780 -6610 0 1 {name=p58518 lab=_49261_/A }
C {sky130_stdcells/buf_2.sym} 58740 -6610 0 0 {name=X_49256_ }
C {devices/lab_pin.sym} 58700 -6490 0 0 {name=p58519 lab=_61413_/A }
C {devices/lab_pin.sym} 58780 -6490 0 1 {name=p58520 lab=_61546_/A }
C {sky130_stdcells/buf_2.sym} 58740 -6490 0 0 {name=X_61534_ }
C {devices/lab_pin.sym} 58660 -6390 0 0 {name=p58521 lab=_66580_/X }
C {devices/lab_pin.sym} 58660 -6350 0 0 {name=p58522 lab=_66584_/X }
C {devices/lab_pin.sym} 58660 -6310 0 0 {name=p58523 lab=_67897_/X }
C {devices/lab_pin.sym} 58820 -6350 0 1 {name=p58524 lab=_68090_/Y }
C {sky130_stdcells/a21oi_4.sym} 58740 -6350 0 0 {name=X_68090_ }
C {devices/lab_pin.sym} 58700 -6210 0 0 {name=p58525 lab=_82926_/Q }
C {devices/lab_pin.sym} 58780 -6210 0 1 {name=p58526 lab=_48034_/B }
C {sky130_stdcells/inv_2.sym} 58740 -6210 0 0 {name=X_46468_ }
C {devices/lab_pin.sym} 58700 -6090 0 0 {name=p58527 lab=_77274_/B }
C {devices/lab_pin.sym} 58780 -6090 0 1 {name=p58528 lab=_77288_/Y }
C {sky130_stdcells/inv_2.sym} 58740 -6090 0 0 {name=X_77288_ }
C {devices/lab_pin.sym} 58700 -5970 0 0 {name=p58529 lab=_47895_/B }
C {devices/lab_pin.sym} 58780 -5970 0 1 {name=p58530 lab=_48207_/X }
C {sky130_stdcells/buf_2.sym} 58740 -5970 0 0 {name=X_48207_ }
C {devices/lab_pin.sym} 58680 -5860 0 0 {name=p58531 lab=_66942_/A }
C {devices/lab_pin.sym} 58680 -5820 0 0 {name=p58532 lab=_67041_/B }
C {devices/lab_pin.sym} 58800 -5840 0 1 {name=p58533 lab=_67041_/X }
C {sky130_stdcells/and2_4.sym} 58740 -5840 0 0 {name=X_67041_ }
C {devices/lab_pin.sym} 58680 -5720 0 0 {name=p58534 lab=_79027_/A }
C {devices/lab_pin.sym} 58680 -5680 0 0 {name=p58535 lab=_79027_/B }
C {devices/lab_pin.sym} 58800 -5700 0 1 {name=p58536 lab=_79028_/B }
C {sky130_stdcells/xor2_4.sym} 58740 -5700 0 0 {name=X_79027_ }
C {devices/lab_pin.sym} 58700 -5570 0 0 {name=p58537 lab=_63017_/B }
C {devices/lab_pin.sym} 58780 -5570 0 1 {name=p58538 lab=_61338_/A }
C {sky130_stdcells/buf_2.sym} 58740 -5570 0 0 {name=X_45419_ }
C {devices/lab_pin.sym} 58660 -5470 0 0 {name=p58539 lab=_64242_/Y }
C {devices/lab_pin.sym} 58660 -5430 0 0 {name=p58540 lab=_64252_/X }
C {devices/lab_pin.sym} 58660 -5390 0 0 {name=p58541 lab=_72577_/B }
C {devices/lab_pin.sym} 58820 -5430 0 1 {name=p58542 lab=_64253_/X }
C {sky130_stdcells/o21a_4.sym} 58740 -5430 0 0 {name=X_64253_ }
C {devices/lab_pin.sym} 58700 -5290 0 0 {name=p58543 lab=_76238_/X }
C {devices/lab_pin.sym} 58780 -5290 0 1 {name=p58544 lab=_76239_/X }
C {sky130_stdcells/buf_2.sym} 58740 -5290 0 0 {name=X_76239_ }
C {devices/lab_pin.sym} 58660 -5190 0 0 {name=p58545 lab=_65392_/B }
C {devices/lab_pin.sym} 58660 -5150 0 0 {name=p58546 lab=_49153_/X }
C {devices/lab_pin.sym} 58660 -5110 0 0 {name=p58547 lab=_49186_/Y }
C {devices/lab_pin.sym} 58820 -5150 0 1 {name=p58548 lab=_49187_/Y }
C {sky130_stdcells/o21ai_4.sym} 58740 -5150 0 0 {name=X_49187_ }
C {devices/lab_pin.sym} 58700 -5010 0 0 {name=p58549 lab=_61308_/A }
C {devices/lab_pin.sym} 58780 -5010 0 1 {name=p58550 lab=_72528_/A }
C {sky130_stdcells/buf_2.sym} 58740 -5010 0 0 {name=X_61465_ }
C {devices/lab_pin.sym} 58700 -4890 0 0 {name=p58551 lab=_46399_/A }
C {devices/lab_pin.sym} 58780 -4890 0 1 {name=p58552 lab=_46399_/X }
C {sky130_stdcells/buf_2.sym} 58740 -4890 0 0 {name=X_46399_ }
C {devices/lab_pin.sym} 58700 -4770 0 0 {name=p58553 lab=_60606_/X }
C {devices/lab_pin.sym} 58780 -4770 0 1 {name=p58554 lab=_63204_/X }
C {sky130_stdcells/buf_2.sym} 58740 -4770 0 0 {name=X_63204_ }
C {devices/lab_pin.sym} 58680 -4660 0 0 {name=p58555 lab=_48138_/A }
C {devices/lab_pin.sym} 58680 -4620 0 0 {name=p58556 lab=_48342_/A }
C {devices/lab_pin.sym} 58800 -4640 0 1 {name=p58557 lab=_48138_/X }
C {sky130_stdcells/and2_4.sym} 58740 -4640 0 0 {name=X_48138_ }
C {devices/lab_pin.sym} 58700 -4510 0 0 {name=p58558 lab=_60447_/B }
C {devices/lab_pin.sym} 58780 -4510 0 1 {name=p58559 lab=_60417_/A }
C {sky130_stdcells/buf_2.sym} 58740 -4510 0 0 {name=X_60416_ }
C {devices/lab_pin.sym} 58680 -4410 0 0 {name=p58560 lab=_64184_/A }
C {devices/lab_pin.sym} 58680 -4370 0 0 {name=p58561 lab=_58370_/A }
C {devices/lab_pin.sym} 58680 -4330 0 0 {name=p58562 lab=_64184_/C }
C {devices/lab_pin.sym} 58800 -4370 0 1 {name=p58563 lab=_64184_/X }
C {sky130_stdcells/and3_4.sym} 58740 -4370 0 0 {name=X_64184_ }
C {devices/lab_pin.sym} 58660 -4250 0 0 {name=p58564 lab=_61393_/X }
C {devices/lab_pin.sym} 58660 -4210 0 0 {name=p58565 lab=_61394_/X }
C {devices/lab_pin.sym} 58660 -4170 0 0 {name=p58566 lab=_61395_/Y }
C {devices/lab_pin.sym} 58820 -4210 0 1 {name=p58567 lab=_84484_/D }
C {sky130_stdcells/a21oi_4.sym} 58740 -4210 0 0 {name=X_61396_ }
C {devices/lab_pin.sym} 58680 -4100 0 0 {name=p58568 lab=_63088_/A }
C {devices/lab_pin.sym} 58680 -4060 0 0 {name=p58569 lab=_84830_/Q }
C {devices/lab_pin.sym} 58680 -4020 0 0 {name=p58570 lab=_63087_/X }
C {devices/lab_pin.sym} 58680 -3980 0 0 {name=p58571 lab=_63135_/D }
C {devices/lab_pin.sym} 58800 -4040 0 1 {name=p58572 lab=_63135_/X }
C {sky130_stdcells/and4_4.sym} 58740 -4040 0 0 {name=X_63135_ }
C {devices/lab_pin.sym} 58680 -3910 0 0 {name=p58573 lab=_52050_/A }
C {devices/lab_pin.sym} 58680 -3870 0 0 {name=p58574 lab=_48069_/B }
C {devices/lab_pin.sym} 58680 -3830 0 0 {name=p58575 lab=_48723_/C }
C {devices/lab_pin.sym} 58800 -3870 0 1 {name=p58576 lab=_48069_/X }
C {sky130_stdcells/and3_4.sym} 58740 -3870 0 0 {name=X_48069_ }
C {devices/lab_pin.sym} 58660 -3770 0 0 {name=p58577 lab=_60069_/Y }
C {devices/lab_pin.sym} 58660 -3730 0 0 {name=p58578 lab=_60343_/Y }
C {devices/lab_pin.sym} 58660 -3690 0 0 {name=p58579 lab=_60337_/D }
C {devices/lab_pin.sym} 58660 -3650 0 0 {name=p58580 lab=_60344_/Y }
C {devices/lab_pin.sym} 58660 -3620 0 0 {name=p58581 lab=_60346_/Y }
C {devices/lab_pin.sym} 58820 -3690 0 1 {name=p58582 lab=_60347_/Y }
C {sky130_stdcells/a41oi_4.sym} 58740 -3690 0 0 {name=X_60347_ }
C {devices/lab_pin.sym} 58660 -3550 0 0 {name=p58583 lab=_68988_/X }
C {devices/lab_pin.sym} 58660 -3510 0 0 {name=p58584 lab=_68991_/X }
C {devices/lab_pin.sym} 58660 -3470 0 0 {name=p58585 lab=_68922_/X }
C {devices/lab_pin.sym} 58820 -3510 0 1 {name=p58586 lab=_68992_/X }
C {sky130_stdcells/a21o_4.sym} 58740 -3510 0 0 {name=X_68992_ }
C {devices/lab_pin.sym} 58660 -3390 0 0 {name=p58587 lab=_86264_/Q }
C {devices/lab_pin.sym} 58660 -3350 0 0 {name=p58588 lab=_50088_/X }
C {devices/lab_pin.sym} 58660 -3310 0 0 {name=p58589 lab=_50099_/Y }
C {devices/lab_pin.sym} 58820 -3350 0 1 {name=p58590 lab=_50100_/Y }
C {sky130_stdcells/o21ai_4.sym} 58740 -3350 0 0 {name=X_50100_ }
C {devices/lab_pin.sym} 58680 -3220 0 0 {name=p58591 lab=_51097_/A }
C {devices/lab_pin.sym} 58680 -3180 0 0 {name=p58592 lab=_52773_/B }
C {devices/lab_pin.sym} 58800 -3200 0 1 {name=p58593 lab=_51080_/Y }
C {sky130_stdcells/nand2_4.sym} 58740 -3200 0 0 {name=X_51080_ }
C {devices/lab_pin.sym} 58680 -3080 0 0 {name=p58594 lab=_67992_/A }
C {devices/lab_pin.sym} 58680 -3040 0 0 {name=p58595 lab=_88218_/Q }
C {devices/lab_pin.sym} 58800 -3060 0 1 {name=p58596 lab=_67943_/X }
C {sky130_stdcells/and2_4.sym} 58740 -3060 0 0 {name=X_67943_ }
C {devices/lab_pin.sym} 58700 -2930 0 0 {name=p58597 lab=_79928_/Y }
C {devices/lab_pin.sym} 58780 -2930 0 1 {name=p58598 lab=_79929_/Y }
C {sky130_stdcells/inv_2.sym} 58740 -2930 0 0 {name=X_79929_ }
C {devices/lab_pin.sym} 58680 -2840 0 0 {name=p58599 lab=_63041_/A }
C {devices/lab_pin.sym} 58680 -2800 0 0 {name=p58600 lab=_63066_/B }
C {devices/lab_pin.sym} 58680 -2760 0 0 {name=p58601 lab=_63030_/C }
C {devices/lab_pin.sym} 58680 -2720 0 0 {name=p58602 lab=_63066_/D }
C {devices/lab_pin.sym} 58800 -2780 0 1 {name=p58603 lab=_63066_/X }
C {sky130_stdcells/and4_4.sym} 58740 -2780 0 0 {name=X_63066_ }
C {devices/lab_pin.sym} 58680 -2650 0 0 {name=p58604 lab=_60244_/A }
C {devices/lab_pin.sym} 58680 -2610 0 0 {name=p58605 lab=_60244_/B }
C {devices/lab_pin.sym} 58680 -2570 0 0 {name=p58606 lab=_79806_/A }
C {devices/lab_pin.sym} 58800 -2610 0 1 {name=p58607 lab=_60278_/Y }
C {sky130_stdcells/nor3_4.sym} 58740 -2610 0 0 {name=X_60278_ }
C {devices/lab_pin.sym} 58680 -2500 0 0 {name=p58608 lab=_50050_/A }
C {devices/lab_pin.sym} 58680 -2460 0 0 {name=p58609 lab=_50040_/B }
C {devices/lab_pin.sym} 58680 -2420 0 0 {name=p58610 lab=_50025_/C }
C {devices/lab_pin.sym} 58680 -2380 0 0 {name=p58611 lab=_53244_/D }
C {devices/lab_pin.sym} 58800 -2440 0 1 {name=p58612 lab=_50031_/X }
C {sky130_stdcells/and4_4.sym} 58740 -2440 0 0 {name=X_50031_ }
C {devices/lab_pin.sym} 58680 -2310 0 0 {name=p58613 lab=_62002_/A }
C {devices/lab_pin.sym} 58680 -2270 0 0 {name=p58614 lab=_62002_/B }
C {devices/lab_pin.sym} 58680 -2230 0 0 {name=p58615 lab=_78062_/B }
C {devices/lab_pin.sym} 58800 -2270 0 1 {name=p58616 lab=_62017_/Y }
C {sky130_stdcells/nor3_4.sym} 58740 -2270 0 0 {name=X_62017_ }
C {devices/lab_pin.sym} 58650 -2130 0 0 {name=p58617 lab=_81198_/CLK }
C {devices/lab_pin.sym} 58650 -2110 0 0 {name=p58618 lab=_78086_/X }
C {devices/lab_pin.sym} 58830 -2130 0 1 {name=p58619 lab=_82940_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -2120 0 0 {name=X_82940_ }
C {devices/lab_pin.sym} 58660 -2020 0 0 {name=p58620 lab=_87145_/Q }
C {devices/lab_pin.sym} 58660 -1980 0 0 {name=p58621 lab=_67825_/X }
C {devices/lab_pin.sym} 58660 -1940 0 0 {name=p58622 lab=_67872_/X }
C {devices/lab_pin.sym} 58660 -1900 0 0 {name=p58623 lab=_67873_/X }
C {devices/lab_pin.sym} 58820 -1960 0 1 {name=p58624 lab=_67874_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -1960 0 0 {name=X_67874_ }
C {devices/lab_pin.sym} 58660 -1840 0 0 {name=p58625 lab=_87068_/Q }
C {devices/lab_pin.sym} 58660 -1800 0 0 {name=p58626 lab=_69485_/X }
C {devices/lab_pin.sym} 58660 -1760 0 0 {name=p58627 lab=_69611_/X }
C {devices/lab_pin.sym} 58660 -1720 0 0 {name=p58628 lab=_69612_/X }
C {devices/lab_pin.sym} 58820 -1780 0 1 {name=p58629 lab=_69613_/X }
C {sky130_stdcells/a211o_4.sym} 58740 -1780 0 0 {name=X_69613_ }
C {devices/lab_pin.sym} 58660 -1650 0 0 {name=p58630 lab=_66821_/X }
C {devices/lab_pin.sym} 58660 -1610 0 0 {name=p58631 lab=_66824_/X }
C {devices/lab_pin.sym} 58660 -1570 0 0 {name=p58632 lab=_66658_/X }
C {devices/lab_pin.sym} 58820 -1610 0 1 {name=p58633 lab=_66825_/Y }
C {sky130_stdcells/a21oi_4.sym} 58740 -1610 0 0 {name=X_66825_ }
C {devices/lab_pin.sym} 58650 -1470 0 0 {name=p58634 lab=_82498_/CLK }
C {devices/lab_pin.sym} 58650 -1450 0 0 {name=p58635 lab=_82495_/Q }
C {devices/lab_pin.sym} 58830 -1470 0 1 {name=p58636 lab=_82871_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -1460 0 0 {name=X_82871_ }
C {devices/lab_pin.sym} 58650 -1330 0 0 {name=p58637 lab=_83216_/CLK }
C {devices/lab_pin.sym} 58650 -1310 0 0 {name=p58638 lab=_60498_/Y }
C {devices/lab_pin.sym} 58830 -1330 0 1 {name=p58639 lab=_79150_/A }
C {sky130_stdcells/dfxtp_4.sym} 58740 -1320 0 0 {name=X_84610_ }
C {devices/lab_pin.sym} 58650 -1190 0 0 {name=p58640 lab=_81275_/CLK }
C {devices/lab_pin.sym} 58650 -1170 0 0 {name=p58641 lab=_81630_/Q }
C {devices/lab_pin.sym} 58830 -1190 0 1 {name=p58642 lab=_81822_/Q }
C {sky130_stdcells/dfxtp_4.sym} 58740 -1180 0 0 {name=X_81822_ }
C {devices/lab_pin.sym} 58680 -1060 0 0 {name=p58643 lab=_69626_/A }
C {devices/lab_pin.sym} 58680 -1020 0 0 {name=p58644 lab=_69544_/B }
C {devices/lab_pin.sym} 58800 -1040 0 1 {name=p58645 lab=_69544_/X }
C {sky130_stdcells/and2_4.sym} 58740 -1040 0 0 {name=X_69544_ }
C {devices/lab_pin.sym} 58680 -940 0 0 {name=p58646 lab=_54775_/A }
C {devices/lab_pin.sym} 58680 -900 0 0 {name=p58647 lab=_54788_/B }
C {devices/lab_pin.sym} 58680 -860 0 0 {name=p58648 lab=_54775_/C }
C {devices/lab_pin.sym} 58680 -820 0 0 {name=p58649 lab=_47494_/A }
C {devices/lab_pin.sym} 58800 -880 0 1 {name=p58650 lab=_54770_/X }
C {sky130_stdcells/and4_4.sym} 58740 -880 0 0 {name=X_54770_ }
C {devices/lab_pin.sym} 58660 -750 0 0 {name=p58651 lab=_84098_/Q }
C {devices/lab_pin.sym} 58660 -710 0 0 {name=p58652 lab=_66734_/X }
C {devices/lab_pin.sym} 58660 -670 0 0 {name=p58653 lab=_66755_/X }
C {devices/lab_pin.sym} 58820 -710 0 1 {name=p58654 lab=_84098_/D }
C {sky130_stdcells/a21bo_4.sym} 58740 -710 0 0 {name=X_66756_ }
C {devices/lab_pin.sym} 59570 -42150 0 0 {name=p58655 lab=_85590_/CLK }
C {devices/lab_pin.sym} 59570 -42130 0 0 {name=p58656 lab=_53677_/Y }
C {devices/lab_pin.sym} 59750 -42150 0 1 {name=p58657 lab=_85590_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -42140 0 0 {name=X_85590_ }
C {devices/lab_pin.sym} 59620 -42010 0 0 {name=p58658 lab=_52407_/A }
C {devices/lab_pin.sym} 59700 -42010 0 1 {name=p58659 lab=_51982_/X }
C {sky130_stdcells/buf_2.sym} 59660 -42010 0 0 {name=X_51982_ }
C {devices/lab_pin.sym} 59580 -41930 0 0 {name=p58660 lab=_60967_/A }
C {devices/lab_pin.sym} 59580 -41890 0 0 {name=p58661 lab=_61502_/A }
C {devices/lab_pin.sym} 59580 -41850 0 0 {name=p58662 lab=_63962_/X }
C {devices/lab_pin.sym} 59580 -41810 0 0 {name=p58663 lab=_63965_/Y }
C {devices/lab_pin.sym} 59580 -41770 0 0 {name=p58664 lab=_63967_/Y }
C {devices/lab_pin.sym} 59740 -41850 0 1 {name=p58665 lab=_63968_/Y }
C {sky130_stdcells/a2111oi_4.sym} 59660 -41850 0 0 {name=X_63968_ }
C {devices/lab_pin.sym} 59580 -41710 0 0 {name=p58666 lab=_53719_/Y }
C {devices/lab_pin.sym} 59580 -41670 0 0 {name=p58667 lab=_53715_/X }
C {devices/lab_pin.sym} 59580 -41630 0 0 {name=p58668 lab=_53720_/X }
C {devices/lab_pin.sym} 59740 -41670 0 1 {name=p58669 lab=_53721_/Y }
C {sky130_stdcells/a21oi_4.sym} 59660 -41670 0 0 {name=X_53721_ }
C {devices/lab_pin.sym} 59620 -41530 0 0 {name=p58670 lab=_65407_/A }
C {devices/lab_pin.sym} 59700 -41530 0 1 {name=p58671 lab=_65707_/X }
C {sky130_stdcells/buf_2.sym} 59660 -41530 0 0 {name=X_65707_ }
C {devices/lab_pin.sym} 59570 -41410 0 0 {name=p58672 lab=_84534_/CLK }
C {devices/lab_pin.sym} 59570 -41390 0 0 {name=p58673 lab=_84541_/D }
C {devices/lab_pin.sym} 59750 -41410 0 1 {name=p58674 lab=_76989_/A }
C {sky130_stdcells/dfxtp_4.sym} 59660 -41400 0 0 {name=X_84541_ }
C {devices/lab_pin.sym} 59580 -41290 0 0 {name=p58675 lab=_86104_/Q }
C {devices/lab_pin.sym} 59580 -41250 0 0 {name=p58676 lab=_50910_/X }
C {devices/lab_pin.sym} 59580 -41210 0 0 {name=p58677 lab=_50932_/Y }
C {devices/lab_pin.sym} 59740 -41250 0 1 {name=p58678 lab=_50933_/Y }
C {sky130_stdcells/o21ai_4.sym} 59660 -41250 0 0 {name=X_50933_ }
C {devices/lab_pin.sym} 59600 -41120 0 0 {name=p58679 lab=_84842_/Q }
C {devices/lab_pin.sym} 59600 -41080 0 0 {name=p58680 lab=_62642_/B }
C {devices/lab_pin.sym} 59720 -41100 0 1 {name=p58681 lab=_62919_/Y }
C {sky130_stdcells/nor2_4.sym} 59660 -41100 0 0 {name=X_62919_ }
C {devices/lab_pin.sym} 59570 -40970 0 0 {name=p58682 lab=_81756_/CLK }
C {devices/lab_pin.sym} 59570 -40950 0 0 {name=p58683 lab=_76090_/B }
C {devices/lab_pin.sym} 59750 -40970 0 1 {name=p58684 lab=_41326_/A }
C {sky130_stdcells/dfxtp_4.sym} 59660 -40960 0 0 {name=X_81753_ }
C {devices/lab_pin.sym} 59580 -40850 0 0 {name=p58685 lab=_68969_/X }
C {devices/lab_pin.sym} 59580 -40810 0 0 {name=p58686 lab=_68971_/X }
C {devices/lab_pin.sym} 59580 -40770 0 0 {name=p58687 lab=_69418_/X }
C {devices/lab_pin.sym} 59740 -40810 0 1 {name=p58688 lab=_69475_/Y }
C {sky130_stdcells/a21oi_4.sym} 59660 -40810 0 0 {name=X_69475_ }
C {devices/lab_pin.sym} 59580 -40690 0 0 {name=p58689 lab=_84101_/Q }
C {devices/lab_pin.sym} 59580 -40650 0 0 {name=p58690 lab=_66614_/X }
C {devices/lab_pin.sym} 59580 -40610 0 0 {name=p58691 lab=_66686_/X }
C {devices/lab_pin.sym} 59740 -40650 0 1 {name=p58692 lab=_66687_/X }
C {sky130_stdcells/a21bo_4.sym} 59660 -40650 0 0 {name=X_66687_ }
C {devices/lab_pin.sym} 59600 -40540 0 0 {name=p58693 lab=_61451_/A }
C {devices/lab_pin.sym} 59600 -40500 0 0 {name=p58694 lab=_63853_/B }
C {devices/lab_pin.sym} 59600 -40460 0 0 {name=p58695 lab=_63947_/C }
C {devices/lab_pin.sym} 59600 -40420 0 0 {name=p58696 lab=_63866_/X }
C {devices/lab_pin.sym} 59720 -40480 0 1 {name=p58697 lab=_63899_/Y }
C {sky130_stdcells/nand4_4.sym} 59660 -40480 0 0 {name=X_63899_ }
C {devices/lab_pin.sym} 59600 -40350 0 0 {name=p58698 lab=_56446_/A }
C {devices/lab_pin.sym} 59600 -40310 0 0 {name=p58699 lab=_56446_/B }
C {devices/lab_pin.sym} 59600 -40270 0 0 {name=p58700 lab=_85193_/Q }
C {devices/lab_pin.sym} 59720 -40310 0 1 {name=p58701 lab=_56440_/Y }
C {sky130_stdcells/nand3_4.sym} 59660 -40310 0 0 {name=X_56440_ }
C {devices/lab_pin.sym} 59580 -40200 0 0 {name=p58702 lab=_88017_/Q }
C {devices/lab_pin.sym} 59580 -40160 0 0 {name=p58703 lab=_68402_/X }
C {devices/lab_pin.sym} 59580 -40120 0 0 {name=p58704 lab=_68359_/X }
C {devices/lab_pin.sym} 59580 -40080 0 0 {name=p58705 lab=_68425_/X }
C {devices/lab_pin.sym} 59740 -40140 0 1 {name=p58706 lab=_68426_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -40140 0 0 {name=X_68426_ }
C {devices/lab_pin.sym} 59570 -39990 0 0 {name=p58707 lab=_81104_/CLK }
C {devices/lab_pin.sym} 59570 -39970 0 0 {name=p58708 lab=_80704_/D }
C {devices/lab_pin.sym} 59750 -39990 0 1 {name=p58709 lab=_80704_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -39980 0 0 {name=X_80704_ }
C {devices/lab_pin.sym} 59570 -39850 0 0 {name=p58710 lab=_87260_/CLK }
C {devices/lab_pin.sym} 59570 -39830 0 0 {name=p58711 lab=_87260_/D }
C {devices/lab_pin.sym} 59750 -39850 0 1 {name=p58712 lab=_87260_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -39840 0 0 {name=X_87260_ }
C {devices/lab_pin.sym} 59620 -39710 0 0 {name=p58713 lab=_65118_/A }
C {devices/lab_pin.sym} 59700 -39710 0 1 {name=p58714 lab=_65638_/X }
C {sky130_stdcells/buf_2.sym} 59660 -39710 0 0 {name=X_65638_ }
C {devices/lab_pin.sym} 59580 -39610 0 0 {name=p58715 lab=_85594_/Q }
C {devices/lab_pin.sym} 59580 -39570 0 0 {name=p58716 lab=_53626_/X }
C {devices/lab_pin.sym} 59580 -39530 0 0 {name=p58717 lab=_53651_/Y }
C {devices/lab_pin.sym} 59740 -39570 0 1 {name=p58718 lab=_53652_/Y }
C {sky130_stdcells/o21ai_4.sym} 59660 -39570 0 0 {name=X_53652_ }
C {devices/lab_pin.sym} 59570 -39430 0 0 {name=p58719 lab=_82452_/CLK }
C {devices/lab_pin.sym} 59570 -39410 0 0 {name=p58720 lab=_61547_/Y }
C {devices/lab_pin.sym} 59750 -39430 0 1 {name=p58721 lab=_61546_/C }
C {sky130_stdcells/dfxtp_4.sym} 59660 -39420 0 0 {name=X_84472_ }
C {devices/lab_pin.sym} 59600 -39300 0 0 {name=p58722 lab=_50845_/A }
C {devices/lab_pin.sym} 59600 -39260 0 0 {name=p58723 lab=_54075_/B }
C {devices/lab_pin.sym} 59720 -39280 0 1 {name=p58724 lab=_50864_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -39280 0 0 {name=X_50864_ }
C {devices/lab_pin.sym} 59570 -39150 0 0 {name=p58725 lab=_81684_/CLK }
C {devices/lab_pin.sym} 59570 -39130 0 0 {name=p58726 lab=_81684_/D }
C {devices/lab_pin.sym} 59750 -39150 0 1 {name=p58727 lab=_81684_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -39140 0 0 {name=X_81684_ }
C {devices/lab_pin.sym} 59570 -39010 0 0 {name=p58728 lab=_86203_/CLK }
C {devices/lab_pin.sym} 59570 -38990 0 0 {name=p58729 lab=_86211_/D }
C {devices/lab_pin.sym} 59750 -39010 0 1 {name=p58730 lab=_86211_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -39000 0 0 {name=X_86211_ }
C {devices/lab_pin.sym} 59600 -38880 0 0 {name=p58731 lab=_52624_/A }
C {devices/lab_pin.sym} 59600 -38840 0 0 {name=p58732 lab=_46662_/A }
C {devices/lab_pin.sym} 59720 -38860 0 1 {name=p58733 lab=_52603_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -38860 0 0 {name=X_52603_ }
C {devices/lab_pin.sym} 59570 -38730 0 0 {name=p58734 lab=_84945_/CLK }
C {devices/lab_pin.sym} 59570 -38710 0 0 {name=p58735 lab=_71657_/Y }
C {devices/lab_pin.sym} 59750 -38730 0 1 {name=p58736 lab=_58508_/A }
C {sky130_stdcells/dfxtp_4.sym} 59660 -38720 0 0 {name=X_83423_ }
C {devices/lab_pin.sym} 59620 -38590 0 0 {name=p58737 lab=_56370_/Y }
C {devices/lab_pin.sym} 59700 -38590 0 1 {name=p58738 lab=_56439_/A }
C {sky130_stdcells/buf_2.sym} 59660 -38590 0 0 {name=X_56371_ }
C {devices/lab_pin.sym} 59600 -38480 0 0 {name=p58739 lab=_80270_/X }
C {devices/lab_pin.sym} 59600 -38440 0 0 {name=p58740 lab=_80271_/Y }
C {devices/lab_pin.sym} 59720 -38460 0 1 {name=p58741 lab=_80635_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -38460 0 0 {name=X_80635_ }
C {devices/lab_pin.sym} 59600 -38340 0 0 {name=p58742 lab=_68352_/X }
C {devices/lab_pin.sym} 59600 -38300 0 0 {name=p58743 lab=_68356_/X }
C {devices/lab_pin.sym} 59720 -38320 0 1 {name=p58744 lab=_68357_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -38320 0 0 {name=X_68357_ }
C {devices/lab_pin.sym} 59570 -38190 0 0 {name=p58745 lab=_87189_/CLK }
C {devices/lab_pin.sym} 59570 -38170 0 0 {name=p58746 lab=_87191_/D }
C {devices/lab_pin.sym} 59750 -38190 0 1 {name=p58747 lab=_68000_/B }
C {sky130_stdcells/dfxtp_4.sym} 59660 -38180 0 0 {name=X_87191_ }
C {devices/lab_pin.sym} 59600 -38070 0 0 {name=p58748 lab=_50360_/A }
C {devices/lab_pin.sym} 59600 -38030 0 0 {name=p58749 lab=_53620_/B }
C {devices/lab_pin.sym} 59600 -37990 0 0 {name=p58750 lab=_53620_/C }
C {devices/lab_pin.sym} 59720 -38030 0 1 {name=p58751 lab=_53583_/X }
C {sky130_stdcells/and3_4.sym} 59660 -38030 0 0 {name=X_53583_ }
C {devices/lab_pin.sym} 59600 -37900 0 0 {name=p58752 lab=_65416_/X }
C {devices/lab_pin.sym} 59600 -37860 0 0 {name=p58753 lab=_73016_/B }
C {devices/lab_pin.sym} 59720 -37880 0 1 {name=p58754 lab=_65569_/X }
C {sky130_stdcells/and2_4.sym} 59660 -37880 0 0 {name=X_65569_ }
C {devices/lab_pin.sym} 59600 -37760 0 0 {name=p58755 lab=_50777_/A }
C {devices/lab_pin.sym} 59600 -37720 0 0 {name=p58756 lab=_46412_/B }
C {devices/lab_pin.sym} 59720 -37740 0 1 {name=p58757 lab=_50795_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -37740 0 0 {name=X_50795_ }
C {devices/lab_pin.sym} 59580 -37630 0 0 {name=p58758 lab=_57997_/X }
C {devices/lab_pin.sym} 59580 -37590 0 0 {name=p58759 lab=_85476_/Q }
C {devices/lab_pin.sym} 59580 -37550 0 0 {name=p58760 lab=_58109_/X }
C {devices/lab_pin.sym} 59740 -37590 0 1 {name=p58761 lab=_58110_/X }
C {sky130_stdcells/o21a_4.sym} 59660 -37590 0 0 {name=X_58110_ }
C {sky130_stdcells/decap_3.sym} 59660 -37420 0 0 {name=XPHY_105 }
C {devices/lab_pin.sym} 59580 -37290 0 0 {name=p58762 lab=_55318_/X }
C {devices/lab_pin.sym} 59580 -37250 0 0 {name=p58763 lab=_55321_/X }
C {devices/lab_pin.sym} 59580 -37210 0 0 {name=p58764 lab=_55309_/X }
C {devices/lab_pin.sym} 59740 -37250 0 1 {name=p58765 lab=_55322_/X }
C {sky130_stdcells/a21o_4.sym} 59660 -37250 0 0 {name=X_55322_ }
C {devices/lab_pin.sym} 59600 -37120 0 0 {name=p58766 lab=_67308_/A }
C {devices/lab_pin.sym} 59600 -37080 0 0 {name=p58767 lab=_86807_/Q }
C {devices/lab_pin.sym} 59720 -37100 0 1 {name=p58768 lab=_67308_/X }
C {sky130_stdcells/and2_4.sym} 59660 -37100 0 0 {name=X_67308_ }
C {devices/lab_pin.sym} 59570 -36970 0 0 {name=p58769 lab=_85535_/CLK }
C {devices/lab_pin.sym} 59570 -36950 0 0 {name=p58770 lab=_86142_/D }
C {devices/lab_pin.sym} 59750 -36970 0 1 {name=p58771 lab=_86142_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -36960 0 0 {name=X_86142_ }
C {devices/lab_pin.sym} 59580 -36850 0 0 {name=p58772 lab=_52531_/Y }
C {devices/lab_pin.sym} 59580 -36810 0 0 {name=p58773 lab=_52532_/X }
C {devices/lab_pin.sym} 59580 -36770 0 0 {name=p58774 lab=_52533_/X }
C {devices/lab_pin.sym} 59740 -36810 0 1 {name=p58775 lab=_85803_/D }
C {sky130_stdcells/a21oi_4.sym} 59660 -36810 0 0 {name=X_52534_ }
C {sky130_stdcells/decap_3.sym} 59660 -36640 0 0 {name=XPHY_116 }
C {devices/lab_pin.sym} 59600 -36500 0 0 {name=p58776 lab=_59090_/A }
C {devices/lab_pin.sym} 59600 -36460 0 0 {name=p58777 lab=_59090_/B }
C {devices/lab_pin.sym} 59720 -36480 0 1 {name=p58778 lab=_59090_/Y }
C {sky130_stdcells/nor2_4.sym} 59660 -36480 0 0 {name=X_59090_ }
C {devices/lab_pin.sym} 59570 -36350 0 0 {name=p58779 lab=_83761_/CLK }
C {devices/lab_pin.sym} 59570 -36330 0 0 {name=p58780 lab=_71844_/X }
C {devices/lab_pin.sym} 59750 -36350 0 1 {name=p58781 lab=_83354_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -36340 0 0 {name=X_83354_ }
C {devices/lab_pin.sym} 59580 -36230 0 0 {name=p58782 lab=_80560_/A }
C {devices/lab_pin.sym} 59580 -36190 0 0 {name=p58783 lab=_80560_/B }
C {devices/lab_pin.sym} 59580 -36150 0 0 {name=p58784 lab=_80565_/Y }
C {devices/lab_pin.sym} 59740 -36190 0 1 {name=p58785 lab=_80566_/Y }
C {sky130_stdcells/a21boi_4.sym} 59660 -36190 0 0 {name=X_80566_ }
C {devices/lab_pin.sym} 59580 -36070 0 0 {name=p58786 lab=_67775_/X }
C {devices/lab_pin.sym} 59580 -36030 0 0 {name=p58787 lab=_67778_/X }
C {devices/lab_pin.sym} 59580 -35990 0 0 {name=p58788 lab=_68260_/X }
C {devices/lab_pin.sym} 59740 -36030 0 1 {name=p58789 lab=_68288_/Y }
C {sky130_stdcells/a21oi_4.sym} 59660 -36030 0 0 {name=X_68288_ }
C {sky130_stdcells/decap_3.sym} 59660 -35860 0 0 {name=XPHY_127 }
C {sky130_stdcells/decap_3.sym} 59660 -35680 0 0 {name=XPHY_138 }
C {sky130_stdcells/decap_3.sym} 59660 -35500 0 0 {name=XPHY_149 }
C {devices/lab_pin.sym} 59580 -35370 0 0 {name=p58790 lab=_58030_/X }
C {devices/lab_pin.sym} 59580 -35330 0 0 {name=p58791 lab=_85482_/Q }
C {devices/lab_pin.sym} 59580 -35290 0 0 {name=p58792 lab=_57962_/X }
C {devices/lab_pin.sym} 59740 -35330 0 1 {name=p58793 lab=_58041_/X }
C {sky130_stdcells/o21a_4.sym} 59660 -35330 0 0 {name=X_58041_ }
C {devices/lab_pin.sym} 59570 -35190 0 0 {name=p58794 lab=_82557_/CLK }
C {devices/lab_pin.sym} 59570 -35170 0 0 {name=p58795 lab=_82305_/D }
C {devices/lab_pin.sym} 59750 -35190 0 1 {name=p58796 lab=_82305_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -35180 0 0 {name=X_82305_ }
C {devices/lab_pin.sym} 59620 -35050 0 0 {name=p58797 lab=clkbuf_9_275_0_CLK/X }
C {devices/lab_pin.sym} 59700 -35050 0 1 {name=p58798 lab=_81783_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 59660 -35050 0 0 {name=Xclkbuf_10_551_0_CLK }
C {devices/lab_pin.sym} 59580 -34960 0 0 {name=p58799 lab=_82984_/Q }
C {devices/lab_pin.sym} 59580 -34920 0 0 {name=p58800 lab=_44059_/A }
C {devices/lab_pin.sym} 59580 -34880 0 0 {name=p58801 lab=_55140_/X }
C {devices/lab_pin.sym} 59580 -34840 0 0 {name=p58802 lab=_55252_/X }
C {devices/lab_pin.sym} 59740 -34900 0 1 {name=p58803 lab=_55253_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -34900 0 0 {name=X_55253_ }
C {devices/lab_pin.sym} 59620 -34750 0 0 {name=p58804 lab=_67120_/X }
C {devices/lab_pin.sym} 59700 -34750 0 1 {name=p58805 lab=_67239_/X }
C {sky130_stdcells/buf_2.sym} 59660 -34750 0 0 {name=X_67239_ }
C {devices/lab_pin.sym} 59570 -34630 0 0 {name=p58806 lab=_85754_/CLK }
C {devices/lab_pin.sym} 59570 -34610 0 0 {name=p58807 lab=_51106_/Y }
C {devices/lab_pin.sym} 59750 -34630 0 1 {name=p58808 lab=_86073_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -34620 0 0 {name=X_86073_ }
C {devices/lab_pin.sym} 59580 -34510 0 0 {name=p58809 lab=_52461_/Y }
C {devices/lab_pin.sym} 59580 -34470 0 0 {name=p58810 lab=_52462_/X }
C {devices/lab_pin.sym} 59580 -34430 0 0 {name=p58811 lab=_52464_/Y }
C {devices/lab_pin.sym} 59740 -34470 0 1 {name=p58812 lab=_52465_/Y }
C {sky130_stdcells/a21boi_4.sym} 59660 -34470 0 0 {name=X_52465_ }
C {devices/lab_pin.sym} 59620 -34330 0 0 {name=p58813 lab=clkbuf_6_43_0_CLK/A }
C {devices/lab_pin.sym} 59700 -34330 0 1 {name=p58814 lab=clkbuf_7_85_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 59660 -34330 0 0 {name=Xclkbuf_6_42_0_CLK }
C {devices/lab_pin.sym} 59570 -34210 0 0 {name=p58815 lab=_86149_/CLK }
C {devices/lab_pin.sym} 59570 -34190 0 0 {name=p58816 lab=_83285_/D }
C {devices/lab_pin.sym} 59750 -34210 0 1 {name=p58817 lab=_83285_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -34200 0 0 {name=X_83285_ }
C {devices/lab_pin.sym} 59600 -34080 0 0 {name=p58818 lab=_80497_/A }
C {devices/lab_pin.sym} 59600 -34040 0 0 {name=p58819 lab=_63517_/C }
C {devices/lab_pin.sym} 59720 -34060 0 1 {name=p58820 lab=_80498_/B }
C {sky130_stdcells/xor2_4.sym} 59660 -34060 0 0 {name=X_80497_ }
C {devices/lab_pin.sym} 59580 -33950 0 0 {name=p58821 lab=_54202_/Y }
C {devices/lab_pin.sym} 59580 -33910 0 0 {name=p58822 lab=_54197_/X }
C {devices/lab_pin.sym} 59580 -33870 0 0 {name=p58823 lab=_54203_/X }
C {devices/lab_pin.sym} 59740 -33910 0 1 {name=p58824 lab=_85485_/D }
C {sky130_stdcells/a21oi_4.sym} 59660 -33910 0 0 {name=X_54204_ }
C {devices/lab_pin.sym} 59570 -33770 0 0 {name=p58825 lab=_83008_/CLK }
C {devices/lab_pin.sym} 59570 -33750 0 0 {name=p58826 lab=_85024_/D }
C {devices/lab_pin.sym} 59750 -33770 0 1 {name=p58827 lab=_85024_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -33760 0 0 {name=X_85024_ }
C {devices/lab_pin.sym} 59600 -33660 0 0 {name=p58828 lab=_51410_/X }
C {devices/lab_pin.sym} 59600 -33620 0 0 {name=p58829 lab=_51230_/X }
C {devices/lab_pin.sym} 59600 -33580 0 0 {name=p58830 lab=_51438_/C }
C {devices/lab_pin.sym} 59600 -33540 0 0 {name=p58831 lab=_52942_/D }
C {devices/lab_pin.sym} 59720 -33600 0 1 {name=p58832 lab=_51416_/X }
C {sky130_stdcells/and4_4.sym} 59660 -33600 0 0 {name=X_51416_ }
C {devices/lab_pin.sym} 59620 -33450 0 0 {name=p58833 lab=_70249_/X }
C {devices/lab_pin.sym} 59700 -33450 0 1 {name=p58834 lab=_70260_/D }
C {sky130_stdcells/buf_2.sym} 59660 -33450 0 0 {name=X_70250_ }
C {devices/lab_pin.sym} 59570 -33330 0 0 {name=p58835 lab=_82515_/CLK }
C {devices/lab_pin.sym} 59570 -33310 0 0 {name=p58836 lab=_82268_/Q }
C {devices/lab_pin.sym} 59750 -33330 0 1 {name=p58837 lab=_82236_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -33320 0 0 {name=X_82236_ }
C {devices/lab_pin.sym} 59600 -33200 0 0 {name=p58838 lab=_55711_/A }
C {devices/lab_pin.sym} 59600 -33160 0 0 {name=p58839 lab=_57430_/A }
C {devices/lab_pin.sym} 59720 -33180 0 1 {name=p58840 lab=_55184_/X }
C {sky130_stdcells/and2_4.sym} 59660 -33180 0 0 {name=X_55184_ }
C {devices/lab_pin.sym} 59580 -33070 0 0 {name=p58841 lab=_52394_/Y }
C {devices/lab_pin.sym} 59580 -33030 0 0 {name=p58842 lab=_52390_/X }
C {devices/lab_pin.sym} 59580 -32990 0 0 {name=p58843 lab=_52395_/X }
C {devices/lab_pin.sym} 59740 -33030 0 1 {name=p58844 lab=_52396_/Y }
C {sky130_stdcells/a21oi_4.sym} 59660 -33030 0 0 {name=X_52396_ }
C {devices/lab_pin.sym} 59580 -32910 0 0 {name=p58845 lab=_85497_/Q }
C {devices/lab_pin.sym} 59580 -32870 0 0 {name=p58846 lab=_54113_/X }
C {devices/lab_pin.sym} 59580 -32830 0 0 {name=p58847 lab=_54134_/Y }
C {devices/lab_pin.sym} 59740 -32870 0 1 {name=p58848 lab=_54135_/Y }
C {sky130_stdcells/o21ai_4.sym} 59660 -32870 0 0 {name=X_54135_ }
C {devices/lab_pin.sym} 59620 -32730 0 0 {name=p58849 lab=_51265_/A }
C {devices/lab_pin.sym} 59700 -32730 0 1 {name=p58850 lab=_51352_/B }
C {sky130_stdcells/buf_2.sym} 59660 -32730 0 0 {name=X_51347_ }
C {devices/lab_pin.sym} 59600 -32640 0 0 {name=p58851 lab=_70181_/A }
C {devices/lab_pin.sym} 59600 -32600 0 0 {name=p58852 lab=_70160_/X }
C {devices/lab_pin.sym} 59600 -32560 0 0 {name=p58853 lab=_70162_/X }
C {devices/lab_pin.sym} 59600 -32520 0 0 {name=p58854 lab=_70164_/X }
C {devices/lab_pin.sym} 59720 -32580 0 1 {name=p58855 lab=_70181_/Y }
C {sky130_stdcells/nand4_4.sym} 59660 -32580 0 0 {name=X_70181_ }
C {devices/lab_pin.sym} 59570 -32430 0 0 {name=p58856 lab=_82009_/CLK }
C {devices/lab_pin.sym} 59570 -32410 0 0 {name=p58857 lab=_84159_/Q }
C {devices/lab_pin.sym} 59750 -32430 0 1 {name=p58858 lab=_82167_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -32420 0 0 {name=X_82167_ }
C {devices/lab_pin.sym} 59600 -32310 0 0 {name=p58859 lab=_59873_/A }
C {devices/lab_pin.sym} 59600 -32270 0 0 {name=p58860 lab=_59873_/B }
C {devices/lab_pin.sym} 59600 -32230 0 0 {name=p58861 lab=_59992_/C }
C {devices/lab_pin.sym} 59720 -32270 0 1 {name=p58862 lab=_59992_/Y }
C {sky130_stdcells/nor3_4.sym} 59660 -32270 0 0 {name=X_59992_ }
C {devices/lab_pin.sym} 59620 -32130 0 0 {name=p58863 lab=_40931_/A }
C {devices/lab_pin.sym} 59700 -32130 0 1 {name=p58864 lab=_41100_/X }
C {sky130_stdcells/buf_2.sym} 59660 -32130 0 0 {name=X_41100_ }
C {devices/lab_pin.sym} 59620 -32010 0 0 {name=p58865 lab=clkbuf_9_283_0_CLK/X }
C {devices/lab_pin.sym} 59700 -32010 0 1 {name=p58866 lab=_87348_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 59660 -32010 0 0 {name=Xclkbuf_10_566_0_CLK }
C {devices/lab_pin.sym} 59570 -31890 0 0 {name=p58867 lab=_81048_/CLK }
C {devices/lab_pin.sym} 59570 -31870 0 0 {name=p58868 lab=_79859_/X }
C {devices/lab_pin.sym} 59750 -31890 0 1 {name=p58869 lab=_81118_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -31880 0 0 {name=X_81118_ }
C {devices/lab_pin.sym} 59620 -31750 0 0 {name=p58870 lab=clkbuf_6_57_0_CLK/A }
C {devices/lab_pin.sym} 59700 -31750 0 1 {name=p58871 lab=clkbuf_6_57_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 59660 -31750 0 0 {name=Xclkbuf_6_57_0_CLK }
C {devices/lab_pin.sym} 59620 -31630 0 0 {name=p58872 lab=_42080_/A }
C {devices/lab_pin.sym} 59700 -31630 0 1 {name=p58873 lab=_88044_/D }
C {sky130_stdcells/inv_2.sym} 59660 -31630 0 0 {name=X_42080_ }
C {devices/lab_pin.sym} 59620 -31510 0 0 {name=p58874 lab=_58766_/A }
C {devices/lab_pin.sym} 59700 -31510 0 1 {name=p58875 lab=_58943_/X }
C {sky130_stdcells/buf_2.sym} 59660 -31510 0 0 {name=X_58943_ }
C {devices/lab_pin.sym} 59580 -31410 0 0 {name=p58876 lab=_54064_/Y }
C {devices/lab_pin.sym} 59580 -31370 0 0 {name=p58877 lab=_54060_/X }
C {devices/lab_pin.sym} 59580 -31330 0 0 {name=p58878 lab=_54065_/Y }
C {devices/lab_pin.sym} 59740 -31370 0 1 {name=p58879 lab=_85512_/D }
C {sky130_stdcells/a21boi_4.sym} 59660 -31370 0 0 {name=X_54066_ }
C {devices/lab_pin.sym} 59600 -31240 0 0 {name=p58880 lab=_51278_/A }
C {devices/lab_pin.sym} 59600 -31200 0 0 {name=p58881 lab=_51278_/B }
C {devices/lab_pin.sym} 59720 -31220 0 1 {name=p58882 lab=_51278_/X }
C {sky130_stdcells/and2_4.sym} 59660 -31220 0 0 {name=X_51278_ }
C {devices/lab_pin.sym} 59570 -31090 0 0 {name=p58883 lab=_87416_/CLK }
C {devices/lab_pin.sym} 59570 -31070 0 0 {name=p58884 lab=_86975_/D }
C {devices/lab_pin.sym} 59750 -31090 0 1 {name=p58885 lab=_86975_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -31080 0 0 {name=X_86975_ }
C {devices/lab_pin.sym} 59570 -30950 0 0 {name=p58886 lab=_82860_/CLK }
C {devices/lab_pin.sym} 59570 -30930 0 0 {name=p58887 lab=_77468_/B }
C {devices/lab_pin.sym} 59750 -30950 0 1 {name=p58888 lab=_77118_/A }
C {sky130_stdcells/dfxtp_4.sym} 59660 -30940 0 0 {name=X_82098_ }
C {devices/lab_pin.sym} 59580 -30830 0 0 {name=p58889 lab=_41024_/X }
C {devices/lab_pin.sym} 59580 -30790 0 0 {name=p58890 lab=_81712_/Q }
C {devices/lab_pin.sym} 59580 -30750 0 0 {name=p58891 lab=_41030_/X }
C {devices/lab_pin.sym} 59740 -30790 0 1 {name=p58892 lab=_41032_/A }
C {sky130_stdcells/o21ai_4.sym} 59660 -30790 0 0 {name=X_41031_ }
C {devices/lab_pin.sym} 59600 -30660 0 0 {name=p58893 lab=_53025_/A }
C {devices/lab_pin.sym} 59600 -30620 0 0 {name=p58894 lab=_53017_/B }
C {devices/lab_pin.sym} 59720 -30640 0 1 {name=p58895 lab=_53017_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -30640 0 0 {name=X_53017_ }
C {devices/lab_pin.sym} 59620 -30510 0 0 {name=p58896 lab=_50228_/X }
C {devices/lab_pin.sym} 59700 -30510 0 1 {name=p58897 lab=_50230_/A }
C {sky130_stdcells/buf_2.sym} 59660 -30510 0 0 {name=X_50229_ }
C {devices/lab_pin.sym} 59600 -30400 0 0 {name=p58898 lab=_73940_/A }
C {devices/lab_pin.sym} 59600 -30360 0 0 {name=p58899 lab=_74244_/B }
C {devices/lab_pin.sym} 59720 -30380 0 1 {name=p58900 lab=_73940_/Y }
C {sky130_stdcells/nor2_4.sym} 59660 -30380 0 0 {name=X_73940_ }
C {devices/lab_pin.sym} 59570 -30250 0 0 {name=p58901 lab=_85447_/CLK }
C {devices/lab_pin.sym} 59570 -30230 0 0 {name=p58902 lab=_51899_/Y }
C {devices/lab_pin.sym} 59750 -30250 0 1 {name=p58903 lab=_85926_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -30240 0 0 {name=X_85926_ }
C {devices/lab_pin.sym} 59570 -30110 0 0 {name=p58904 lab=_84269_/CLK }
C {devices/lab_pin.sym} 59570 -30090 0 0 {name=p58905 lab=_75421_/X }
C {devices/lab_pin.sym} 59750 -30110 0 1 {name=p58906 lab=_81049_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -30100 0 0 {name=X_81049_ }
C {devices/lab_pin.sym} 59620 -29970 0 0 {name=p58907 lab=_58603_/A }
C {devices/lab_pin.sym} 59700 -29970 0 1 {name=p58908 lab=_58874_/X }
C {sky130_stdcells/buf_2.sym} 59660 -29970 0 0 {name=X_58874_ }
C {devices/lab_pin.sym} 59620 -29850 0 0 {name=p58909 lab=clkbuf_1_0_2_CLK/A }
C {devices/lab_pin.sym} 59700 -29850 0 1 {name=p58910 lab=clkbuf_2_1_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 59660 -29850 0 0 {name=Xclkbuf_1_0_2_CLK }
C {devices/lab_pin.sym} 59580 -29750 0 0 {name=p58911 lab=_57824_/X }
C {devices/lab_pin.sym} 59580 -29710 0 0 {name=p58912 lab=_85499_/Q }
C {devices/lab_pin.sym} 59580 -29670 0 0 {name=p58913 lab=_57736_/X }
C {devices/lab_pin.sym} 59740 -29710 0 1 {name=p58914 lab=_57825_/X }
C {sky130_stdcells/o21a_4.sym} 59660 -29710 0 0 {name=X_57825_ }
C {devices/lab_pin.sym} 59570 -29570 0 0 {name=p58915 lab=_83311_/CLK }
C {devices/lab_pin.sym} 59570 -29550 0 0 {name=p58916 lab=_52264_/Y }
C {devices/lab_pin.sym} 59750 -29570 0 1 {name=p58917 lab=_85857_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -29560 0 0 {name=X_85857_ }
C {devices/lab_pin.sym} 59580 -29460 0 0 {name=p58918 lab=_68693_/B }
C {devices/lab_pin.sym} 59580 -29420 0 0 {name=p58919 lab=_73674_/X }
C {devices/lab_pin.sym} 59580 -29380 0 0 {name=p58920 lab=_73819_/X }
C {devices/lab_pin.sym} 59580 -29340 0 0 {name=p58921 lab=_73870_/Y }
C {devices/lab_pin.sym} 59740 -29400 0 1 {name=p58922 lab=_73871_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -29400 0 0 {name=X_73871_ }
C {devices/lab_pin.sym} 59600 -29260 0 0 {name=p58923 lab=_75640_/A }
C {devices/lab_pin.sym} 59600 -29220 0 0 {name=p58924 lab=_75609_/Y }
C {devices/lab_pin.sym} 59720 -29240 0 1 {name=p58925 lab=_75611_/B }
C {sky130_stdcells/xor2_4.sym} 59660 -29240 0 0 {name=X_75610_ }
C {devices/lab_pin.sym} 59570 -29110 0 0 {name=p58926 lab=_84807_/CLK }
C {devices/lab_pin.sym} 59570 -29090 0 0 {name=p58927 lab=_84808_/D }
C {devices/lab_pin.sym} 59750 -29110 0 1 {name=p58928 lab=_84808_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -29100 0 0 {name=X_84808_ }
C {devices/lab_pin.sym} 59600 -28990 0 0 {name=p58929 lab=_72820_/X }
C {devices/lab_pin.sym} 59600 -28950 0 0 {name=p58930 lab=_72802_/X }
C {devices/lab_pin.sym} 59600 -28910 0 0 {name=p58931 lab=_72822_/C }
C {devices/lab_pin.sym} 59720 -28950 0 1 {name=p58932 lab=_72822_/Y }
C {sky130_stdcells/nand3_4.sym} 59660 -28950 0 0 {name=X_72822_ }
C {devices/lab_pin.sym} 59580 -28840 0 0 {name=p58933 lab=_45768_/Y }
C {devices/lab_pin.sym} 59580 -28800 0 0 {name=p58934 lab=_45734_/X }
C {devices/lab_pin.sym} 59580 -28760 0 0 {name=p58935 lab=_45720_/X }
C {devices/lab_pin.sym} 59580 -28720 0 0 {name=p58936 lab=_45769_/Y }
C {devices/lab_pin.sym} 59740 -28780 0 1 {name=p58937 lab=_45770_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -28780 0 0 {name=X_45770_ }
C {devices/lab_pin.sym} 59620 -28630 0 0 {name=p58938 lab=_59801_/A }
C {devices/lab_pin.sym} 59700 -28630 0 1 {name=p58939 lab=_57757_/A }
C {sky130_stdcells/buf_2.sym} 59660 -28630 0 0 {name=X_57756_ }
C {devices/lab_pin.sym} 59580 -28530 0 0 {name=p58940 lab=_76516_/Y }
C {devices/lab_pin.sym} 59580 -28490 0 0 {name=p58941 lab=_76584_/X }
C {devices/lab_pin.sym} 59580 -28450 0 0 {name=p58942 lab=_76589_/Y }
C {devices/lab_pin.sym} 59740 -28490 0 1 {name=p58943 lab=_76616_/B }
C {sky130_stdcells/a21oi_4.sym} 59660 -28490 0 0 {name=X_76590_ }
C {devices/lab_pin.sym} 59620 -28350 0 0 {name=p58944 lab=_42981_/Y }
C {devices/lab_pin.sym} 59700 -28350 0 1 {name=p58945 lab=_87620_/D }
C {sky130_stdcells/inv_2.sym} 59660 -28350 0 0 {name=X_42982_ }
C {devices/lab_pin.sym} 59620 -28230 0 0 {name=p58946 lab=_54250_/A }
C {devices/lab_pin.sym} 59700 -28230 0 1 {name=p58947 lab=_54985_/A }
C {sky130_stdcells/buf_2.sym} 59660 -28230 0 0 {name=X_54968_ }
C {devices/lab_pin.sym} 59570 -28110 0 0 {name=p58948 lab=_85786_/CLK }
C {devices/lab_pin.sym} 59570 -28090 0 0 {name=p58949 lab=_85788_/D }
C {devices/lab_pin.sym} 59750 -28110 0 1 {name=p58950 lab=_85788_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -28100 0 0 {name=X_85788_ }
C {devices/lab_pin.sym} 59580 -28010 0 0 {name=p58951 lab=_44712_/X }
C {devices/lab_pin.sym} 59580 -27970 0 0 {name=p58952 lab=_44713_/X }
C {devices/lab_pin.sym} 59580 -27930 0 0 {name=p58953 lab=_40702_/X }
C {devices/lab_pin.sym} 59580 -27890 0 0 {name=p58954 lab=_86987_/Q }
C {devices/lab_pin.sym} 59580 -27850 0 0 {name=p58955 lab=_44714_/X }
C {devices/lab_pin.sym} 59740 -27930 0 1 {name=p58956 lab=_44721_/Y }
C {sky130_stdcells/o32ai_4.sym} 59660 -27930 0 0 {name=X_44721_ }
C {devices/lab_pin.sym} 59620 -27770 0 0 {name=p58957 lab=_46234_/Y }
C {devices/lab_pin.sym} 59700 -27770 0 1 {name=p58958 lab=_56707_/X }
C {sky130_stdcells/buf_2.sym} 59660 -27770 0 0 {name=X_56707_ }
C {devices/lab_pin.sym} 59620 -27650 0 0 {name=p58959 lab=_75541_/A }
C {devices/lab_pin.sym} 59700 -27650 0 1 {name=p58960 lab=_75543_/A }
C {sky130_stdcells/inv_2.sym} 59660 -27650 0 0 {name=X_75541_ }
C {devices/lab_pin.sym} 59570 -27530 0 0 {name=p58961 lab=_87782_/CLK }
C {devices/lab_pin.sym} 59570 -27510 0 0 {name=p58962 lab=_43231_/Y }
C {devices/lab_pin.sym} 59750 -27530 0 1 {name=p58963 lab=_87527_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -27520 0 0 {name=X_87527_ }
C {devices/lab_pin.sym} 59580 -27430 0 0 {name=p58964 lab=_41932_/X }
C {devices/lab_pin.sym} 59580 -27390 0 0 {name=p58965 lab=_41927_/X }
C {devices/lab_pin.sym} 59580 -27350 0 0 {name=p58966 lab=_40667_/X }
C {devices/lab_pin.sym} 59580 -27310 0 0 {name=p58967 lab=_73892_/A }
C {devices/lab_pin.sym} 59580 -27270 0 0 {name=p58968 lab=_41928_/X }
C {devices/lab_pin.sym} 59740 -27350 0 1 {name=p58969 lab=_41934_/A }
C {sky130_stdcells/o32ai_4.sym} 59660 -27350 0 0 {name=X_41933_ }
C {devices/lab_pin.sym} 59600 -27200 0 0 {name=p58970 lab=_53902_/A }
C {devices/lab_pin.sym} 59600 -27160 0 0 {name=p58971 lab=_53919_/B }
C {devices/lab_pin.sym} 59720 -27180 0 1 {name=p58972 lab=_53919_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -27180 0 0 {name=X_53919_ }
C {devices/lab_pin.sym} 59580 -27080 0 0 {name=p58973 lab=_72750_/X }
C {devices/lab_pin.sym} 59580 -27040 0 0 {name=p58974 lab=_85601_/Q }
C {devices/lab_pin.sym} 59580 -27000 0 0 {name=p58975 lab=_44130_/X }
C {devices/lab_pin.sym} 59580 -26960 0 0 {name=p58976 lab=_72752_/X }
C {devices/lab_pin.sym} 59740 -27020 0 1 {name=p58977 lab=_72753_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -27020 0 0 {name=X_72753_ }
C {devices/lab_pin.sym} 59570 -26870 0 0 {name=p58978 lab=_83451_/CLK }
C {devices/lab_pin.sym} 59570 -26850 0 0 {name=p58979 lab=_84739_/D }
C {devices/lab_pin.sym} 59750 -26870 0 1 {name=p58980 lab=_84739_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -26860 0 0 {name=X_84739_ }
C {devices/lab_pin.sym} 59620 -26730 0 0 {name=p58981 lab=_57687_/A }
C {devices/lab_pin.sym} 59700 -26730 0 1 {name=p58982 lab=_59629_/A }
C {sky130_stdcells/inv_2.sym} 59660 -26730 0 0 {name=X_57687_ }
C {devices/lab_pin.sym} 59580 -26630 0 0 {name=p58983 lab=_85357_/Q }
C {devices/lab_pin.sym} 59580 -26590 0 0 {name=p58984 lab=_54892_/X }
C {devices/lab_pin.sym} 59580 -26550 0 0 {name=p58985 lab=_54898_/Y }
C {devices/lab_pin.sym} 59740 -26590 0 1 {name=p58986 lab=_54899_/Y }
C {sky130_stdcells/o21ai_4.sym} 59660 -26590 0 0 {name=X_54899_ }
C {devices/lab_pin.sym} 59620 -26450 0 0 {name=p58987 lab=clkbuf_9_252_0_CLK/X }
C {devices/lab_pin.sym} 59700 -26450 0 1 {name=p58988 lab=_86393_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 59660 -26450 0 0 {name=Xclkbuf_10_504_0_CLK }
C {devices/lab_pin.sym} 59600 -26360 0 0 {name=p58989 lab=_47437_/X }
C {devices/lab_pin.sym} 59600 -26320 0 0 {name=p58990 lab=_47415_/X }
C {devices/lab_pin.sym} 59600 -26280 0 0 {name=p58991 lab=_47466_/C }
C {devices/lab_pin.sym} 59600 -26240 0 0 {name=p58992 lab=_53048_/D }
C {devices/lab_pin.sym} 59720 -26300 0 1 {name=p58993 lab=_47440_/X }
C {sky130_stdcells/and4_4.sym} 59660 -26300 0 0 {name=X_47440_ }
C {devices/lab_pin.sym} 59600 -26170 0 0 {name=p58994 lab=_71338_/A }
C {devices/lab_pin.sym} 59600 -26130 0 0 {name=p58995 lab=_71685_/X }
C {devices/lab_pin.sym} 59600 -26090 0 0 {name=p58996 lab=_71333_/C }
C {devices/lab_pin.sym} 59720 -26130 0 1 {name=p58997 lab=_71704_/Y }
C {sky130_stdcells/nand3_4.sym} 59660 -26130 0 0 {name=X_71704_ }
C {devices/lab_pin.sym} 59620 -25990 0 0 {name=p58998 lab=_74831_/A }
C {devices/lab_pin.sym} 59700 -25990 0 1 {name=p58999 lab=_59426_/X }
C {sky130_stdcells/buf_2.sym} 59660 -25990 0 0 {name=X_59426_ }
C {devices/lab_pin.sym} 59600 -25880 0 0 {name=p59000 lab=_78263_/A }
C {devices/lab_pin.sym} 59600 -25840 0 0 {name=p59001 lab=_78259_/Y }
C {devices/lab_pin.sym} 59720 -25860 0 1 {name=p59002 lab=_78261_/B }
C {sky130_stdcells/xor2_4.sym} 59660 -25860 0 0 {name=X_78260_ }
C {devices/lab_pin.sym} 59580 -25760 0 0 {name=p59003 lab=_41064_/A }
C {devices/lab_pin.sym} 59580 -25720 0 0 {name=p59004 lab=_44648_/X }
C {devices/lab_pin.sym} 59580 -25680 0 0 {name=p59005 lab=_87016_/Q }
C {devices/lab_pin.sym} 59580 -25640 0 0 {name=p59006 lab=_44650_/X }
C {devices/lab_pin.sym} 59740 -25700 0 1 {name=p59007 lab=_44652_/X }
C {sky130_stdcells/a2bb2o_4.sym} 59660 -25700 0 0 {name=X_44652_ }
C {devices/lab_pin.sym} 59600 -25560 0 0 {name=p59008 lab=_55467_/X }
C {devices/lab_pin.sym} 59600 -25520 0 0 {name=p59009 lab=_56638_/B }
C {devices/lab_pin.sym} 59720 -25540 0 1 {name=p59010 lab=_56638_/X }
C {sky130_stdcells/xor2_4.sym} 59660 -25540 0 0 {name=X_56638_ }
C {devices/lab_pin.sym} 59570 -25410 0 0 {name=p59011 lab=_87720_/CLK }
C {devices/lab_pin.sym} 59570 -25390 0 0 {name=p59012 lab=_87458_/D }
C {devices/lab_pin.sym} 59750 -25410 0 1 {name=p59013 lab=_87458_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -25400 0 0 {name=X_87458_ }
C {devices/lab_pin.sym} 59600 -25280 0 0 {name=p59014 lab=_75472_/A }
C {devices/lab_pin.sym} 59600 -25240 0 0 {name=p59015 lab=_81052_/D }
C {devices/lab_pin.sym} 59720 -25260 0 1 {name=p59016 lab=_75472_/X }
C {sky130_stdcells/xor2_4.sym} 59660 -25260 0 0 {name=X_75472_ }
C {devices/lab_pin.sym} 59620 -25130 0 0 {name=p59017 lab=_42626_/A }
C {devices/lab_pin.sym} 59700 -25130 0 1 {name=p59018 lab=_41902_/A }
C {sky130_stdcells/buf_2.sym} 59660 -25130 0 0 {name=X_41864_ }
C {devices/lab_pin.sym} 59580 -25030 0 0 {name=p59019 lab=_83190_/Q }
C {devices/lab_pin.sym} 59580 -24990 0 0 {name=p59020 lab=_72672_/X }
C {devices/lab_pin.sym} 59580 -24950 0 0 {name=p59021 lab=_72683_/Y }
C {devices/lab_pin.sym} 59740 -24990 0 1 {name=p59022 lab=_72684_/X }
C {sky130_stdcells/a21bo_4.sym} 59660 -24990 0 0 {name=X_72684_ }
C {devices/lab_pin.sym} 59600 -24860 0 0 {name=p59023 lab=_77200_/A }
C {devices/lab_pin.sym} 59600 -24820 0 0 {name=p59024 lab=_82302_/D }
C {devices/lab_pin.sym} 59720 -24840 0 1 {name=p59025 lab=_77211_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -24840 0 0 {name=X_77211_ }
C {devices/lab_pin.sym} 59620 -24710 0 0 {name=p59026 lab=_43602_/X }
C {devices/lab_pin.sym} 59700 -24710 0 1 {name=p59027 lab=_55102_/A }
C {sky130_stdcells/buf_2.sym} 59660 -24710 0 0 {name=X_43603_ }
C {devices/lab_pin.sym} 59600 -24600 0 0 {name=p59028 lab=_74413_/X }
C {devices/lab_pin.sym} 59600 -24560 0 0 {name=p59029 lab=_53678_/B }
C {devices/lab_pin.sym} 59720 -24580 0 1 {name=p59030 lab=_74423_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -24580 0 0 {name=X_74423_ }
C {devices/lab_pin.sym} 59570 -24450 0 0 {name=p59031 lab=_85800_/CLK }
C {devices/lab_pin.sym} 59570 -24430 0 0 {name=p59032 lab=_49329_/Y }
C {devices/lab_pin.sym} 59750 -24450 0 1 {name=p59033 lab=_86409_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -24440 0 0 {name=X_86409_ }
C {devices/lab_pin.sym} 59580 -24350 0 0 {name=p59034 lab=_40758_/X }
C {devices/lab_pin.sym} 59580 -24310 0 0 {name=p59035 lab=_40759_/X }
C {devices/lab_pin.sym} 59580 -24270 0 0 {name=p59036 lab=_40814_/X }
C {devices/lab_pin.sym} 59580 -24230 0 0 {name=p59037 lab=_88329_/Q }
C {devices/lab_pin.sym} 59580 -24190 0 0 {name=p59038 lab=_40744_/X }
C {devices/lab_pin.sym} 59740 -24270 0 1 {name=p59039 lab=_40816_/A }
C {sky130_stdcells/o32ai_4.sym} 59660 -24270 0 0 {name=X_40815_ }
C {devices/lab_pin.sym} 59580 -24130 0 0 {name=p59040 lab=_47362_/Y }
C {devices/lab_pin.sym} 59580 -24090 0 0 {name=p59041 lab=_47364_/X }
C {devices/lab_pin.sym} 59580 -24050 0 0 {name=p59042 lab=_47370_/X }
C {devices/lab_pin.sym} 59740 -24090 0 1 {name=p59043 lab=_86642_/D }
C {sky130_stdcells/a21oi_4.sym} 59660 -24090 0 0 {name=X_47371_ }
C {devices/lab_pin.sym} 59580 -23970 0 0 {name=p59044 lab=_59219_/X }
C {devices/lab_pin.sym} 59580 -23930 0 0 {name=p59045 lab=_85732_/Q }
C {devices/lab_pin.sym} 59580 -23890 0 0 {name=p59046 lab=_59220_/X }
C {devices/lab_pin.sym} 59740 -23930 0 1 {name=p59047 lab=_59357_/X }
C {sky130_stdcells/o21a_4.sym} 59660 -23930 0 0 {name=X_59357_ }
C {devices/lab_pin.sym} 59600 -23810 0 0 {name=p59048 lab=_71637_/A }
C {devices/lab_pin.sym} 59600 -23770 0 0 {name=p59049 lab=_71223_/B }
C {devices/lab_pin.sym} 59600 -23730 0 0 {name=p59050 lab=_71637_/C }
C {devices/lab_pin.sym} 59720 -23770 0 1 {name=p59051 lab=_71635_/Y }
C {sky130_stdcells/nand3_4.sym} 59660 -23770 0 0 {name=X_71635_ }
C {devices/lab_pin.sym} 59600 -23650 0 0 {name=p59052 lab=_78191_/A }
C {devices/lab_pin.sym} 59600 -23610 0 0 {name=p59053 lab=_78191_/B }
C {devices/lab_pin.sym} 59600 -23570 0 0 {name=p59054 lab=_78191_/C }
C {devices/lab_pin.sym} 59720 -23610 0 1 {name=p59055 lab=_78191_/X }
C {sky130_stdcells/and3_4.sym} 59660 -23610 0 0 {name=X_78191_ }
C {devices/lab_pin.sym} 59620 -23470 0 0 {name=p59056 lab=_44583_/A }
C {devices/lab_pin.sym} 59700 -23470 0 1 {name=p59057 lab=_44583_/Y }
C {sky130_stdcells/inv_2.sym} 59660 -23470 0 0 {name=X_44583_ }
C {devices/lab_pin.sym} 59600 -23370 0 0 {name=p59058 lab=_56558_/X }
C {devices/lab_pin.sym} 59600 -23330 0 0 {name=p59059 lab=_72641_/C }
C {devices/lab_pin.sym} 59600 -23290 0 0 {name=p59060 lab=_56564_/B }
C {devices/lab_pin.sym} 59720 -23330 0 1 {name=p59061 lab=_56569_/X }
C {sky130_stdcells/and3_4.sym} 59660 -23330 0 0 {name=X_56569_ }
C {devices/lab_pin.sym} 59570 -23190 0 0 {name=p59062 lab=_87195_/CLK }
C {devices/lab_pin.sym} 59570 -23170 0 0 {name=p59063 lab=_87389_/D }
C {devices/lab_pin.sym} 59750 -23190 0 1 {name=p59064 lab=_87389_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -23180 0 0 {name=X_87389_ }
C {devices/lab_pin.sym} 59600 -23060 0 0 {name=p59065 lab=_40620_/X }
C {devices/lab_pin.sym} 59600 -23020 0 0 {name=p59066 lab=_81185_/Q }
C {devices/lab_pin.sym} 59720 -23040 0 1 {name=p59067 lab=_41795_/X }
C {sky130_stdcells/or2_4.sym} 59660 -23040 0 0 {name=X_41795_ }
C {sky130_stdcells/decap_3.sym} 59660 -22880 0 0 {name=XPHY_7 }
C {devices/lab_pin.sym} 59600 -22740 0 0 {name=p59068 lab=_49110_/A }
C {devices/lab_pin.sym} 59600 -22700 0 0 {name=p59069 lab=_46348_/A }
C {devices/lab_pin.sym} 59720 -22720 0 1 {name=p59070 lab=_49110_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -22720 0 0 {name=X_49110_ }
C {devices/lab_pin.sym} 59600 -22610 0 0 {name=p59071 lab=_50755_/A }
C {devices/lab_pin.sym} 59600 -22570 0 0 {name=p59072 lab=_46428_/B }
C {devices/lab_pin.sym} 59600 -22530 0 0 {name=p59073 lab=_46428_/C }
C {devices/lab_pin.sym} 59720 -22570 0 1 {name=p59074 lab=_46322_/X }
C {sky130_stdcells/and3_4.sym} 59660 -22570 0 0 {name=X_46322_ }
C {devices/lab_pin.sym} 59600 -22440 0 0 {name=p59075 lab=_63348_/A }
C {devices/lab_pin.sym} 59600 -22400 0 0 {name=p59076 lab=_58280_/B }
C {devices/lab_pin.sym} 59720 -22420 0 1 {name=p59077 lab=_58308_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -22420 0 0 {name=X_58308_ }
C {devices/lab_pin.sym} 59600 -22300 0 0 {name=p59078 lab=_77142_/A }
C {devices/lab_pin.sym} 59600 -22260 0 0 {name=p59079 lab=_77142_/B }
C {devices/lab_pin.sym} 59720 -22280 0 1 {name=p59080 lab=_77142_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -22280 0 0 {name=X_77142_ }
C {devices/lab_pin.sym} 59580 -22180 0 0 {name=p59081 lab=_40400_/X }
C {devices/lab_pin.sym} 59580 -22140 0 0 {name=p59082 lab=_43532_/X }
C {devices/lab_pin.sym} 59580 -22100 0 0 {name=p59083 lab=_87373_/Q }
C {devices/lab_pin.sym} 59580 -22060 0 0 {name=p59084 lab=_43533_/X }
C {devices/lab_pin.sym} 59740 -22120 0 1 {name=p59085 lab=_87373_/D }
C {sky130_stdcells/a2bb2o_4.sym} 59660 -22120 0 0 {name=X_43534_ }
C {devices/lab_pin.sym} 59580 -21990 0 0 {name=p59086 lab=_83086_/Q }
C {devices/lab_pin.sym} 59580 -21950 0 0 {name=p59087 lab=_73050_/A }
C {devices/lab_pin.sym} 59580 -21910 0 0 {name=p59088 lab=_74353_/Y }
C {devices/lab_pin.sym} 59740 -21950 0 1 {name=p59089 lab=_83086_/D }
C {sky130_stdcells/a21o_4.sym} 59660 -21950 0 0 {name=X_74354_ }
C {devices/lab_pin.sym} 59620 -21810 0 0 {name=p59090 lab=_40746_/A }
C {devices/lab_pin.sym} 59700 -21810 0 1 {name=p59091 lab=_88343_/D }
C {sky130_stdcells/inv_2.sym} 59660 -21810 0 0 {name=X_40746_ }
C {devices/lab_pin.sym} 59580 -21710 0 0 {name=p59092 lab=_71557_/X }
C {devices/lab_pin.sym} 59580 -21670 0 0 {name=p59093 lab=_83454_/Q }
C {devices/lab_pin.sym} 59580 -21630 0 0 {name=p59094 lab=_71565_/Y }
C {devices/lab_pin.sym} 59740 -21670 0 1 {name=p59095 lab=_71566_/X }
C {sky130_stdcells/a21o_4.sym} 59660 -21670 0 0 {name=X_71566_ }
C {devices/lab_pin.sym} 59580 -21550 0 0 {name=p59096 lab=_59286_/X }
C {devices/lab_pin.sym} 59580 -21510 0 0 {name=p59097 lab=_86058_/Q }
C {devices/lab_pin.sym} 59580 -21470 0 0 {name=p59098 lab=_59287_/X }
C {devices/lab_pin.sym} 59740 -21510 0 1 {name=p59099 lab=_59288_/Y }
C {sky130_stdcells/o21ai_4.sym} 59660 -21510 0 0 {name=X_59288_ }
C {devices/lab_pin.sym} 59620 -21370 0 0 {name=p59100 lab=clkbuf_9_259_0_CLK/X }
C {devices/lab_pin.sym} 59700 -21370 0 1 {name=p59101 lab=_81322_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 59660 -21370 0 0 {name=Xclkbuf_10_519_0_CLK }
C {devices/lab_pin.sym} 59620 -21250 0 0 {name=p59102 lab=_49041_/A }
C {devices/lab_pin.sym} 59700 -21250 0 1 {name=p59103 lab=_53858_/B }
C {sky130_stdcells/buf_2.sym} 59660 -21250 0 0 {name=X_49041_ }
C {devices/lab_pin.sym} 59580 -21160 0 0 {name=p59104 lab=_73257_/X }
C {devices/lab_pin.sym} 59580 -21120 0 0 {name=p59105 lab=_86188_/Q }
C {devices/lab_pin.sym} 59580 -21080 0 0 {name=p59106 lab=_73205_/X }
C {devices/lab_pin.sym} 59580 -21040 0 0 {name=p59107 lab=_73304_/X }
C {devices/lab_pin.sym} 59740 -21100 0 1 {name=p59108 lab=_73305_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -21100 0 0 {name=X_73305_ }
C {devices/lab_pin.sym} 59620 -20950 0 0 {name=p59109 lab=_46280_/A }
C {devices/lab_pin.sym} 59700 -20950 0 1 {name=p59110 lab=_46272_/A }
C {sky130_stdcells/buf_2.sym} 59660 -20950 0 0 {name=X_46253_ }
C {devices/lab_pin.sym} 59580 -20850 0 0 {name=p59111 lab=_57663_/Y }
C {devices/lab_pin.sym} 59580 -20810 0 0 {name=p59112 lab=_70501_/X }
C {devices/lab_pin.sym} 59580 -20770 0 0 {name=p59113 lab=_70516_/Y }
C {devices/lab_pin.sym} 59740 -20810 0 1 {name=p59114 lab=_83758_/D }
C {sky130_stdcells/o21ai_4.sym} 59660 -20810 0 0 {name=X_70517_ }
C {sky130_stdcells/decap_3.sym} 59660 -20640 0 0 {name=XPHY_650 }
C {devices/lab_pin.sym} 59580 -20510 0 0 {name=p59115 lab=_58219_/X }
C {devices/lab_pin.sym} 59580 -20470 0 0 {name=p59116 lab=_58236_/Y }
C {devices/lab_pin.sym} 59580 -20430 0 0 {name=p59117 lab=_58238_/Y }
C {devices/lab_pin.sym} 59740 -20470 0 1 {name=p59118 lab=_58239_/Y }
C {sky130_stdcells/a21oi_4.sym} 59660 -20470 0 0 {name=X_58239_ }
C {devices/lab_pin.sym} 59600 -20340 0 0 {name=p59119 lab=_77073_/A }
C {devices/lab_pin.sym} 59600 -20300 0 0 {name=p59120 lab=_77084_/A }
C {devices/lab_pin.sym} 59720 -20320 0 1 {name=p59121 lab=_77074_/B }
C {sky130_stdcells/xor2_4.sym} 59660 -20320 0 0 {name=X_77073_ }
C {devices/lab_pin.sym} 59620 -20190 0 0 {name=p59122 lab=_43513_/A }
C {devices/lab_pin.sym} 59700 -20190 0 1 {name=p59123 lab=_43465_/X }
C {sky130_stdcells/buf_2.sym} 59660 -20190 0 0 {name=X_43465_ }
C {devices/lab_pin.sym} 59580 -20090 0 0 {name=p59124 lab=_70267_/C }
C {devices/lab_pin.sym} 59580 -20050 0 0 {name=p59125 lab=_72702_/X }
C {devices/lab_pin.sym} 59580 -20010 0 0 {name=p59126 lab=_74284_/Y }
C {devices/lab_pin.sym} 59740 -20050 0 1 {name=p59127 lab=_74285_/X }
C {sky130_stdcells/a21bo_4.sym} 59660 -20050 0 0 {name=X_74285_ }
C {sky130_stdcells/decap_3.sym} 59660 -19880 0 0 {name=XPHY_661 }
C {devices/lab_pin.sym} 59580 -19750 0 0 {name=p59128 lab=_40670_/X }
C {devices/lab_pin.sym} 59580 -19710 0 0 {name=p59129 lab=_82865_/Q }
C {devices/lab_pin.sym} 59580 -19670 0 0 {name=p59130 lab=_40676_/X }
C {devices/lab_pin.sym} 59740 -19710 0 1 {name=p59131 lab=_40678_/A }
C {sky130_stdcells/o21ai_4.sym} 59660 -19710 0 0 {name=X_40677_ }
C {devices/lab_pin.sym} 59580 -19590 0 0 {name=p59132 lab=_71487_/X }
C {devices/lab_pin.sym} 59580 -19550 0 0 {name=p59133 lab=_83478_/Q }
C {devices/lab_pin.sym} 59580 -19510 0 0 {name=p59134 lab=_71496_/X }
C {devices/lab_pin.sym} 59740 -19550 0 1 {name=p59135 lab=_71497_/X }
C {sky130_stdcells/a21o_4.sym} 59660 -19550 0 0 {name=X_71497_ }
C {sky130_stdcells/decap_3.sym} 59660 -19380 0 0 {name=XPHY_672 }
C {sky130_stdcells/decap_3.sym} 59660 -19200 0 0 {name=XPHY_683 }
C {devices/lab_pin.sym} 59580 -19070 0 0 {name=p59136 lab=_45202_/X }
C {devices/lab_pin.sym} 59580 -19030 0 0 {name=p59137 lab=_61558_/B }
C {devices/lab_pin.sym} 59580 -18990 0 0 {name=p59138 lab=_45144_/X }
C {devices/lab_pin.sym} 59740 -19030 0 1 {name=p59139 lab=_45204_/Y }
C {sky130_stdcells/o21ai_4.sym} 59660 -19030 0 0 {name=X_45204_ }
C {devices/lab_pin.sym} 59600 -18900 0 0 {name=p59140 lab=_76024_/A }
C {devices/lab_pin.sym} 59600 -18860 0 0 {name=p59141 lab=_76023_/Y }
C {devices/lab_pin.sym} 59720 -18880 0 1 {name=p59142 lab=_81744_/D }
C {sky130_stdcells/xor2_4.sym} 59660 -18880 0 0 {name=X_76024_ }
C {devices/lab_pin.sym} 59580 -18780 0 0 {name=p59143 lab=_40469_/X }
C {devices/lab_pin.sym} 59580 -18740 0 0 {name=p59144 lab=_42414_/X }
C {devices/lab_pin.sym} 59580 -18700 0 0 {name=p59145 lab=_87875_/Q }
C {devices/lab_pin.sym} 59580 -18660 0 0 {name=p59146 lab=_42415_/X }
C {devices/lab_pin.sym} 59740 -18720 0 1 {name=p59147 lab=_42416_/X }
C {sky130_stdcells/a2bb2o_4.sym} 59660 -18720 0 0 {name=X_42416_ }
C {sky130_stdcells/decap_3.sym} 59660 -18540 0 0 {name=XPHY_694 }
C {devices/lab_pin.sym} 59600 -18410 0 0 {name=p59148 lab=_61262_/A }
C {devices/lab_pin.sym} 59600 -18370 0 0 {name=p59149 lab=_61250_/B }
C {devices/lab_pin.sym} 59600 -18330 0 0 {name=p59150 lab=_61250_/C }
C {devices/lab_pin.sym} 59720 -18370 0 1 {name=p59151 lab=_61250_/Y }
C {sky130_stdcells/nor3_4.sym} 59660 -18370 0 0 {name=X_61250_ }
C {devices/lab_pin.sym} 59580 -18260 0 0 {name=p59152 lab=_73210_/X }
C {devices/lab_pin.sym} 59580 -18220 0 0 {name=p59153 lab=_85583_/Q }
C {devices/lab_pin.sym} 59580 -18180 0 0 {name=p59154 lab=_73092_/X }
C {devices/lab_pin.sym} 59580 -18140 0 0 {name=p59155 lab=_73235_/X }
C {devices/lab_pin.sym} 59740 -18200 0 1 {name=p59156 lab=_73236_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -18200 0 0 {name=X_73236_ }
C {devices/lab_pin.sym} 59600 -18070 0 0 {name=p59157 lab=_46195_/A }
C {devices/lab_pin.sym} 59600 -18030 0 0 {name=p59158 lab=_46128_/A }
C {devices/lab_pin.sym} 59600 -17990 0 0 {name=p59159 lab=_46133_/B }
C {devices/lab_pin.sym} 59720 -18030 0 1 {name=p59160 lab=_46184_/Y }
C {sky130_stdcells/nand3_4.sym} 59660 -18030 0 0 {name=X_46184_ }
C {devices/lab_pin.sym} 59600 -17910 0 0 {name=p59161 lab=_71650_/A }
C {devices/lab_pin.sym} 59600 -17870 0 0 {name=p59162 lab=_70954_/B }
C {devices/lab_pin.sym} 59600 -17830 0 0 {name=p59163 lab=_71194_/C }
C {devices/lab_pin.sym} 59720 -17870 0 1 {name=p59164 lab=_70448_/Y }
C {sky130_stdcells/nand3_4.sym} 59660 -17870 0 0 {name=X_70448_ }
C {devices/lab_pin.sym} 59620 -17730 0 0 {name=p59165 lab=_43396_/A }
C {devices/lab_pin.sym} 59700 -17730 0 1 {name=p59166 lab=_43396_/X }
C {sky130_stdcells/buf_2.sym} 59660 -17730 0 0 {name=X_43396_ }
C {devices/lab_pin.sym} 59620 -17610 0 0 {name=p59167 lab=_60227_/A }
C {devices/lab_pin.sym} 59700 -17610 0 1 {name=p59168 lab=_60202_/A }
C {sky130_stdcells/buf_2.sym} 59660 -17610 0 0 {name=X_60201_ }
C {devices/lab_pin.sym} 59580 -17510 0 0 {name=p59169 lab=_55848_/B }
C {devices/lab_pin.sym} 59580 -17470 0 0 {name=p59170 lab=_45134_/X }
C {devices/lab_pin.sym} 59580 -17430 0 0 {name=p59171 lab=_45116_/X }
C {devices/lab_pin.sym} 59740 -17470 0 1 {name=p59172 lab=_45135_/X }
C {sky130_stdcells/o21a_4.sym} 59660 -17470 0 0 {name=X_45135_ }
C {devices/lab_pin.sym} 59620 -17330 0 0 {name=p59173 lab=_41872_/A }
C {devices/lab_pin.sym} 59700 -17330 0 1 {name=p59174 lab=_42347_/X }
C {sky130_stdcells/buf_2.sym} 59660 -17330 0 0 {name=X_42347_ }
C {devices/lab_pin.sym} 59580 -17240 0 0 {name=p59175 lab=_73163_/X }
C {devices/lab_pin.sym} 59580 -17200 0 0 {name=p59176 lab=_83066_/Q }
C {devices/lab_pin.sym} 59580 -17160 0 0 {name=p59177 lab=_72880_/X }
C {devices/lab_pin.sym} 59580 -17120 0 0 {name=p59178 lab=_73166_/X }
C {devices/lab_pin.sym} 59740 -17180 0 1 {name=p59179 lab=_73167_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -17180 0 0 {name=X_73167_ }
C {devices/lab_pin.sym} 59620 -17030 0 0 {name=p59180 lab=_64263_/A }
C {devices/lab_pin.sym} 59700 -17030 0 1 {name=p59181 lab=_64250_/A }
C {sky130_stdcells/buf_2.sym} 59660 -17030 0 0 {name=X_61181_ }
C {devices/lab_pin.sym} 59600 -16930 0 0 {name=p59182 lab=_70366_/X }
C {devices/lab_pin.sym} 59600 -16890 0 0 {name=p59183 lab=_74523_/A }
C {devices/lab_pin.sym} 59600 -16850 0 0 {name=p59184 lab=_70375_/C }
C {devices/lab_pin.sym} 59720 -16890 0 1 {name=p59185 lab=_70379_/Y }
C {sky130_stdcells/nand3_4.sym} 59660 -16890 0 0 {name=X_70379_ }
C {devices/lab_pin.sym} 59620 -16750 0 0 {name=p59186 lab=_60132_/A }
C {devices/lab_pin.sym} 59700 -16750 0 1 {name=p59187 lab=_60132_/X }
C {sky130_stdcells/buf_2.sym} 59660 -16750 0 0 {name=X_60132_ }
C {devices/lab_pin.sym} 59600 -16640 0 0 {name=p59188 lab=_86625_/Q }
C {devices/lab_pin.sym} 59600 -16600 0 0 {name=p59189 lab=_72193_/B }
C {devices/lab_pin.sym} 59720 -16620 0 1 {name=p59190 lab=_72118_/Y }
C {sky130_stdcells/nor2_4.sym} 59660 -16620 0 0 {name=X_72118_ }
C {devices/lab_pin.sym} 59600 -16520 0 0 {name=p59191 lab=_49925_/X }
C {devices/lab_pin.sym} 59600 -16480 0 0 {name=p59192 lab=_49943_/B }
C {devices/lab_pin.sym} 59600 -16440 0 0 {name=p59193 lab=_49953_/C }
C {devices/lab_pin.sym} 59600 -16400 0 0 {name=p59194 lab=_53155_/D }
C {devices/lab_pin.sym} 59720 -16460 0 1 {name=p59195 lab=_49943_/X }
C {sky130_stdcells/and4_4.sym} 59660 -16460 0 0 {name=X_49943_ }
C {devices/lab_pin.sym} 59620 -16310 0 0 {name=p59196 lab=_83031_/Q }
C {devices/lab_pin.sym} 59700 -16310 0 1 {name=p59197 lab=_45067_/A }
C {sky130_stdcells/inv_2.sym} 59660 -16310 0 0 {name=X_45066_ }
C {devices/lab_pin.sym} 59620 -16190 0 0 {name=p59198 lab=_42277_/Y }
C {devices/lab_pin.sym} 59700 -16190 0 1 {name=p59199 lab=_87944_/D }
C {sky130_stdcells/inv_2.sym} 59660 -16190 0 0 {name=X_42278_ }
C {devices/lab_pin.sym} 59600 -16080 0 0 {name=p59200 lab=_73098_/A }
C {devices/lab_pin.sym} 59600 -16040 0 0 {name=p59201 lab=_73097_/X }
C {devices/lab_pin.sym} 59720 -16060 0 1 {name=p59202 lab=_73098_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -16060 0 0 {name=X_73098_ }
C {devices/lab_pin.sym} 59600 -15940 0 0 {name=p59203 lab=_77975_/A }
C {devices/lab_pin.sym} 59600 -15900 0 0 {name=p59204 lab=_78043_/A }
C {devices/lab_pin.sym} 59720 -15920 0 1 {name=p59205 lab=_77975_/Y }
C {sky130_stdcells/nor2_4.sym} 59660 -15920 0 0 {name=X_77975_ }
C {devices/lab_pin.sym} 59620 -15790 0 0 {name=p59206 lab=_57848_/A }
C {devices/lab_pin.sym} 59700 -15790 0 1 {name=p59207 lab=_57736_/A }
C {sky130_stdcells/buf_2.sym} 59660 -15790 0 0 {name=X_44017_ }
C {devices/lab_pin.sym} 59600 -15680 0 0 {name=p59208 lab=_79712_/X }
C {devices/lab_pin.sym} 59600 -15640 0 0 {name=p59209 lab=_79719_/B }
C {devices/lab_pin.sym} 59720 -15660 0 1 {name=p59210 lab=_79714_/Y }
C {sky130_stdcells/xnor2_4.sym} 59660 -15660 0 0 {name=X_79714_ }
C {devices/lab_pin.sym} 59580 -15550 0 0 {name=p59211 lab=_41184_/X }
C {devices/lab_pin.sym} 59580 -15510 0 0 {name=p59212 lab=_40710_/A }
C {devices/lab_pin.sym} 59580 -15470 0 0 {name=p59213 lab=_41228_/X }
C {devices/lab_pin.sym} 59740 -15510 0 1 {name=p59214 lab=_41230_/A }
C {sky130_stdcells/o21ai_4.sym} 59660 -15510 0 0 {name=X_41229_ }
C {devices/lab_pin.sym} 59620 -15370 0 0 {name=p59215 lab=_64739_/A }
C {devices/lab_pin.sym} 59700 -15370 0 1 {name=p59216 lab=_65047_/A }
C {sky130_stdcells/buf_2.sym} 59660 -15370 0 0 {name=X_64940_ }
C {devices/lab_pin.sym} 59620 -15250 0 0 {name=p59217 lab=_60062_/X }
C {devices/lab_pin.sym} 59700 -15250 0 1 {name=p59218 lab=_60063_/Y }
C {sky130_stdcells/inv_2.sym} 59660 -15250 0 0 {name=X_60063_ }
C {devices/lab_pin.sym} 59600 -15150 0 0 {name=p59219 lab=_49069_/A }
C {devices/lab_pin.sym} 59600 -15110 0 0 {name=p59220 lab=_72043_/X }
C {devices/lab_pin.sym} 59600 -15070 0 0 {name=p59221 lab=_72048_/X }
C {devices/lab_pin.sym} 59720 -15110 0 1 {name=p59222 lab=_72049_/X }
C {sky130_stdcells/and3_4.sym} 59660 -15110 0 0 {name=X_72049_ }
C {devices/lab_pin.sym} 59600 -14980 0 0 {name=p59223 lab=_81471_/D }
C {devices/lab_pin.sym} 59600 -14940 0 0 {name=p59224 lab=_76926_/B }
C {devices/lab_pin.sym} 59720 -14960 0 1 {name=p59225 lab=_76928_/A }
C {sky130_stdcells/nand2_4.sym} 59660 -14960 0 0 {name=X_76926_ }
C {devices/lab_pin.sym} 59600 -14840 0 0 {name=p59226 lab=_49864_/A }
C {devices/lab_pin.sym} 59600 -14800 0 0 {name=p59227 lab=_53086_/B }
C {devices/lab_pin.sym} 59720 -14820 0 1 {name=p59228 lab=_49874_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -14820 0 0 {name=X_49874_ }
C {devices/lab_pin.sym} 59600 -14700 0 0 {name=p59229 lab=_48831_/A }
C {devices/lab_pin.sym} 59600 -14660 0 0 {name=p59230 lab=_50508_/B }
C {devices/lab_pin.sym} 59720 -14680 0 1 {name=p59231 lab=_48825_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -14680 0 0 {name=X_48825_ }
C {devices/lab_pin.sym} 59600 -14560 0 0 {name=p59232 lab=_79639_/X }
C {devices/lab_pin.sym} 59600 -14520 0 0 {name=p59233 lab=_79645_/B }
C {devices/lab_pin.sym} 59720 -14540 0 1 {name=p59234 lab=_79645_/X }
C {sky130_stdcells/xor2_4.sym} 59660 -14540 0 0 {name=X_79645_ }
C {devices/lab_pin.sym} 59580 -14430 0 0 {name=p59235 lab=_64868_/Y }
C {devices/lab_pin.sym} 59580 -14390 0 0 {name=p59236 lab=_64814_/X }
C {devices/lab_pin.sym} 59580 -14350 0 0 {name=p59237 lab=_64870_/Y }
C {devices/lab_pin.sym} 59740 -14390 0 1 {name=p59238 lab=_64871_/X }
C {sky130_stdcells/a21o_4.sym} 59660 -14390 0 0 {name=X_64871_ }
C {devices/lab_pin.sym} 59600 -14260 0 0 {name=p59239 lab=_81673_/Q }
C {devices/lab_pin.sym} 59600 -14220 0 0 {name=p59240 lab=_76857_/B }
C {devices/lab_pin.sym} 59720 -14240 0 1 {name=p59241 lab=_76857_/Y }
C {sky130_stdcells/xnor2_4.sym} 59660 -14240 0 0 {name=X_76857_ }
C {devices/lab_pin.sym} 59580 -14140 0 0 {name=p59242 lab=_88402_/Q }
C {devices/lab_pin.sym} 59580 -14100 0 0 {name=p59243 lab=_66608_/X }
C {devices/lab_pin.sym} 59580 -14060 0 0 {name=p59244 lab=_46212_/A }
C {devices/lab_pin.sym} 59580 -14020 0 0 {name=p59245 lab=_66609_/X }
C {devices/lab_pin.sym} 59740 -14080 0 1 {name=p59246 lab=_66610_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -14080 0 0 {name=X_66610_ }
C {devices/lab_pin.sym} 59600 -13960 0 0 {name=p59247 lab=_58237_/X }
C {devices/lab_pin.sym} 59600 -13920 0 0 {name=p59248 lab=_63858_/B }
C {devices/lab_pin.sym} 59600 -13880 0 0 {name=p59249 lab=_63858_/C }
C {devices/lab_pin.sym} 59600 -13840 0 0 {name=p59250 lab=_63793_/D }
C {devices/lab_pin.sym} 59720 -13900 0 1 {name=p59251 lab=_63822_/Y }
C {sky130_stdcells/nand4_4.sym} 59660 -13900 0 0 {name=X_63822_ }
C {devices/lab_pin.sym} 59620 -13750 0 0 {name=p59252 lab=_75832_/B }
C {devices/lab_pin.sym} 59700 -13750 0 1 {name=p59253 lab=_75810_/B }
C {sky130_stdcells/inv_2.sym} 59660 -13750 0 0 {name=X_75808_ }
C {devices/lab_pin.sym} 59620 -13630 0 0 {name=p59254 lab=_48837_/A }
C {devices/lab_pin.sym} 59700 -13630 0 1 {name=p59255 lab=_48777_/A }
C {sky130_stdcells/buf_2.sym} 59660 -13630 0 0 {name=X_48756_ }
C {devices/lab_pin.sym} 59580 -13530 0 0 {name=p59256 lab=_84063_/Q }
C {devices/lab_pin.sym} 59580 -13490 0 0 {name=p59257 lab=_67568_/X }
C {devices/lab_pin.sym} 59580 -13450 0 0 {name=p59258 lab=_67589_/X }
C {devices/lab_pin.sym} 59740 -13490 0 1 {name=p59259 lab=_67590_/X }
C {sky130_stdcells/a21bo_4.sym} 59660 -13490 0 0 {name=X_67590_ }
C {devices/lab_pin.sym} 59600 -13360 0 0 {name=p59260 lab=_79576_/A }
C {devices/lab_pin.sym} 59600 -13320 0 0 {name=p59261 lab=_79576_/B }
C {devices/lab_pin.sym} 59720 -13340 0 1 {name=p59262 lab=_79577_/A }
C {sky130_stdcells/nand2_4.sym} 59660 -13340 0 0 {name=X_79576_ }
C {devices/lab_pin.sym} 59620 -13210 0 0 {name=p59263 lab=_45967_/Y }
C {devices/lab_pin.sym} 59700 -13210 0 1 {name=p59264 lab=_86836_/D }
C {sky130_stdcells/inv_2.sym} 59660 -13210 0 0 {name=X_45968_ }
C {devices/lab_pin.sym} 59580 -13110 0 0 {name=p59265 lab=_76781_/Y }
C {devices/lab_pin.sym} 59580 -13070 0 0 {name=p59266 lab=_76774_/X }
C {devices/lab_pin.sym} 59580 -13030 0 0 {name=p59267 lab=_76787_/Y }
C {devices/lab_pin.sym} 59740 -13070 0 1 {name=p59268 lab=_76788_/Y }
C {sky130_stdcells/a21oi_4.sym} 59660 -13070 0 0 {name=X_76788_ }
C {devices/lab_pin.sym} 59580 -12950 0 0 {name=p59269 lab=_86606_/Q }
C {devices/lab_pin.sym} 59580 -12910 0 0 {name=p59270 lab=_47666_/X }
C {devices/lab_pin.sym} 59580 -12870 0 0 {name=p59271 lab=_47706_/Y }
C {devices/lab_pin.sym} 59740 -12910 0 1 {name=p59272 lab=_47707_/Y }
C {sky130_stdcells/o21ai_4.sym} 59660 -12910 0 0 {name=X_47707_ }
C {devices/lab_pin.sym} 59620 -12770 0 0 {name=p59273 lab=_44019_/A }
C {devices/lab_pin.sym} 59700 -12770 0 1 {name=p59274 lab=_67816_/A }
C {sky130_stdcells/buf_2.sym} 59660 -12770 0 0 {name=X_66541_ }
C {devices/lab_pin.sym} 59580 -12670 0 0 {name=p59275 lab=_78526_/B }
C {devices/lab_pin.sym} 59580 -12630 0 0 {name=p59276 lab=_78526_/C }
C {devices/lab_pin.sym} 59580 -12590 0 0 {name=p59277 lab=_78522_/Y }
C {devices/lab_pin.sym} 59740 -12630 0 1 {name=p59278 lab=_78528_/B }
C {sky130_stdcells/o21ai_4.sym} 59660 -12630 0 0 {name=X_78527_ }
C {devices/lab_pin.sym} 59620 -12490 0 0 {name=p59279 lab=_45153_/A }
C {devices/lab_pin.sym} 59700 -12490 0 1 {name=p59280 lab=_44919_/X }
C {sky130_stdcells/buf_2.sym} 59660 -12490 0 0 {name=X_44919_ }
C {devices/lab_pin.sym} 59600 -12400 0 0 {name=p59281 lab=_63369_/B }
C {devices/lab_pin.sym} 59600 -12360 0 0 {name=p59282 lab=_64177_/B }
C {devices/lab_pin.sym} 59600 -12320 0 0 {name=p59283 lab=_63753_/C }
C {devices/lab_pin.sym} 59600 -12280 0 0 {name=p59284 lab=_64177_/D }
C {devices/lab_pin.sym} 59720 -12340 0 1 {name=p59285 lab=_63759_/B }
C {sky130_stdcells/nand4_4.sym} 59660 -12340 0 0 {name=X_63753_ }
C {devices/lab_pin.sym} 59580 -12210 0 0 {name=p59286 lab=_75723_/B }
C {devices/lab_pin.sym} 59580 -12170 0 0 {name=p59287 lab=_75736_/X }
C {devices/lab_pin.sym} 59580 -12130 0 0 {name=p59288 lab=_75738_/Y }
C {devices/lab_pin.sym} 59740 -12170 0 1 {name=p59289 lab=_75740_/B }
C {sky130_stdcells/a21oi_4.sym} 59660 -12170 0 0 {name=X_75739_ }
C {devices/lab_pin.sym} 59600 -12040 0 0 {name=p59290 lab=_48687_/A }
C {devices/lab_pin.sym} 59600 -12000 0 0 {name=p59291 lab=_48632_/B }
C {devices/lab_pin.sym} 59720 -12020 0 1 {name=p59292 lab=_48687_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -12020 0 0 {name=X_48687_ }
C {devices/lab_pin.sym} 59600 -11910 0 0 {name=p59293 lab=_60930_/A }
C {devices/lab_pin.sym} 59600 -11870 0 0 {name=p59294 lab=_60855_/X }
C {devices/lab_pin.sym} 59600 -11830 0 0 {name=p59295 lab=_60930_/C }
C {devices/lab_pin.sym} 59720 -11870 0 1 {name=p59296 lab=_60966_/A }
C {sky130_stdcells/nand3_4.sym} 59660 -11870 0 0 {name=X_60965_ }
C {devices/lab_pin.sym} 59620 -11730 0 0 {name=p59297 lab=_44039_/X }
C {devices/lab_pin.sym} 59700 -11730 0 1 {name=p59298 lab=_46159_/A }
C {sky130_stdcells/buf_2.sym} 59660 -11730 0 0 {name=X_45899_ }
C {devices/lab_pin.sym} 59600 -11640 0 0 {name=p59299 lab=_62669_/A }
C {devices/lab_pin.sym} 59600 -11600 0 0 {name=p59300 lab=_63054_/A }
C {devices/lab_pin.sym} 59600 -11560 0 0 {name=p59301 lab=_62704_/C }
C {devices/lab_pin.sym} 59600 -11520 0 0 {name=p59302 lab=_62669_/D }
C {devices/lab_pin.sym} 59720 -11580 0 1 {name=p59303 lab=_62704_/X }
C {sky130_stdcells/and4_4.sym} 59660 -11580 0 0 {name=X_62704_ }
C {devices/lab_pin.sym} 59580 -11460 0 0 {name=p59304 lab=_88042_/Q }
C {devices/lab_pin.sym} 59580 -11420 0 0 {name=p59305 lab=_69217_/X }
C {devices/lab_pin.sym} 59580 -11380 0 0 {name=p59306 lab=_69245_/X }
C {devices/lab_pin.sym} 59580 -11340 0 0 {name=p59307 lab=_69259_/X }
C {devices/lab_pin.sym} 59740 -11400 0 1 {name=p59308 lab=_69260_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -11400 0 0 {name=X_69260_ }
C {devices/lab_pin.sym} 59580 -11270 0 0 {name=p59309 lab=_47634_/Y }
C {devices/lab_pin.sym} 59580 -11230 0 0 {name=p59310 lab=_47602_/X }
C {devices/lab_pin.sym} 59580 -11190 0 0 {name=p59311 lab=_47637_/X }
C {devices/lab_pin.sym} 59740 -11230 0 1 {name=p59312 lab=_86614_/D }
C {sky130_stdcells/a21oi_4.sym} 59660 -11230 0 0 {name=X_47638_ }
C {devices/lab_pin.sym} 59580 -11110 0 0 {name=p59313 lab=_60110_/X }
C {devices/lab_pin.sym} 59580 -11070 0 0 {name=p59314 lab=_65154_/Y }
C {devices/lab_pin.sym} 59580 -11030 0 0 {name=p59315 lab=_66471_/Y }
C {devices/lab_pin.sym} 59740 -11070 0 1 {name=p59316 lab=_66472_/Y }
C {sky130_stdcells/o21ai_4.sym} 59660 -11070 0 0 {name=X_66472_ }
C {devices/lab_pin.sym} 59600 -10940 0 0 {name=p59317 lab=_78458_/A }
C {devices/lab_pin.sym} 59600 -10900 0 0 {name=p59318 lab=_82669_/D }
C {devices/lab_pin.sym} 59720 -10920 0 1 {name=p59319 lab=_78458_/Y }
C {sky130_stdcells/nor2_4.sym} 59660 -10920 0 0 {name=X_78458_ }
C {devices/lab_pin.sym} 59600 -10800 0 0 {name=p59320 lab=_63696_/A }
C {devices/lab_pin.sym} 59600 -10760 0 0 {name=p59321 lab=_62151_/X }
C {devices/lab_pin.sym} 59720 -10780 0 1 {name=p59322 lab=_63684_/X }
C {sky130_stdcells/and2_4.sym} 59660 -10780 0 0 {name=X_63684_ }
C {devices/lab_pin.sym} 59620 -10650 0 0 {name=p59323 lab=_60895_/X }
C {devices/lab_pin.sym} 59700 -10650 0 1 {name=p59324 lab=_60896_/Y }
C {sky130_stdcells/inv_2.sym} 59660 -10650 0 0 {name=X_60896_ }
C {devices/lab_pin.sym} 59580 -10560 0 0 {name=p59325 lab=_68196_/X }
C {devices/lab_pin.sym} 59580 -10520 0 0 {name=p59326 lab=_67292_/Y }
C {devices/lab_pin.sym} 59580 -10480 0 0 {name=p59327 lab=_68207_/X }
C {devices/lab_pin.sym} 59580 -10440 0 0 {name=p59328 lab=_68210_/Y }
C {devices/lab_pin.sym} 59740 -10500 0 1 {name=p59329 lab=_68211_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -10500 0 0 {name=X_68211_ }
C {devices/lab_pin.sym} 59600 -10360 0 0 {name=p59330 lab=_65401_/A }
C {devices/lab_pin.sym} 59600 -10320 0 0 {name=p59331 lab=_65423_/B }
C {devices/lab_pin.sym} 59720 -10340 0 1 {name=p59332 lab=_65423_/X }
C {sky130_stdcells/and2_4.sym} 59660 -10340 0 0 {name=X_65423_ }
C {devices/lab_pin.sym} 59600 -10220 0 0 {name=p59333 lab=_77409_/A }
C {devices/lab_pin.sym} 59600 -10180 0 0 {name=p59334 lab=_82095_/D }
C {devices/lab_pin.sym} 59720 -10200 0 1 {name=p59335 lab=_77412_/B }
C {sky130_stdcells/nor2_4.sym} 59660 -10200 0 0 {name=X_77409_ }
C {devices/lab_pin.sym} 59580 -10110 0 0 {name=p59336 lab=_62628_/X }
C {devices/lab_pin.sym} 59580 -10070 0 0 {name=p59337 lab=_62630_/X }
C {devices/lab_pin.sym} 59580 -10030 0 0 {name=p59338 lab=_62634_/Y }
C {devices/lab_pin.sym} 59580 -9990 0 0 {name=p59339 lab=_58374_/A }
C {devices/lab_pin.sym} 59580 -9950 0 0 {name=p59340 lab=_62212_/A }
C {devices/lab_pin.sym} 59740 -10030 0 1 {name=p59341 lab=_62635_/Y }
C {sky130_stdcells/o32ai_4.sym} 59660 -10030 0 0 {name=X_62635_ }
C {devices/lab_pin.sym} 59600 -9880 0 0 {name=p59342 lab=_69191_/A }
C {devices/lab_pin.sym} 59600 -9840 0 0 {name=p59343 lab=_87791_/Q }
C {devices/lab_pin.sym} 59720 -9860 0 1 {name=p59344 lab=_69191_/X }
C {sky130_stdcells/and2_4.sym} 59660 -9860 0 0 {name=X_69191_ }
C {devices/lab_pin.sym} 59580 -9750 0 0 {name=p59345 lab=_47564_/Y }
C {devices/lab_pin.sym} 59580 -9710 0 0 {name=p59346 lab=_47555_/X }
C {devices/lab_pin.sym} 59580 -9670 0 0 {name=p59347 lab=_47568_/X }
C {devices/lab_pin.sym} 59740 -9710 0 1 {name=p59348 lab=_47569_/Y }
C {sky130_stdcells/a21oi_4.sym} 59660 -9710 0 0 {name=X_47569_ }
C {devices/lab_pin.sym} 59620 -9570 0 0 {name=p59349 lab=_78384_/Y }
C {devices/lab_pin.sym} 59700 -9570 0 1 {name=p59350 lab=_78390_/A }
C {sky130_stdcells/inv_2.sym} 59660 -9570 0 0 {name=X_78389_ }
C {devices/lab_pin.sym} 59600 -9470 0 0 {name=p59351 lab=_52524_/A }
C {devices/lab_pin.sym} 59600 -9430 0 0 {name=p59352 lab=_49283_/B }
C {devices/lab_pin.sym} 59600 -9390 0 0 {name=p59353 lab=_49234_/X }
C {devices/lab_pin.sym} 59720 -9430 0 1 {name=p59354 lab=_49308_/X }
C {sky130_stdcells/and3_4.sym} 59660 -9430 0 0 {name=X_49308_ }
C {devices/lab_pin.sym} 59580 -9310 0 0 {name=p59355 lab=_80412_/X }
C {devices/lab_pin.sym} 59580 -9270 0 0 {name=p59356 lab=_80413_/X }
C {devices/lab_pin.sym} 59580 -9230 0 0 {name=p59357 lab=_80419_/Y }
C {devices/lab_pin.sym} 59740 -9270 0 1 {name=p59358 lab=_80436_/A }
C {sky130_stdcells/a21boi_4.sym} 59660 -9270 0 0 {name=X_80420_ }
C {devices/lab_pin.sym} 59580 -9160 0 0 {name=p59359 lab=_68121_/X }
C {devices/lab_pin.sym} 59580 -9120 0 0 {name=p59360 lab=_66886_/Y }
C {devices/lab_pin.sym} 59580 -9080 0 0 {name=p59361 lab=_68128_/X }
C {devices/lab_pin.sym} 59580 -9040 0 0 {name=p59362 lab=_68141_/Y }
C {devices/lab_pin.sym} 59740 -9100 0 1 {name=p59363 lab=_68142_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -9100 0 0 {name=X_68142_ }
C {devices/lab_pin.sym} 59600 -8960 0 0 {name=p59364 lab=_65403_/A }
C {devices/lab_pin.sym} 59600 -8920 0 0 {name=p59365 lab=_86244_/Q }
C {devices/lab_pin.sym} 59720 -8940 0 1 {name=p59366 lab=_65354_/X }
C {sky130_stdcells/and2_4.sym} 59660 -8940 0 0 {name=X_65354_ }
C {devices/lab_pin.sym} 59600 -8820 0 0 {name=p59367 lab=_50580_/A }
C {devices/lab_pin.sym} 59600 -8780 0 0 {name=p59368 lab=_71974_/B }
C {devices/lab_pin.sym} 59720 -8800 0 1 {name=p59369 lab=_50580_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -8800 0 0 {name=X_50580_ }
C {devices/lab_pin.sym} 59600 -8700 0 0 {name=p59370 lab=_61630_/A }
C {devices/lab_pin.sym} 59600 -8660 0 0 {name=p59371 lab=_62566_/B }
C {devices/lab_pin.sym} 59600 -8620 0 0 {name=p59372 lab=_62501_/X }
C {devices/lab_pin.sym} 59600 -8580 0 0 {name=p59373 lab=_62566_/D }
C {devices/lab_pin.sym} 59720 -8640 0 1 {name=p59374 lab=_62569_/B }
C {sky130_stdcells/nand4_4.sym} 59660 -8640 0 0 {name=X_62566_ }
C {devices/lab_pin.sym} 59600 -8510 0 0 {name=p59375 lab=_64275_/A }
C {devices/lab_pin.sym} 59600 -8470 0 0 {name=p59376 lab=_64305_/B }
C {devices/lab_pin.sym} 59600 -8430 0 0 {name=p59377 lab=_64274_/X }
C {devices/lab_pin.sym} 59720 -8470 0 1 {name=p59378 lab=_64305_/X }
C {sky130_stdcells/and3_4.sym} 59660 -8470 0 0 {name=X_64305_ }
C {devices/lab_pin.sym} 59600 -8340 0 0 {name=p59379 lab=_49220_/A }
C {devices/lab_pin.sym} 59600 -8300 0 0 {name=p59380 lab=_52454_/B }
C {devices/lab_pin.sym} 59720 -8320 0 1 {name=p59381 lab=_49239_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -8320 0 0 {name=X_49239_ }
C {devices/lab_pin.sym} 59620 -8190 0 0 {name=p59382 lab=_61394_/A }
C {devices/lab_pin.sym} 59700 -8190 0 1 {name=p59383 lab=_61517_/X }
C {sky130_stdcells/buf_2.sym} 59660 -8190 0 0 {name=X_61517_ }
C {devices/lab_pin.sym} 59600 -8080 0 0 {name=p59384 lab=_80350_/B }
C {devices/lab_pin.sym} 59600 -8040 0 0 {name=p59385 lab=_80350_/C }
C {devices/lab_pin.sym} 59720 -8060 0 1 {name=p59386 lab=_80352_/A }
C {sky130_stdcells/nand2_4.sym} 59660 -8060 0 0 {name=X_80351_ }
C {devices/lab_pin.sym} 59580 -7950 0 0 {name=p59387 lab=_68068_/X }
C {devices/lab_pin.sym} 59580 -7910 0 0 {name=p59388 lab=_68072_/X }
C {devices/lab_pin.sym} 59580 -7870 0 0 {name=p59389 lab=_67977_/X }
C {devices/lab_pin.sym} 59740 -7910 0 1 {name=p59390 lab=_68077_/A }
C {sky130_stdcells/a21o_4.sym} 59660 -7910 0 0 {name=X_68073_ }
C {devices/lab_pin.sym} 59600 -7780 0 0 {name=p59391 lab=_65285_/A }
C {devices/lab_pin.sym} 59600 -7740 0 0 {name=p59392 lab=_65285_/B }
C {devices/lab_pin.sym} 59720 -7760 0 1 {name=p59393 lab=_65285_/X }
C {sky130_stdcells/and2_4.sym} 59660 -7760 0 0 {name=X_65285_ }
C {devices/lab_pin.sym} 59580 -7670 0 0 {name=p59394 lab=_62488_/X }
C {devices/lab_pin.sym} 59580 -7630 0 0 {name=p59395 lab=_62493_/Y }
C {devices/lab_pin.sym} 59580 -7590 0 0 {name=p59396 lab=_62496_/X }
C {devices/lab_pin.sym} 59580 -7550 0 0 {name=p59397 lab=_84846_/Q }
C {devices/lab_pin.sym} 59580 -7510 0 0 {name=p59398 lab=_62440_/X }
C {devices/lab_pin.sym} 59740 -7590 0 1 {name=p59399 lab=_62497_/Y }
C {sky130_stdcells/o32ai_4.sym} 59660 -7590 0 0 {name=X_62497_ }
C {devices/lab_pin.sym} 59580 -7460 0 0 {name=p59400 lab=_87360_/Q }
C {devices/lab_pin.sym} 59580 -7420 0 0 {name=p59401 lab=_66997_/X }
C {devices/lab_pin.sym} 59580 -7380 0 0 {name=p59402 lab=_66998_/X }
C {devices/lab_pin.sym} 59580 -7340 0 0 {name=p59403 lab=_67023_/X }
C {devices/lab_pin.sym} 59740 -7400 0 1 {name=p59404 lab=_67024_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -7400 0 0 {name=X_67024_ }
C {devices/lab_pin.sym} 59600 -7260 0 0 {name=p59405 lab=_52250_/A }
C {devices/lab_pin.sym} 59600 -7220 0 0 {name=p59406 lab=_48695_/B }
C {devices/lab_pin.sym} 59720 -7240 0 1 {name=p59407 lab=_52250_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -7240 0 0 {name=X_52250_ }
C {devices/lab_pin.sym} 59600 -7130 0 0 {name=p59408 lab=_64248_/A }
C {devices/lab_pin.sym} 59600 -7090 0 0 {name=p59409 lab=_64225_/B }
C {devices/lab_pin.sym} 59600 -7050 0 0 {name=p59410 lab=_64236_/C }
C {devices/lab_pin.sym} 59720 -7090 0 1 {name=p59411 lab=_64236_/X }
C {sky130_stdcells/and3_4.sym} 59660 -7090 0 0 {name=X_64236_ }
C {devices/lab_pin.sym} 59570 -6950 0 0 {name=p59412 lab=_86516_/CLK }
C {devices/lab_pin.sym} 59570 -6930 0 0 {name=p59413 lab=_74422_/Y }
C {devices/lab_pin.sym} 59750 -6950 0 1 {name=p59414 lab=_83070_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -6940 0 0 {name=X_83070_ }
C {devices/lab_pin.sym} 59620 -6810 0 0 {name=p59415 lab=_58543_/A }
C {devices/lab_pin.sym} 59700 -6810 0 1 {name=p59416 lab=_61448_/X }
C {sky130_stdcells/buf_2.sym} 59660 -6810 0 0 {name=X_61448_ }
C {devices/lab_pin.sym} 59620 -6690 0 0 {name=p59417 lab=_80274_/Y }
C {devices/lab_pin.sym} 59700 -6690 0 1 {name=p59418 lab=_80282_/Y }
C {sky130_stdcells/inv_2.sym} 59660 -6690 0 0 {name=X_80282_ }
C {devices/lab_pin.sym} 59620 -6570 0 0 {name=p59419 lab=_51147_/A }
C {devices/lab_pin.sym} 59700 -6570 0 1 {name=p59420 lab=_51201_/X }
C {sky130_stdcells/buf_2.sym} 59660 -6570 0 0 {name=X_51201_ }
C {devices/lab_pin.sym} 59570 -6450 0 0 {name=p59421 lab=_81954_/CLK }
C {devices/lab_pin.sym} 59570 -6430 0 0 {name=p59422 lab=_77761_/B }
C {devices/lab_pin.sym} 59750 -6450 0 1 {name=p59423 lab=_81989_/D }
C {sky130_stdcells/dfxtp_4.sym} 59660 -6440 0 0 {name=X_82021_ }
C {devices/lab_pin.sym} 59580 -6330 0 0 {name=p59424 lab=_85873_/Q }
C {devices/lab_pin.sym} 59580 -6290 0 0 {name=p59425 lab=_52178_/X }
C {devices/lab_pin.sym} 59580 -6250 0 0 {name=p59426 lab=_52180_/Y }
C {devices/lab_pin.sym} 59740 -6290 0 1 {name=p59427 lab=_52181_/Y }
C {sky130_stdcells/o21ai_4.sym} 59660 -6290 0 0 {name=X_52181_ }
C {devices/lab_pin.sym} 59600 -6180 0 0 {name=p59428 lab=_63694_/B }
C {devices/lab_pin.sym} 59600 -6140 0 0 {name=p59429 lab=_64190_/B }
C {devices/lab_pin.sym} 59600 -6100 0 0 {name=p59430 lab=_64178_/C }
C {devices/lab_pin.sym} 59600 -6060 0 0 {name=p59431 lab=_64190_/D }
C {devices/lab_pin.sym} 59720 -6120 0 1 {name=p59432 lab=_64167_/Y }
C {sky130_stdcells/nand4_4.sym} 59660 -6120 0 0 {name=X_64167_ }
C {devices/lab_pin.sym} 59620 -5970 0 0 {name=p59433 lab=_61313_/A }
C {devices/lab_pin.sym} 59700 -5970 0 1 {name=p59434 lab=_61380_/A }
C {sky130_stdcells/buf_2.sym} 59660 -5970 0 0 {name=X_61379_ }
C {devices/lab_pin.sym} 59600 -5880 0 0 {name=p59435 lab=_51115_/A }
C {devices/lab_pin.sym} 59600 -5840 0 0 {name=p59436 lab=_51121_/B }
C {devices/lab_pin.sym} 59600 -5800 0 0 {name=p59437 lab=_51115_/C }
C {devices/lab_pin.sym} 59600 -5760 0 0 {name=p59438 lab=_52827_/D }
C {devices/lab_pin.sym} 59720 -5820 0 1 {name=p59439 lab=_51132_/X }
C {sky130_stdcells/and4_4.sym} 59660 -5820 0 0 {name=X_51132_ }
C {devices/lab_pin.sym} 59620 -5670 0 0 {name=p59440 lab=_63118_/A }
C {devices/lab_pin.sym} 59700 -5670 0 1 {name=p59441 lab=_63118_/X }
C {sky130_stdcells/buf_2.sym} 59660 -5670 0 0 {name=X_63118_ }
C {devices/lab_pin.sym} 59600 -5570 0 0 {name=p59442 lab=_64162_/A }
C {devices/lab_pin.sym} 59600 -5530 0 0 {name=p59443 lab=_58461_/A }
C {devices/lab_pin.sym} 59600 -5490 0 0 {name=p59444 lab=_64173_/C }
C {devices/lab_pin.sym} 59720 -5530 0 1 {name=p59445 lab=_64098_/X }
C {sky130_stdcells/and3_4.sym} 59660 -5530 0 0 {name=X_64098_ }
C {devices/lab_pin.sym} 59620 -5390 0 0 {name=p59446 lab=_69958_/A }
C {devices/lab_pin.sym} 59700 -5390 0 1 {name=p59447 lab=_68975_/X }
C {sky130_stdcells/buf_2.sym} 59660 -5390 0 0 {name=X_68975_ }
C {devices/lab_pin.sym} 59600 -5280 0 0 {name=p59448 lab=_55949_/A }
C {devices/lab_pin.sym} 59600 -5240 0 0 {name=p59449 lab=_85180_/Q }
C {devices/lab_pin.sym} 59720 -5260 0 1 {name=p59450 lab=_55940_/X }
C {sky130_stdcells/and2_4.sym} 59660 -5260 0 0 {name=X_55940_ }
C {devices/lab_pin.sym} 59600 -5140 0 0 {name=p59451 lab=_51058_/A }
C {devices/lab_pin.sym} 59600 -5100 0 0 {name=p59452 lab=_52752_/B }
C {devices/lab_pin.sym} 59720 -5120 0 1 {name=p59453 lab=_51063_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -5120 0 0 {name=X_51063_ }
C {devices/lab_pin.sym} 59620 -4990 0 0 {name=p59454 lab=_68637_/A }
C {devices/lab_pin.sym} 59700 -4990 0 1 {name=p59455 lab=_67972_/A }
C {sky130_stdcells/buf_2.sym} 59660 -4990 0 0 {name=X_67926_ }
C {devices/lab_pin.sym} 59600 -4900 0 0 {name=p59456 lab=_63038_/A }
C {devices/lab_pin.sym} 59600 -4860 0 0 {name=p59457 lab=_63049_/B }
C {devices/lab_pin.sym} 59600 -4820 0 0 {name=p59458 lab=_63085_/C }
C {devices/lab_pin.sym} 59600 -4780 0 0 {name=p59459 lab=_60541_/B }
C {devices/lab_pin.sym} 59720 -4840 0 1 {name=p59460 lab=_63049_/X }
C {sky130_stdcells/and4_4.sym} 59660 -4840 0 0 {name=X_63049_ }
C {devices/lab_pin.sym} 59570 -4690 0 0 {name=p59461 lab=_81990_/CLK }
C {devices/lab_pin.sym} 59570 -4670 0 0 {name=p59462 lab=_46216_/Y }
C {devices/lab_pin.sym} 59750 -4690 0 1 {name=p59463 lab=_44012_/A }
C {sky130_stdcells/dfxtp_4.sym} 59660 -4680 0 0 {name=X_86760_ }
C {devices/lab_pin.sym} 59570 -4550 0 0 {name=p59464 lab=_80931_/CLK }
C {devices/lab_pin.sym} 59570 -4530 0 0 {name=p59465 lab=_68515_/X }
C {devices/lab_pin.sym} 59750 -4550 0 1 {name=p59466 lab=_83972_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -4540 0 0 {name=X_83972_ }
C {devices/lab_pin.sym} 59600 -4420 0 0 {name=p59467 lab=_50027_/A }
C {devices/lab_pin.sym} 59600 -4380 0 0 {name=p59468 lab=_53227_/B }
C {devices/lab_pin.sym} 59720 -4400 0 1 {name=p59469 lab=_50014_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -4400 0 0 {name=X_50014_ }
C {devices/lab_pin.sym} 59570 -4270 0 0 {name=p59470 lab=_84766_/CLK }
C {devices/lab_pin.sym} 59570 -4250 0 0 {name=p59471 lab=_53024_/Y }
C {devices/lab_pin.sym} 59750 -4270 0 1 {name=p59472 lab=_85711_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -4260 0 0 {name=X_85711_ }
C {devices/lab_pin.sym} 59570 -4130 0 0 {name=p59473 lab=_82923_/CLK }
C {devices/lab_pin.sym} 59570 -4110 0 0 {name=p59474 lab=_78197_/X }
C {devices/lab_pin.sym} 59750 -4130 0 1 {name=p59475 lab=_82923_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -4120 0 0 {name=X_82923_ }
C {devices/lab_pin.sym} 59580 -4020 0 0 {name=p59476 lab=_45107_/A }
C {devices/lab_pin.sym} 59580 -3980 0 0 {name=p59477 lab=_55531_/X }
C {devices/lab_pin.sym} 59580 -3940 0 0 {name=p59478 lab=_55533_/X }
C {devices/lab_pin.sym} 59580 -3900 0 0 {name=p59479 lab=_55870_/X }
C {devices/lab_pin.sym} 59740 -3960 0 1 {name=p59480 lab=_55871_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -3960 0 0 {name=X_55871_ }
C {devices/lab_pin.sym} 59580 -3840 0 0 {name=p59481 lab=_87453_/Q }
C {devices/lab_pin.sym} 59580 -3800 0 0 {name=p59482 lab=_67834_/X }
C {devices/lab_pin.sym} 59580 -3760 0 0 {name=p59483 lab=_67835_/X }
C {devices/lab_pin.sym} 59580 -3720 0 0 {name=p59484 lab=_67856_/X }
C {devices/lab_pin.sym} 59740 -3780 0 1 {name=p59485 lab=_67857_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -3780 0 0 {name=X_67857_ }
C {devices/lab_pin.sym} 59570 -3630 0 0 {name=p59486 lab=_86372_/CLK }
C {devices/lab_pin.sym} 59570 -3610 0 0 {name=p59487 lab=_86691_/D }
C {devices/lab_pin.sym} 59750 -3630 0 1 {name=p59488 lab=_58953_/A }
C {sky130_stdcells/dfxtp_4.sym} 59660 -3620 0 0 {name=X_86691_ }
C {devices/lab_pin.sym} 59580 -3510 0 0 {name=p59489 lab=_57606_/Y }
C {devices/lab_pin.sym} 59580 -3470 0 0 {name=p59490 lab=_57581_/X }
C {devices/lab_pin.sym} 59580 -3430 0 0 {name=p59491 lab=_57609_/Y }
C {devices/lab_pin.sym} 59740 -3470 0 1 {name=p59492 lab=_57610_/Y }
C {sky130_stdcells/a21boi_4.sym} 59660 -3470 0 0 {name=X_57610_ }
C {devices/lab_pin.sym} 59580 -3350 0 0 {name=p59493 lab=_54819_/Y }
C {devices/lab_pin.sym} 59580 -3310 0 0 {name=p59494 lab=_54802_/X }
C {devices/lab_pin.sym} 59580 -3270 0 0 {name=p59495 lab=_54821_/X }
C {devices/lab_pin.sym} 59740 -3310 0 1 {name=p59496 lab=_85372_/D }
C {sky130_stdcells/a21oi_4.sym} 59660 -3310 0 0 {name=X_54822_ }
C {devices/lab_pin.sym} 59600 -3180 0 0 {name=p59497 lab=_66760_/A }
C {devices/lab_pin.sym} 59600 -3140 0 0 {name=p59498 lab=_66808_/B }
C {devices/lab_pin.sym} 59720 -3160 0 1 {name=p59499 lab=_66808_/X }
C {sky130_stdcells/and2_4.sym} 59660 -3160 0 0 {name=X_66808_ }
C {devices/lab_pin.sym} 59570 -3030 0 0 {name=p59500 lab=_85738_/CLK }
C {devices/lab_pin.sym} 59570 -3010 0 0 {name=p59501 lab=_53394_/Y }
C {devices/lab_pin.sym} 59750 -3030 0 1 {name=p59502 lab=_85642_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -3020 0 0 {name=X_85642_ }
C {devices/lab_pin.sym} 59580 -2930 0 0 {name=p59503 lab=_58585_/X }
C {devices/lab_pin.sym} 59580 -2890 0 0 {name=p59504 lab=_58587_/Y }
C {devices/lab_pin.sym} 59580 -2850 0 0 {name=p59505 lab=_58588_/Y }
C {devices/lab_pin.sym} 59580 -2810 0 0 {name=p59506 lab=_58098_/X }
C {devices/lab_pin.sym} 59580 -2770 0 0 {name=p59507 lab=_58589_/X }
C {devices/lab_pin.sym} 59740 -2850 0 1 {name=p59508 lab=_58590_/X }
C {sky130_stdcells/o32a_4.sym} 59660 -2850 0 0 {name=X_58590_ }
C {devices/lab_pin.sym} 59570 -2690 0 0 {name=p59509 lab=_82855_/CLK }
C {devices/lab_pin.sym} 59570 -2670 0 0 {name=p59510 lab=_78102_/B }
C {devices/lab_pin.sym} 59750 -2690 0 1 {name=p59511 lab=_82854_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -2680 0 0 {name=X_82854_ }
C {devices/lab_pin.sym} 59620 -2550 0 0 {name=p59512 lab=_67550_/X }
C {devices/lab_pin.sym} 59700 -2550 0 1 {name=p59513 lab=_67788_/X }
C {sky130_stdcells/buf_2.sym} 59660 -2550 0 0 {name=X_67788_ }
C {devices/lab_pin.sym} 59600 -2440 0 0 {name=p59514 lab=_57528_/X }
C {devices/lab_pin.sym} 59600 -2400 0 0 {name=p59515 lab=_53514_/B }
C {devices/lab_pin.sym} 59720 -2420 0 1 {name=p59516 lab=_57541_/Y }
C {sky130_stdcells/nand2_4.sym} 59660 -2420 0 0 {name=X_57541_ }
C {devices/lab_pin.sym} 59570 -2290 0 0 {name=p59517 lab=_81620_/CLK }
C {devices/lab_pin.sym} 59570 -2270 0 0 {name=p59518 lab=_81613_/Q }
C {devices/lab_pin.sym} 59750 -2290 0 1 {name=p59519 lab=_81805_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -2280 0 0 {name=X_81805_ }
C {devices/lab_pin.sym} 59580 -2180 0 0 {name=p59520 lab=_87011_/Q }
C {devices/lab_pin.sym} 59580 -2140 0 0 {name=p59521 lab=_69485_/X }
C {devices/lab_pin.sym} 59580 -2100 0 0 {name=p59522 lab=_69361_/X }
C {devices/lab_pin.sym} 59580 -2060 0 0 {name=p59523 lab=_69526_/X }
C {devices/lab_pin.sym} 59740 -2120 0 1 {name=p59524 lab=_69527_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -2120 0 0 {name=X_69527_ }
C {devices/lab_pin.sym} 59570 -1970 0 0 {name=p59525 lab=_82541_/CLK }
C {devices/lab_pin.sym} 59570 -1950 0 0 {name=p59526 lab=_88361_/D }
C {devices/lab_pin.sym} 59750 -1970 0 1 {name=p59527 lab=_88361_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -1960 0 0 {name=X_88361_ }
C {devices/lab_pin.sym} 59620 -1830 0 0 {name=p59528 lab=_54807_/A }
C {devices/lab_pin.sym} 59700 -1830 0 1 {name=p59529 lab=_54775_/A }
C {sky130_stdcells/buf_2.sym} 59660 -1830 0 0 {name=X_54753_ }
C {devices/lab_pin.sym} 59580 -1740 0 0 {name=p59530 lab=_87372_/Q }
C {devices/lab_pin.sym} 59580 -1700 0 0 {name=p59531 lab=_66642_/X }
C {devices/lab_pin.sym} 59580 -1660 0 0 {name=p59532 lab=_66643_/X }
C {devices/lab_pin.sym} 59580 -1620 0 0 {name=p59533 lab=_66738_/X }
C {devices/lab_pin.sym} 59740 -1680 0 1 {name=p59534 lab=_66739_/X }
C {sky130_stdcells/a211o_4.sym} 59660 -1680 0 0 {name=X_66739_ }
C {devices/lab_pin.sym} 59570 -1530 0 0 {name=p59535 lab=_83564_/CLK }
C {devices/lab_pin.sym} 59570 -1510 0 0 {name=p59536 lab=_85573_/D }
C {devices/lab_pin.sym} 59750 -1530 0 1 {name=p59537 lab=_85573_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -1520 0 0 {name=X_85573_ }
C {devices/lab_pin.sym} 59580 -1410 0 0 {name=p59538 lab=_51963_/Y }
C {devices/lab_pin.sym} 59580 -1370 0 0 {name=p59539 lab=_51934_/X }
C {devices/lab_pin.sym} 59580 -1330 0 0 {name=p59540 lab=_51964_/Y }
C {devices/lab_pin.sym} 59740 -1370 0 1 {name=p59541 lab=_85916_/D }
C {sky130_stdcells/a21boi_4.sym} 59660 -1370 0 0 {name=X_51965_ }
C {devices/lab_pin.sym} 59570 -1230 0 0 {name=p59542 lab=_82973_/CLK }
C {devices/lab_pin.sym} 59570 -1210 0 0 {name=p59543 lab=_82785_/D }
C {devices/lab_pin.sym} 59750 -1230 0 1 {name=p59544 lab=_82785_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -1220 0 0 {name=X_82785_ }
C {devices/lab_pin.sym} 59570 -1090 0 0 {name=p59545 lab=_86534_/CLK }
C {devices/lab_pin.sym} 59570 -1070 0 0 {name=p59546 lab=_43681_/X }
C {devices/lab_pin.sym} 59750 -1090 0 1 {name=p59547 lab=_72831_/A }
C {sky130_stdcells/dfxtp_4.sym} 59660 -1080 0 0 {name=X_87312_ }
C {devices/lab_pin.sym} 59580 -970 0 0 {name=p59548 lab=_53700_/Y }
C {devices/lab_pin.sym} 59580 -930 0 0 {name=p59549 lab=_53680_/X }
C {devices/lab_pin.sym} 59580 -890 0 0 {name=p59550 lab=_53703_/X }
C {devices/lab_pin.sym} 59740 -930 0 1 {name=p59551 lab=_85585_/D }
C {sky130_stdcells/a21oi_4.sym} 59660 -930 0 0 {name=X_53704_ }
C {devices/lab_pin.sym} 59570 -790 0 0 {name=p59552 lab=_81048_/CLK }
C {devices/lab_pin.sym} 59570 -770 0 0 {name=p59553 lab=_84524_/D }
C {devices/lab_pin.sym} 59750 -790 0 1 {name=p59554 lab=_84524_/Q }
C {sky130_stdcells/dfxtp_4.sym} 59660 -780 0 0 {name=X_84524_ }
C {devices/lab_pin.sym} 60520 -42160 0 0 {name=p59555 lab=_50932_/A }
C {devices/lab_pin.sym} 60520 -42120 0 0 {name=p59556 lab=_51779_/B }
C {devices/lab_pin.sym} 60640 -42140 0 1 {name=p59557 lab=_50916_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -42140 0 0 {name=X_50916_ }
C {devices/lab_pin.sym} 60540 -42010 0 0 {name=p59558 lab=_57472_/A }
C {devices/lab_pin.sym} 60620 -42010 0 1 {name=p59559 lab=_84998_/D }
C {sky130_stdcells/inv_2.sym} 60580 -42010 0 0 {name=X_57472_ }
C {devices/lab_pin.sym} 60490 -41890 0 0 {name=p59560 lab=_82067_/CLK }
C {devices/lab_pin.sym} 60490 -41870 0 0 {name=p59561 lab=_81736_/D }
C {devices/lab_pin.sym} 60670 -41890 0 1 {name=p59562 lab=_41422_/A }
C {sky130_stdcells/dfxtp_4.sym} 60580 -41880 0 0 {name=X_81736_ }
C {devices/lab_pin.sym} 60540 -41750 0 0 {name=p59563 lab=_69183_/A }
C {devices/lab_pin.sym} 60620 -41750 0 1 {name=p59564 lab=_69458_/X }
C {sky130_stdcells/buf_2.sym} 60580 -41750 0 0 {name=X_69458_ }
C {devices/lab_pin.sym} 60490 -41630 0 0 {name=p59565 lab=_87790_/CLK }
C {devices/lab_pin.sym} 60490 -41610 0 0 {name=p59566 lab=_88292_/D }
C {devices/lab_pin.sym} 60670 -41630 0 1 {name=p59567 lab=_88292_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -41620 0 0 {name=X_88292_ }
C {devices/lab_pin.sym} 60540 -41490 0 0 {name=p59568 lab=_54656_/X }
C {devices/lab_pin.sym} 60620 -41490 0 1 {name=p59569 lab=_54707_/B }
C {sky130_stdcells/buf_2.sym} 60580 -41490 0 0 {name=X_54684_ }
C {devices/lab_pin.sym} 60500 -41390 0 0 {name=p59570 lab=_85926_/Q }
C {devices/lab_pin.sym} 60500 -41350 0 0 {name=p59571 lab=_51873_/X }
C {devices/lab_pin.sym} 60500 -41310 0 0 {name=p59572 lab=_51895_/Y }
C {devices/lab_pin.sym} 60660 -41350 0 1 {name=p59573 lab=_51896_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -41350 0 0 {name=X_51896_ }
C {devices/lab_pin.sym} 60500 -41230 0 0 {name=p59574 lab=_59207_/Y }
C {devices/lab_pin.sym} 60500 -41190 0 0 {name=p59575 lab=_59210_/Y }
C {devices/lab_pin.sym} 60500 -41150 0 0 {name=p59576 lab=_59165_/X }
C {devices/lab_pin.sym} 60660 -41190 0 1 {name=p59577 lab=_59211_/X }
C {sky130_stdcells/a21o_4.sym} 60580 -41190 0 0 {name=X_59211_ }
C {devices/lab_pin.sym} 60540 -41050 0 0 {name=p59578 lab=_56436_/A }
C {devices/lab_pin.sym} 60620 -41050 0 1 {name=p59579 lab=_56433_/B }
C {sky130_stdcells/buf_2.sym} 60580 -41050 0 0 {name=X_56423_ }
C {devices/lab_pin.sym} 60520 -40940 0 0 {name=p59580 lab=_68409_/A }
C {devices/lab_pin.sym} 60520 -40900 0 0 {name=p59581 lab=_88274_/Q }
C {devices/lab_pin.sym} 60640 -40920 0 1 {name=p59582 lab=_68409_/X }
C {sky130_stdcells/and2_4.sym} 60580 -40920 0 0 {name=X_68409_ }
C {devices/lab_pin.sym} 60490 -40790 0 0 {name=p59583 lab=_87757_/CLK }
C {devices/lab_pin.sym} 60490 -40770 0 0 {name=p59584 lab=_43835_/X }
C {devices/lab_pin.sym} 60670 -40790 0 1 {name=p59585 lab=_87243_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -40780 0 0 {name=X_87243_ }
C {devices/lab_pin.sym} 60540 -40650 0 0 {name=p59586 lab=_53671_/A }
C {devices/lab_pin.sym} 60620 -40650 0 1 {name=p59587 lab=_53667_/C }
C {sky130_stdcells/buf_2.sym} 60580 -40650 0 0 {name=X_53635_ }
C {devices/lab_pin.sym} 60490 -40530 0 0 {name=p59588 lab=_84564_/CLK }
C {devices/lab_pin.sym} 60490 -40510 0 0 {name=p59589 lab=_61769_/Y }
C {devices/lab_pin.sym} 60670 -40530 0 1 {name=p59590 lab=_78078_/B }
C {sky130_stdcells/dfxtp_4.sym} 60580 -40520 0 0 {name=X_84455_ }
C {devices/lab_pin.sym} 60520 -40400 0 0 {name=p59591 lab=_50806_/A }
C {devices/lab_pin.sym} 60520 -40360 0 0 {name=p59592 lab=_51358_/B }
C {devices/lab_pin.sym} 60640 -40380 0 1 {name=p59593 lab=_50847_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -40380 0 0 {name=X_50847_ }
C {devices/lab_pin.sym} 60490 -40250 0 0 {name=p59594 lab=_81040_/CLK }
C {devices/lab_pin.sym} 60490 -40230 0 0 {name=p59595 lab=_80262_/X }
C {devices/lab_pin.sym} 60670 -40250 0 1 {name=p59596 lab=_81667_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -40240 0 0 {name=X_81667_ }
C {devices/lab_pin.sym} 60540 -40110 0 0 {name=p59597 lab=_68660_/X }
C {devices/lab_pin.sym} 60620 -40110 0 1 {name=p59598 lab=_69389_/X }
C {sky130_stdcells/buf_2.sym} 60580 -40110 0 0 {name=X_69389_ }
C {devices/lab_pin.sym} 60500 -40020 0 0 {name=p59599 lab=_40590_/X }
C {devices/lab_pin.sym} 60500 -39980 0 0 {name=p59600 lab=_40596_/X }
C {devices/lab_pin.sym} 60500 -39940 0 0 {name=p59601 lab=_88368_/Q }
C {devices/lab_pin.sym} 60500 -39900 0 0 {name=p59602 lab=_40599_/X }
C {devices/lab_pin.sym} 60660 -39960 0 1 {name=p59603 lab=_40600_/X }
C {sky130_stdcells/a2bb2o_4.sym} 60580 -39960 0 0 {name=X_40600_ }
C {devices/lab_pin.sym} 60540 -39810 0 0 {name=p59604 lab=_71419_/Y }
C {devices/lab_pin.sym} 60620 -39810 0 1 {name=p59605 lab=_71420_/X }
C {sky130_stdcells/buf_2.sym} 60580 -39810 0 0 {name=X_71420_ }
C {devices/lab_pin.sym} 60500 -39720 0 0 {name=p59606 lab=_84766_/Q }
C {devices/lab_pin.sym} 60500 -39680 0 0 {name=p59607 lab=_59129_/X }
C {devices/lab_pin.sym} 60500 -39640 0 0 {name=p59608 lab=_59134_/X }
C {devices/lab_pin.sym} 60500 -39600 0 0 {name=p59609 lab=_59141_/X }
C {devices/lab_pin.sym} 60660 -39660 0 1 {name=p59610 lab=_59142_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 60580 -39660 0 0 {name=X_59142_ }
C {devices/lab_pin.sym} 60490 -39510 0 0 {name=p59611 lab=_83482_/CLK }
C {devices/lab_pin.sym} 60490 -39490 0 0 {name=p59612 lab=_71701_/Y }
C {devices/lab_pin.sym} 60670 -39510 0 1 {name=p59613 lab=_83406_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -39500 0 0 {name=X_83406_ }
C {devices/lab_pin.sym} 60500 -39400 0 0 {name=p59614 lab=_80608_/A }
C {devices/lab_pin.sym} 60500 -39360 0 0 {name=p59615 lab=_80608_/B }
C {devices/lab_pin.sym} 60500 -39320 0 0 {name=p59616 lab=_80607_/A }
C {devices/lab_pin.sym} 60500 -39280 0 0 {name=p59617 lab=_80607_/B }
C {devices/lab_pin.sym} 60660 -39340 0 1 {name=p59618 lab=_80618_/X }
C {sky130_stdcells/o22a_4.sym} 60580 -39340 0 0 {name=X_80618_ }
C {devices/lab_pin.sym} 60520 -39210 0 0 {name=p59619 lab=_56358_/A }
C {devices/lab_pin.sym} 60520 -39170 0 0 {name=p59620 lab=_56358_/B }
C {devices/lab_pin.sym} 60520 -39130 0 0 {name=p59621 lab=_55748_/B }
C {devices/lab_pin.sym} 60640 -39170 0 1 {name=p59622 lab=_56354_/Y }
C {sky130_stdcells/nand3_4.sym} 60580 -39170 0 0 {name=X_56354_ }
C {devices/lab_pin.sym} 60490 -39030 0 0 {name=p59623 lab=_87174_/CLK }
C {devices/lab_pin.sym} 60490 -39010 0 0 {name=p59624 lab=_44281_/Y }
C {devices/lab_pin.sym} 60670 -39030 0 1 {name=p59625 lab=_87174_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -39020 0 0 {name=X_87174_ }
C {devices/lab_pin.sym} 60540 -38890 0 0 {name=p59626 lab=_41580_/A }
C {devices/lab_pin.sym} 60620 -38890 0 1 {name=p59627 lab=_41580_/X }
C {sky130_stdcells/buf_2.sym} 60580 -38890 0 0 {name=X_41580_ }
C {devices/lab_pin.sym} 60540 -38770 0 0 {name=p59628 lab=clkbuf_9_245_0_CLK/X }
C {devices/lab_pin.sym} 60620 -38770 0 1 {name=p59629 lab=_85959_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 60580 -38770 0 0 {name=Xclkbuf_10_490_0_CLK }
C {devices/lab_pin.sym} 60500 -38670 0 0 {name=p59630 lab=_53564_/Y }
C {devices/lab_pin.sym} 60500 -38630 0 0 {name=p59631 lab=_53524_/X }
C {devices/lab_pin.sym} 60500 -38590 0 0 {name=p59632 lab=_53565_/Y }
C {devices/lab_pin.sym} 60660 -38630 0 1 {name=p59633 lab=_53566_/Y }
C {sky130_stdcells/a21boi_4.sym} 60580 -38630 0 0 {name=X_53566_ }
C {devices/lab_pin.sym} 60490 -38490 0 0 {name=p59634 lab=_84508_/CLK }
C {devices/lab_pin.sym} 60490 -38470 0 0 {name=p59635 lab=_84386_/D }
C {devices/lab_pin.sym} 60670 -38490 0 1 {name=p59636 lab=_84386_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -38480 0 0 {name=X_84386_ }
C {devices/lab_pin.sym} 60500 -38370 0 0 {name=p59637 lab=_86135_/Q }
C {devices/lab_pin.sym} 60500 -38330 0 0 {name=p59638 lab=_50775_/X }
C {devices/lab_pin.sym} 60500 -38290 0 0 {name=p59639 lab=_50777_/Y }
C {devices/lab_pin.sym} 60660 -38330 0 1 {name=p59640 lab=_50778_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -38330 0 0 {name=X_50778_ }
C {devices/lab_pin.sym} 60490 -38190 0 0 {name=p59641 lab=_81482_/CLK }
C {devices/lab_pin.sym} 60490 -38170 0 0 {name=p59642 lab=_65481_/C }
C {devices/lab_pin.sym} 60670 -38190 0 1 {name=p59643 lab=_76915_/A }
C {sky130_stdcells/dfxtp_4.sym} 60580 -38180 0 0 {name=X_81598_ }
C {devices/lab_pin.sym} 60540 -38050 0 0 {name=p59644 lab=_55190_/X }
C {devices/lab_pin.sym} 60620 -38050 0 1 {name=p59645 lab=_55305_/X }
C {sky130_stdcells/buf_2.sym} 60580 -38050 0 0 {name=X_55305_ }
C {devices/lab_pin.sym} 60490 -37930 0 0 {name=p59646 lab=_86040_/CLK }
C {devices/lab_pin.sym} 60490 -37910 0 0 {name=p59647 lab=_86125_/D }
C {devices/lab_pin.sym} 60670 -37930 0 1 {name=p59648 lab=_86125_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -37920 0 0 {name=X_86125_ }
C {devices/lab_pin.sym} 60500 -37810 0 0 {name=p59649 lab=_40429_/X }
C {devices/lab_pin.sym} 60500 -37770 0 0 {name=p59650 lab=_82309_/Q }
C {devices/lab_pin.sym} 60500 -37730 0 0 {name=p59651 lab=_40530_/X }
C {devices/lab_pin.sym} 60660 -37770 0 1 {name=p59652 lab=_40531_/X }
C {sky130_stdcells/o21a_4.sym} 60580 -37770 0 0 {name=X_40531_ }
C {devices/lab_pin.sym} 60540 -37630 0 0 {name=p59653 lab=_52602_/A }
C {devices/lab_pin.sym} 60620 -37630 0 1 {name=p59654 lab=_52518_/A }
C {sky130_stdcells/buf_2.sym} 60580 -37630 0 0 {name=X_52517_ }
C {devices/lab_pin.sym} 60540 -37510 0 0 {name=p59655 lab=_58904_/A }
C {devices/lab_pin.sym} 60620 -37510 0 1 {name=p59656 lab=_59073_/X }
C {sky130_stdcells/buf_2.sym} 60580 -37510 0 0 {name=X_59073_ }
C {devices/lab_pin.sym} 60540 -37390 0 0 {name=p59657 lab=_70935_/A }
C {devices/lab_pin.sym} 60620 -37390 0 1 {name=p59658 lab=_71351_/X }
C {sky130_stdcells/buf_2.sym} 60580 -37390 0 0 {name=X_71351_ }
C {devices/lab_pin.sym} 60490 -37270 0 0 {name=p59659 lab=_83337_/CLK }
C {devices/lab_pin.sym} 60490 -37250 0 0 {name=p59660 lab=_83337_/D }
C {devices/lab_pin.sym} 60670 -37270 0 1 {name=p59661 lab=_83337_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -37260 0 0 {name=X_83337_ }
C {devices/lab_pin.sym} 60540 -37130 0 0 {name=p59662 lab=_56282_/Y }
C {devices/lab_pin.sym} 60620 -37130 0 1 {name=p59663 lab=_56347_/A }
C {sky130_stdcells/buf_2.sym} 60580 -37130 0 0 {name=X_56285_ }
C {devices/lab_pin.sym} 60520 -37020 0 0 {name=p59664 lab=_80547_/X }
C {devices/lab_pin.sym} 60520 -36980 0 0 {name=p59665 lab=_80549_/B }
C {devices/lab_pin.sym} 60640 -37000 0 1 {name=p59666 lab=_80549_/Y }
C {sky130_stdcells/xnor2_4.sym} 60580 -37000 0 0 {name=X_80549_ }
C {devices/lab_pin.sym} 60540 -36870 0 0 {name=p59667 lab=_53798_/A }
C {devices/lab_pin.sym} 60620 -36870 0 1 {name=p59668 lab=_53696_/A }
C {sky130_stdcells/buf_2.sym} 60580 -36870 0 0 {name=X_53497_ }
C {devices/lab_pin.sym} 60500 -36780 0 0 {name=p59669 lab=_84932_/Q }
C {devices/lab_pin.sym} 60500 -36740 0 0 {name=p59670 lab=_57896_/X }
C {devices/lab_pin.sym} 60500 -36700 0 0 {name=p59671 lab=_58016_/X }
C {devices/lab_pin.sym} 60500 -36660 0 0 {name=p59672 lab=_58023_/X }
C {devices/lab_pin.sym} 60660 -36720 0 1 {name=p59673 lab=_84932_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 60580 -36720 0 0 {name=X_58024_ }
C {devices/lab_pin.sym} 60500 -36590 0 0 {name=p59674 lab=_70289_/X }
C {devices/lab_pin.sym} 60500 -36550 0 0 {name=p59675 lab=_74770_/A }
C {devices/lab_pin.sym} 60500 -36510 0 0 {name=p59676 lab=_70301_/X }
C {devices/lab_pin.sym} 60660 -36550 0 1 {name=p59677 lab=_83805_/D }
C {sky130_stdcells/a21o_4.sym} 60580 -36550 0 0 {name=X_70302_ }
C {devices/lab_pin.sym} 60500 -36440 0 0 {name=p59678 lab=_45847_/A }
C {devices/lab_pin.sym} 60500 -36400 0 0 {name=p59679 lab=_55244_/A }
C {devices/lab_pin.sym} 60500 -36360 0 0 {name=p59680 lab=_55158_/A }
C {devices/lab_pin.sym} 60500 -36320 0 0 {name=p59681 lab=_55235_/X }
C {devices/lab_pin.sym} 60660 -36380 0 1 {name=p59682 lab=_55655_/B }
C {sky130_stdcells/a211o_4.sym} 60580 -36380 0 0 {name=X_55236_ }
C {devices/lab_pin.sym} 60540 -36230 0 0 {name=p59683 lab=_43212_/A }
C {devices/lab_pin.sym} 60620 -36230 0 1 {name=p59684 lab=_43250_/X }
C {sky130_stdcells/buf_2.sym} 60580 -36230 0 0 {name=X_43250_ }
C {devices/lab_pin.sym} 60500 -36130 0 0 {name=p59685 lab=_70111_/Y }
C {devices/lab_pin.sym} 60500 -36090 0 0 {name=p59686 lab=_74003_/B }
C {devices/lab_pin.sym} 60500 -36050 0 0 {name=p59687 lab=_74069_/X }
C {devices/lab_pin.sym} 60660 -36090 0 1 {name=p59688 lab=_74070_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -36090 0 0 {name=X_74070_ }
C {devices/lab_pin.sym} 60490 -35950 0 0 {name=p59689 lab=_85643_/CLK }
C {devices/lab_pin.sym} 60490 -35930 0 0 {name=p59690 lab=_86056_/D }
C {devices/lab_pin.sym} 60670 -35950 0 1 {name=p59691 lab=_86056_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -35940 0 0 {name=X_86056_ }
C {devices/lab_pin.sym} 60520 -35820 0 0 {name=p59692 lab=_52448_/A }
C {devices/lab_pin.sym} 60520 -35780 0 0 {name=p59693 lab=_46313_/Y }
C {devices/lab_pin.sym} 60640 -35800 0 1 {name=p59694 lab=_52448_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -35800 0 0 {name=X_52448_ }
C {devices/lab_pin.sym} 60540 -35670 0 0 {name=p59695 lab=_40380_/A }
C {devices/lab_pin.sym} 60620 -35670 0 1 {name=p59696 lab=_40931_/A }
C {sky130_stdcells/buf_2.sym} 60580 -35670 0 0 {name=X_40462_ }
C {devices/lab_pin.sym} 60500 -35570 0 0 {name=p59697 lab=_53209_/B }
C {devices/lab_pin.sym} 60500 -35530 0 0 {name=p59698 lab=_71264_/X }
C {devices/lab_pin.sym} 60500 -35490 0 0 {name=p59699 lab=_71281_/Y }
C {devices/lab_pin.sym} 60660 -35530 0 1 {name=p59700 lab=_83548_/D }
C {sky130_stdcells/o21ai_4.sym} 60580 -35530 0 0 {name=X_71282_ }
C {devices/lab_pin.sym} 60490 -35390 0 0 {name=p59701 lab=_83630_/CLK }
C {devices/lab_pin.sym} 60490 -35370 0 0 {name=p59702 lab=_83268_/D }
C {devices/lab_pin.sym} 60670 -35390 0 1 {name=p59703 lab=_83268_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -35380 0 0 {name=X_83268_ }
C {devices/lab_pin.sym} 60540 -35250 0 0 {name=p59704 lab=_42096_/A }
C {devices/lab_pin.sym} 60620 -35250 0 1 {name=p59705 lab=_42201_/X }
C {sky130_stdcells/buf_2.sym} 60580 -35250 0 0 {name=X_42201_ }
C {devices/lab_pin.sym} 60520 -35150 0 0 {name=p59706 lab=_73019_/X }
C {devices/lab_pin.sym} 60520 -35110 0 0 {name=p59707 lab=_73021_/B }
C {devices/lab_pin.sym} 60520 -35070 0 0 {name=p59708 lab=_73021_/C }
C {devices/lab_pin.sym} 60640 -35110 0 1 {name=p59709 lab=_73021_/Y }
C {sky130_stdcells/nand3_4.sym} 60580 -35110 0 0 {name=X_73021_ }
C {devices/lab_pin.sym} 60490 -34970 0 0 {name=p59710 lab=_85034_/CLK }
C {devices/lab_pin.sym} 60490 -34950 0 0 {name=p59711 lab=_85007_/D }
C {devices/lab_pin.sym} 60670 -34970 0 1 {name=p59712 lab=_57419_/A }
C {sky130_stdcells/dfxtp_4.sym} 60580 -34960 0 0 {name=X_85007_ }
C {devices/lab_pin.sym} 60540 -34830 0 0 {name=p59713 lab=_70233_/A }
C {devices/lab_pin.sym} 60620 -34830 0 1 {name=p59714 lab=_70239_/D }
C {sky130_stdcells/buf_2.sym} 60580 -34830 0 0 {name=X_70233_ }
C {devices/lab_pin.sym} 60490 -34710 0 0 {name=p59715 lab=_81928_/CLK }
C {devices/lab_pin.sym} 60490 -34690 0 0 {name=p59716 lab=_82251_/Q }
C {devices/lab_pin.sym} 60670 -34710 0 1 {name=p59717 lab=_77354_/A }
C {sky130_stdcells/dfxtp_4.sym} 60580 -34700 0 0 {name=X_82219_ }
C {devices/lab_pin.sym} 60540 -34570 0 0 {name=p59718 lab=_43013_/X }
C {devices/lab_pin.sym} 60620 -34570 0 1 {name=p59719 lab=_51340_/A }
C {sky130_stdcells/buf_2.sym} 60580 -34570 0 0 {name=X_43181_ }
C {devices/lab_pin.sym} 60500 -34480 0 0 {name=p59720 lab=_45719_/A }
C {devices/lab_pin.sym} 60500 -34440 0 0 {name=p59721 lab=_44059_/A }
C {devices/lab_pin.sym} 60500 -34400 0 0 {name=p59722 lab=_55165_/X }
C {devices/lab_pin.sym} 60500 -34360 0 0 {name=p59723 lab=_55166_/X }
C {devices/lab_pin.sym} 60660 -34420 0 1 {name=p59724 lab=_55167_/X }
C {sky130_stdcells/a211o_4.sym} 60580 -34420 0 0 {name=X_55167_ }
C {devices/lab_pin.sym} 60520 -34280 0 0 {name=p59725 lab=_40368_/X }
C {devices/lab_pin.sym} 60520 -34240 0 0 {name=p59726 lab=_81180_/Q }
C {devices/lab_pin.sym} 60640 -34260 0 1 {name=p59727 lab=_40393_/X }
C {sky130_stdcells/or2_4.sym} 60580 -34260 0 0 {name=X_40393_ }
C {devices/lab_pin.sym} 60520 -34140 0 0 {name=p59728 lab=_52373_/X }
C {devices/lab_pin.sym} 60520 -34100 0 0 {name=p59729 lab=_50169_/B }
C {devices/lab_pin.sym} 60640 -34120 0 1 {name=p59730 lab=_52379_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -34120 0 0 {name=X_52379_ }
C {devices/lab_pin.sym} 60490 -33990 0 0 {name=p59731 lab=_83835_/CLK }
C {devices/lab_pin.sym} 60490 -33970 0 0 {name=p59732 lab=_83199_/D }
C {devices/lab_pin.sym} 60670 -33990 0 1 {name=p59733 lab=_83199_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -33980 0 0 {name=X_83199_ }
C {devices/lab_pin.sym} 60540 -33850 0 0 {name=p59734 lab=_42132_/A }
C {devices/lab_pin.sym} 60620 -33850 0 1 {name=p59735 lab=_88019_/D }
C {sky130_stdcells/inv_2.sym} 60580 -33850 0 0 {name=X_42132_ }
C {devices/lab_pin.sym} 60540 -33730 0 0 {name=p59736 lab=_53357_/A }
C {devices/lab_pin.sym} 60620 -33730 0 1 {name=p59737 lab=_54118_/X }
C {sky130_stdcells/buf_2.sym} 60580 -33730 0 0 {name=X_54118_ }
C {devices/lab_pin.sym} 60540 -33610 0 0 {name=p59738 lab=_70348_/D }
C {devices/lab_pin.sym} 60620 -33610 0 1 {name=p59739 lab=_70164_/X }
C {sky130_stdcells/buf_2.sym} 60580 -33610 0 0 {name=X_70164_ }
C {devices/lab_pin.sym} 60540 -33490 0 0 {name=p59740 lab=_47841_/A }
C {devices/lab_pin.sym} 60620 -33490 0 1 {name=p59741 lab=_55098_/X }
C {sky130_stdcells/buf_2.sym} 60580 -33490 0 0 {name=X_55098_ }
C {devices/lab_pin.sym} 60540 -33370 0 0 {name=p59742 lab=_59910_/X }
C {devices/lab_pin.sym} 60620 -33370 0 1 {name=p59743 lab=_59976_/A }
C {sky130_stdcells/buf_2.sym} 60580 -33370 0 0 {name=X_59975_ }
C {devices/lab_pin.sym} 60500 -33270 0 0 {name=p59744 lab=_58877_/X }
C {devices/lab_pin.sym} 60500 -33230 0 0 {name=p59745 lab=_85925_/Q }
C {devices/lab_pin.sym} 60500 -33190 0 0 {name=p59746 lab=_58900_/X }
C {devices/lab_pin.sym} 60660 -33230 0 1 {name=p59747 lab=_58926_/X }
C {sky130_stdcells/o21a_4.sym} 60580 -33230 0 0 {name=X_58926_ }
C {devices/lab_pin.sym} 60540 -33090 0 0 {name=p59748 lab=_47081_/A }
C {devices/lab_pin.sym} 60620 -33090 0 1 {name=p59749 lab=_46940_/X }
C {sky130_stdcells/buf_2.sym} 60580 -33090 0 0 {name=X_46940_ }
C {devices/lab_pin.sym} 60540 -32970 0 0 {name=p59750 lab=_42063_/A }
C {devices/lab_pin.sym} 60620 -32970 0 1 {name=p59751 lab=_42063_/Y }
C {sky130_stdcells/inv_2.sym} 60580 -32970 0 0 {name=X_42063_ }
C {devices/lab_pin.sym} 60520 -32860 0 0 {name=p59752 lab=_54037_/A }
C {devices/lab_pin.sym} 60520 -32820 0 0 {name=p59753 lab=_46500_/Y }
C {devices/lab_pin.sym} 60640 -32840 0 1 {name=p59754 lab=_54049_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -32840 0 0 {name=X_54049_ }
C {devices/lab_pin.sym} 60520 -32720 0 0 {name=p59755 lab=_77757_/X }
C {devices/lab_pin.sym} 60520 -32680 0 0 {name=p59756 lab=_77759_/Y }
C {devices/lab_pin.sym} 60640 -32700 0 1 {name=p59757 lab=_77761_/B }
C {sky130_stdcells/xor2_4.sym} 60580 -32700 0 0 {name=X_77760_ }
C {devices/lab_pin.sym} 60490 -32570 0 0 {name=p59758 lab=_86965_/CLK }
C {devices/lab_pin.sym} 60490 -32550 0 0 {name=p59759 lab=_86958_/D }
C {devices/lab_pin.sym} 60670 -32570 0 1 {name=p59760 lab=_86958_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -32560 0 0 {name=X_86958_ }
C {devices/lab_pin.sym} 60520 -32440 0 0 {name=p59761 lab=_74963_/B }
C {devices/lab_pin.sym} 60520 -32400 0 0 {name=p59762 lab=_74972_/B }
C {devices/lab_pin.sym} 60640 -32420 0 1 {name=p59763 lab=_74972_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -32420 0 0 {name=X_74972_ }
C {devices/lab_pin.sym} 60500 -32310 0 0 {name=p59764 lab=_69117_/X }
C {devices/lab_pin.sym} 60500 -32270 0 0 {name=p59765 lab=_69119_/X }
C {devices/lab_pin.sym} 60500 -32230 0 0 {name=p59766 lab=_69156_/X }
C {devices/lab_pin.sym} 60660 -32270 0 1 {name=p59767 lab=_70095_/Y }
C {sky130_stdcells/a21oi_4.sym} 60580 -32270 0 0 {name=X_70095_ }
C {devices/lab_pin.sym} 60520 -32140 0 0 {name=p59768 lab=_41014_/A }
C {devices/lab_pin.sym} 60520 -32100 0 0 {name=p59769 lab=_41019_/B }
C {devices/lab_pin.sym} 60640 -32120 0 1 {name=p59770 lab=_41014_/X }
C {sky130_stdcells/or2_4.sym} 60580 -32120 0 0 {name=X_41014_ }
C {devices/lab_pin.sym} 60520 -32000 0 0 {name=p59771 lab=_76709_/X }
C {devices/lab_pin.sym} 60520 -31960 0 0 {name=p59772 lab=_76710_/Y }
C {devices/lab_pin.sym} 60640 -31980 0 1 {name=p59773 lab=_76711_/Y }
C {sky130_stdcells/nor2_4.sym} 60580 -31980 0 0 {name=X_76711_ }
C {devices/lab_pin.sym} 60490 -31850 0 0 {name=p59774 lab=_86549_/CLK }
C {devices/lab_pin.sym} 60490 -31830 0 0 {name=p59775 lab=_85909_/D }
C {devices/lab_pin.sym} 60670 -31850 0 1 {name=p59776 lab=_66082_/B }
C {sky130_stdcells/dfxtp_4.sym} 60580 -31840 0 0 {name=X_85909_ }
C {devices/lab_pin.sym} 60500 -31730 0 0 {name=p59777 lab=_73919_/X }
C {devices/lab_pin.sym} 60500 -31690 0 0 {name=p59778 lab=_73922_/X }
C {devices/lab_pin.sym} 60500 -31650 0 0 {name=p59779 lab=_73421_/X }
C {devices/lab_pin.sym} 60660 -31690 0 1 {name=p59780 lab=_73923_/X }
C {sky130_stdcells/a21o_4.sym} 60580 -31690 0 0 {name=X_73923_ }
C {devices/lab_pin.sym} 60540 -31550 0 0 {name=p59781 lab=_52722_/B }
C {devices/lab_pin.sym} 60620 -31550 0 1 {name=p59782 lab=_51031_/B }
C {sky130_stdcells/buf_2.sym} 60580 -31550 0 0 {name=X_46871_ }
C {devices/lab_pin.sym} 60540 -31430 0 0 {name=p59783 lab=_58857_/A }
C {devices/lab_pin.sym} 60620 -31430 0 1 {name=p59784 lab=_58857_/X }
C {sky130_stdcells/buf_2.sym} 60580 -31430 0 0 {name=X_58857_ }
C {devices/lab_pin.sym} 60540 -31310 0 0 {name=p59785 lab=_77690_/Y }
C {devices/lab_pin.sym} 60620 -31310 0 1 {name=p59786 lab=_77692_/B }
C {sky130_stdcells/inv_2.sym} 60580 -31310 0 0 {name=X_77691_ }
C {devices/lab_pin.sym} 60490 -31190 0 0 {name=p59787 lab=_86861_/CLK }
C {devices/lab_pin.sym} 60490 -31170 0 0 {name=p59788 lab=_45249_/Y }
C {devices/lab_pin.sym} 60670 -31190 0 1 {name=p59789 lab=_64466_/B }
C {sky130_stdcells/dfxtp_4.sym} 60580 -31180 0 0 {name=X_86889_ }
C {devices/lab_pin.sym} 60520 -31070 0 0 {name=p59790 lab=_50511_/A }
C {devices/lab_pin.sym} 60520 -31030 0 0 {name=p59791 lab=_48624_/B }
C {devices/lab_pin.sym} 60520 -30990 0 0 {name=p59792 lab=_48610_/C }
C {devices/lab_pin.sym} 60640 -31030 0 1 {name=p59793 lab=_48610_/X }
C {sky130_stdcells/and3_4.sym} 60580 -31030 0 0 {name=X_48610_ }
C {devices/lab_pin.sym} 60520 -30900 0 0 {name=p59794 lab=_79416_/A }
C {devices/lab_pin.sym} 60520 -30860 0 0 {name=p59795 lab=_79416_/B }
C {devices/lab_pin.sym} 60640 -30880 0 1 {name=p59796 lab=_79430_/X }
C {sky130_stdcells/or2_4.sym} 60580 -30880 0 0 {name=X_79430_ }
C {devices/lab_pin.sym} 60500 -30770 0 0 {name=p59797 lab=_45814_/X }
C {devices/lab_pin.sym} 60500 -30730 0 0 {name=p59798 lab=_45818_/Y }
C {devices/lab_pin.sym} 60500 -30690 0 0 {name=p59799 lab=_45821_/Y }
C {devices/lab_pin.sym} 60660 -30730 0 1 {name=p59800 lab=_86852_/D }
C {sky130_stdcells/a21oi_4.sym} 60580 -30730 0 0 {name=X_45822_ }
C {devices/lab_pin.sym} 60520 -30600 0 0 {name=p59801 lab=_86652_/Q }
C {devices/lab_pin.sym} 60520 -30560 0 0 {name=p59802 lab=_57833_/B }
C {devices/lab_pin.sym} 60640 -30580 0 1 {name=p59803 lab=_57808_/Y }
C {sky130_stdcells/nor2_4.sym} 60580 -30580 0 0 {name=X_57808_ }
C {devices/lab_pin.sym} 60540 -30450 0 0 {name=p59804 lab=_81377_/Q }
C {devices/lab_pin.sym} 60620 -30450 0 1 {name=p59805 lab=_76642_/Y }
C {sky130_stdcells/inv_2.sym} 60580 -30450 0 0 {name=X_76642_ }
C {devices/lab_pin.sym} 60520 -30340 0 0 {name=p59806 lab=_49580_/X }
C {devices/lab_pin.sym} 60520 -30300 0 0 {name=p59807 lab=_52803_/B }
C {devices/lab_pin.sym} 60640 -30320 0 1 {name=p59808 lab=_49590_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -30320 0 0 {name=X_49590_ }
C {devices/lab_pin.sym} 60540 -30190 0 0 {name=p59809 lab=_74012_/A }
C {devices/lab_pin.sym} 60620 -30190 0 1 {name=p59810 lab=_73854_/X }
C {sky130_stdcells/buf_2.sym} 60580 -30190 0 0 {name=X_73854_ }
C {devices/lab_pin.sym} 60500 -30090 0 0 {name=p59811 lab=_58682_/X }
C {devices/lab_pin.sym} 60500 -30050 0 0 {name=p59812 lab=_85776_/Q }
C {devices/lab_pin.sym} 60500 -30010 0 0 {name=p59813 lab=_58706_/X }
C {devices/lab_pin.sym} 60660 -30050 0 1 {name=p59814 lab=_58788_/X }
C {sky130_stdcells/o21a_4.sym} 60580 -30050 0 0 {name=X_58788_ }
C {devices/lab_pin.sym} 60500 -29930 0 0 {name=p59815 lab=_86513_/Q }
C {devices/lab_pin.sym} 60500 -29890 0 0 {name=p59816 lab=_48536_/X }
C {devices/lab_pin.sym} 60500 -29850 0 0 {name=p59817 lab=_48540_/Y }
C {devices/lab_pin.sym} 60660 -29890 0 1 {name=p59818 lab=_48541_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -29890 0 0 {name=X_48541_ }
C {devices/lab_pin.sym} 60500 -29770 0 0 {name=p59819 lab=_44520_/Y }
C {devices/lab_pin.sym} 60500 -29730 0 0 {name=p59820 lab=_72775_/X }
C {devices/lab_pin.sym} 60500 -29690 0 0 {name=p59821 lab=_72804_/Y }
C {devices/lab_pin.sym} 60660 -29730 0 1 {name=p59822 lab=_72822_/C }
C {sky130_stdcells/a21o_4.sym} 60580 -29730 0 0 {name=X_72805_ }
C {devices/lab_pin.sym} 60540 -29590 0 0 {name=p59823 lab=clkbuf_9_221_0_CLK/X }
C {devices/lab_pin.sym} 60620 -29590 0 1 {name=p59824 lab=_84194_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 60580 -29590 0 0 {name=Xclkbuf_10_443_0_CLK }
C {devices/lab_pin.sym} 60500 -29490 0 0 {name=p59825 lab=_58755_/Y }
C {devices/lab_pin.sym} 60500 -29450 0 0 {name=p59826 lab=_66445_/C }
C {devices/lab_pin.sym} 60500 -29410 0 0 {name=p59827 lab=_79360_/Y }
C {devices/lab_pin.sym} 60660 -29450 0 1 {name=p59828 lab=_79361_/X }
C {sky130_stdcells/o21a_4.sym} 60580 -29450 0 0 {name=X_79361_ }
C {devices/lab_pin.sym} 60520 -29320 0 0 {name=p59829 lab=_85066_/Q }
C {devices/lab_pin.sym} 60520 -29280 0 0 {name=p59830 lab=_45736_/B }
C {devices/lab_pin.sym} 60640 -29300 0 1 {name=p59831 lab=_45753_/Y }
C {sky130_stdcells/nor2_4.sym} 60580 -29300 0 0 {name=X_45753_ }
C {devices/lab_pin.sym} 60540 -29170 0 0 {name=p59832 lab=_57711_/X }
C {devices/lab_pin.sym} 60620 -29170 0 1 {name=p59833 lab=_57739_/X }
C {sky130_stdcells/buf_2.sym} 60580 -29170 0 0 {name=X_57739_ }
C {devices/lab_pin.sym} 60520 -29060 0 0 {name=p59834 lab=_81278_/Q }
C {devices/lab_pin.sym} 60520 -29020 0 0 {name=p59835 lab=_81546_/Q }
C {devices/lab_pin.sym} 60640 -29040 0 1 {name=p59836 lab=_76576_/B }
C {sky130_stdcells/nor2_4.sym} 60580 -29040 0 0 {name=X_76573_ }
C {devices/lab_pin.sym} 60500 -28940 0 0 {name=p59837 lab=_40408_/X }
C {devices/lab_pin.sym} 60500 -28900 0 0 {name=p59838 lab=_42962_/X }
C {devices/lab_pin.sym} 60500 -28860 0 0 {name=p59839 lab=_87627_/Q }
C {devices/lab_pin.sym} 60500 -28820 0 0 {name=p59840 lab=_42963_/X }
C {devices/lab_pin.sym} 60660 -28880 0 1 {name=p59841 lab=_87627_/D }
C {sky130_stdcells/a2bb2o_4.sym} 60580 -28880 0 0 {name=X_42965_ }
C {devices/lab_pin.sym} 60500 -28750 0 0 {name=p59842 lab=_73781_/X }
C {devices/lab_pin.sym} 60500 -28710 0 0 {name=p59843 lab=_73784_/X }
C {devices/lab_pin.sym} 60500 -28670 0 0 {name=p59844 lab=_73738_/X }
C {devices/lab_pin.sym} 60660 -28710 0 1 {name=p59845 lab=_73789_/A }
C {sky130_stdcells/a21o_4.sym} 60580 -28710 0 0 {name=X_73785_ }
C {devices/lab_pin.sym} 60540 -28570 0 0 {name=p59846 lab=_70997_/A }
C {devices/lab_pin.sym} 60620 -28570 0 1 {name=p59847 lab=_71082_/B }
C {sky130_stdcells/buf_2.sym} 60580 -28570 0 0 {name=X_70997_ }
C {devices/lab_pin.sym} 60520 -28460 0 0 {name=p59848 lab=_78312_/A }
C {devices/lab_pin.sym} 60520 -28420 0 0 {name=p59849 lab=_82658_/D }
C {devices/lab_pin.sym} 60640 -28440 0 1 {name=p59850 lab=_78312_/X }
C {sky130_stdcells/xor2_4.sym} 60580 -28440 0 0 {name=X_78312_ }
C {devices/lab_pin.sym} 60540 -28310 0 0 {name=p59851 lab=_44704_/A }
C {devices/lab_pin.sym} 60620 -28310 0 1 {name=p59852 lab=_86993_/D }
C {sky130_stdcells/inv_2.sym} 60580 -28310 0 0 {name=X_44704_ }
C {devices/lab_pin.sym} 60520 -28210 0 0 {name=p59853 lab=_75519_/X }
C {devices/lab_pin.sym} 60520 -28170 0 0 {name=p59854 lab=_75524_/B }
C {devices/lab_pin.sym} 60520 -28130 0 0 {name=p59855 lab=_75520_/Y }
C {devices/lab_pin.sym} 60640 -28170 0 1 {name=p59856 lab=_75524_/Y }
C {sky130_stdcells/nand3_4.sym} 60580 -28170 0 0 {name=X_75524_ }
C {devices/lab_pin.sym} 60500 -28070 0 0 {name=p59857 lab=_41894_/X }
C {devices/lab_pin.sym} 60500 -28030 0 0 {name=p59858 lab=_41879_/X }
C {devices/lab_pin.sym} 60500 -27990 0 0 {name=p59859 lab=_40641_/X }
C {devices/lab_pin.sym} 60500 -27950 0 0 {name=p59860 lab=_88106_/Q }
C {devices/lab_pin.sym} 60500 -27910 0 0 {name=p59861 lab=_41882_/X }
C {devices/lab_pin.sym} 60660 -27990 0 1 {name=p59862 lab=_41917_/A }
C {sky130_stdcells/o32ai_4.sym} 60580 -27990 0 0 {name=X_41916_ }
C {devices/lab_pin.sym} 60540 -27830 0 0 {name=p59863 lab=_48472_/A }
C {devices/lab_pin.sym} 60620 -27830 0 1 {name=p59864 lab=_48473_/A }
C {sky130_stdcells/inv_2.sym} 60580 -27830 0 0 {name=X_48472_ }
C {devices/lab_pin.sym} 60520 -27730 0 0 {name=p59865 lab=_60727_/A }
C {devices/lab_pin.sym} 60520 -27690 0 0 {name=p59866 lab=_60132_/A }
C {devices/lab_pin.sym} 60520 -27650 0 0 {name=p59867 lab=_60749_/Y }
C {devices/lab_pin.sym} 60640 -27690 0 1 {name=p59868 lab=_60750_/X }
C {sky130_stdcells/and3_4.sym} 60580 -27690 0 0 {name=X_60750_ }
C {devices/lab_pin.sym} 60540 -27550 0 0 {name=p59869 lab=_72735_/X }
C {devices/lab_pin.sym} 60620 -27550 0 1 {name=p59870 lab=_72737_/A }
C {sky130_stdcells/buf_2.sym} 60580 -27550 0 0 {name=X_72736_ }
C {devices/lab_pin.sym} 60520 -27440 0 0 {name=p59871 lab=_79281_/X }
C {devices/lab_pin.sym} 60520 -27400 0 0 {name=p59872 lab=_79292_/B }
C {devices/lab_pin.sym} 60640 -27420 0 1 {name=p59873 lab=_79292_/X }
C {sky130_stdcells/and2_4.sym} 60580 -27420 0 0 {name=X_79292_ }
C {devices/lab_pin.sym} 60540 -27290 0 0 {name=p59874 lab=_63217_/B }
C {devices/lab_pin.sym} 60620 -27290 0 1 {name=p59875 lab=_61551_/A }
C {sky130_stdcells/buf_2.sym} 60580 -27290 0 0 {name=X_45684_ }
C {devices/lab_pin.sym} 60540 -27170 0 0 {name=p59876 lab=_42945_/A }
C {devices/lab_pin.sym} 60620 -27170 0 1 {name=p59877 lab=_42896_/X }
C {sky130_stdcells/buf_2.sym} 60580 -27170 0 0 {name=X_42896_ }
C {devices/lab_pin.sym} 60500 -27070 0 0 {name=p59878 lab=_86636_/Q }
C {devices/lab_pin.sym} 60500 -27030 0 0 {name=p59879 lab=_47382_/X }
C {devices/lab_pin.sym} 60500 -26990 0 0 {name=p59880 lab=_47422_/Y }
C {devices/lab_pin.sym} 60660 -27030 0 1 {name=p59881 lab=_47423_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -27030 0 0 {name=X_47423_ }
C {devices/lab_pin.sym} 60540 -26890 0 0 {name=p59882 lab=_84740_/Q }
C {devices/lab_pin.sym} 60620 -26890 0 1 {name=p59883 lab=_63161_/A }
C {sky130_stdcells/inv_2.sym} 60580 -26890 0 0 {name=X_59409_ }
C {devices/lab_pin.sym} 60520 -26780 0 0 {name=p59884 lab=_78241_/X }
C {devices/lab_pin.sym} 60520 -26740 0 0 {name=p59885 lab=_78252_/C }
C {devices/lab_pin.sym} 60640 -26760 0 1 {name=p59886 lab=_78246_/A }
C {sky130_stdcells/nand2_4.sym} 60580 -26760 0 0 {name=X_78243_ }
C {devices/lab_pin.sym} 60540 -26630 0 0 {name=p59887 lab=_44634_/Y }
C {devices/lab_pin.sym} 60620 -26630 0 1 {name=p59888 lab=_87024_/D }
C {sky130_stdcells/inv_2.sym} 60580 -26630 0 0 {name=X_44635_ }
C {devices/lab_pin.sym} 60520 -26520 0 0 {name=p59889 lab=_80700_/Q }
C {devices/lab_pin.sym} 60520 -26480 0 0 {name=p59890 lab=_80956_/D }
C {devices/lab_pin.sym} 60640 -26500 0 1 {name=p59891 lab=_75456_/A }
C {sky130_stdcells/nand2_4.sym} 60580 -26500 0 0 {name=X_75455_ }
C {devices/lab_pin.sym} 60540 -26370 0 0 {name=p59892 lab=_48164_/A }
C {devices/lab_pin.sym} 60620 -26370 0 1 {name=p59893 lab=_41847_/X }
C {sky130_stdcells/buf_2.sym} 60580 -26370 0 0 {name=X_41847_ }
C {devices/lab_pin.sym} 60500 -26270 0 0 {name=p59894 lab=_83197_/Q }
C {devices/lab_pin.sym} 60500 -26230 0 0 {name=p59895 lab=_72658_/X }
C {devices/lab_pin.sym} 60500 -26190 0 0 {name=p59896 lab=_72666_/Y }
C {devices/lab_pin.sym} 60660 -26230 0 1 {name=p59897 lab=_83197_/D }
C {sky130_stdcells/a21bo_4.sym} 60580 -26230 0 0 {name=X_72667_ }
C {devices/lab_pin.sym} 60540 -26090 0 0 {name=p59898 lab=_60652_/X }
C {devices/lab_pin.sym} 60620 -26090 0 1 {name=p59899 lab=_60682_/A }
C {sky130_stdcells/buf_2.sym} 60580 -26090 0 0 {name=X_60681_ }
C {devices/lab_pin.sym} 60540 -25970 0 0 {name=p59900 lab=clkbuf_9_229_0_CLK/X }
C {devices/lab_pin.sym} 60620 -25970 0 1 {name=p59901 lab=_83630_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 60580 -25970 0 0 {name=Xclkbuf_10_458_0_CLK }
C {devices/lab_pin.sym} 60520 -25870 0 0 {name=p59902 lab=_74406_/A }
C {devices/lab_pin.sym} 60520 -25830 0 0 {name=p59903 lab=_74395_/X }
C {devices/lab_pin.sym} 60520 -25790 0 0 {name=p59904 lab=_74421_/C }
C {devices/lab_pin.sym} 60640 -25830 0 1 {name=p59905 lab=_74406_/X }
C {sky130_stdcells/and3_4.sym} 60580 -25830 0 0 {name=X_74406_ }
C {devices/lab_pin.sym} 60520 -25720 0 0 {name=p59906 lab=_61500_/X }
C {devices/lab_pin.sym} 60520 -25680 0 0 {name=p59907 lab=_62420_/B }
C {devices/lab_pin.sym} 60520 -25640 0 0 {name=p59908 lab=_62420_/C }
C {devices/lab_pin.sym} 60520 -25600 0 0 {name=p59909 lab=_62404_/X }
C {devices/lab_pin.sym} 60640 -25660 0 1 {name=p59910 lab=_62421_/D }
C {sky130_stdcells/nand4_4.sym} 60580 -25660 0 0 {name=X_62420_ }
C {devices/lab_pin.sym} 60500 -25530 0 0 {name=p59911 lab=_86643_/Q }
C {devices/lab_pin.sym} 60500 -25490 0 0 {name=p59912 lab=_47332_/X }
C {devices/lab_pin.sym} 60500 -25450 0 0 {name=p59913 lab=_47353_/Y }
C {devices/lab_pin.sym} 60660 -25490 0 1 {name=p59914 lab=_47354_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -25490 0 0 {name=X_47354_ }
C {devices/lab_pin.sym} 60520 -25380 0 0 {name=p59915 lab=_71863_/A }
C {devices/lab_pin.sym} 60520 -25340 0 0 {name=p59916 lab=_70667_/A }
C {devices/lab_pin.sym} 60520 -25300 0 0 {name=p59917 lab=_71614_/C }
C {devices/lab_pin.sym} 60520 -25260 0 0 {name=p59918 lab=_71622_/D }
C {devices/lab_pin.sym} 60640 -25320 0 1 {name=p59919 lab=_71618_/Y }
C {sky130_stdcells/nor4_4.sym} 60580 -25320 0 0 {name=X_71618_ }
C {devices/lab_pin.sym} 60520 -25180 0 0 {name=p59920 lab=_78193_/B }
C {devices/lab_pin.sym} 60520 -25140 0 0 {name=p59921 lab=_78174_/B }
C {devices/lab_pin.sym} 60640 -25160 0 1 {name=p59922 lab=_78191_/A }
C {sky130_stdcells/xor2_4.sym} 60580 -25160 0 0 {name=X_78174_ }
C {devices/lab_pin.sym} 60540 -25030 0 0 {name=p59923 lab=_42081_/A }
C {devices/lab_pin.sym} 60620 -25030 0 1 {name=p59924 lab=_44567_/A }
C {sky130_stdcells/buf_2.sym} 60580 -25030 0 0 {name=X_44566_ }
C {devices/lab_pin.sym} 60520 -24920 0 0 {name=p59925 lab=_75383_/X }
C {devices/lab_pin.sym} 60520 -24880 0 0 {name=p59926 lab=_75386_/B }
C {devices/lab_pin.sym} 60640 -24900 0 1 {name=p59927 lab=_75390_/A }
C {sky130_stdcells/nand2_4.sym} 60580 -24900 0 0 {name=X_75386_ }
C {devices/lab_pin.sym} 60540 -24770 0 0 {name=p59928 lab=_41777_/Y }
C {devices/lab_pin.sym} 60620 -24770 0 1 {name=p59929 lab=_41778_/X }
C {sky130_stdcells/buf_2.sym} 60580 -24770 0 0 {name=X_41778_ }
C {devices/lab_pin.sym} 60520 -24670 0 0 {name=p59930 lab=_72581_/A }
C {devices/lab_pin.sym} 60520 -24630 0 0 {name=p59931 lab=_72573_/B }
C {devices/lab_pin.sym} 60520 -24590 0 0 {name=p59932 lab=_79310_/B }
C {devices/lab_pin.sym} 60640 -24630 0 1 {name=p59933 lab=_72598_/Y }
C {sky130_stdcells/nor3_4.sym} 60580 -24630 0 0 {name=X_72598_ }
C {devices/lab_pin.sym} 60540 -24490 0 0 {name=p59934 lab=_53964_/A }
C {devices/lab_pin.sym} 60620 -24490 0 1 {name=p59935 lab=_51256_/A }
C {sky130_stdcells/buf_2.sym} 60580 -24490 0 0 {name=X_46305_ }
C {devices/lab_pin.sym} 60520 -24380 0 0 {name=p59936 lab=_77111_/X }
C {devices/lab_pin.sym} 60520 -24340 0 0 {name=p59937 lab=_77122_/A }
C {devices/lab_pin.sym} 60640 -24360 0 1 {name=p59938 lab=_77125_/X }
C {sky130_stdcells/and2_4.sym} 60580 -24360 0 0 {name=X_77125_ }
C {devices/lab_pin.sym} 60540 -24230 0 0 {name=p59939 lab=_43516_/Y }
C {devices/lab_pin.sym} 60620 -24230 0 1 {name=p59940 lab=_87381_/D }
C {sky130_stdcells/inv_2.sym} 60580 -24230 0 0 {name=X_43517_ }
C {devices/lab_pin.sym} 60520 -24140 0 0 {name=p59941 lab=_62634_/A }
C {devices/lab_pin.sym} 60520 -24100 0 0 {name=p59942 lab=_62351_/B }
C {devices/lab_pin.sym} 60520 -24060 0 0 {name=p59943 lab=_62351_/C }
C {devices/lab_pin.sym} 60520 -24020 0 0 {name=p59944 lab=_62351_/D }
C {devices/lab_pin.sym} 60640 -24080 0 1 {name=p59945 lab=_62351_/Y }
C {sky130_stdcells/nand4_4.sym} 60580 -24080 0 0 {name=X_62351_ }
C {devices/lab_pin.sym} 60500 -23950 0 0 {name=p59946 lab=_70323_/C }
C {devices/lab_pin.sym} 60500 -23910 0 0 {name=p59947 lab=_74327_/X }
C {devices/lab_pin.sym} 60500 -23870 0 0 {name=p59948 lab=_74336_/Y }
C {devices/lab_pin.sym} 60660 -23910 0 1 {name=p59949 lab=_74337_/X }
C {sky130_stdcells/a21bo_4.sym} 60580 -23910 0 0 {name=X_74337_ }
C {devices/lab_pin.sym} 60540 -23770 0 0 {name=p59950 lab=_40729_/A }
C {devices/lab_pin.sym} 60620 -23770 0 1 {name=p59951 lab=_40729_/X }
C {sky130_stdcells/buf_2.sym} 60580 -23770 0 0 {name=X_40729_ }
C {devices/lab_pin.sym} 60500 -23670 0 0 {name=p59952 lab=_47280_/Y }
C {devices/lab_pin.sym} 60500 -23630 0 0 {name=p59953 lab=_47271_/X }
C {devices/lab_pin.sym} 60500 -23590 0 0 {name=p59954 lab=_47284_/X }
C {devices/lab_pin.sym} 60660 -23630 0 1 {name=p59955 lab=_86651_/D }
C {sky130_stdcells/a21oi_4.sym} 60580 -23630 0 0 {name=X_47285_ }
C {devices/lab_pin.sym} 60500 -23510 0 0 {name=p59956 lab=_71530_/Y }
C {devices/lab_pin.sym} 60500 -23470 0 0 {name=p59957 lab=_83460_/Q }
C {devices/lab_pin.sym} 60500 -23430 0 0 {name=p59958 lab=_71548_/Y }
C {devices/lab_pin.sym} 60660 -23470 0 1 {name=p59959 lab=_71549_/X }
C {sky130_stdcells/a21o_4.sym} 60580 -23470 0 0 {name=X_71549_ }
C {devices/lab_pin.sym} 60540 -23330 0 0 {name=p59960 lab=_44548_/A }
C {devices/lab_pin.sym} 60620 -23330 0 1 {name=p59961 lab=_44497_/X }
C {sky130_stdcells/buf_2.sym} 60580 -23330 0 0 {name=X_44497_ }
C {devices/lab_pin.sym} 60540 -23210 0 0 {name=p59962 lab=_83611_/Q }
C {devices/lab_pin.sym} 60620 -23210 0 1 {name=p59963 lab=_53852_/B }
C {sky130_stdcells/inv_2.sym} 60580 -23210 0 0 {name=X_49024_ }
C {devices/lab_pin.sym} 60540 -23090 0 0 {name=p59964 lab=_61302_/A }
C {devices/lab_pin.sym} 60620 -23090 0 1 {name=p59965 lab=_61302_/Y }
C {sky130_stdcells/inv_2.sym} 60580 -23090 0 0 {name=X_61302_ }
C {devices/lab_pin.sym} 60540 -22970 0 0 {name=p59966 lab=_56777_/B }
C {devices/lab_pin.sym} 60620 -22970 0 1 {name=p59967 lab=_46237_/A }
C {sky130_stdcells/buf_2.sym} 60580 -22970 0 0 {name=X_46236_ }
C {devices/lab_pin.sym} 60540 -22850 0 0 {name=p59968 lab=_64939_/A }
C {devices/lab_pin.sym} 60620 -22850 0 1 {name=p59969 lab=_65070_/X }
C {sky130_stdcells/buf_2.sym} 60580 -22850 0 0 {name=X_65070_ }
C {sky130_stdcells/decap_3.sym} 60580 -22700 0 0 {name=XPHY_480 }
C {devices/lab_pin.sym} 60500 -22570 0 0 {name=p59970 lab=_77054_/A }
C {devices/lab_pin.sym} 60500 -22530 0 0 {name=p59971 lab=_82281_/D }
C {devices/lab_pin.sym} 60500 -22490 0 0 {name=p59972 lab=_77055_/Y }
C {devices/lab_pin.sym} 60660 -22530 0 1 {name=p59973 lab=_77056_/Y }
C {sky130_stdcells/a21oi_4.sym} 60580 -22530 0 0 {name=X_77056_ }
C {devices/lab_pin.sym} 60500 -22420 0 0 {name=p59974 lab=_41601_/X }
C {devices/lab_pin.sym} 60500 -22380 0 0 {name=p59975 lab=_43446_/X }
C {devices/lab_pin.sym} 60500 -22340 0 0 {name=p59976 lab=_87416_/Q }
C {devices/lab_pin.sym} 60500 -22300 0 0 {name=p59977 lab=_43447_/X }
C {devices/lab_pin.sym} 60660 -22360 0 1 {name=p59978 lab=_43448_/X }
C {sky130_stdcells/a2bb2o_4.sym} 60580 -22360 0 0 {name=X_43448_ }
C {devices/lab_pin.sym} 60500 -22250 0 0 {name=p59979 lab=_62271_/X }
C {devices/lab_pin.sym} 60500 -22210 0 0 {name=p59980 lab=_62275_/Y }
C {devices/lab_pin.sym} 60500 -22170 0 0 {name=p59981 lab=_62281_/X }
C {devices/lab_pin.sym} 60500 -22130 0 0 {name=p59982 lab=_58162_/A }
C {devices/lab_pin.sym} 60500 -22090 0 0 {name=p59983 lab=_62214_/X }
C {devices/lab_pin.sym} 60660 -22170 0 1 {name=p59984 lab=_62282_/Y }
C {sky130_stdcells/o32ai_4.sym} 60580 -22170 0 0 {name=X_62282_ }
C {devices/lab_pin.sym} 60500 -22030 0 0 {name=p59985 lab=_74265_/X }
C {devices/lab_pin.sym} 60500 -21990 0 0 {name=p59986 lab=_74267_/X }
C {devices/lab_pin.sym} 60500 -21950 0 0 {name=p59987 lab=_72741_/X }
C {devices/lab_pin.sym} 60660 -21990 0 1 {name=p59988 lab=_74268_/X }
C {sky130_stdcells/a21o_4.sym} 60580 -21990 0 0 {name=X_74268_ }
C {sky130_stdcells/decap_3.sym} 60580 -21820 0 0 {name=XPHY_491 }
C {devices/lab_pin.sym} 60520 -21690 0 0 {name=p59989 lab=_76005_/B }
C {devices/lab_pin.sym} 60520 -21650 0 0 {name=p59990 lab=_81708_/D }
C {devices/lab_pin.sym} 60520 -21610 0 0 {name=p59991 lab=_81420_/Q }
C {devices/lab_pin.sym} 60640 -21650 0 1 {name=p59992 lab=_76008_/A }
C {sky130_stdcells/nand3_4.sym} 60580 -21650 0 0 {name=X_76007_ }
C {devices/lab_pin.sym} 60500 -21550 0 0 {name=p59993 lab=_64017_/X }
C {devices/lab_pin.sym} 60500 -21510 0 0 {name=p59994 lab=_63969_/X }
C {devices/lab_pin.sym} 60500 -21470 0 0 {name=p59995 lab=_64018_/Y }
C {devices/lab_pin.sym} 60500 -21430 0 0 {name=p59996 lab=_64019_/Y }
C {devices/lab_pin.sym} 60500 -21400 0 0 {name=p59997 lab=_64020_/X }
C {devices/lab_pin.sym} 60660 -21470 0 1 {name=p59998 lab=_64021_/X }
C {sky130_stdcells/a41o_4.sym} 60580 -21470 0 0 {name=X_64021_ }
C {devices/lab_pin.sym} 60520 -21330 0 0 {name=p59999 lab=_61232_/X }
C {devices/lab_pin.sym} 60520 -21290 0 0 {name=p60000 lab=_61107_/X }
C {devices/lab_pin.sym} 60520 -21250 0 0 {name=p60001 lab=_61176_/B }
C {devices/lab_pin.sym} 60640 -21290 0 1 {name=p60002 lab=_61264_/A }
C {sky130_stdcells/nand3_4.sym} 60580 -21290 0 0 {name=X_61233_ }
C {devices/lab_pin.sym} 60500 -21170 0 0 {name=p60003 lab=_73220_/B }
C {devices/lab_pin.sym} 60500 -21130 0 0 {name=p60004 lab=_73220_/C }
C {devices/lab_pin.sym} 60500 -21090 0 0 {name=p60005 lab=_73218_/X }
C {devices/lab_pin.sym} 60660 -21130 0 1 {name=p60006 lab=_73219_/X }
C {sky130_stdcells/a21o_4.sym} 60580 -21130 0 0 {name=X_73219_ }
C {devices/lab_pin.sym} 60520 -21010 0 0 {name=p60007 lab=_46167_/A }
C {devices/lab_pin.sym} 60520 -20970 0 0 {name=p60008 lab=_46167_/B }
C {devices/lab_pin.sym} 60520 -20930 0 0 {name=p60009 lab=_46159_/X }
C {devices/lab_pin.sym} 60640 -20970 0 1 {name=p60010 lab=_46167_/Y }
C {sky130_stdcells/nor3_4.sym} 60580 -20970 0 0 {name=X_46167_ }
C {devices/lab_pin.sym} 60500 -20870 0 0 {name=p60011 lab=_43367_/X }
C {devices/lab_pin.sym} 60500 -20830 0 0 {name=p60012 lab=_43375_/X }
C {devices/lab_pin.sym} 60500 -20790 0 0 {name=p60013 lab=_41408_/X }
C {devices/lab_pin.sym} 60500 -20750 0 0 {name=p60014 lab=_87452_/Q }
C {devices/lab_pin.sym} 60500 -20710 0 0 {name=p60015 lab=_43378_/X }
C {devices/lab_pin.sym} 60660 -20790 0 1 {name=p60016 lab=_43379_/Y }
C {sky130_stdcells/o32ai_4.sym} 60580 -20790 0 0 {name=X_43379_ }
C {devices/lab_pin.sym} 60520 -20640 0 0 {name=p60017 lab=_74199_/A }
C {devices/lab_pin.sym} 60520 -20600 0 0 {name=p60018 lab=_74198_/X }
C {devices/lab_pin.sym} 60640 -20620 0 1 {name=p60019 lab=_74200_/B }
C {sky130_stdcells/nand2_4.sym} 60580 -20620 0 0 {name=X_74199_ }
C {devices/lab_pin.sym} 60500 -20510 0 0 {name=p60020 lab=_56414_/C }
C {devices/lab_pin.sym} 60500 -20470 0 0 {name=p60021 lab=_45102_/X }
C {devices/lab_pin.sym} 60500 -20430 0 0 {name=p60022 lab=_45117_/X }
C {devices/lab_pin.sym} 60660 -20470 0 1 {name=p60023 lab=_45118_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -20470 0 0 {name=X_45118_ }
C {devices/lab_pin.sym} 60540 -20330 0 0 {name=p60024 lab=clkbuf_9_502_0_CLK/A }
C {devices/lab_pin.sym} 60620 -20330 0 1 {name=p60025 lab=clkbuf_9_502_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 60580 -20330 0 0 {name=Xclkbuf_9_502_0_CLK }
C {devices/lab_pin.sym} 60540 -20210 0 0 {name=p60026 lab=_72564_/A }
C {devices/lab_pin.sym} 60620 -20210 0 1 {name=p60027 lab=_61165_/B }
C {sky130_stdcells/buf_2.sym} 60580 -20210 0 0 {name=X_61164_ }
C {devices/lab_pin.sym} 60520 -20100 0 0 {name=p60028 lab=_46098_/A }
C {devices/lab_pin.sym} 60520 -20060 0 0 {name=p60029 lab=_40381_/X }
C {devices/lab_pin.sym} 60640 -20080 0 1 {name=p60030 lab=_46109_/A }
C {sky130_stdcells/nand2_4.sym} 60580 -20080 0 0 {name=X_46098_ }
C {devices/lab_pin.sym} 60500 -19990 0 0 {name=p60031 lab=_59971_/X }
C {devices/lab_pin.sym} 60500 -19950 0 0 {name=p60032 lab=_60049_/Y }
C {devices/lab_pin.sym} 60500 -19910 0 0 {name=p60033 lab=_60113_/Y }
C {devices/lab_pin.sym} 60500 -19870 0 0 {name=p60034 lab=_62203_/A }
C {devices/lab_pin.sym} 60500 -19840 0 0 {name=p60035 lab=_60114_/Y }
C {devices/lab_pin.sym} 60660 -19910 0 1 {name=p60036 lab=_84659_/D }
C {sky130_stdcells/a41oi_4.sym} 60580 -19910 0 0 {name=X_60115_ }
C {devices/lab_pin.sym} 60520 -19780 0 0 {name=p60037 lab=_49925_/X }
C {devices/lab_pin.sym} 60520 -19740 0 0 {name=p60038 lab=_49915_/X }
C {devices/lab_pin.sym} 60520 -19700 0 0 {name=p60039 lab=_49904_/C }
C {devices/lab_pin.sym} 60520 -19660 0 0 {name=p60040 lab=_53139_/D }
C {devices/lab_pin.sym} 60640 -19720 0 1 {name=p60041 lab=_49926_/X }
C {sky130_stdcells/and4_4.sym} 60580 -19720 0 0 {name=X_49926_ }
C {devices/lab_pin.sym} 60540 -19570 0 0 {name=p60042 lab=_44972_/X }
C {devices/lab_pin.sym} 60620 -19570 0 1 {name=p60043 lab=_45049_/X }
C {sky130_stdcells/buf_2.sym} 60580 -19570 0 0 {name=X_45049_ }
C {devices/lab_pin.sym} 60500 -19480 0 0 {name=p60044 lab=_87492_/Q }
C {devices/lab_pin.sym} 60500 -19440 0 0 {name=p60045 lab=_68757_/X }
C {devices/lab_pin.sym} 60500 -19400 0 0 {name=p60046 lab=_68731_/X }
C {devices/lab_pin.sym} 60500 -19360 0 0 {name=p60047 lab=_68759_/X }
C {devices/lab_pin.sym} 60660 -19420 0 1 {name=p60048 lab=_68760_/X }
C {sky130_stdcells/a211o_4.sym} 60580 -19420 0 0 {name=X_68760_ }
C {devices/lab_pin.sym} 60520 -19280 0 0 {name=p60049 lab=_65702_/A }
C {devices/lab_pin.sym} 60520 -19240 0 0 {name=p60050 lab=_65972_/B }
C {devices/lab_pin.sym} 60640 -19260 0 1 {name=p60051 lab=_65972_/X }
C {sky130_stdcells/and2_4.sym} 60580 -19260 0 0 {name=X_65972_ }
C {devices/lab_pin.sym} 60540 -19130 0 0 {name=p60052 lab=_61153_/A }
C {devices/lab_pin.sym} 60620 -19130 0 1 {name=p60053 lab=_61095_/X }
C {sky130_stdcells/buf_2.sym} 60580 -19130 0 0 {name=X_61095_ }
C {devices/lab_pin.sym} 60520 -19020 0 0 {name=p60054 lab=_82171_/Q }
C {devices/lab_pin.sym} 60520 -18980 0 0 {name=p60055 lab=_77958_/B }
C {devices/lab_pin.sym} 60640 -19000 0 1 {name=p60056 lab=_77958_/X }
C {sky130_stdcells/xor2_4.sym} 60580 -19000 0 0 {name=X_77958_ }
C {devices/lab_pin.sym} 60500 -18900 0 0 {name=p60057 lab=_67496_/X }
C {devices/lab_pin.sym} 60500 -18860 0 0 {name=p60058 lab=_67698_/Y }
C {devices/lab_pin.sym} 60500 -18820 0 0 {name=p60059 lab=_67624_/X }
C {devices/lab_pin.sym} 60500 -18780 0 0 {name=p60060 lab=_67710_/Y }
C {devices/lab_pin.sym} 60660 -18840 0 1 {name=p60061 lab=_67711_/X }
C {sky130_stdcells/a211o_4.sym} 60580 -18840 0 0 {name=X_67711_ }
C {devices/lab_pin.sym} 60540 -18690 0 0 {name=p60062 lab=_64923_/A }
C {devices/lab_pin.sym} 60620 -18690 0 1 {name=p60063 lab=_64924_/A }
C {sky130_stdcells/buf_2.sym} 60580 -18690 0 0 {name=X_64923_ }
C {devices/lab_pin.sym} 60540 -18570 0 0 {name=p60064 lab=_59852_/A }
C {devices/lab_pin.sym} 60620 -18570 0 1 {name=p60065 lab=_60081_/B }
C {sky130_stdcells/buf_2.sym} 60580 -18570 0 0 {name=X_60046_ }
C {devices/lab_pin.sym} 60540 -18450 0 0 {name=p60066 lab=_76931_/A }
C {devices/lab_pin.sym} 60620 -18450 0 1 {name=p60067 lab=_76914_/A }
C {sky130_stdcells/inv_2.sym} 60580 -18450 0 0 {name=X_76909_ }
C {devices/lab_pin.sym} 60520 -18360 0 0 {name=p60068 lab=_49851_/A }
C {devices/lab_pin.sym} 60520 -18320 0 0 {name=p60069 lab=_49851_/B }
C {devices/lab_pin.sym} 60520 -18280 0 0 {name=p60070 lab=_49862_/C }
C {devices/lab_pin.sym} 60520 -18240 0 0 {name=p60071 lab=_53070_/D }
C {devices/lab_pin.sym} 60640 -18300 0 1 {name=p60072 lab=_49857_/X }
C {sky130_stdcells/and4_4.sym} 60580 -18300 0 0 {name=X_49857_ }
C {devices/lab_pin.sym} 60540 -18150 0 0 {name=p60073 lab=_69567_/A }
C {devices/lab_pin.sym} 60620 -18150 0 1 {name=p60074 lab=_68691_/X }
C {sky130_stdcells/buf_2.sym} 60580 -18150 0 0 {name=X_68691_ }
C {devices/lab_pin.sym} 60540 -18030 0 0 {name=p60075 lab=_82068_/Q }
C {devices/lab_pin.sym} 60620 -18030 0 1 {name=p60076 lab=_77891_/A }
C {sky130_stdcells/inv_2.sym} 60580 -18030 0 0 {name=X_77889_ }
C {devices/lab_pin.sym} 60540 -17910 0 0 {name=p60077 lab=_48808_/A }
C {devices/lab_pin.sym} 60620 -17910 0 1 {name=p60078 lab=_48836_/A }
C {sky130_stdcells/buf_2.sym} 60580 -17910 0 0 {name=X_48808_ }
C {devices/lab_pin.sym} 60520 -17800 0 0 {name=p60079 lab=_67569_/X }
C {devices/lab_pin.sym} 60520 -17760 0 0 {name=p60080 lab=_87718_/Q }
C {devices/lab_pin.sym} 60640 -17780 0 1 {name=p60081 lab=_67642_/X }
C {sky130_stdcells/and2_4.sym} 60580 -17780 0 0 {name=X_67642_ }
C {devices/lab_pin.sym} 60520 -17660 0 0 {name=p60082 lab=_84209_/Q }
C {devices/lab_pin.sym} 60520 -17620 0 0 {name=p60083 lab=_83257_/Q }
C {devices/lab_pin.sym} 60640 -17640 0 1 {name=p60084 lab=_79630_/A }
C {sky130_stdcells/xor2_4.sym} 60580 -17640 0 0 {name=X_79628_ }
C {devices/lab_pin.sym} 60500 -17540 0 0 {name=p60085 lab=_64797_/X }
C {devices/lab_pin.sym} 60500 -17500 0 0 {name=p60086 lab=_83304_/Q }
C {devices/lab_pin.sym} 60500 -17460 0 0 {name=p60087 lab=_64772_/X }
C {devices/lab_pin.sym} 60500 -17420 0 0 {name=p60088 lab=_64853_/X }
C {devices/lab_pin.sym} 60660 -17480 0 1 {name=p60089 lab=_64854_/X }
C {sky130_stdcells/a211o_4.sym} 60580 -17480 0 0 {name=X_64854_ }
C {devices/lab_pin.sym} 60540 -17330 0 0 {name=p60090 lab=_49678_/X }
C {devices/lab_pin.sym} 60620 -17330 0 1 {name=p60091 lab=_49807_/A }
C {sky130_stdcells/buf_2.sym} 60580 -17330 0 0 {name=X_49788_ }
C {devices/lab_pin.sym} 60520 -17240 0 0 {name=p60092 lab=_63049_/B }
C {devices/lab_pin.sym} 60520 -17200 0 0 {name=p60093 lab=_63790_/X }
C {devices/lab_pin.sym} 60520 -17160 0 0 {name=p60094 lab=_63757_/C }
C {devices/lab_pin.sym} 60520 -17120 0 0 {name=p60095 lab=_63776_/X }
C {devices/lab_pin.sym} 60640 -17180 0 1 {name=p60096 lab=_63805_/Y }
C {sky130_stdcells/nand4_4.sym} 60580 -17180 0 0 {name=X_63805_ }
C {devices/lab_pin.sym} 60520 -17040 0 0 {name=p60097 lab=_48801_/A }
C {devices/lab_pin.sym} 60520 -17000 0 0 {name=p60098 lab=_48416_/A }
C {devices/lab_pin.sym} 60640 -17020 0 1 {name=p60099 lab=_48739_/X }
C {sky130_stdcells/and2_4.sym} 60580 -17020 0 0 {name=X_48739_ }
C {devices/lab_pin.sym} 60540 -16890 0 0 {name=p60100 lab=clkbuf_8_71_0_CLK/A }
C {devices/lab_pin.sym} 60620 -16890 0 1 {name=p60101 lab=clkbuf_8_70_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 60580 -16890 0 0 {name=Xclkbuf_8_70_0_CLK }
C {devices/lab_pin.sym} 60500 -16800 0 0 {name=p60102 lab=_87401_/Q }
C {devices/lab_pin.sym} 60500 -16760 0 0 {name=p60103 lab=_67476_/X }
C {devices/lab_pin.sym} 60500 -16720 0 0 {name=p60104 lab=_67477_/X }
C {devices/lab_pin.sym} 60500 -16680 0 0 {name=p60105 lab=_67572_/X }
C {devices/lab_pin.sym} 60660 -16740 0 1 {name=p60106 lab=_67573_/X }
C {sky130_stdcells/a211o_4.sym} 60580 -16740 0 0 {name=X_67573_ }
C {devices/lab_pin.sym} 60520 -16600 0 0 {name=p60107 lab=_79548_/Y }
C {devices/lab_pin.sym} 60520 -16560 0 0 {name=p60108 lab=_79558_/Y }
C {devices/lab_pin.sym} 60640 -16580 0 1 {name=p60109 lab=_79559_/Y }
C {sky130_stdcells/nor2_4.sym} 60580 -16580 0 0 {name=X_79559_ }
C {devices/lab_pin.sym} 60500 -16480 0 0 {name=p60110 lab=_64657_/X }
C {devices/lab_pin.sym} 60500 -16440 0 0 {name=p60111 lab=_86747_/Q }
C {devices/lab_pin.sym} 60500 -16400 0 0 {name=p60112 lab=_64733_/X }
C {devices/lab_pin.sym} 60500 -16360 0 0 {name=p60113 lab=_64784_/X }
C {devices/lab_pin.sym} 60660 -16420 0 1 {name=p60114 lab=_64785_/X }
C {sky130_stdcells/a211o_4.sym} 60580 -16420 0 0 {name=X_64785_ }
C {devices/lab_pin.sym} 60540 -16270 0 0 {name=p60115 lab=_58254_/A }
C {devices/lab_pin.sym} 60620 -16270 0 1 {name=p60116 lab=_61997_/X }
C {sky130_stdcells/buf_2.sym} 60580 -16270 0 0 {name=X_61997_ }
C {devices/lab_pin.sym} 60540 -16150 0 0 {name=p60117 lab=clkbuf_7_3_0_CLK/A }
C {devices/lab_pin.sym} 60620 -16150 0 1 {name=p60118 lab=clkbuf_8_5_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 60580 -16150 0 0 {name=Xclkbuf_7_2_0_CLK }
C {devices/lab_pin.sym} 60500 -16050 0 0 {name=p60119 lab=_68685_/X }
C {devices/lab_pin.sym} 60500 -16010 0 0 {name=p60120 lab=_68687_/X }
C {devices/lab_pin.sym} 60500 -15970 0 0 {name=p60121 lab=_69295_/X }
C {devices/lab_pin.sym} 60660 -16010 0 1 {name=p60122 lab=_69312_/Y }
C {sky130_stdcells/a21oi_4.sym} 60580 -16010 0 0 {name=X_69312_ }
C {devices/lab_pin.sym} 60520 -15890 0 0 {name=p60123 lab=_64867_/B }
C {devices/lab_pin.sym} 60520 -15850 0 0 {name=p60124 lab=_66524_/B }
C {devices/lab_pin.sym} 60520 -15810 0 0 {name=p60125 lab=_66524_/C }
C {devices/lab_pin.sym} 60640 -15850 0 1 {name=p60126 lab=_66524_/X }
C {sky130_stdcells/and3_4.sym} 60580 -15850 0 0 {name=X_66524_ }
C {devices/lab_pin.sym} 60520 -15740 0 0 {name=p60127 lab=_51768_/A }
C {devices/lab_pin.sym} 60520 -15700 0 0 {name=p60128 lab=_51749_/X }
C {devices/lab_pin.sym} 60520 -15660 0 0 {name=p60129 lab=_51750_/C }
C {devices/lab_pin.sym} 60520 -15620 0 0 {name=p60130 lab=_52580_/D }
C {devices/lab_pin.sym} 60640 -15680 0 1 {name=p60131 lab=_51750_/X }
C {sky130_stdcells/and4_4.sym} 60580 -15680 0 0 {name=X_51750_ }
C {devices/lab_pin.sym} 60540 -15530 0 0 {name=p60132 lab=_64136_/B }
C {devices/lab_pin.sym} 60620 -15530 0 1 {name=p60133 lab=_63736_/X }
C {sky130_stdcells/buf_2.sym} 60580 -15530 0 0 {name=X_63736_ }
C {devices/lab_pin.sym} 60490 -15410 0 0 {name=p60134 lab=_82570_/CLK }
C {devices/lab_pin.sym} 60490 -15390 0 0 {name=p60135 lab=_82602_/Q }
C {devices/lab_pin.sym} 60670 -15410 0 1 {name=p60136 lab=_82570_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -15400 0 0 {name=X_82570_ }
C {devices/lab_pin.sym} 60500 -15310 0 0 {name=p60137 lab=_60933_/X }
C {devices/lab_pin.sym} 60500 -15270 0 0 {name=p60138 lab=_60938_/Y }
C {devices/lab_pin.sym} 60500 -15230 0 0 {name=p60139 lab=_61024_/B }
C {devices/lab_pin.sym} 60500 -15190 0 0 {name=p60140 lab=_60944_/Y }
C {devices/lab_pin.sym} 60500 -15160 0 0 {name=p60141 lab=_60947_/Y }
C {devices/lab_pin.sym} 60660 -15230 0 1 {name=p60142 lab=_84549_/D }
C {sky130_stdcells/a41oi_4.sym} 60580 -15230 0 0 {name=X_60948_ }
C {devices/lab_pin.sym} 60500 -15090 0 0 {name=p60143 lab=_50698_/Y }
C {devices/lab_pin.sym} 60500 -15050 0 0 {name=p60144 lab=_50699_/X }
C {devices/lab_pin.sym} 60500 -15010 0 0 {name=p60145 lab=_50700_/Y }
C {devices/lab_pin.sym} 60660 -15050 0 1 {name=p60146 lab=_86151_/D }
C {sky130_stdcells/a21boi_4.sym} 60580 -15050 0 0 {name=X_50701_ }
C {devices/lab_pin.sym} 60490 -14910 0 0 {name=p60147 lab=_82642_/CLK }
C {devices/lab_pin.sym} 60490 -14890 0 0 {name=p60148 lab=_76366_/B }
C {devices/lab_pin.sym} 60670 -14910 0 1 {name=p60149 lab=_76032_/A }
C {sky130_stdcells/dfxtp_4.sym} 60580 -14900 0 0 {name=X_81521_ }
C {devices/lab_pin.sym} 60500 -14800 0 0 {name=p60150 lab=_68929_/X }
C {devices/lab_pin.sym} 60500 -14760 0 0 {name=p60151 lab=_68551_/Y }
C {devices/lab_pin.sym} 60500 -14720 0 0 {name=p60152 lab=_69231_/X }
C {devices/lab_pin.sym} 60500 -14680 0 0 {name=p60153 lab=_69242_/Y }
C {devices/lab_pin.sym} 60660 -14740 0 1 {name=p60154 lab=_69243_/X }
C {sky130_stdcells/a211o_4.sym} 60580 -14740 0 0 {name=X_69243_ }
C {devices/lab_pin.sym} 60500 -14610 0 0 {name=p60155 lab=_66453_/Y }
C {devices/lab_pin.sym} 60500 -14570 0 0 {name=p60156 lab=_66454_/Y }
C {devices/lab_pin.sym} 60500 -14530 0 0 {name=p60157 lab=_65842_/X }
C {devices/lab_pin.sym} 60660 -14570 0 1 {name=p60158 lab=_66455_/Y }
C {sky130_stdcells/a21oi_4.sym} 60580 -14570 0 0 {name=X_66455_ }
C {devices/lab_pin.sym} 60520 -14440 0 0 {name=p60159 lab=_51697_/A }
C {devices/lab_pin.sym} 60520 -14400 0 0 {name=p60160 lab=_53205_/B }
C {devices/lab_pin.sym} 60640 -14420 0 1 {name=p60161 lab=_51681_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -14420 0 0 {name=X_51681_ }
C {devices/lab_pin.sym} 60500 -14330 0 0 {name=p60162 lab=_58976_/A }
C {devices/lab_pin.sym} 60500 -14290 0 0 {name=p60163 lab=_60667_/A }
C {devices/lab_pin.sym} 60500 -14250 0 0 {name=p60164 lab=_60724_/A }
C {devices/lab_pin.sym} 60500 -14210 0 0 {name=p60165 lab=_62577_/Y }
C {devices/lab_pin.sym} 60500 -14170 0 0 {name=p60166 lab=_60663_/Y }
C {devices/lab_pin.sym} 60660 -14250 0 1 {name=p60167 lab=_63667_/Y }
C {sky130_stdcells/o32ai_4.sym} 60580 -14250 0 0 {name=X_63667_ }
C {devices/lab_pin.sym} 60520 -14120 0 0 {name=p60168 lab=_60934_/A }
C {devices/lab_pin.sym} 60520 -14080 0 0 {name=p60169 lab=_60879_/B }
C {devices/lab_pin.sym} 60520 -14040 0 0 {name=p60170 lab=_60863_/X }
C {devices/lab_pin.sym} 60520 -14000 0 0 {name=p60171 lab=_60879_/D }
C {devices/lab_pin.sym} 60640 -14060 0 1 {name=p60172 lab=_60879_/Y }
C {sky130_stdcells/nand4_4.sym} 60580 -14060 0 0 {name=X_60879_ }
C {devices/lab_pin.sym} 60520 -13940 0 0 {name=p60173 lab=_53420_/A }
C {devices/lab_pin.sym} 60520 -13900 0 0 {name=p60174 lab=_53402_/B }
C {devices/lab_pin.sym} 60520 -13860 0 0 {name=p60175 lab=_53410_/C }
C {devices/lab_pin.sym} 60520 -13820 0 0 {name=p60176 lab=_51214_/D }
C {devices/lab_pin.sym} 60640 -13880 0 1 {name=p60177 lab=_53420_/X }
C {sky130_stdcells/and4_4.sym} 60580 -13880 0 0 {name=X_53420_ }
C {devices/lab_pin.sym} 60540 -13730 0 0 {name=p60178 lab=_44170_/A }
C {devices/lab_pin.sym} 60620 -13730 0 1 {name=p60179 lab=_65407_/A }
C {sky130_stdcells/buf_2.sym} 60580 -13730 0 0 {name=X_65406_ }
C {devices/lab_pin.sym} 60540 -13610 0 0 {name=p60180 lab=clkbuf_8_85_0_CLK/A }
C {devices/lab_pin.sym} 60620 -13610 0 1 {name=p60181 lab=clkbuf_8_85_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 60580 -13610 0 0 {name=Xclkbuf_8_85_0_CLK }
C {devices/lab_pin.sym} 60490 -13490 0 0 {name=p60182 lab=_82436_/CLK }
C {devices/lab_pin.sym} 60490 -13470 0 0 {name=p60183 lab=_84240_/D }
C {devices/lab_pin.sym} 60670 -13490 0 1 {name=p60184 lab=_84240_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -13480 0 0 {name=X_84240_ }
C {devices/lab_pin.sym} 60520 -13360 0 0 {name=p60185 lab=_50627_/X }
C {devices/lab_pin.sym} 60520 -13320 0 0 {name=p60186 lab=_49025_/X }
C {devices/lab_pin.sym} 60640 -13340 0 1 {name=p60187 lab=_50632_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -13340 0 0 {name=X_50632_ }
C {devices/lab_pin.sym} 60520 -13240 0 0 {name=p60188 lab=_62269_/X }
C {devices/lab_pin.sym} 60520 -13200 0 0 {name=p60189 lab=_58210_/X }
C {devices/lab_pin.sym} 60520 -13160 0 0 {name=p60190 lab=_62618_/C }
C {devices/lab_pin.sym} 60520 -13120 0 0 {name=p60191 lab=_62618_/D }
C {devices/lab_pin.sym} 60640 -13180 0 1 {name=p60192 lab=_62618_/X }
C {sky130_stdcells/and4_4.sym} 60580 -13180 0 0 {name=X_62618_ }
C {devices/lab_pin.sym} 60490 -13030 0 0 {name=p60193 lab=_81433_/CLK }
C {devices/lab_pin.sym} 60490 -13010 0 0 {name=p60194 lab=_76745_/B }
C {devices/lab_pin.sym} 60670 -13030 0 1 {name=p60195 lab=_81452_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -13020 0 0 {name=X_81452_ }
C {devices/lab_pin.sym} 60500 -12920 0 0 {name=p60196 lab=_69146_/X }
C {devices/lab_pin.sym} 60500 -12880 0 0 {name=p60197 lab=_69109_/X }
C {devices/lab_pin.sym} 60500 -12840 0 0 {name=p60198 lab=_69172_/Y }
C {devices/lab_pin.sym} 60500 -12800 0 0 {name=p60199 lab=_69173_/Y }
C {devices/lab_pin.sym} 60660 -12860 0 1 {name=p60200 lab=_69174_/X }
C {sky130_stdcells/a211o_4.sym} 60580 -12860 0 0 {name=X_69174_ }
C {devices/lab_pin.sym} 60500 -12730 0 0 {name=p60201 lab=_66282_/X }
C {devices/lab_pin.sym} 60500 -12690 0 0 {name=p60202 lab=_65983_/Y }
C {devices/lab_pin.sym} 60500 -12650 0 0 {name=p60203 lab=_66385_/Y }
C {devices/lab_pin.sym} 60660 -12690 0 1 {name=p60204 lab=_66386_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -12690 0 0 {name=X_66386_ }
C {devices/lab_pin.sym} 60520 -12570 0 0 {name=p60205 lab=_63598_/A }
C {devices/lab_pin.sym} 60520 -12530 0 0 {name=p60206 lab=_63630_/B }
C {devices/lab_pin.sym} 60520 -12490 0 0 {name=p60207 lab=_63630_/C }
C {devices/lab_pin.sym} 60640 -12530 0 1 {name=p60208 lab=_63598_/Y }
C {sky130_stdcells/nor3_4.sym} 60580 -12530 0 0 {name=X_63598_ }
C {devices/lab_pin.sym} 60540 -12390 0 0 {name=p60209 lab=_80425_/A }
C {devices/lab_pin.sym} 60620 -12390 0 1 {name=p60210 lab=_80409_/A }
C {sky130_stdcells/inv_2.sym} 60580 -12390 0 0 {name=X_80403_ }
C {devices/lab_pin.sym} 60500 -12290 0 0 {name=p60211 lab=_66800_/X }
C {devices/lab_pin.sym} 60500 -12250 0 0 {name=p60212 lab=_66803_/X }
C {devices/lab_pin.sym} 60500 -12210 0 0 {name=p60213 lab=_68106_/X }
C {devices/lab_pin.sym} 60660 -12250 0 1 {name=p60214 lab=_68125_/Y }
C {sky130_stdcells/a21oi_4.sym} 60580 -12250 0 0 {name=X_68125_ }
C {devices/lab_pin.sym} 60540 -12110 0 0 {name=p60215 lab=_53351_/A }
C {devices/lab_pin.sym} 60620 -12110 0 1 {name=p60216 lab=_53351_/X }
C {sky130_stdcells/buf_2.sym} 60580 -12110 0 0 {name=X_53351_ }
C {devices/lab_pin.sym} 60520 -12000 0 0 {name=p60217 lab=_65285_/A }
C {devices/lab_pin.sym} 60520 -11960 0 0 {name=p60218 lab=_65337_/B }
C {devices/lab_pin.sym} 60640 -11980 0 1 {name=p60219 lab=_65337_/X }
C {sky130_stdcells/and2_4.sym} 60580 -11980 0 0 {name=X_65337_ }
C {devices/lab_pin.sym} 60490 -11850 0 0 {name=p60220 lab=_81233_/CLK }
C {devices/lab_pin.sym} 60490 -11830 0 0 {name=p60221 lab=_84171_/D }
C {devices/lab_pin.sym} 60670 -11850 0 1 {name=p60222 lab=_84171_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -11840 0 0 {name=X_84171_ }
C {devices/lab_pin.sym} 60540 -11710 0 0 {name=p60223 lab=_50506_/A }
C {devices/lab_pin.sym} 60620 -11710 0 1 {name=p60224 lab=_50563_/X }
C {sky130_stdcells/buf_2.sym} 60580 -11710 0 0 {name=X_50563_ }
C {devices/lab_pin.sym} 60520 -11610 0 0 {name=p60225 lab=_62549_/A }
C {devices/lab_pin.sym} 60520 -11570 0 0 {name=p60226 lab=_62561_/B }
C {devices/lab_pin.sym} 60520 -11530 0 0 {name=p60227 lab=_62548_/Y }
C {devices/lab_pin.sym} 60640 -11570 0 1 {name=p60228 lab=_62549_/Y }
C {sky130_stdcells/nand3_4.sym} 60580 -11570 0 0 {name=X_62549_ }
C {devices/lab_pin.sym} 60490 -11430 0 0 {name=p60229 lab=_83918_/CLK }
C {devices/lab_pin.sym} 60490 -11410 0 0 {name=p60230 lab=_81383_/D }
C {devices/lab_pin.sym} 60670 -11430 0 1 {name=p60231 lab=_76840_/B }
C {sky130_stdcells/dfxtp_4.sym} 60580 -11420 0 0 {name=X_81383_ }
C {devices/lab_pin.sym} 60540 -11290 0 0 {name=p60232 lab=_71216_/A }
C {devices/lab_pin.sym} 60620 -11290 0 1 {name=p60233 lab=_71231_/A2 }
C {sky130_stdcells/buf_2.sym} 60580 -11290 0 0 {name=Xpsn_inst_psn_buff_8 }
C {devices/lab_pin.sym} 60500 -11190 0 0 {name=p60234 lab=_52300_/Y }
C {devices/lab_pin.sym} 60500 -11150 0 0 {name=p60235 lab=_52289_/X }
C {devices/lab_pin.sym} 60500 -11110 0 0 {name=p60236 lab=_52301_/X }
C {devices/lab_pin.sym} 60660 -11150 0 1 {name=p60237 lab=_52302_/Y }
C {sky130_stdcells/a21oi_4.sym} 60580 -11150 0 0 {name=X_52302_ }
C {devices/lab_pin.sym} 60490 -11010 0 0 {name=p60238 lab=_86213_/CLK }
C {devices/lab_pin.sym} 60490 -10990 0 0 {name=p60239 lab=_83122_/D }
C {devices/lab_pin.sym} 60670 -11010 0 1 {name=p60240 lab=_83122_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -11000 0 0 {name=X_83122_ }
C {devices/lab_pin.sym} 60520 -10880 0 0 {name=p60241 lab=_80331_/Y }
C {devices/lab_pin.sym} 60520 -10840 0 0 {name=p60242 lab=_80333_/Y }
C {devices/lab_pin.sym} 60640 -10860 0 1 {name=p60243 lab=_80334_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -10860 0 0 {name=X_80334_ }
C {devices/lab_pin.sym} 60540 -10730 0 0 {name=p60244 lab=_56069_/Y }
C {devices/lab_pin.sym} 60620 -10730 0 1 {name=p60245 lab=_56070_/X }
C {sky130_stdcells/buf_2.sym} 60580 -10730 0 0 {name=X_56070_ }
C {devices/lab_pin.sym} 60500 -10630 0 0 {name=p60246 lab=_68052_/X }
C {devices/lab_pin.sym} 60500 -10590 0 0 {name=p60247 lab=_68055_/X }
C {devices/lab_pin.sym} 60500 -10550 0 0 {name=p60248 lab=_68033_/X }
C {devices/lab_pin.sym} 60660 -10590 0 1 {name=p60249 lab=_68056_/X }
C {sky130_stdcells/a21o_4.sym} 60580 -10590 0 0 {name=X_68056_ }
C {devices/lab_pin.sym} 60540 -10450 0 0 {name=p60250 lab=_53282_/A }
C {devices/lab_pin.sym} 60620 -10450 0 1 {name=p60251 lab=_53311_/A }
C {sky130_stdcells/buf_2.sym} 60580 -10450 0 0 {name=X_53282_ }
C {devices/lab_pin.sym} 60520 -10350 0 0 {name=p60252 lab=_65268_/A }
C {devices/lab_pin.sym} 60520 -10310 0 0 {name=p60253 lab=_65268_/B }
C {devices/lab_pin.sym} 60520 -10270 0 0 {name=p60254 lab=_65268_/C }
C {devices/lab_pin.sym} 60640 -10310 0 1 {name=p60255 lab=_65268_/X }
C {sky130_stdcells/and3_4.sym} 60580 -10310 0 0 {name=X_65268_ }
C {devices/lab_pin.sym} 60520 -10180 0 0 {name=p60256 lab=_50465_/X }
C {devices/lab_pin.sym} 60520 -10140 0 0 {name=p60257 lab=_48816_/B }
C {devices/lab_pin.sym} 60640 -10160 0 1 {name=p60258 lab=_50494_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -10160 0 0 {name=X_50494_ }
C {devices/lab_pin.sym} 60540 -10030 0 0 {name=p60259 lab=_54250_/A }
C {devices/lab_pin.sym} 60620 -10030 0 1 {name=p60260 lab=_55037_/A }
C {sky130_stdcells/buf_2.sym} 60580 -10030 0 0 {name=X_55021_ }
C {devices/lab_pin.sym} 60500 -9940 0 0 {name=p60261 lab=_87937_/Q }
C {devices/lab_pin.sym} 60500 -9900 0 0 {name=p60262 lab=_66935_/X }
C {devices/lab_pin.sym} 60500 -9860 0 0 {name=p60263 lab=_66911_/X }
C {devices/lab_pin.sym} 60500 -9820 0 0 {name=p60264 lab=_67006_/X }
C {devices/lab_pin.sym} 60660 -9880 0 1 {name=p60265 lab=_67007_/X }
C {sky130_stdcells/a211o_4.sym} 60580 -9880 0 0 {name=X_67007_ }
C {devices/lab_pin.sym} 60520 -9750 0 0 {name=p60266 lab=_48849_/A }
C {devices/lab_pin.sym} 60520 -9710 0 0 {name=p60267 lab=_52248_/B }
C {devices/lab_pin.sym} 60520 -9670 0 0 {name=p60268 lab=_52223_/C }
C {devices/lab_pin.sym} 60640 -9710 0 1 {name=p60269 lab=_52233_/X }
C {sky130_stdcells/and3_4.sym} 60580 -9710 0 0 {name=X_52233_ }
C {devices/lab_pin.sym} 60520 -9580 0 0 {name=p60270 lab=_63380_/A }
C {devices/lab_pin.sym} 60520 -9540 0 0 {name=p60271 lab=_64219_/B }
C {devices/lab_pin.sym} 60640 -9560 0 1 {name=p60272 lab=_64219_/Y }
C {sky130_stdcells/nor2_4.sym} 60580 -9560 0 0 {name=X_64219_ }
C {devices/lab_pin.sym} 60490 -9430 0 0 {name=p60273 lab=_83310_/CLK }
C {devices/lab_pin.sym} 60490 -9410 0 0 {name=p60274 lab=_74502_/Y }
C {devices/lab_pin.sym} 60670 -9430 0 1 {name=p60275 lab=_83053_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -9420 0 0 {name=X_83053_ }
C {devices/lab_pin.sym} 60490 -9290 0 0 {name=p60276 lab=_87110_/CLK }
C {devices/lab_pin.sym} 60490 -9270 0 0 {name=p60277 lab=_87930_/D }
C {devices/lab_pin.sym} 60670 -9290 0 1 {name=p60278 lab=_87930_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -9280 0 0 {name=X_87930_ }
C {devices/lab_pin.sym} 60540 -9150 0 0 {name=p60279 lab=_80268_/B }
C {devices/lab_pin.sym} 60620 -9150 0 1 {name=p60280 lab=_80265_/Y }
C {sky130_stdcells/inv_2.sym} 60580 -9150 0 0 {name=X_80265_ }
C {devices/lab_pin.sym} 60540 -9030 0 0 {name=p60281 lab=_64666_/A }
C {devices/lab_pin.sym} 60620 -9030 0 1 {name=p60282 lab=_65199_/X }
C {sky130_stdcells/buf_2.sym} 60580 -9030 0 0 {name=X_65199_ }
C {devices/lab_pin.sym} 60490 -8910 0 0 {name=p60283 lab=_82008_/CLK }
C {devices/lab_pin.sym} 60490 -8890 0 0 {name=p60284 lab=_82036_/Q }
C {devices/lab_pin.sym} 60670 -8910 0 1 {name=p60285 lab=_77143_/B }
C {sky130_stdcells/dfxtp_4.sym} 60580 -8900 0 0 {name=X_82004_ }
C {devices/lab_pin.sym} 60500 -8790 0 0 {name=p60286 lab=_85876_/Q }
C {devices/lab_pin.sym} 60500 -8750 0 0 {name=p60287 lab=_52152_/X }
C {devices/lab_pin.sym} 60500 -8710 0 0 {name=p60288 lab=_52163_/Y }
C {devices/lab_pin.sym} 60660 -8750 0 1 {name=p60289 lab=_52164_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -8750 0 0 {name=X_52164_ }
C {devices/lab_pin.sym} 60490 -8610 0 0 {name=p60290 lab=_87348_/CLK }
C {devices/lab_pin.sym} 60490 -8590 0 0 {name=p60291 lab=_87861_/D }
C {devices/lab_pin.sym} 60670 -8610 0 1 {name=p60292 lab=_87861_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -8600 0 0 {name=X_87861_ }
C {devices/lab_pin.sym} 60520 -8480 0 0 {name=p60293 lab=_80196_/A }
C {devices/lab_pin.sym} 60520 -8440 0 0 {name=p60294 lab=_80195_/X }
C {devices/lab_pin.sym} 60640 -8460 0 1 {name=p60295 lab=_80209_/B }
C {sky130_stdcells/xnor2_4.sym} 60580 -8460 0 0 {name=X_80196_ }
C {devices/lab_pin.sym} 60520 -8360 0 0 {name=p60296 lab=_51115_/A }
C {devices/lab_pin.sym} 60520 -8320 0 0 {name=p60297 lab=_51115_/B }
C {devices/lab_pin.sym} 60520 -8280 0 0 {name=p60298 lab=_51115_/C }
C {devices/lab_pin.sym} 60520 -8240 0 0 {name=p60299 lab=_52805_/D }
C {devices/lab_pin.sym} 60640 -8300 0 1 {name=p60300 lab=_51115_/X }
C {sky130_stdcells/and4_4.sym} 60580 -8300 0 0 {name=X_51115_ }
C {devices/lab_pin.sym} 60490 -8150 0 0 {name=p60301 lab=_81182_/CLK }
C {devices/lab_pin.sym} 60490 -8130 0 0 {name=p60302 lab=_86812_/D }
C {devices/lab_pin.sym} 60670 -8150 0 1 {name=p60303 lab=_67201_/B }
C {sky130_stdcells/dfxtp_4.sym} 60580 -8140 0 0 {name=X_86812_ }
C {devices/lab_pin.sym} 60540 -8010 0 0 {name=p60304 lab=clkbuf_8_23_0_CLK/A }
C {devices/lab_pin.sym} 60620 -8010 0 1 {name=p60305 lab=clkbuf_9_47_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 60580 -8010 0 0 {name=Xclkbuf_8_23_0_CLK }
C {devices/lab_pin.sym} 60540 -7890 0 0 {name=p60306 lab=_59699_/A }
C {devices/lab_pin.sym} 60620 -7890 0 1 {name=p60307 lab=_59761_/B }
C {sky130_stdcells/buf_2.sym} 60580 -7890 0 0 {name=X_59760_ }
C {devices/lab_pin.sym} 60520 -7780 0 0 {name=p60308 lab=_52100_/A }
C {devices/lab_pin.sym} 60520 -7740 0 0 {name=p60309 lab=_48358_/X }
C {devices/lab_pin.sym} 60640 -7760 0 1 {name=p60310 lab=_52095_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -7760 0 0 {name=X_52095_ }
C {devices/lab_pin.sym} 60520 -7640 0 0 {name=p60311 lab=_56972_/A }
C {devices/lab_pin.sym} 60520 -7600 0 0 {name=p60312 lab=_56650_/Y }
C {devices/lab_pin.sym} 60640 -7620 0 1 {name=p60313 lab=_56972_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -7620 0 0 {name=X_56972_ }
C {devices/lab_pin.sym} 60540 -7490 0 0 {name=p60314 lab=_68384_/A }
C {devices/lab_pin.sym} 60620 -7490 0 1 {name=p60315 lab=_68958_/X }
C {sky130_stdcells/buf_2.sym} 60580 -7490 0 0 {name=X_68958_ }
C {devices/lab_pin.sym} 60490 -7370 0 0 {name=p60316 lab=_88084_/CLK }
C {devices/lab_pin.sym} 60490 -7350 0 0 {name=p60317 lab=_42640_/X }
C {devices/lab_pin.sym} 60670 -7370 0 1 {name=p60318 lab=_69176_/B }
C {sky130_stdcells/dfxtp_4.sym} 60580 -7360 0 0 {name=X_87792_ }
C {devices/lab_pin.sym} 60540 -7230 0 0 {name=p60319 lab=_84805_/Q }
C {devices/lab_pin.sym} 60620 -7230 0 1 {name=p60320 lab=_58711_/Y }
C {sky130_stdcells/inv_2.sym} 60580 -7230 0 0 {name=X_58711_ }
C {devices/lab_pin.sym} 60500 -7130 0 0 {name=p60321 lab=_51044_/Y }
C {devices/lab_pin.sym} 60500 -7090 0 0 {name=p60322 lab=_51039_/X }
C {devices/lab_pin.sym} 60500 -7050 0 0 {name=p60323 lab=_51045_/X }
C {devices/lab_pin.sym} 60660 -7090 0 1 {name=p60324 lab=_51046_/Y }
C {sky130_stdcells/a21oi_4.sym} 60580 -7090 0 0 {name=X_51046_ }
C {devices/lab_pin.sym} 60500 -6970 0 0 {name=p60325 lab=_55920_/X }
C {devices/lab_pin.sym} 60500 -6930 0 0 {name=p60326 lab=_55922_/X }
C {devices/lab_pin.sym} 60500 -6890 0 0 {name=p60327 lab=_44118_/B }
C {devices/lab_pin.sym} 60660 -6930 0 1 {name=p60328 lab=_55926_/A }
C {sky130_stdcells/a21o_4.sym} 60580 -6930 0 0 {name=X_55923_ }
C {devices/lab_pin.sym} 60520 -6800 0 0 {name=p60329 lab=_67909_/A }
C {devices/lab_pin.sym} 60520 -6760 0 0 {name=p60330 lab=_67909_/B }
C {devices/lab_pin.sym} 60640 -6780 0 1 {name=p60331 lab=_67909_/X }
C {sky130_stdcells/and2_4.sym} 60580 -6780 0 0 {name=X_67909_ }
C {devices/lab_pin.sym} 60490 -6650 0 0 {name=p60332 lab=_85527_/CLK }
C {devices/lab_pin.sym} 60490 -6630 0 0 {name=p60333 lab=_46375_/Y }
C {devices/lab_pin.sym} 60670 -6650 0 1 {name=p60334 lab=_86743_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -6640 0 0 {name=X_86743_ }
C {devices/lab_pin.sym} 60540 -6510 0 0 {name=p60335 lab=_59816_/A }
C {devices/lab_pin.sym} 60620 -6510 0 1 {name=p60336 lab=_59691_/X }
C {sky130_stdcells/buf_2.sym} 60580 -6510 0 0 {name=X_59691_ }
C {devices/lab_pin.sym} 60490 -6390 0 0 {name=p60337 lab=_83957_/CLK }
C {devices/lab_pin.sym} 60490 -6370 0 0 {name=p60338 lab=_68928_/X }
C {devices/lab_pin.sym} 60670 -6390 0 1 {name=p60339 lab=_83955_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -6380 0 0 {name=X_83955_ }
C {devices/lab_pin.sym} 60500 -6280 0 0 {name=p60340 lab=_74053_/A }
C {devices/lab_pin.sym} 60500 -6240 0 0 {name=p60341 lab=_68493_/X }
C {devices/lab_pin.sym} 60500 -6200 0 0 {name=p60342 lab=_68494_/X }
C {devices/lab_pin.sym} 60500 -6160 0 0 {name=p60343 lab=_68888_/Y }
C {devices/lab_pin.sym} 60660 -6220 0 1 {name=p60344 lab=_68889_/X }
C {sky130_stdcells/a211o_4.sym} 60580 -6220 0 0 {name=X_68889_ }
C {devices/lab_pin.sym} 60500 -6090 0 0 {name=p60345 lab=_51026_/B }
C {devices/lab_pin.sym} 60500 -6050 0 0 {name=p60346 lab=_70909_/X }
C {devices/lab_pin.sym} 60500 -6010 0 0 {name=p60347 lab=_70919_/Y }
C {devices/lab_pin.sym} 60660 -6050 0 1 {name=p60348 lab=_83663_/D }
C {sky130_stdcells/o21ai_4.sym} 60580 -6050 0 0 {name=X_70920_ }
C {devices/lab_pin.sym} 60500 -5930 0 0 {name=p60349 lab=_58641_/X }
C {devices/lab_pin.sym} 60500 -5890 0 0 {name=p60350 lab=_85947_/Q }
C {devices/lab_pin.sym} 60500 -5850 0 0 {name=p60351 lab=_58109_/X }
C {devices/lab_pin.sym} 60660 -5890 0 1 {name=p60352 lab=_58642_/X }
C {sky130_stdcells/o21a_4.sym} 60580 -5890 0 0 {name=X_58642_ }
C {devices/lab_pin.sym} 60490 -5750 0 0 {name=p60353 lab=_82906_/CLK }
C {devices/lab_pin.sym} 60490 -5730 0 0 {name=p60354 lab=_78257_/B }
C {devices/lab_pin.sym} 60670 -5750 0 1 {name=p60355 lab=_41319_/B }
C {sky130_stdcells/dfxtp_4.sym} 60580 -5740 0 0 {name=X_82906_ }
C {devices/lab_pin.sym} 60540 -5610 0 0 {name=p60356 lab=_55853_/X }
C {devices/lab_pin.sym} 60620 -5610 0 1 {name=p60357 lab=_55854_/X }
C {sky130_stdcells/buf_2.sym} 60580 -5610 0 0 {name=X_55854_ }
C {devices/lab_pin.sym} 60490 -5490 0 0 {name=p60358 lab=_86353_/CLK }
C {devices/lab_pin.sym} 60490 -5470 0 0 {name=p60359 lab=_47068_/Y }
C {devices/lab_pin.sym} 60670 -5490 0 1 {name=p60360 lab=_59189_/A }
C {sky130_stdcells/dfxtp_4.sym} 60580 -5480 0 0 {name=X_86674_ }
C {devices/lab_pin.sym} 60490 -5350 0 0 {name=p60361 lab=_82339_/CLK }
C {devices/lab_pin.sym} 60490 -5330 0 0 {name=p60362 lab=_69928_/X }
C {devices/lab_pin.sym} 60670 -5350 0 1 {name=p60363 lab=_83886_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -5340 0 0 {name=X_83886_ }
C {devices/lab_pin.sym} 60540 -5210 0 0 {name=p60364 lab=clkbuf_8_39_0_CLK/A }
C {devices/lab_pin.sym} 60620 -5210 0 1 {name=p60365 lab=clkbuf_8_38_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 60580 -5210 0 0 {name=Xclkbuf_8_38_0_CLK }
C {devices/lab_pin.sym} 60520 -5100 0 0 {name=p60366 lab=_54790_/A }
C {devices/lab_pin.sym} 60520 -5060 0 0 {name=p60367 lab=_47552_/A }
C {devices/lab_pin.sym} 60640 -5080 0 1 {name=p60368 lab=_54805_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -5080 0 0 {name=X_54805_ }
C {devices/lab_pin.sym} 60490 -4950 0 0 {name=p60369 lab=_86235_/CLK }
C {devices/lab_pin.sym} 60490 -4930 0 0 {name=p60370 lab=_53500_/Y }
C {devices/lab_pin.sym} 60670 -4950 0 1 {name=p60371 lab=_85625_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -4940 0 0 {name=X_85625_ }
C {devices/lab_pin.sym} 60540 -4810 0 0 {name=p60372 lab=_70832_/A }
C {devices/lab_pin.sym} 60620 -4810 0 1 {name=p60373 lab=_70852_/C }
C {sky130_stdcells/buf_2.sym} 60580 -4810 0 0 {name=X_70851_ }
C {devices/lab_pin.sym} 60500 -4710 0 0 {name=p60374 lab=_58140_/X }
C {devices/lab_pin.sym} 60500 -4670 0 0 {name=p60375 lab=_86113_/Q }
C {devices/lab_pin.sym} 60500 -4630 0 0 {name=p60376 lab=_58572_/X }
C {devices/lab_pin.sym} 60660 -4670 0 1 {name=p60377 lab=_58573_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -4670 0 0 {name=X_58573_ }
C {devices/lab_pin.sym} 60490 -4530 0 0 {name=p60378 lab=_84177_/CLK }
C {devices/lab_pin.sym} 60490 -4510 0 0 {name=p60379 lab=_82837_/D }
C {devices/lab_pin.sym} 60670 -4530 0 1 {name=p60380 lab=_82837_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -4520 0 0 {name=X_82837_ }
C {devices/lab_pin.sym} 60520 -4400 0 0 {name=p60381 lab=_55794_/A }
C {devices/lab_pin.sym} 60520 -4360 0 0 {name=p60382 lab=_56523_/C }
C {devices/lab_pin.sym} 60640 -4380 0 1 {name=p60383 lab=_55785_/X }
C {sky130_stdcells/and2_4.sym} 60580 -4380 0 0 {name=X_55785_ }
C {devices/lab_pin.sym} 60520 -4280 0 0 {name=p60384 lab=_52997_/A }
C {devices/lab_pin.sym} 60520 -4240 0 0 {name=p60385 lab=_52997_/B }
C {devices/lab_pin.sym} 60520 -4200 0 0 {name=p60386 lab=_52997_/C }
C {devices/lab_pin.sym} 60520 -4160 0 0 {name=p60387 lab=_52997_/D }
C {devices/lab_pin.sym} 60640 -4220 0 1 {name=p60388 lab=_52997_/X }
C {sky130_stdcells/and4_4.sym} 60580 -4220 0 0 {name=X_52997_ }
C {devices/lab_pin.sym} 60500 -4090 0 0 {name=p60389 lab=_84986_/Q }
C {devices/lab_pin.sym} 60500 -4050 0 0 {name=p60390 lab=_47806_/X }
C {devices/lab_pin.sym} 60500 -4010 0 0 {name=p60391 lab=_57523_/Y }
C {devices/lab_pin.sym} 60660 -4050 0 1 {name=p60392 lab=_57524_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -4050 0 0 {name=X_57524_ }
C {devices/lab_pin.sym} 60490 -3910 0 0 {name=p60393 lab=_88345_/CLK }
C {devices/lab_pin.sym} 60490 -3890 0 0 {name=p60394 lab=_40740_/X }
C {devices/lab_pin.sym} 60670 -3910 0 1 {name=p60395 lab=_88344_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -3900 0 0 {name=X_88344_ }
C {devices/lab_pin.sym} 60520 -3780 0 0 {name=p60396 lab=_54731_/X }
C {devices/lab_pin.sym} 60520 -3740 0 0 {name=p60397 lab=_47431_/Y }
C {devices/lab_pin.sym} 60640 -3760 0 1 {name=p60398 lab=_54736_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -3760 0 0 {name=X_54736_ }
C {devices/lab_pin.sym} 60540 -3630 0 0 {name=p60399 lab=_42700_/A }
C {devices/lab_pin.sym} 60620 -3630 0 1 {name=p60400 lab=_42750_/X }
C {sky130_stdcells/buf_2.sym} 60580 -3630 0 0 {name=X_42750_ }
C {devices/lab_pin.sym} 60520 -3520 0 0 {name=p60401 lab=_73570_/A }
C {devices/lab_pin.sym} 60520 -3480 0 0 {name=p60402 lab=_73569_/X }
C {devices/lab_pin.sym} 60640 -3500 0 1 {name=p60403 lab=_73570_/Y }
C {sky130_stdcells/nand2_4.sym} 60580 -3500 0 0 {name=X_73570_ }
C {devices/lab_pin.sym} 60490 -3370 0 0 {name=p60404 lab=_85556_/CLK }
C {devices/lab_pin.sym} 60490 -3350 0 0 {name=p60405 lab=_85556_/D }
C {devices/lab_pin.sym} 60670 -3370 0 1 {name=p60406 lab=_85556_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -3360 0 0 {name=X_85556_ }
C {devices/lab_pin.sym} 60500 -3250 0 0 {name=p60407 lab=_73636_/B }
C {devices/lab_pin.sym} 60500 -3210 0 0 {name=p60408 lab=_51945_/X }
C {devices/lab_pin.sym} 60500 -3170 0 0 {name=p60409 lab=_51947_/Y }
C {devices/lab_pin.sym} 60660 -3210 0 1 {name=p60410 lab=_51948_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -3210 0 0 {name=X_51948_ }
C {devices/lab_pin.sym} 60540 -3070 0 0 {name=p60411 lab=_70782_/A }
C {devices/lab_pin.sym} 60620 -3070 0 1 {name=p60412 lab=_70871_/A }
C {sky130_stdcells/buf_2.sym} 60580 -3070 0 0 {name=X_70782_ }
C {devices/lab_pin.sym} 60490 -2950 0 0 {name=p60413 lab=_82768_/CLK }
C {devices/lab_pin.sym} 60490 -2930 0 0 {name=p60414 lab=_82768_/D }
C {devices/lab_pin.sym} 60670 -2950 0 1 {name=p60415 lab=_82960_/D }
C {sky130_stdcells/dfxtp_4.sym} 60580 -2940 0 0 {name=X_82768_ }
C {devices/lab_pin.sym} 60540 -2810 0 0 {name=p60416 lab=_41700_/Y }
C {devices/lab_pin.sym} 60620 -2810 0 1 {name=p60417 lab=_41701_/X }
C {sky130_stdcells/buf_2.sym} 60580 -2810 0 0 {name=X_41701_ }
C {devices/lab_pin.sym} 60500 -2720 0 0 {name=p60418 lab=_79502_/B }
C {devices/lab_pin.sym} 60500 -2680 0 0 {name=p60419 lab=_61252_/X }
C {devices/lab_pin.sym} 60500 -2640 0 0 {name=p60420 lab=_72517_/Y }
C {devices/lab_pin.sym} 60500 -2600 0 0 {name=p60421 lab=_72520_/X }
C {devices/lab_pin.sym} 60660 -2660 0 1 {name=p60422 lab=_72521_/X }
C {sky130_stdcells/o22a_4.sym} 60580 -2660 0 0 {name=X_72521_ }
C {devices/lab_pin.sym} 60490 -2510 0 0 {name=p60423 lab=_84507_/CLK }
C {devices/lab_pin.sym} 60490 -2490 0 0 {name=p60424 lab=_84507_/D }
C {devices/lab_pin.sym} 60670 -2510 0 1 {name=p60425 lab=_75909_/A }
C {sky130_stdcells/dfxtp_4.sym} 60580 -2500 0 0 {name=X_84507_ }
C {devices/lab_pin.sym} 60490 -2370 0 0 {name=p60426 lab=_81532_/CLK }
C {devices/lab_pin.sym} 60490 -2350 0 0 {name=p60427 lab=_81719_/D }
C {devices/lab_pin.sym} 60670 -2370 0 1 {name=p60428 lab=_40984_/B }
C {sky130_stdcells/dfxtp_4.sym} 60580 -2360 0 0 {name=X_81719_ }
C {devices/lab_pin.sym} 60520 -2250 0 0 {name=p60429 lab=_57331_/A }
C {devices/lab_pin.sym} 60520 -2210 0 0 {name=p60430 lab=_57470_/B }
C {devices/lab_pin.sym} 60520 -2170 0 0 {name=p60431 lab=_57331_/C }
C {devices/lab_pin.sym} 60640 -2210 0 1 {name=p60432 lab=_57455_/Y }
C {sky130_stdcells/nand3_4.sym} 60580 -2210 0 0 {name=X_57455_ }
C {devices/lab_pin.sym} 60490 -2070 0 0 {name=p60433 lab=_88263_/CLK }
C {devices/lab_pin.sym} 60490 -2050 0 0 {name=p60434 lab=_88275_/D }
C {devices/lab_pin.sym} 60670 -2070 0 1 {name=p60435 lab=_88275_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -2060 0 0 {name=X_88275_ }
C {devices/lab_pin.sym} 60540 -1930 0 0 {name=p60436 lab=_42681_/A }
C {devices/lab_pin.sym} 60620 -1930 0 1 {name=p60437 lab=_42681_/X }
C {sky130_stdcells/buf_2.sym} 60580 -1930 0 0 {name=X_42681_ }
C {devices/lab_pin.sym} 60520 -1840 0 0 {name=p60438 lab=_54667_/A }
C {devices/lab_pin.sym} 60520 -1800 0 0 {name=p60439 lab=_54674_/B }
C {devices/lab_pin.sym} 60520 -1760 0 0 {name=p60440 lab=_54644_/X }
C {devices/lab_pin.sym} 60520 -1720 0 0 {name=p60441 lab=_47310_/A }
C {devices/lab_pin.sym} 60640 -1780 0 1 {name=p60442 lab=_54667_/X }
C {sky130_stdcells/and4_4.sym} 60580 -1780 0 0 {name=X_54667_ }
C {devices/lab_pin.sym} 60490 -1630 0 0 {name=p60443 lab=_83736_/CLK }
C {devices/lab_pin.sym} 60490 -1610 0 0 {name=p60444 lab=_54192_/Y }
C {devices/lab_pin.sym} 60670 -1630 0 1 {name=p60445 lab=_85487_/Q }
C {sky130_stdcells/dfxtp_4.sym} 60580 -1620 0 0 {name=X_85487_ }
C {devices/lab_pin.sym} 60500 -1510 0 0 {name=p60446 lab=_51876_/Y }
C {devices/lab_pin.sym} 60500 -1470 0 0 {name=p60447 lab=_51877_/X }
C {devices/lab_pin.sym} 60500 -1430 0 0 {name=p60448 lab=_51878_/X }
C {devices/lab_pin.sym} 60660 -1470 0 1 {name=p60449 lab=_85930_/D }
C {sky130_stdcells/a21oi_4.sym} 60580 -1470 0 0 {name=X_51879_ }
C {devices/lab_pin.sym} 60490 -1330 0 0 {name=p60450 lab=_84111_/CLK }
C {devices/lab_pin.sym} 60490 -1310 0 0 {name=p60451 lab=_82699_/D }
C {devices/lab_pin.sym} 60670 -1330 0 1 {name=p60452 lab=_82687_/D }
C {sky130_stdcells/dfxtp_4.sym} 60580 -1320 0 0 {name=X_82699_ }
C {devices/lab_pin.sym} 60500 -1220 0 0 {name=p60453 lab=_41556_/X }
C {devices/lab_pin.sym} 60500 -1180 0 0 {name=p60454 lab=_44412_/X }
C {devices/lab_pin.sym} 60500 -1140 0 0 {name=p60455 lab=_87117_/Q }
C {devices/lab_pin.sym} 60500 -1100 0 0 {name=p60456 lab=_44413_/X }
C {devices/lab_pin.sym} 60660 -1160 0 1 {name=p60457 lab=_44420_/X }
C {sky130_stdcells/a2bb2o_4.sym} 60580 -1160 0 0 {name=X_44420_ }
C {devices/lab_pin.sym} 60500 -1030 0 0 {name=p60458 lab=_56064_/X }
C {devices/lab_pin.sym} 60500 -990 0 0 {name=p60459 lab=_56394_/X }
C {devices/lab_pin.sym} 60500 -950 0 0 {name=p60460 lab=_56405_/Y }
C {devices/lab_pin.sym} 60660 -990 0 1 {name=p60461 lab=_56406_/Y }
C {sky130_stdcells/o21ai_4.sym} 60580 -990 0 0 {name=X_56406_ }
C {devices/lab_pin.sym} 60520 -860 0 0 {name=p60462 lab=_75240_/A }
C {devices/lab_pin.sym} 60520 -820 0 0 {name=p60463 lab=_75251_/A }
C {devices/lab_pin.sym} 60640 -840 0 1 {name=p60464 lab=_75240_/X }
C {sky130_stdcells/xor2_4.sym} 60580 -840 0 0 {name=X_75240_ }
C {devices/lab_pin.sym} 60500 -750 0 0 {name=p60465 lab=_41611_/X }
C {devices/lab_pin.sym} 60500 -710 0 0 {name=p60466 lab=_41613_/X }
C {devices/lab_pin.sym} 60500 -670 0 0 {name=p60467 lab=_41631_/X }
C {devices/lab_pin.sym} 60500 -630 0 0 {name=p60468 lab=_67349_/B }
C {devices/lab_pin.sym} 60500 -590 0 0 {name=p60469 lab=_41608_/X }
C {devices/lab_pin.sym} 60660 -670 0 1 {name=p60470 lab=_41632_/Y }
C {sky130_stdcells/o32ai_4.sym} 60580 -670 0 0 {name=X_41632_ }
C {devices/lab_pin.sym} 61410 -42150 0 0 {name=p60471 lab=_88002_/CLK }
C {devices/lab_pin.sym} 61410 -42130 0 0 {name=p60472 lab=_43871_/X }
C {devices/lab_pin.sym} 61590 -42150 0 1 {name=p60473 lab=_68980_/B }
C {sky130_stdcells/dfxtp_4.sym} 61500 -42140 0 0 {name=X_87226_ }
C {devices/lab_pin.sym} 61460 -42010 0 0 {name=p60474 lab=_53798_/A }
C {devices/lab_pin.sym} 61540 -42010 0 1 {name=p60475 lab=_53747_/A }
C {sky130_stdcells/buf_2.sym} 61500 -42010 0 0 {name=X_53618_ }
C {devices/lab_pin.sym} 61420 -41910 0 0 {name=p60476 lab=_57697_/X }
C {devices/lab_pin.sym} 61420 -41870 0 0 {name=p60477 lab=_85957_/Q }
C {devices/lab_pin.sym} 61420 -41830 0 0 {name=p60478 lab=_72451_/X }
C {devices/lab_pin.sym} 61580 -41870 0 1 {name=p60479 lab=_72452_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -41870 0 0 {name=X_72452_ }
C {devices/lab_pin.sym} 61410 -41730 0 0 {name=p60480 lab=_84438_/CLK }
C {devices/lab_pin.sym} 61410 -41710 0 0 {name=p60481 lab=_62035_/Y }
C {devices/lab_pin.sym} 61590 -41730 0 1 {name=p60482 lab=_78061_/B }
C {sky130_stdcells/dfxtp_4.sym} 61500 -41720 0 0 {name=X_84438_ }
C {devices/lab_pin.sym} 61420 -41620 0 0 {name=p60483 lab=_57384_/X }
C {devices/lab_pin.sym} 61420 -41580 0 0 {name=p60484 lab=_56571_/X }
C {devices/lab_pin.sym} 61420 -41540 0 0 {name=p60485 lab=_85024_/Q }
C {devices/lab_pin.sym} 61420 -41500 0 0 {name=p60486 lab=_57385_/X }
C {devices/lab_pin.sym} 61580 -41560 0 1 {name=p60487 lab=_85024_/D }
C {sky130_stdcells/a2bb2o_4.sym} 61500 -41560 0 0 {name=X_57386_ }
C {devices/lab_pin.sym} 61440 -41440 0 0 {name=p60488 lab=_54589_/X }
C {devices/lab_pin.sym} 61440 -41400 0 0 {name=p60489 lab=_54585_/B }
C {devices/lab_pin.sym} 61440 -41360 0 0 {name=p60490 lab=_54591_/C }
C {devices/lab_pin.sym} 61440 -41320 0 0 {name=p60491 lab=_47189_/A }
C {devices/lab_pin.sym} 61560 -41380 0 1 {name=p60492 lab=_54598_/X }
C {sky130_stdcells/and4_4.sym} 61500 -41380 0 0 {name=X_54598_ }
C {devices/lab_pin.sym} 61420 -41250 0 0 {name=p60493 lab=_59073_/X }
C {devices/lab_pin.sym} 61420 -41210 0 0 {name=p60494 lab=_85751_/Q }
C {devices/lab_pin.sym} 61420 -41170 0 0 {name=p60495 lab=_59124_/X }
C {devices/lab_pin.sym} 61580 -41210 0 1 {name=p60496 lab=_59125_/X }
C {sky130_stdcells/o21a_4.sym} 61500 -41210 0 0 {name=X_59125_ }
C {devices/lab_pin.sym} 61460 -41070 0 0 {name=p60497 lab=_71342_/B }
C {devices/lab_pin.sym} 61540 -41070 0 1 {name=p60498 lab=_71411_/C }
C {sky130_stdcells/buf_2.sym} 61500 -41070 0 0 {name=X_71403_ }
C {devices/lab_pin.sym} 61460 -40950 0 0 {name=p60499 lab=_56350_/A }
C {devices/lab_pin.sym} 61540 -40950 0 1 {name=p60500 lab=_56337_/X }
C {sky130_stdcells/buf_2.sym} 61500 -40950 0 0 {name=X_56337_ }
C {devices/lab_pin.sym} 61460 -40830 0 0 {name=p60501 lab=_44382_/A }
C {devices/lab_pin.sym} 61540 -40830 0 1 {name=p60502 lab=_44351_/X }
C {sky130_stdcells/buf_2.sym} 61500 -40830 0 0 {name=X_44351_ }
C {devices/lab_pin.sym} 61460 -40710 0 0 {name=p60503 lab=_75175_/C }
C {devices/lab_pin.sym} 61540 -40710 0 1 {name=p60504 lab=_75171_/Y }
C {sky130_stdcells/inv_2.sym} 61500 -40710 0 0 {name=X_75171_ }
C {devices/lab_pin.sym} 61410 -40590 0 0 {name=p60505 lab=_87915_/CLK }
C {devices/lab_pin.sym} 61410 -40570 0 0 {name=p60506 lab=_44342_/Y }
C {devices/lab_pin.sym} 61590 -40590 0 1 {name=p60507 lab=_87157_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -40580 0 0 {name=X_87157_ }
C {devices/lab_pin.sym} 61440 -40460 0 0 {name=p60508 lab=_41563_/A }
C {devices/lab_pin.sym} 61440 -40420 0 0 {name=p60509 lab=_41563_/B }
C {devices/lab_pin.sym} 61560 -40440 0 1 {name=p60510 lab=_41563_/X }
C {sky130_stdcells/or2_4.sym} 61500 -40440 0 0 {name=X_41563_ }
C {devices/lab_pin.sym} 61460 -40310 0 0 {name=p60511 lab=_57696_/X }
C {devices/lab_pin.sym} 61540 -40310 0 1 {name=p60512 lab=_72428_/B }
C {sky130_stdcells/buf_2.sym} 61500 -40310 0 0 {name=X_72383_ }
C {devices/lab_pin.sym} 61420 -40210 0 0 {name=p60513 lab=_85615_/Q }
C {devices/lab_pin.sym} 61420 -40170 0 0 {name=p60514 lab=_53540_/X }
C {devices/lab_pin.sym} 61420 -40130 0 0 {name=p60515 lab=_53548_/Y }
C {devices/lab_pin.sym} 61580 -40170 0 1 {name=p60516 lab=_53549_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -40170 0 0 {name=X_53549_ }
C {devices/lab_pin.sym} 61410 -40030 0 0 {name=p60517 lab=_84449_/CLK }
C {devices/lab_pin.sym} 61410 -40010 0 0 {name=p60518 lab=_84369_/D }
C {devices/lab_pin.sym} 61590 -40030 0 1 {name=p60519 lab=_84369_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -40020 0 0 {name=X_84369_ }
C {devices/lab_pin.sym} 61460 -39890 0 0 {name=p60520 lab=_43302_/A }
C {devices/lab_pin.sym} 61540 -39890 0 1 {name=p60521 lab=_43302_/X }
C {sky130_stdcells/buf_2.sym} 61500 -39890 0 0 {name=X_43302_ }
C {devices/lab_pin.sym} 61420 -39800 0 0 {name=p60522 lab=_68956_/B }
C {devices/lab_pin.sym} 61420 -39760 0 0 {name=p60523 lab=_44235_/X }
C {devices/lab_pin.sym} 61420 -39720 0 0 {name=p60524 lab=_72725_/A }
C {devices/lab_pin.sym} 61420 -39680 0 0 {name=p60525 lab=_74121_/Y }
C {devices/lab_pin.sym} 61580 -39740 0 1 {name=p60526 lab=_74122_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -39740 0 0 {name=X_74122_ }
C {devices/lab_pin.sym} 61410 -39590 0 0 {name=p60527 lab=_85786_/CLK }
C {devices/lab_pin.sym} 61410 -39570 0 0 {name=p60528 lab=_50915_/Y }
C {devices/lab_pin.sym} 61590 -39590 0 1 {name=p60529 lab=_86108_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -39580 0 0 {name=X_86108_ }
C {devices/lab_pin.sym} 61420 -39470 0 0 {name=p60530 lab=_40512_/X }
C {devices/lab_pin.sym} 61420 -39430 0 0 {name=p60531 lab=_41584_/A }
C {devices/lab_pin.sym} 61420 -39390 0 0 {name=p60532 lab=_40513_/X }
C {devices/lab_pin.sym} 61580 -39430 0 1 {name=p60533 lab=_40514_/X }
C {sky130_stdcells/o21a_4.sym} 61500 -39430 0 0 {name=X_40514_ }
C {devices/lab_pin.sym} 61460 -39290 0 0 {name=p60534 lab=_53353_/B }
C {devices/lab_pin.sym} 61540 -39290 0 1 {name=p60535 lab=_52837_/B }
C {sky130_stdcells/buf_2.sym} 61500 -39290 0 0 {name=X_47070_ }
C {devices/lab_pin.sym} 61440 -39180 0 0 {name=p60536 lab=_59029_/A }
C {devices/lab_pin.sym} 61440 -39140 0 0 {name=p60537 lab=_86364_/Q }
C {devices/lab_pin.sym} 61560 -39160 0 1 {name=p60538 lab=_59056_/Y }
C {sky130_stdcells/nor2_4.sym} 61500 -39160 0 0 {name=X_59056_ }
C {devices/lab_pin.sym} 61420 -39050 0 0 {name=p60539 lab=_50378_/B }
C {devices/lab_pin.sym} 61420 -39010 0 0 {name=p60540 lab=_71320_/A }
C {devices/lab_pin.sym} 61420 -38970 0 0 {name=p60541 lab=_71333_/Y }
C {devices/lab_pin.sym} 61580 -39010 0 1 {name=p60542 lab=_71334_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -39010 0 0 {name=X_71334_ }
C {devices/lab_pin.sym} 61460 -38870 0 0 {name=p60543 lab=_44038_/X }
C {devices/lab_pin.sym} 61540 -38870 0 1 {name=p60544 lab=_44282_/X }
C {sky130_stdcells/buf_2.sym} 61500 -38870 0 0 {name=X_44282_ }
C {devices/lab_pin.sym} 61420 -38770 0 0 {name=p60545 lab=_56164_/X }
C {devices/lab_pin.sym} 61420 -38730 0 0 {name=p60546 lab=_56188_/X }
C {devices/lab_pin.sym} 61420 -38690 0 0 {name=p60547 lab=_56267_/Y }
C {devices/lab_pin.sym} 61580 -38730 0 1 {name=p60548 lab=_56268_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -38730 0 0 {name=X_56268_ }
C {devices/lab_pin.sym} 61420 -38630 0 0 {name=p60549 lab=_41489_/X }
C {devices/lab_pin.sym} 61420 -38590 0 0 {name=p60550 lab=_41490_/X }
C {devices/lab_pin.sym} 61420 -38550 0 0 {name=p60551 lab=_41493_/X }
C {devices/lab_pin.sym} 61420 -38510 0 0 {name=p60552 lab=_66718_/B }
C {devices/lab_pin.sym} 61420 -38470 0 0 {name=p60553 lab=_41474_/X }
C {devices/lab_pin.sym} 61580 -38550 0 1 {name=p60554 lab=_41494_/Y }
C {sky130_stdcells/o32ai_4.sym} 61500 -38550 0 0 {name=X_41494_ }
C {devices/lab_pin.sym} 61410 -38390 0 0 {name=p60555 lab=_88263_/CLK }
C {devices/lab_pin.sym} 61410 -38370 0 0 {name=p60556 lab=_87088_/D }
C {devices/lab_pin.sym} 61590 -38390 0 1 {name=p60557 lab=_87088_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -38380 0 0 {name=X_87088_ }
C {devices/lab_pin.sym} 61460 -38250 0 0 {name=p60558 lab=_46021_/A }
C {devices/lab_pin.sym} 61540 -38250 0 1 {name=p60559 lab=_46021_/Y }
C {sky130_stdcells/inv_2.sym} 61500 -38250 0 0 {name=X_46021_ }
C {devices/lab_pin.sym} 61460 -38130 0 0 {name=p60560 lab=_58007_/A }
C {devices/lab_pin.sym} 61540 -38130 0 1 {name=p60561 lab=_58007_/X }
C {sky130_stdcells/buf_2.sym} 61500 -38130 0 0 {name=X_58007_ }
C {devices/lab_pin.sym} 61420 -38050 0 0 {name=p60562 lab=_43226_/X }
C {devices/lab_pin.sym} 61420 -38010 0 0 {name=p60563 lab=_43229_/X }
C {devices/lab_pin.sym} 61420 -37970 0 0 {name=p60564 lab=_41009_/X }
C {devices/lab_pin.sym} 61420 -37930 0 0 {name=p60565 lab=_87526_/Q }
C {devices/lab_pin.sym} 61420 -37890 0 0 {name=p60566 lab=_43232_/X }
C {devices/lab_pin.sym} 61580 -37970 0 1 {name=p60567 lab=_43234_/A }
C {sky130_stdcells/o32ai_4.sym} 61500 -37970 0 0 {name=X_43233_ }
C {devices/lab_pin.sym} 61440 -37820 0 0 {name=p60568 lab=_55149_/A }
C {devices/lab_pin.sym} 61440 -37780 0 0 {name=p60569 lab=_55219_/B }
C {devices/lab_pin.sym} 61560 -37800 0 1 {name=p60570 lab=_55219_/X }
C {sky130_stdcells/and2_4.sym} 61500 -37800 0 0 {name=X_55219_ }
C {devices/lab_pin.sym} 61440 -37680 0 0 {name=p60571 lab=_74053_/A }
C {devices/lab_pin.sym} 61440 -37640 0 0 {name=p60572 lab=_72853_/X }
C {devices/lab_pin.sym} 61560 -37660 0 1 {name=p60573 lab=_74053_/Y }
C {sky130_stdcells/nor2_4.sym} 61500 -37660 0 0 {name=X_74053_ }
C {devices/lab_pin.sym} 61440 -37540 0 0 {name=p60574 lab=_78928_/Y }
C {devices/lab_pin.sym} 61440 -37500 0 0 {name=p60575 lab=_78930_/B }
C {devices/lab_pin.sym} 61560 -37520 0 1 {name=p60576 lab=_78938_/A }
C {sky130_stdcells/xor2_4.sym} 61500 -37520 0 0 {name=X_78930_ }
C {devices/lab_pin.sym} 61410 -37390 0 0 {name=p60577 lab=_85527_/CLK }
C {devices/lab_pin.sym} 61410 -37370 0 0 {name=p60578 lab=_86039_/D }
C {devices/lab_pin.sym} 61590 -37390 0 1 {name=p60579 lab=_64874_/B }
C {sky130_stdcells/dfxtp_4.sym} 61500 -37380 0 0 {name=X_86039_ }
C {devices/lab_pin.sym} 61420 -37270 0 0 {name=p60580 lab=_40429_/X }
C {devices/lab_pin.sym} 61420 -37230 0 0 {name=p60581 lab=_82324_/Q }
C {devices/lab_pin.sym} 61420 -37190 0 0 {name=p60582 lab=_40444_/X }
C {devices/lab_pin.sym} 61580 -37230 0 1 {name=p60583 lab=_40445_/X }
C {sky130_stdcells/o21a_4.sym} 61500 -37230 0 0 {name=X_40445_ }
C {devices/lab_pin.sym} 61460 -37090 0 0 {name=p60584 lab=_71264_/X }
C {devices/lab_pin.sym} 61540 -37090 0 1 {name=p60585 lab=_71265_/X }
C {sky130_stdcells/buf_2.sym} 61500 -37090 0 0 {name=X_71265_ }
C {devices/lab_pin.sym} 61420 -36990 0 0 {name=p60586 lab=_56188_/X }
C {devices/lab_pin.sym} 61420 -36950 0 0 {name=p60587 lab=_56016_/X }
C {devices/lab_pin.sym} 61420 -36910 0 0 {name=p60588 lab=_56198_/Y }
C {devices/lab_pin.sym} 61580 -36950 0 1 {name=p60589 lab=_85279_/D }
C {sky130_stdcells/o21ai_4.sym} 61500 -36950 0 0 {name=X_56199_ }
C {devices/lab_pin.sym} 61420 -36840 0 0 {name=p60590 lab=_43137_/Y }
C {devices/lab_pin.sym} 61420 -36800 0 0 {name=p60591 lab=_72830_/X }
C {devices/lab_pin.sym} 61420 -36760 0 0 {name=p60592 lab=_72799_/X }
C {devices/lab_pin.sym} 61420 -36720 0 0 {name=p60593 lab=_73003_/Y }
C {devices/lab_pin.sym} 61580 -36780 0 1 {name=p60594 lab=_73004_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -36780 0 0 {name=X_73004_ }
C {devices/lab_pin.sym} 61460 -36630 0 0 {name=p60595 lab=_70231_/A }
C {devices/lab_pin.sym} 61540 -36630 0 1 {name=p60596 lab=_70229_/A }
C {sky130_stdcells/buf_2.sym} 61500 -36630 0 0 {name=X_70216_ }
C {devices/lab_pin.sym} 61460 -36510 0 0 {name=p60597 lab=_43164_/A }
C {devices/lab_pin.sym} 61540 -36510 0 1 {name=p60598 lab=_43164_/Y }
C {sky130_stdcells/inv_2.sym} 61500 -36510 0 0 {name=X_43164_ }
C {devices/lab_pin.sym} 61440 -36400 0 0 {name=p60599 lab=_78866_/A }
C {devices/lab_pin.sym} 61440 -36360 0 0 {name=p60600 lab=_78860_/Y }
C {devices/lab_pin.sym} 61560 -36380 0 1 {name=p60601 lab=_78862_/B }
C {sky130_stdcells/xor2_4.sym} 61500 -36380 0 0 {name=X_78861_ }
C {devices/lab_pin.sym} 61420 -36290 0 0 {name=p60602 lab=_57491_/A }
C {devices/lab_pin.sym} 61420 -36250 0 0 {name=p60603 lab=_40364_/X }
C {devices/lab_pin.sym} 61420 -36210 0 0 {name=p60604 lab=_40371_/X }
C {devices/lab_pin.sym} 61420 -36170 0 0 {name=p60605 lab=_88401_/Q }
C {devices/lab_pin.sym} 61420 -36130 0 0 {name=p60606 lab=_40375_/X }
C {devices/lab_pin.sym} 61580 -36210 0 1 {name=p60607 lab=_40376_/Y }
C {sky130_stdcells/o32ai_4.sym} 61500 -36210 0 0 {name=X_40376_ }
C {devices/lab_pin.sym} 61460 -36050 0 0 {name=p60608 lab=_71196_/A }
C {devices/lab_pin.sym} 61540 -36050 0 1 {name=p60609 lab=_71197_/C }
C {sky130_stdcells/buf_2.sym} 61500 -36050 0 0 {name=X_71196_ }
C {devices/lab_pin.sym} 61420 -35960 0 0 {name=p60610 lab=_41070_/X }
C {devices/lab_pin.sym} 61420 -35920 0 0 {name=p60611 lab=_42103_/X }
C {devices/lab_pin.sym} 61420 -35880 0 0 {name=p60612 lab=_88027_/Q }
C {devices/lab_pin.sym} 61420 -35840 0 0 {name=p60613 lab=_42104_/X }
C {devices/lab_pin.sym} 61580 -35900 0 1 {name=p60614 lab=_42115_/X }
C {sky130_stdcells/a2bb2o_4.sym} 61500 -35900 0 0 {name=X_42115_ }
C {devices/lab_pin.sym} 61440 -35760 0 0 {name=p60615 lab=_82155_/Q }
C {devices/lab_pin.sym} 61440 -35720 0 0 {name=p60616 lab=_77812_/B }
C {devices/lab_pin.sym} 61560 -35740 0 1 {name=p60617 lab=_77812_/X }
C {sky130_stdcells/xor2_4.sym} 61500 -35740 0 0 {name=X_77812_ }
C {devices/lab_pin.sym} 61420 -35640 0 0 {name=p60618 lab=_83523_/Q }
C {devices/lab_pin.sym} 61420 -35600 0 0 {name=p60619 lab=_83171_/Q }
C {devices/lab_pin.sym} 61420 -35560 0 0 {name=p60620 lab=_83498_/Q }
C {devices/lab_pin.sym} 61420 -35520 0 0 {name=p60621 lab=_83146_/Q }
C {devices/lab_pin.sym} 61580 -35580 0 1 {name=p60622 lab=_70147_/Y }
C {sky130_stdcells/a22oi_4.sym} 61500 -35580 0 0 {name=X_70147_ }
C {devices/lab_pin.sym} 61460 -35430 0 0 {name=p60623 lab=_47972_/A }
C {devices/lab_pin.sym} 61540 -35430 0 1 {name=p60624 lab=_47973_/B }
C {sky130_stdcells/buf_2.sym} 61500 -35430 0 0 {name=X_47972_ }
C {devices/lab_pin.sym} 61420 -35350 0 0 {name=p60625 lab=_43085_/X }
C {devices/lab_pin.sym} 61420 -35310 0 0 {name=p60626 lab=_43086_/X }
C {devices/lab_pin.sym} 61420 -35270 0 0 {name=p60627 lab=_40729_/X }
C {devices/lab_pin.sym} 61420 -35230 0 0 {name=p60628 lab=_43094_/Y }
C {devices/lab_pin.sym} 61420 -35190 0 0 {name=p60629 lab=_43090_/X }
C {devices/lab_pin.sym} 61580 -35270 0 1 {name=p60630 lab=_43095_/Y }
C {sky130_stdcells/o32ai_4.sym} 61500 -35270 0 0 {name=X_43095_ }
C {devices/lab_pin.sym} 61460 -35110 0 0 {name=p60631 lab=_62504_/A }
C {devices/lab_pin.sym} 61540 -35110 0 1 {name=p60632 lab=_62515_/A }
C {sky130_stdcells/buf_2.sym} 61500 -35110 0 0 {name=X_59958_ }
C {devices/lab_pin.sym} 61440 -35000 0 0 {name=p60633 lab=_82433_/Q }
C {devices/lab_pin.sym} 61440 -34960 0 0 {name=p60634 lab=_78792_/B }
C {devices/lab_pin.sym} 61560 -34980 0 1 {name=p60635 lab=_78793_/B }
C {sky130_stdcells/xnor2_4.sym} 61500 -34980 0 0 {name=X_78792_ }
C {devices/lab_pin.sym} 61420 -34870 0 0 {name=p60636 lab=_57692_/B }
C {devices/lab_pin.sym} 61420 -34830 0 0 {name=p60637 lab=_49687_/X }
C {devices/lab_pin.sym} 61420 -34790 0 0 {name=p60638 lab=_49710_/Y }
C {devices/lab_pin.sym} 61580 -34830 0 1 {name=p60639 lab=_49711_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -34830 0 0 {name=X_49711_ }
C {devices/lab_pin.sym} 61420 -34710 0 0 {name=p60640 lab=_58997_/A }
C {devices/lab_pin.sym} 61420 -34670 0 0 {name=p60641 lab=_46908_/X }
C {devices/lab_pin.sym} 61420 -34630 0 0 {name=p60642 lab=_46922_/Y }
C {devices/lab_pin.sym} 61580 -34670 0 1 {name=p60643 lab=_46923_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -34670 0 0 {name=X_46923_ }
C {devices/lab_pin.sym} 61460 -34530 0 0 {name=p60644 lab=_42046_/A }
C {devices/lab_pin.sym} 61540 -34530 0 1 {name=p60645 lab=_42046_/Y }
C {sky130_stdcells/inv_2.sym} 61500 -34530 0 0 {name=X_42046_ }
C {devices/lab_pin.sym} 61440 -34420 0 0 {name=p60646 lab=_58872_/A }
C {devices/lab_pin.sym} 61440 -34380 0 0 {name=p60647 lab=_86374_/Q }
C {devices/lab_pin.sym} 61560 -34400 0 1 {name=p60648 lab=_58909_/Y }
C {sky130_stdcells/nor2_4.sym} 61500 -34400 0 0 {name=X_58909_ }
C {devices/lab_pin.sym} 61440 -34280 0 0 {name=p60649 lab=_77743_/A }
C {devices/lab_pin.sym} 61440 -34240 0 0 {name=p60650 lab=_77742_/Y }
C {devices/lab_pin.sym} 61560 -34260 0 1 {name=p60651 lab=_77744_/B }
C {sky130_stdcells/xnor2_4.sym} 61500 -34260 0 0 {name=X_77743_ }
C {devices/lab_pin.sym} 61440 -34140 0 0 {name=p60652 lab=_74952_/Y }
C {devices/lab_pin.sym} 61440 -34100 0 0 {name=p60653 lab=_74954_/Y }
C {devices/lab_pin.sym} 61560 -34120 0 1 {name=p60654 lab=_74956_/B }
C {sky130_stdcells/xor2_4.sym} 61500 -34120 0 0 {name=X_74955_ }
C {devices/lab_pin.sym} 61420 -34010 0 0 {name=p60655 lab=_69910_/X }
C {devices/lab_pin.sym} 61420 -33970 0 0 {name=p60656 lab=_69912_/X }
C {devices/lab_pin.sym} 61420 -33930 0 0 {name=p60657 lab=_69994_/X }
C {devices/lab_pin.sym} 61580 -33970 0 1 {name=p60658 lab=_70078_/X }
C {sky130_stdcells/a21o_4.sym} 61500 -33970 0 0 {name=X_70078_ }
C {devices/lab_pin.sym} 61440 -33860 0 0 {name=p60659 lab=_59562_/B }
C {devices/lab_pin.sym} 61440 -33820 0 0 {name=p60660 lab=_59544_/A }
C {devices/lab_pin.sym} 61440 -33780 0 0 {name=p60661 lab=_59544_/B }
C {devices/lab_pin.sym} 61440 -33740 0 0 {name=p60662 lab=_59890_/C }
C {devices/lab_pin.sym} 61560 -33800 0 1 {name=p60663 lab=_60171_/B }
C {sky130_stdcells/nand4_4.sym} 61500 -33800 0 0 {name=X_59889_ }
C {devices/lab_pin.sym} 61440 -33680 0 0 {name=p60664 lab=_49625_/A }
C {devices/lab_pin.sym} 61440 -33640 0 0 {name=p60665 lab=_49642_/B }
C {devices/lab_pin.sym} 61440 -33600 0 0 {name=p60666 lab=_49629_/X }
C {devices/lab_pin.sym} 61440 -33560 0 0 {name=p60667 lab=_52857_/D }
C {devices/lab_pin.sym} 61560 -33620 0 1 {name=p60668 lab=_49642_/X }
C {sky130_stdcells/and4_4.sym} 61500 -33620 0 0 {name=X_49642_ }
C {devices/lab_pin.sym} 61420 -33490 0 0 {name=p60669 lab=_73902_/X }
C {devices/lab_pin.sym} 61420 -33450 0 0 {name=p60670 lab=_73905_/X }
C {devices/lab_pin.sym} 61420 -33410 0 0 {name=p60671 lab=_73857_/X }
C {devices/lab_pin.sym} 61580 -33450 0 1 {name=p60672 lab=_73910_/A }
C {sky130_stdcells/a21o_4.sym} 61500 -33450 0 0 {name=X_73906_ }
C {devices/lab_pin.sym} 61460 -33310 0 0 {name=p60673 lab=_61842_/A }
C {devices/lab_pin.sym} 61540 -33310 0 1 {name=p60674 lab=_61953_/B }
C {sky130_stdcells/buf_2.sym} 61500 -33310 0 0 {name=X_61920_ }
C {devices/lab_pin.sym} 61460 -33190 0 0 {name=p60675 lab=_46667_/A }
C {devices/lab_pin.sym} 61540 -33190 0 1 {name=p60676 lab=_46868_/C }
C {sky130_stdcells/buf_2.sym} 61500 -33190 0 0 {name=X_46854_ }
C {devices/lab_pin.sym} 61460 -33070 0 0 {name=p60677 lab=clkbuf_9_191_0_CLK/X }
C {devices/lab_pin.sym} 61540 -33070 0 1 {name=p60678 lab=_85439_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 61500 -33070 0 0 {name=Xclkbuf_10_382_0_CLK }
C {devices/lab_pin.sym} 61440 -32960 0 0 {name=p60679 lab=_77674_/A }
C {devices/lab_pin.sym} 61440 -32920 0 0 {name=p60680 lab=_82123_/Q }
C {devices/lab_pin.sym} 61560 -32940 0 1 {name=p60681 lab=_77675_/A }
C {sky130_stdcells/nand2_4.sym} 61500 -32940 0 0 {name=X_77674_ }
C {devices/lab_pin.sym} 61420 -32830 0 0 {name=p60682 lab=_74887_/A }
C {devices/lab_pin.sym} 61420 -32790 0 0 {name=p60683 lab=_74887_/C }
C {devices/lab_pin.sym} 61420 -32750 0 0 {name=p60684 lab=_74887_/B }
C {devices/lab_pin.sym} 61580 -32790 0 1 {name=p60685 lab=_74888_/A }
C {sky130_stdcells/a21o_4.sym} 61500 -32790 0 0 {name=X_74886_ }
C {devices/lab_pin.sym} 61440 -32660 0 0 {name=p60686 lab=_84808_/Q }
C {devices/lab_pin.sym} 61440 -32620 0 0 {name=p60687 lab=_66415_/C }
C {devices/lab_pin.sym} 61560 -32640 0 1 {name=p60688 lab=_79415_/A }
C {sky130_stdcells/xor2_4.sym} 61500 -32640 0 0 {name=X_79413_ }
C {devices/lab_pin.sym} 61460 -32510 0 0 {name=p60689 lab=_62126_/D }
C {devices/lab_pin.sym} 61540 -32510 0 1 {name=p60690 lab=_61640_/A }
C {sky130_stdcells/buf_2.sym} 61500 -32510 0 0 {name=X_45805_ }
C {devices/lab_pin.sym} 61420 -32410 0 0 {name=p60691 lab=_76615_/Y }
C {devices/lab_pin.sym} 61420 -32370 0 0 {name=p60692 lab=_76616_/B }
C {devices/lab_pin.sym} 61420 -32330 0 0 {name=p60693 lab=_76624_/B }
C {devices/lab_pin.sym} 61580 -32370 0 1 {name=p60694 lab=_76625_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -32370 0 0 {name=X_76625_ }
C {devices/lab_pin.sym} 61420 -32250 0 0 {name=p60695 lab=_49568_/Y }
C {devices/lab_pin.sym} 61420 -32210 0 0 {name=p60696 lab=_49570_/X }
C {devices/lab_pin.sym} 61420 -32170 0 0 {name=p60697 lab=_49572_/X }
C {devices/lab_pin.sym} 61580 -32210 0 1 {name=p60698 lab=_86363_/D }
C {sky130_stdcells/a21oi_4.sym} 61500 -32210 0 0 {name=X_49573_ }
C {devices/lab_pin.sym} 61440 -32100 0 0 {name=p60699 lab=_61823_/A }
C {devices/lab_pin.sym} 61440 -32060 0 0 {name=p60700 lab=_61823_/B }
C {devices/lab_pin.sym} 61440 -32020 0 0 {name=p60701 lab=_63459_/B }
C {devices/lab_pin.sym} 61440 -31980 0 0 {name=p60702 lab=_61788_/X }
C {devices/lab_pin.sym} 61560 -32040 0 1 {name=p60703 lab=_61851_/X }
C {sky130_stdcells/and4_4.sym} 61500 -32040 0 0 {name=X_61851_ }
C {devices/lab_pin.sym} 61420 -31910 0 0 {name=p60704 lab=_73838_/B }
C {devices/lab_pin.sym} 61420 -31870 0 0 {name=p60705 lab=_73838_/C }
C {devices/lab_pin.sym} 61420 -31830 0 0 {name=p60706 lab=_73836_/X }
C {devices/lab_pin.sym} 61580 -31870 0 1 {name=p60707 lab=_73837_/X }
C {sky130_stdcells/a21o_4.sym} 61500 -31870 0 0 {name=X_73837_ }
C {devices/lab_pin.sym} 61420 -31750 0 0 {name=p60708 lab=_46781_/Y }
C {devices/lab_pin.sym} 61420 -31710 0 0 {name=p60709 lab=_46751_/X }
C {devices/lab_pin.sym} 61420 -31670 0 0 {name=p60710 lab=_46784_/X }
C {devices/lab_pin.sym} 61580 -31710 0 1 {name=p60711 lab=_86704_/D }
C {sky130_stdcells/a21oi_4.sym} 61500 -31710 0 0 {name=X_46785_ }
C {devices/lab_pin.sym} 61460 -31570 0 0 {name=p60712 lab=_43994_/A }
C {devices/lab_pin.sym} 61540 -31570 0 1 {name=p60713 lab=_43998_/A }
C {sky130_stdcells/inv_2.sym} 61500 -31570 0 0 {name=X_43997_ }
C {devices/lab_pin.sym} 61420 -31470 0 0 {name=p60714 lab=_48516_/Y }
C {devices/lab_pin.sym} 61420 -31430 0 0 {name=p60715 lab=_48517_/X }
C {devices/lab_pin.sym} 61420 -31390 0 0 {name=p60716 lab=_48523_/X }
C {devices/lab_pin.sym} 61580 -31430 0 1 {name=p60717 lab=_86515_/D }
C {sky130_stdcells/a21oi_4.sym} 61500 -31430 0 0 {name=X_48524_ }
C {devices/lab_pin.sym} 61420 -31320 0 0 {name=p60718 lab=_78059_/A }
C {devices/lab_pin.sym} 61420 -31280 0 0 {name=p60719 lab=_60673_/X }
C {devices/lab_pin.sym} 61420 -31240 0 0 {name=p60720 lab=_60675_/Y }
C {devices/lab_pin.sym} 61420 -31200 0 0 {name=p60721 lab=_60801_/X }
C {devices/lab_pin.sym} 61580 -31260 0 1 {name=p60722 lab=_84564_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 61500 -31260 0 0 {name=X_60802_ }
C {devices/lab_pin.sym} 61440 -31120 0 0 {name=p60723 lab=_79342_/X }
C {devices/lab_pin.sym} 61440 -31080 0 0 {name=p60724 lab=_79344_/B }
C {devices/lab_pin.sym} 61560 -31100 0 1 {name=p60725 lab=_79344_/Y }
C {sky130_stdcells/xnor2_4.sym} 61500 -31100 0 0 {name=X_79344_ }
C {devices/lab_pin.sym} 61440 -30980 0 0 {name=p60726 lab=_57179_/B }
C {devices/lab_pin.sym} 61440 -30940 0 0 {name=p60727 lab=_45736_/B }
C {devices/lab_pin.sym} 61560 -30960 0 1 {name=p60728 lab=_45736_/Y }
C {sky130_stdcells/nor2_4.sym} 61500 -30960 0 0 {name=X_45736_ }
C {devices/lab_pin.sym} 61420 -30860 0 0 {name=p60729 lab=_64564_/X }
C {devices/lab_pin.sym} 61420 -30820 0 0 {name=p60730 lab=_86145_/Q }
C {devices/lab_pin.sym} 61420 -30780 0 0 {name=p60731 lab=_64566_/X }
C {devices/lab_pin.sym} 61420 -30740 0 0 {name=p60732 lab=_64569_/X }
C {devices/lab_pin.sym} 61580 -30800 0 1 {name=p60733 lab=_64570_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -30800 0 0 {name=X_64570_ }
C {devices/lab_pin.sym} 61420 -30670 0 0 {name=p60734 lab=_76531_/Y }
C {devices/lab_pin.sym} 61420 -30630 0 0 {name=p60735 lab=_76535_/B }
C {devices/lab_pin.sym} 61420 -30590 0 0 {name=p60736 lab=_76533_/Y }
C {devices/lab_pin.sym} 61580 -30630 0 1 {name=p60737 lab=_76557_/A }
C {sky130_stdcells/o21a_4.sym} 61500 -30630 0 0 {name=X_76556_ }
C {devices/lab_pin.sym} 61420 -30530 0 0 {name=p60738 lab=_42944_/X }
C {devices/lab_pin.sym} 61420 -30490 0 0 {name=p60739 lab=_42945_/X }
C {devices/lab_pin.sym} 61420 -30450 0 0 {name=p60740 lab=_41791_/X }
C {devices/lab_pin.sym} 61420 -30410 0 0 {name=p60741 lab=_68078_/B }
C {devices/lab_pin.sym} 61420 -30370 0 0 {name=p60742 lab=_42934_/X }
C {devices/lab_pin.sym} 61580 -30450 0 1 {name=p60743 lab=_42949_/A }
C {sky130_stdcells/o32ai_4.sym} 61500 -30450 0 0 {name=X_42948_ }
C {devices/lab_pin.sym} 61440 -30320 0 0 {name=p60744 lab=_61782_/A }
C {devices/lab_pin.sym} 61440 -30280 0 0 {name=p60745 lab=_61776_/Y }
C {devices/lab_pin.sym} 61440 -30240 0 0 {name=p60746 lab=_61779_/Y }
C {devices/lab_pin.sym} 61440 -30200 0 0 {name=p60747 lab=_61781_/Y }
C {devices/lab_pin.sym} 61560 -30260 0 1 {name=p60748 lab=_61782_/Y }
C {sky130_stdcells/nand4_4.sym} 61500 -30260 0 0 {name=X_61782_ }
C {devices/lab_pin.sym} 61420 -30130 0 0 {name=p60749 lab=_73766_/X }
C {devices/lab_pin.sym} 61420 -30090 0 0 {name=p60750 lab=_73767_/Y }
C {devices/lab_pin.sym} 61420 -30050 0 0 {name=p60751 lab=_73720_/X }
C {devices/lab_pin.sym} 61580 -30090 0 1 {name=p60752 lab=_73768_/X }
C {sky130_stdcells/a21o_4.sym} 61500 -30090 0 0 {name=X_73768_ }
C {devices/lab_pin.sym} 61440 -29980 0 0 {name=p60753 lab=_75507_/A }
C {devices/lab_pin.sym} 61440 -29940 0 0 {name=p60754 lab=_75462_/X }
C {devices/lab_pin.sym} 61440 -29900 0 0 {name=p60755 lab=_75481_/X }
C {devices/lab_pin.sym} 61440 -29860 0 0 {name=p60756 lab=_75482_/Y }
C {devices/lab_pin.sym} 61560 -29920 0 1 {name=p60757 lab=_75508_/A }
C {sky130_stdcells/nand4_4.sym} 61500 -29920 0 0 {name=X_75507_ }
C {devices/lab_pin.sym} 61420 -29800 0 0 {name=p60758 lab=_58554_/A }
C {devices/lab_pin.sym} 61420 -29760 0 0 {name=p60759 lab=_63497_/X }
C {devices/lab_pin.sym} 61420 -29720 0 0 {name=p60760 lab=_61492_/A }
C {devices/lab_pin.sym} 61420 -29680 0 0 {name=p60761 lab=_63498_/X }
C {devices/lab_pin.sym} 61580 -29740 0 1 {name=p60762 lab=_63521_/X }
C {sky130_stdcells/a2bb2o_4.sym} 61500 -29740 0 0 {name=X_63521_ }
C {devices/lab_pin.sym} 61460 -29590 0 0 {name=p60763 lab=clkbuf_9_198_0_CLK/X }
C {devices/lab_pin.sym} 61540 -29590 0 1 {name=p60764 lab=_82272_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 61500 -29590 0 0 {name=Xclkbuf_10_397_0_CLK }
C {devices/lab_pin.sym} 61460 -29470 0 0 {name=p60765 lab=_53663_/B }
C {devices/lab_pin.sym} 61540 -29470 0 1 {name=p60766 lab=_50440_/B }
C {sky130_stdcells/buf_2.sym} 61500 -29470 0 0 {name=X_48455_ }
C {devices/lab_pin.sym} 61420 -29370 0 0 {name=p60767 lab=_63410_/A }
C {devices/lab_pin.sym} 61420 -29330 0 0 {name=p60768 lab=_60714_/A }
C {devices/lab_pin.sym} 61420 -29290 0 0 {name=p60769 lab=_60732_/Y }
C {devices/lab_pin.sym} 61580 -29330 0 1 {name=p60770 lab=_60733_/Y }
C {sky130_stdcells/a21boi_4.sym} 61500 -29330 0 0 {name=X_60733_ }
C {devices/lab_pin.sym} 61420 -29210 0 0 {name=p60771 lab=_83178_/Q }
C {devices/lab_pin.sym} 61420 -29170 0 0 {name=p60772 lab=_72709_/X }
C {devices/lab_pin.sym} 61420 -29130 0 0 {name=p60773 lab=_72718_/X }
C {devices/lab_pin.sym} 61580 -29170 0 1 {name=p60774 lab=_72719_/X }
C {sky130_stdcells/a21o_4.sym} 61500 -29170 0 0 {name=X_72719_ }
C {devices/lab_pin.sym} 61440 -29040 0 0 {name=p60775 lab=_79292_/B }
C {devices/lab_pin.sym} 61440 -29000 0 0 {name=p60776 lab=_79275_/B }
C {devices/lab_pin.sym} 61560 -29020 0 1 {name=p60777 lab=_79275_/X }
C {sky130_stdcells/xor2_4.sym} 61500 -29020 0 0 {name=X_79275_ }
C {devices/lab_pin.sym} 61440 -28900 0 0 {name=p60778 lab=_45666_/Y }
C {devices/lab_pin.sym} 61440 -28860 0 0 {name=p60779 lab=_44975_/A }
C {devices/lab_pin.sym} 61560 -28880 0 1 {name=p60780 lab=_45667_/X }
C {sky130_stdcells/and2_4.sym} 61500 -28880 0 0 {name=X_45667_ }
C {devices/lab_pin.sym} 61460 -28750 0 0 {name=p60781 lab=_81657_/Q }
C {devices/lab_pin.sym} 61540 -28750 0 1 {name=p60782 lab=_76487_/Y }
C {sky130_stdcells/inv_2.sym} 61500 -28750 0 0 {name=X_76487_ }
C {devices/lab_pin.sym} 61420 -28670 0 0 {name=p60783 lab=_42874_/X }
C {devices/lab_pin.sym} 61420 -28630 0 0 {name=p60784 lab=_42875_/X }
C {devices/lab_pin.sym} 61420 -28590 0 0 {name=p60785 lab=_41606_/X }
C {devices/lab_pin.sym} 61420 -28550 0 0 {name=p60786 lab=_67248_/B }
C {devices/lab_pin.sym} 61420 -28510 0 0 {name=p60787 lab=_42858_/X }
C {devices/lab_pin.sym} 61580 -28590 0 1 {name=p60788 lab=_42879_/Y }
C {sky130_stdcells/o32ai_4.sym} 61500 -28590 0 0 {name=X_42879_ }
C {devices/lab_pin.sym} 61440 -28440 0 0 {name=p60789 lab=_73699_/A }
C {devices/lab_pin.sym} 61440 -28400 0 0 {name=p60790 lab=_73624_/X }
C {devices/lab_pin.sym} 61560 -28420 0 1 {name=p60791 lab=_73699_/Y }
C {sky130_stdcells/nor2_4.sym} 61500 -28420 0 0 {name=X_73699_ }
C {devices/lab_pin.sym} 61460 -28290 0 0 {name=p60792 lab=_81806_/Q }
C {devices/lab_pin.sym} 61540 -28290 0 1 {name=p60793 lab=_47407_/A }
C {sky130_stdcells/inv_2.sym} 61500 -28290 0 0 {name=X_47406_ }
C {devices/lab_pin.sym} 61460 -28170 0 0 {name=p60794 lab=_65880_/A }
C {devices/lab_pin.sym} 61540 -28170 0 1 {name=p60795 lab=_66240_/X }
C {sky130_stdcells/buf_2.sym} 61500 -28170 0 0 {name=X_66240_ }
C {devices/lab_pin.sym} 61440 -28060 0 0 {name=p60796 lab=_78226_/A }
C {devices/lab_pin.sym} 61440 -28020 0 0 {name=p60797 lab=_78226_/B }
C {devices/lab_pin.sym} 61560 -28040 0 1 {name=p60798 lab=_78226_/X }
C {sky130_stdcells/xor2_4.sym} 61500 -28040 0 0 {name=X_78226_ }
C {devices/lab_pin.sym} 61460 -27910 0 0 {name=p60799 lab=_44618_/A }
C {devices/lab_pin.sym} 61540 -27910 0 1 {name=p60800 lab=_44618_/X }
C {sky130_stdcells/buf_2.sym} 61500 -27910 0 0 {name=X_44618_ }
C {devices/lab_pin.sym} 61420 -27820 0 0 {name=p60801 lab=_61417_/B }
C {devices/lab_pin.sym} 61420 -27780 0 0 {name=p60802 lab=_63426_/X }
C {devices/lab_pin.sym} 61420 -27740 0 0 {name=p60803 lab=_63450_/X }
C {devices/lab_pin.sym} 61420 -27700 0 0 {name=p60804 lab=_63451_/X }
C {devices/lab_pin.sym} 61580 -27760 0 1 {name=p60805 lab=_63452_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -27760 0 0 {name=X_63452_ }
C {devices/lab_pin.sym} 61420 -27630 0 0 {name=p60806 lab=_75436_/Y }
C {devices/lab_pin.sym} 61420 -27590 0 0 {name=p60807 lab=_75406_/Y }
C {devices/lab_pin.sym} 61420 -27550 0 0 {name=p60808 lab=_75437_/X }
C {devices/lab_pin.sym} 61580 -27590 0 1 {name=p60809 lab=_75438_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -27590 0 0 {name=X_75438_ }
C {devices/lab_pin.sym} 61460 -27450 0 0 {name=p60810 lab=_60663_/Y }
C {devices/lab_pin.sym} 61540 -27450 0 1 {name=p60811 lab=_60671_/B }
C {sky130_stdcells/buf_2.sym} 61500 -27450 0 0 {name=X_60664_ }
C {devices/lab_pin.sym} 61420 -27350 0 0 {name=p60812 lab=_48372_/X }
C {devices/lab_pin.sym} 61420 -27310 0 0 {name=p60813 lab=_82367_/Q }
C {devices/lab_pin.sym} 61420 -27270 0 0 {name=p60814 lab=_48385_/Y }
C {devices/lab_pin.sym} 61580 -27310 0 1 {name=p60815 lab=_74375_/A }
C {sky130_stdcells/o21ai_4.sym} 61500 -27310 0 0 {name=X_48386_ }
C {devices/lab_pin.sym} 61420 -27200 0 0 {name=p60816 lab=_45595_/Y }
C {devices/lab_pin.sym} 61420 -27160 0 0 {name=p60817 lab=_45596_/X }
C {devices/lab_pin.sym} 61420 -27120 0 0 {name=p60818 lab=_45548_/X }
C {devices/lab_pin.sym} 61420 -27080 0 0 {name=p60819 lab=_45597_/Y }
C {devices/lab_pin.sym} 61580 -27140 0 1 {name=p60820 lab=_45598_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -27140 0 0 {name=X_45598_ }
C {devices/lab_pin.sym} 61440 -27010 0 0 {name=p60821 lab=_62448_/A }
C {devices/lab_pin.sym} 61440 -26970 0 0 {name=p60822 lab=_63520_/B }
C {devices/lab_pin.sym} 61440 -26930 0 0 {name=p60823 lab=_62375_/C }
C {devices/lab_pin.sym} 61560 -26970 0 1 {name=p60824 lab=_62406_/C }
C {sky130_stdcells/nand3_4.sym} 61500 -26970 0 0 {name=X_62403_ }
C {devices/lab_pin.sym} 61420 -26850 0 0 {name=p60825 lab=_86645_/Q }
C {devices/lab_pin.sym} 61420 -26810 0 0 {name=p60826 lab=_47332_/X }
C {devices/lab_pin.sym} 61420 -26770 0 0 {name=p60827 lab=_47336_/Y }
C {devices/lab_pin.sym} 61580 -26810 0 1 {name=p60828 lab=_47337_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -26810 0 0 {name=X_47337_ }
C {devices/lab_pin.sym} 61440 -26680 0 0 {name=p60829 lab=_64710_/A }
C {devices/lab_pin.sym} 61440 -26640 0 0 {name=p60830 lab=_66171_/B }
C {devices/lab_pin.sym} 61560 -26660 0 1 {name=p60831 lab=_66171_/X }
C {sky130_stdcells/and2_4.sym} 61500 -26660 0 0 {name=X_66171_ }
C {devices/lab_pin.sym} 61440 -26540 0 0 {name=p60832 lab=_78145_/A }
C {devices/lab_pin.sym} 61440 -26500 0 0 {name=p60833 lab=_82860_/D }
C {devices/lab_pin.sym} 61560 -26520 0 1 {name=p60834 lab=_78157_/Y }
C {sky130_stdcells/nand2_4.sym} 61500 -26520 0 0 {name=X_78157_ }
C {devices/lab_pin.sym} 61460 -26390 0 0 {name=p60835 lab=_44549_/A }
C {devices/lab_pin.sym} 61540 -26390 0 1 {name=p60836 lab=_44549_/X }
C {sky130_stdcells/buf_2.sym} 61500 -26390 0 0 {name=X_44549_ }
C {devices/lab_pin.sym} 61420 -26290 0 0 {name=p60837 lab=_63381_/Y }
C {devices/lab_pin.sym} 61420 -26250 0 0 {name=p60838 lab=_63284_/X }
C {devices/lab_pin.sym} 61420 -26210 0 0 {name=p60839 lab=_63382_/Y }
C {devices/lab_pin.sym} 61580 -26250 0 1 {name=p60840 lab=_84328_/D }
C {sky130_stdcells/a21oi_4.sym} 61500 -26250 0 0 {name=X_63383_ }
C {devices/lab_pin.sym} 61420 -26130 0 0 {name=p60841 lab=_75365_/Y }
C {devices/lab_pin.sym} 61420 -26090 0 0 {name=p60842 lab=_75345_/B }
C {devices/lab_pin.sym} 61420 -26050 0 0 {name=p60843 lab=_75368_/X }
C {devices/lab_pin.sym} 61580 -26090 0 1 {name=p60844 lab=_75369_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -26090 0 0 {name=X_75369_ }
C {devices/lab_pin.sym} 61460 -25950 0 0 {name=p60845 lab=clkbuf_9_160_0_CLK/X }
C {devices/lab_pin.sym} 61540 -25950 0 1 {name=p60846 lab=_86655_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 61500 -25950 0 0 {name=Xclkbuf_10_320_0_CLK }
C {devices/lab_pin.sym} 61440 -25850 0 0 {name=p60847 lab=_60570_/B }
C {devices/lab_pin.sym} 61440 -25810 0 0 {name=p60848 lab=_60570_/C }
C {devices/lab_pin.sym} 61440 -25770 0 0 {name=p60849 lab=_60595_/C }
C {devices/lab_pin.sym} 61560 -25810 0 1 {name=p60850 lab=_60596_/B }
C {sky130_stdcells/nor3_4.sym} 61500 -25810 0 0 {name=X_60595_ }
C {devices/lab_pin.sym} 61460 -25670 0 0 {name=p60851 lab=_64851_/A }
C {devices/lab_pin.sym} 61540 -25670 0 1 {name=p60852 lab=_65122_/X }
C {sky130_stdcells/buf_2.sym} 61500 -25670 0 0 {name=X_65122_ }
C {devices/lab_pin.sym} 61420 -25570 0 0 {name=p60853 lab=_77113_/A }
C {devices/lab_pin.sym} 61420 -25530 0 0 {name=p60854 lab=_77112_/A }
C {devices/lab_pin.sym} 61420 -25490 0 0 {name=p60855 lab=_77107_/Y }
C {devices/lab_pin.sym} 61580 -25530 0 1 {name=p60856 lab=_77109_/B }
C {sky130_stdcells/a21boi_4.sym} 61500 -25530 0 0 {name=X_77108_ }
C {devices/lab_pin.sym} 61440 -25420 0 0 {name=p60857 lab=_61428_/X }
C {devices/lab_pin.sym} 61440 -25380 0 0 {name=p60858 lab=_59898_/A }
C {devices/lab_pin.sym} 61440 -25340 0 0 {name=p60859 lab=_62233_/C }
C {devices/lab_pin.sym} 61440 -25300 0 0 {name=p60860 lab=_62334_/D }
C {devices/lab_pin.sym} 61560 -25360 0 1 {name=p60861 lab=_62335_/D }
C {sky130_stdcells/nand4_4.sym} 61500 -25360 0 0 {name=X_62334_ }
C {devices/lab_pin.sym} 61460 -25210 0 0 {name=p60862 lab=clkbuf_9_475_0_CLK/X }
C {devices/lab_pin.sym} 61540 -25210 0 1 {name=p60863 lab=_83153_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 61500 -25210 0 0 {name=Xclkbuf_10_950_0_CLK }
C {devices/lab_pin.sym} 61460 -25090 0 0 {name=p60864 lab=_54121_/B }
C {devices/lab_pin.sym} 61540 -25090 0 1 {name=p60865 lab=_52950_/B }
C {sky130_stdcells/buf_2.sym} 61500 -25090 0 0 {name=X_47268_ }
C {devices/lab_pin.sym} 61440 -24980 0 0 {name=p60866 lab=_78088_/A }
C {devices/lab_pin.sym} 61440 -24940 0 0 {name=p60867 lab=_78088_/B }
C {devices/lab_pin.sym} 61560 -24960 0 1 {name=p60868 lab=_78089_/A }
C {sky130_stdcells/nand2_4.sym} 61500 -24960 0 0 {name=X_78088_ }
C {devices/lab_pin.sym} 61440 -24840 0 0 {name=p60869 lab=_49007_/A }
C {devices/lab_pin.sym} 61440 -24800 0 0 {name=p60870 lab=_49006_/X }
C {devices/lab_pin.sym} 61560 -24820 0 1 {name=p60871 lab=_49007_/Y }
C {sky130_stdcells/nand2_4.sym} 61500 -24820 0 0 {name=X_49007_ }
C {devices/lab_pin.sym} 61440 -24710 0 0 {name=p60872 lab=_46217_/Y }
C {devices/lab_pin.sym} 61440 -24670 0 0 {name=p60873 lab=_46215_/B }
C {devices/lab_pin.sym} 61440 -24630 0 0 {name=p60874 lab=_46218_/Y }
C {devices/lab_pin.sym} 61560 -24670 0 1 {name=p60875 lab=_46220_/A }
C {sky130_stdcells/nand3_4.sym} 61500 -24670 0 0 {name=X_46219_ }
C {devices/lab_pin.sym} 61420 -24550 0 0 {name=p60876 lab=_65050_/X }
C {devices/lab_pin.sym} 61420 -24510 0 0 {name=p60877 lab=_65052_/X }
C {devices/lab_pin.sym} 61420 -24470 0 0 {name=p60878 lab=_64701_/X }
C {devices/lab_pin.sym} 61580 -24510 0 1 {name=p60879 lab=_65053_/X }
C {sky130_stdcells/a21o_4.sym} 61500 -24510 0 0 {name=X_65053_ }
C {devices/lab_pin.sym} 61440 -24380 0 0 {name=p60880 lab=_69791_/A }
C {devices/lab_pin.sym} 61440 -24340 0 0 {name=p60881 lab=_69929_/Y }
C {devices/lab_pin.sym} 61560 -24360 0 1 {name=p60882 lab=_69930_/Y }
C {sky130_stdcells/nor2_4.sym} 61500 -24360 0 0 {name=X_69930_ }
C {devices/lab_pin.sym} 61460 -24230 0 0 {name=p60883 lab=_77038_/X }
C {devices/lab_pin.sym} 61540 -24230 0 1 {name=p60884 lab=_77041_/B }
C {sky130_stdcells/inv_2.sym} 61500 -24230 0 0 {name=X_77039_ }
C {devices/lab_pin.sym} 61460 -24110 0 0 {name=p60885 lab=_62120_/A }
C {devices/lab_pin.sym} 61540 -24110 0 1 {name=p60886 lab=_62267_/A }
C {sky130_stdcells/buf_2.sym} 61500 -24110 0 0 {name=X_62265_ }
C {devices/lab_pin.sym} 61460 -23990 0 0 {name=p60887 lab=clkbuf_9_441_0_CLK/A }
C {devices/lab_pin.sym} 61540 -23990 0 1 {name=p60888 lab=clkbuf_9_441_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 61500 -23990 0 0 {name=Xclkbuf_9_441_0_CLK }
C {devices/lab_pin.sym} 61460 -23870 0 0 {name=p60889 lab=_47198_/X }
C {devices/lab_pin.sym} 61540 -23870 0 1 {name=p60890 lab=_47210_/A }
C {sky130_stdcells/buf_2.sym} 61500 -23870 0 0 {name=X_47199_ }
C {devices/lab_pin.sym} 61460 -23750 0 0 {name=p60891 lab=_55686_/C }
C {devices/lab_pin.sym} 61540 -23750 0 1 {name=p60892 lab=_56175_/B }
C {sky130_stdcells/buf_2.sym} 61500 -23750 0 0 {name=Xpsn_inst_psn_buff_15 }
C {devices/lab_pin.sym} 61460 -23630 0 0 {name=p60893 lab=_63733_/X }
C {devices/lab_pin.sym} 61540 -23630 0 1 {name=p60894 lab=_64071_/C }
C {sky130_stdcells/buf_2.sym} 61500 -23630 0 0 {name=X_64004_ }
C {devices/lab_pin.sym} 61460 -23510 0 0 {name=p60895 lab=_50212_/A }
C {devices/lab_pin.sym} 61540 -23510 0 1 {name=p60896 lab=_41870_/B1 }
C {sky130_stdcells/buf_2.sym} 61500 -23510 0 0 {name=Xpsn_inst_psn_buff_26 }
C {devices/lab_pin.sym} 61440 -23400 0 0 {name=p60897 lab=_80048_/X }
C {devices/lab_pin.sym} 61440 -23360 0 0 {name=p60898 lab=_80057_/B }
C {devices/lab_pin.sym} 61560 -23380 0 1 {name=p60899 lab=_80050_/Y }
C {sky130_stdcells/xnor2_4.sym} 61500 -23380 0 0 {name=X_80050_ }
C {devices/lab_pin.sym} 61440 -23260 0 0 {name=p60900 lab=_61215_/Y }
C {devices/lab_pin.sym} 61440 -23220 0 0 {name=p60901 lab=_61238_/C }
C {devices/lab_pin.sym} 61560 -23240 0 1 {name=p60902 lab=_61216_/Y }
C {sky130_stdcells/nand2_4.sym} 61500 -23240 0 0 {name=X_61216_ }
C {devices/lab_pin.sym} 61460 -23110 0 0 {name=p60903 lab=clkbuf_9_167_0_CLK/X }
C {devices/lab_pin.sym} 61540 -23110 0 1 {name=p60904 lab=_84757_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 61500 -23110 0 0 {name=Xclkbuf_10_335_0_CLK }
C {devices/lab_pin.sym} 61420 -23020 0 0 {name=p60905 lab=_73320_/A }
C {devices/lab_pin.sym} 61420 -22980 0 0 {name=p60906 lab=_44299_/A }
C {devices/lab_pin.sym} 61420 -22940 0 0 {name=p60907 lab=_68933_/X }
C {devices/lab_pin.sym} 61420 -22900 0 0 {name=p60908 lab=_69860_/Y }
C {devices/lab_pin.sym} 61580 -22960 0 1 {name=p60909 lab=_69861_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -22960 0 0 {name=X_69861_ }
C {devices/lab_pin.sym} 61460 -22810 0 0 {name=p60910 lab=_62196_/A }
C {devices/lab_pin.sym} 61540 -22810 0 1 {name=p60911 lab=_62196_/X }
C {sky130_stdcells/buf_2.sym} 61500 -22810 0 0 {name=X_62196_ }
C {devices/lab_pin.sym} 61460 -22690 0 0 {name=p60912 lab=clkbuf_9_482_0_CLK/X }
C {devices/lab_pin.sym} 61540 -22690 0 1 {name=p60913 lab=_83594_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 61500 -22690 0 0 {name=Xclkbuf_10_965_0_CLK }
C {devices/lab_pin.sym} 61420 -22590 0 0 {name=p60914 lab=_80816_/D }
C {devices/lab_pin.sym} 61420 -22550 0 0 {name=p60915 lab=_68713_/X }
C {devices/lab_pin.sym} 61420 -22510 0 0 {name=p60916 lab=_68811_/X }
C {devices/lab_pin.sym} 61580 -22550 0 1 {name=p60917 lab=_68812_/X }
C {sky130_stdcells/a21bo_4.sym} 61500 -22550 0 0 {name=X_68812_ }
C {devices/lab_pin.sym} 61440 -22430 0 0 {name=p60918 lab=_61153_/A }
C {devices/lab_pin.sym} 61440 -22390 0 0 {name=p60919 lab=_64523_/D }
C {devices/lab_pin.sym} 61440 -22350 0 0 {name=p60920 lab=_64523_/B }
C {devices/lab_pin.sym} 61560 -22390 0 1 {name=p60921 lab=_61147_/Y }
C {sky130_stdcells/nand3_4.sym} 61500 -22390 0 0 {name=X_61147_ }
C {devices/lab_pin.sym} 61420 -22280 0 0 {name=p60922 lab=_73196_/A }
C {devices/lab_pin.sym} 61420 -22240 0 0 {name=p60923 lab=_69747_/X }
C {devices/lab_pin.sym} 61420 -22200 0 0 {name=p60924 lab=_68691_/X }
C {devices/lab_pin.sym} 61420 -22160 0 0 {name=p60925 lab=_69791_/Y }
C {devices/lab_pin.sym} 61580 -22220 0 1 {name=p60926 lab=_69792_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -22220 0 0 {name=X_69792_ }
C {devices/lab_pin.sym} 61420 -22090 0 0 {name=p60927 lab=_72174_/B }
C {devices/lab_pin.sym} 61420 -22050 0 0 {name=p60928 lab=_49906_/X }
C {devices/lab_pin.sym} 61420 -22010 0 0 {name=p60929 lab=_49908_/Y }
C {devices/lab_pin.sym} 61580 -22050 0 1 {name=p60930 lab=_49909_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -22050 0 0 {name=X_49909_ }
C {devices/lab_pin.sym} 61460 -21910 0 0 {name=p60931 lab=clkbuf_8_228_0_CLK/X }
C {devices/lab_pin.sym} 61540 -21910 0 1 {name=p60932 lab=clkbuf_9_456_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 61500 -21910 0 0 {name=Xclkbuf_9_456_0_CLK }
C {devices/lab_pin.sym} 61440 -21800 0 0 {name=p60933 lab=_69067_/A }
C {devices/lab_pin.sym} 61440 -21760 0 0 {name=p60934 lab=_73921_/A }
C {devices/lab_pin.sym} 61560 -21780 0 1 {name=p60935 lab=_68743_/X }
C {sky130_stdcells/and2_4.sym} 61500 -21780 0 0 {name=X_68743_ }
C {devices/lab_pin.sym} 61440 -21670 0 0 {name=p60936 lab=_65916_/A }
C {devices/lab_pin.sym} 61440 -21630 0 0 {name=p60937 lab=_65970_/B }
C {devices/lab_pin.sym} 61440 -21590 0 0 {name=p60938 lab=_84166_/Q }
C {devices/lab_pin.sym} 61560 -21630 0 1 {name=p60939 lab=_65955_/X }
C {sky130_stdcells/and3_4.sym} 61500 -21630 0 0 {name=X_65955_ }
C {devices/lab_pin.sym} 61440 -21510 0 0 {name=p60940 lab=_59657_/A }
C {devices/lab_pin.sym} 61440 -21470 0 0 {name=p60941 lab=_61078_/B }
C {devices/lab_pin.sym} 61440 -21430 0 0 {name=p60942 lab=_60615_/A }
C {devices/lab_pin.sym} 61560 -21470 0 1 {name=p60943 lab=_61079_/A }
C {sky130_stdcells/nand3_4.sym} 61500 -21470 0 0 {name=X_61078_ }
C {devices/lab_pin.sym} 61460 -21330 0 0 {name=p60944 lab=_52892_/A }
C {devices/lab_pin.sym} 61540 -21330 0 1 {name=p60945 lab=_52920_/X }
C {sky130_stdcells/buf_2.sym} 61500 -21330 0 0 {name=X_52920_ }
C {devices/lab_pin.sym} 61440 -21220 0 0 {name=p60946 lab=_64883_/A }
C {devices/lab_pin.sym} 61440 -21180 0 0 {name=p60947 lab=_86262_/Q }
C {devices/lab_pin.sym} 61560 -21200 0 1 {name=p60948 lab=_64906_/X }
C {sky130_stdcells/and2_4.sym} 61500 -21200 0 0 {name=X_64906_ }
C {devices/lab_pin.sym} 61460 -21070 0 0 {name=p60949 lab=_62198_/B }
C {devices/lab_pin.sym} 61540 -21070 0 1 {name=p60950 lab=_60091_/A }
C {sky130_stdcells/buf_2.sym} 61500 -21070 0 0 {name=X_60029_ }
C {devices/lab_pin.sym} 61410 -20950 0 0 {name=p60951 lab=_86322_/CLK }
C {devices/lab_pin.sym} 61410 -20930 0 0 {name=p60952 lab=_83740_/D }
C {devices/lab_pin.sym} 61590 -20950 0 1 {name=p60953 lab=_47343_/A }
C {sky130_stdcells/dfxtp_4.sym} 61500 -20940 0 0 {name=X_83740_ }
C {devices/lab_pin.sym} 61410 -20810 0 0 {name=p60954 lab=_81211_/CLK }
C {devices/lab_pin.sym} 61410 -20790 0 0 {name=p60955 lab=_75393_/B }
C {devices/lab_pin.sym} 61590 -20810 0 1 {name=p60956 lab=_80952_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -20800 0 0 {name=X_80952_ }
C {devices/lab_pin.sym} 61420 -20690 0 0 {name=p60957 lab=_68670_/X }
C {devices/lab_pin.sym} 61420 -20650 0 0 {name=p60958 lab=_68673_/X }
C {devices/lab_pin.sym} 61420 -20610 0 0 {name=p60959 lab=_68390_/X }
C {devices/lab_pin.sym} 61580 -20650 0 1 {name=p60960 lab=_68674_/X }
C {sky130_stdcells/a21o_4.sym} 61500 -20650 0 0 {name=X_68674_ }
C {devices/lab_pin.sym} 61420 -20530 0 0 {name=p60961 lab=_65700_/X }
C {devices/lab_pin.sym} 61420 -20490 0 0 {name=p60962 lab=_65884_/Y }
C {devices/lab_pin.sym} 61420 -20450 0 0 {name=p60963 lab=_65885_/Y }
C {devices/lab_pin.sym} 61580 -20490 0 1 {name=p60964 lab=_65886_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -20490 0 0 {name=X_65886_ }
C {devices/lab_pin.sym} 61460 -20350 0 0 {name=p60965 lab=_67270_/X }
C {devices/lab_pin.sym} 61540 -20350 0 1 {name=p60966 lab=_67625_/X }
C {sky130_stdcells/buf_2.sym} 61500 -20350 0 0 {name=X_67625_ }
C {devices/lab_pin.sym} 61420 -20250 0 0 {name=p60967 lab=_85743_/Q }
C {devices/lab_pin.sym} 61420 -20210 0 0 {name=p60968 lab=_52848_/X }
C {devices/lab_pin.sym} 61420 -20170 0 0 {name=p60969 lab=_52850_/Y }
C {devices/lab_pin.sym} 61580 -20210 0 1 {name=p60970 lab=_52851_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -20210 0 0 {name=X_52851_ }
C {devices/lab_pin.sym} 61420 -20100 0 0 {name=p60971 lab=_64835_/X }
C {devices/lab_pin.sym} 61420 -20060 0 0 {name=p60972 lab=_83305_/Q }
C {devices/lab_pin.sym} 61420 -20020 0 0 {name=p60973 lab=_44171_/X }
C {devices/lab_pin.sym} 61420 -19980 0 0 {name=p60974 lab=_64836_/X }
C {devices/lab_pin.sym} 61580 -20040 0 1 {name=p60975 lab=_64837_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -20040 0 0 {name=X_64837_ }
C {devices/lab_pin.sym} 61410 -19890 0 0 {name=p60976 lab=_83673_/CLK }
C {devices/lab_pin.sym} 61410 -19870 0 0 {name=p60977 lab=_70894_/Y }
C {devices/lab_pin.sym} 61590 -19890 0 1 {name=p60978 lab=_46786_/A }
C {sky130_stdcells/dfxtp_4.sym} 61500 -19880 0 0 {name=X_83671_ }
C {devices/lab_pin.sym} 61410 -19750 0 0 {name=p60979 lab=_81130_/CLK }
C {devices/lab_pin.sym} 61410 -19730 0 0 {name=p60980 lab=_75731_/B }
C {devices/lab_pin.sym} 61590 -19750 0 1 {name=p60981 lab=_80851_/D }
C {sky130_stdcells/dfxtp_4.sym} 61500 -19740 0 0 {name=X_80883_ }
C {devices/lab_pin.sym} 61410 -19610 0 0 {name=p60982 lab=_86655_/CLK }
C {devices/lab_pin.sym} 61410 -19590 0 0 {name=p60983 lab=_54613_/Y }
C {devices/lab_pin.sym} 61590 -19610 0 1 {name=p60984 lab=_85410_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -19600 0 0 {name=X_85410_ }
C {devices/lab_pin.sym} 61460 -19470 0 0 {name=p60985 lab=_53097_/A }
C {devices/lab_pin.sym} 61540 -19470 0 1 {name=p60986 lab=_53282_/A }
C {sky130_stdcells/buf_2.sym} 61500 -19470 0 0 {name=X_51802_ }
C {devices/lab_pin.sym} 61410 -19350 0 0 {name=p60987 lab=_82715_/CLK }
C {devices/lab_pin.sym} 61410 -19330 0 0 {name=p60988 lab=_79071_/B }
C {devices/lab_pin.sym} 61590 -19350 0 1 {name=p60989 lab=_82622_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -19340 0 0 {name=X_82622_ }
C {devices/lab_pin.sym} 61440 -19240 0 0 {name=p60990 lab=_55504_/Y }
C {devices/lab_pin.sym} 61440 -19200 0 0 {name=p60991 lab=_55536_/X }
C {devices/lab_pin.sym} 61440 -19160 0 0 {name=p60992 lab=_55552_/X }
C {devices/lab_pin.sym} 61440 -19120 0 0 {name=p60993 lab=_55570_/D }
C {devices/lab_pin.sym} 61560 -19180 0 1 {name=p60994 lab=_55570_/X }
C {sky130_stdcells/and4_4.sym} 61500 -19180 0 0 {name=X_55570_ }
C {devices/lab_pin.sym} 61440 -19040 0 0 {name=p60995 lab=_67460_/A }
C {devices/lab_pin.sym} 61440 -19000 0 0 {name=p60996 lab=_67556_/B }
C {devices/lab_pin.sym} 61560 -19020 0 1 {name=p60997 lab=_67556_/X }
C {sky130_stdcells/and2_4.sym} 61500 -19020 0 0 {name=X_67556_ }
C {devices/lab_pin.sym} 61410 -18890 0 0 {name=p60998 lab=_83676_/CLK }
C {devices/lab_pin.sym} 61410 -18870 0 0 {name=p60999 lab=_49426_/Y }
C {devices/lab_pin.sym} 61590 -18890 0 1 {name=p61000 lab=_58699_/B }
C {sky130_stdcells/dfxtp_4.sym} 61500 -18880 0 0 {name=X_86390_ }
C {devices/lab_pin.sym} 61420 -18770 0 0 {name=p61001 lab=_85755_/Q }
C {devices/lab_pin.sym} 61420 -18730 0 0 {name=p61002 lab=_52765_/X }
C {devices/lab_pin.sym} 61420 -18690 0 0 {name=p61003 lab=_52781_/Y }
C {devices/lab_pin.sym} 61580 -18730 0 1 {name=p61004 lab=_52782_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -18730 0 0 {name=X_52782_ }
C {devices/lab_pin.sym} 61420 -18620 0 0 {name=p61005 lab=_64666_/X }
C {devices/lab_pin.sym} 61420 -18580 0 0 {name=p61006 lab=_86171_/Q }
C {devices/lab_pin.sym} 61420 -18540 0 0 {name=p61007 lab=_64766_/X }
C {devices/lab_pin.sym} 61420 -18500 0 0 {name=p61008 lab=_64767_/X }
C {devices/lab_pin.sym} 61580 -18560 0 1 {name=p61009 lab=_64768_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -18560 0 0 {name=X_64768_ }
C {devices/lab_pin.sym} 61460 -18410 0 0 {name=p61010 lab=_54521_/A }
C {devices/lab_pin.sym} 61540 -18410 0 1 {name=p61011 lab=_54526_/B }
C {sky130_stdcells/buf_2.sym} 61500 -18410 0 0 {name=X_54521_ }
C {devices/lab_pin.sym} 61460 -18290 0 0 {name=p61012 lab=clkbuf_9_451_0_CLK/X }
C {devices/lab_pin.sym} 61540 -18290 0 1 {name=p61013 lab=_88363_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 61500 -18290 0 0 {name=Xclkbuf_10_903_0_CLK }
C {devices/lab_pin.sym} 61440 -18190 0 0 {name=p61014 lab=_65339_/X }
C {devices/lab_pin.sym} 61440 -18150 0 0 {name=p61015 lab=_66521_/B }
C {devices/lab_pin.sym} 61440 -18110 0 0 {name=p61016 lab=_65344_/X }
C {devices/lab_pin.sym} 61560 -18150 0 1 {name=p61017 lab=_66507_/Y }
C {sky130_stdcells/nand3_4.sym} 61500 -18150 0 0 {name=X_66507_ }
C {devices/lab_pin.sym} 61410 -18010 0 0 {name=p61018 lab=_85375_/CLK }
C {devices/lab_pin.sym} 61410 -17990 0 0 {name=p61019 lab=_54984_/Y }
C {devices/lab_pin.sym} 61590 -18010 0 1 {name=p61020 lab=_85341_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -18000 0 0 {name=X_85341_ }
C {devices/lab_pin.sym} 61420 -17890 0 0 {name=p61021 lab=_85955_/Q }
C {devices/lab_pin.sym} 61420 -17850 0 0 {name=p61022 lab=_50220_/X }
C {devices/lab_pin.sym} 61420 -17810 0 0 {name=p61023 lab=_51732_/Y }
C {devices/lab_pin.sym} 61580 -17850 0 1 {name=p61024 lab=_51733_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -17850 0 0 {name=X_51733_ }
C {devices/lab_pin.sym} 61420 -17730 0 0 {name=p61025 lab=_63717_/Y }
C {devices/lab_pin.sym} 61420 -17690 0 0 {name=p61026 lab=_63679_/X }
C {devices/lab_pin.sym} 61420 -17650 0 0 {name=p61027 lab=_63718_/Y }
C {devices/lab_pin.sym} 61580 -17690 0 1 {name=p61028 lab=_63719_/Y }
C {sky130_stdcells/a21oi_4.sym} 61500 -17690 0 0 {name=X_63719_ }
C {devices/lab_pin.sym} 61410 -17550 0 0 {name=p61029 lab=_82553_/CLK }
C {devices/lab_pin.sym} 61410 -17530 0 0 {name=p61030 lab=_82553_/D }
C {devices/lab_pin.sym} 61590 -17550 0 1 {name=p61031 lab=_82553_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -17540 0 0 {name=X_82553_ }
C {devices/lab_pin.sym} 61440 -17420 0 0 {name=p61032 lab=_67513_/A }
C {devices/lab_pin.sym} 61440 -17380 0 0 {name=p61033 lab=_87213_/Q }
C {devices/lab_pin.sym} 61560 -17400 0 1 {name=p61034 lab=_67487_/X }
C {sky130_stdcells/and2_4.sym} 61500 -17400 0 0 {name=X_67487_ }
C {devices/lab_pin.sym} 61440 -17280 0 0 {name=p61035 lab=_65836_/A }
C {devices/lab_pin.sym} 61440 -17240 0 0 {name=p61036 lab=_86045_/Q }
C {devices/lab_pin.sym} 61560 -17260 0 1 {name=p61037 lab=_64699_/X }
C {sky130_stdcells/and2_4.sym} 61500 -17260 0 0 {name=X_64699_ }
C {devices/lab_pin.sym} 61420 -17160 0 0 {name=p61038 lab=_44288_/X }
C {devices/lab_pin.sym} 61420 -17120 0 0 {name=p61039 lab=_56575_/X }
C {devices/lab_pin.sym} 61420 -17080 0 0 {name=p61040 lab=_45426_/A }
C {devices/lab_pin.sym} 61420 -17040 0 0 {name=p61041 lab=_57238_/X }
C {devices/lab_pin.sym} 61580 -17100 0 1 {name=p61042 lab=_85055_/D }
C {sky130_stdcells/a2bb2o_4.sym} 61500 -17100 0 0 {name=X_57240_ }
C {devices/lab_pin.sym} 61410 -16950 0 0 {name=p61043 lab=_81322_/CLK }
C {devices/lab_pin.sym} 61410 -16930 0 0 {name=p61044 lab=_81504_/D }
C {devices/lab_pin.sym} 61590 -16950 0 1 {name=p61045 lab=_76946_/B }
C {sky130_stdcells/dfxtp_4.sym} 61500 -16940 0 0 {name=X_81504_ }
C {devices/lab_pin.sym} 61440 -16820 0 0 {name=p61046 lab=_69222_/X }
C {devices/lab_pin.sym} 61440 -16780 0 0 {name=p61047 lab=_69226_/B }
C {devices/lab_pin.sym} 61560 -16800 0 1 {name=p61048 lab=_69226_/Y }
C {sky130_stdcells/nand2_4.sym} 61500 -16800 0 0 {name=X_69226_ }
C {devices/lab_pin.sym} 61410 -16670 0 0 {name=p61049 lab=_88060_/CLK }
C {devices/lab_pin.sym} 61410 -16650 0 0 {name=p61050 lab=_88060_/D }
C {devices/lab_pin.sym} 61590 -16670 0 1 {name=p61051 lab=_42041_/A }
C {sky130_stdcells/dfxtp_4.sym} 61500 -16660 0 0 {name=X_88060_ }
C {devices/lab_pin.sym} 61420 -16550 0 0 {name=p61052 lab=_85439_/Q }
C {devices/lab_pin.sym} 61420 -16510 0 0 {name=p61053 lab=_54431_/X }
C {devices/lab_pin.sym} 61420 -16470 0 0 {name=p61054 lab=_54451_/Y }
C {devices/lab_pin.sym} 61580 -16510 0 1 {name=p61055 lab=_54452_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -16510 0 0 {name=X_54452_ }
C {devices/lab_pin.sym} 61460 -16370 0 0 {name=p61056 lab=clkbuf_4_10_1_CLK/X }
C {devices/lab_pin.sym} 61540 -16370 0 1 {name=p61057 lab=clkbuf_6_41_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 61500 -16370 0 0 {name=Xclkbuf_5_20_0_CLK }
C {devices/lab_pin.sym} 61420 -16270 0 0 {name=p61058 lab=_66436_/Y }
C {devices/lab_pin.sym} 61420 -16230 0 0 {name=p61059 lab=_66437_/Y }
C {devices/lab_pin.sym} 61420 -16190 0 0 {name=p61060 lab=_63317_/X }
C {devices/lab_pin.sym} 61580 -16230 0 1 {name=p61061 lab=_66438_/X }
C {sky130_stdcells/a21o_4.sym} 61500 -16230 0 0 {name=X_66438_ }
C {devices/lab_pin.sym} 61410 -16090 0 0 {name=p61062 lab=_85241_/CLK }
C {devices/lab_pin.sym} 61410 -16070 0 0 {name=p61063 lab=_85272_/D }
C {devices/lab_pin.sym} 61590 -16090 0 1 {name=p61064 lab=_56216_/C }
C {sky130_stdcells/dfxtp_4.sym} 61500 -16080 0 0 {name=X_85272_ }
C {devices/lab_pin.sym} 61420 -15970 0 0 {name=p61065 lab=_51661_/Y }
C {devices/lab_pin.sym} 61420 -15930 0 0 {name=p61066 lab=_51639_/X }
C {devices/lab_pin.sym} 61420 -15890 0 0 {name=p61067 lab=_51663_/X }
C {devices/lab_pin.sym} 61580 -15930 0 1 {name=p61068 lab=_85969_/D }
C {sky130_stdcells/a21oi_4.sym} 61500 -15930 0 0 {name=X_51664_ }
C {devices/lab_pin.sym} 61410 -15790 0 0 {name=p61069 lab=_82580_/CLK }
C {devices/lab_pin.sym} 61410 -15770 0 0 {name=p61070 lab=_82484_/D }
C {devices/lab_pin.sym} 61590 -15790 0 1 {name=p61071 lab=_82860_/D }
C {sky130_stdcells/dfxtp_4.sym} 61500 -15780 0 0 {name=X_82484_ }
C {devices/lab_pin.sym} 61410 -15650 0 0 {name=p61072 lab=_87011_/CLK }
C {devices/lab_pin.sym} 61410 -15630 0 0 {name=p61073 lab=_87011_/D }
C {devices/lab_pin.sym} 61590 -15650 0 1 {name=p61074 lab=_87011_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -15640 0 0 {name=X_87011_ }
C {devices/lab_pin.sym} 61420 -15530 0 0 {name=p61075 lab=_53400_/Y }
C {devices/lab_pin.sym} 61420 -15490 0 0 {name=p61076 lab=_53382_/X }
C {devices/lab_pin.sym} 61420 -15450 0 0 {name=p61077 lab=_53402_/X }
C {devices/lab_pin.sym} 61580 -15490 0 1 {name=p61078 lab=_85640_/D }
C {sky130_stdcells/a21oi_4.sym} 61500 -15490 0 0 {name=X_53403_ }
C {devices/lab_pin.sym} 61410 -15350 0 0 {name=p61079 lab=_84223_/CLK }
C {devices/lab_pin.sym} 61410 -15330 0 0 {name=p61080 lab=_84223_/D }
C {devices/lab_pin.sym} 61590 -15350 0 1 {name=p61081 lab=_84223_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -15340 0 0 {name=X_84223_ }
C {devices/lab_pin.sym} 61440 -15220 0 0 {name=p61082 lab=_50624_/A }
C {devices/lab_pin.sym} 61440 -15180 0 0 {name=p61083 lab=_53834_/B }
C {devices/lab_pin.sym} 61560 -15200 0 1 {name=p61084 lab=_50615_/Y }
C {sky130_stdcells/nand2_4.sym} 61500 -15200 0 0 {name=X_50615_ }
C {devices/lab_pin.sym} 61410 -15070 0 0 {name=p61085 lab=_84064_/CLK }
C {devices/lab_pin.sym} 61410 -15050 0 0 {name=p61086 lab=_81467_/Q }
C {devices/lab_pin.sym} 61590 -15070 0 1 {name=p61087 lab=_76109_/B }
C {sky130_stdcells/dfxtp_4.sym} 61500 -15060 0 0 {name=X_81435_ }
C {devices/lab_pin.sym} 61460 -14930 0 0 {name=p61088 lab=_56995_/A }
C {devices/lab_pin.sym} 61540 -14930 0 1 {name=p61089 lab=_74342_/A }
C {sky130_stdcells/buf_2.sym} 61500 -14930 0 0 {name=X_57171_ }
C {devices/lab_pin.sym} 61420 -14830 0 0 {name=p61090 lab=_69152_/X }
C {devices/lab_pin.sym} 61420 -14790 0 0 {name=p61091 lab=_69155_/X }
C {devices/lab_pin.sym} 61420 -14750 0 0 {name=p61092 lab=_69156_/X }
C {devices/lab_pin.sym} 61580 -14790 0 1 {name=p61093 lab=_69157_/Y }
C {sky130_stdcells/a21oi_4.sym} 61500 -14790 0 0 {name=X_69157_ }
C {devices/lab_pin.sym} 61420 -14670 0 0 {name=p61094 lab=_85452_/Q }
C {devices/lab_pin.sym} 61420 -14630 0 0 {name=p61095 lab=_54376_/X }
C {devices/lab_pin.sym} 61420 -14590 0 0 {name=p61096 lab=_54382_/Y }
C {devices/lab_pin.sym} 61580 -14630 0 1 {name=p61097 lab=_54383_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -14630 0 0 {name=X_54383_ }
C {devices/lab_pin.sym} 61440 -14510 0 0 {name=p61098 lab=_66318_/X }
C {devices/lab_pin.sym} 61440 -14470 0 0 {name=p61099 lab=_66415_/B }
C {devices/lab_pin.sym} 61440 -14430 0 0 {name=p61100 lab=_84136_/Q }
C {devices/lab_pin.sym} 61560 -14470 0 1 {name=p61101 lab=_66369_/X }
C {sky130_stdcells/and3_4.sym} 61500 -14470 0 0 {name=X_66369_ }
C {devices/lab_pin.sym} 61460 -14330 0 0 {name=p61102 lab=_51622_/A }
C {devices/lab_pin.sym} 61540 -14330 0 1 {name=p61103 lab=_51617_/A }
C {sky130_stdcells/buf_2.sym} 61500 -14330 0 0 {name=X_51595_ }
C {devices/lab_pin.sym} 61460 -14210 0 0 {name=p61104 lab=clkbuf_9_459_0_CLK/X }
C {devices/lab_pin.sym} 61540 -14210 0 1 {name=p61105 lab=_83561_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 61500 -14210 0 0 {name=Xclkbuf_10_918_0_CLK }
C {devices/lab_pin.sym} 61460 -14090 0 0 {name=p61106 lab=_45369_/A }
C {devices/lab_pin.sym} 61540 -14090 0 1 {name=p61107 lab=_56123_/A }
C {sky130_stdcells/buf_2.sym} 61500 -14090 0 0 {name=X_56122_ }
C {devices/lab_pin.sym} 61420 -14000 0 0 {name=p61108 lab=_68088_/X }
C {devices/lab_pin.sym} 61420 -13960 0 0 {name=p61109 lab=_66671_/Y }
C {devices/lab_pin.sym} 61420 -13920 0 0 {name=p61110 lab=_68089_/X }
C {devices/lab_pin.sym} 61420 -13880 0 0 {name=p61111 lab=_68107_/Y }
C {devices/lab_pin.sym} 61580 -13940 0 1 {name=p61112 lab=_68108_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -13940 0 0 {name=X_68108_ }
C {devices/lab_pin.sym} 61440 -13820 0 0 {name=p61113 lab=_53330_/A }
C {devices/lab_pin.sym} 61440 -13780 0 0 {name=p61114 lab=_53330_/B }
C {devices/lab_pin.sym} 61440 -13740 0 0 {name=p61115 lab=_53330_/C }
C {devices/lab_pin.sym} 61440 -13700 0 0 {name=p61116 lab=_52818_/D }
C {devices/lab_pin.sym} 61560 -13760 0 1 {name=p61117 lab=_53334_/X }
C {sky130_stdcells/and4_4.sym} 61500 -13760 0 0 {name=X_53334_ }
C {devices/lab_pin.sym} 61410 -13610 0 0 {name=p61118 lab=_82746_/CLK }
C {devices/lab_pin.sym} 61410 -13590 0 0 {name=p61119 lab=_84154_/D }
C {devices/lab_pin.sym} 61590 -13610 0 1 {name=p61120 lab=_66138_/A }
C {sky130_stdcells/dfxtp_4.sym} 61500 -13600 0 0 {name=X_84154_ }
C {devices/lab_pin.sym} 61420 -13490 0 0 {name=p61121 lab=_86180_/Q }
C {devices/lab_pin.sym} 61420 -13450 0 0 {name=p61122 lab=_50533_/X }
C {devices/lab_pin.sym} 61420 -13410 0 0 {name=p61123 lab=_50545_/Y }
C {devices/lab_pin.sym} 61580 -13450 0 1 {name=p61124 lab=_50546_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -13450 0 0 {name=X_50546_ }
C {devices/lab_pin.sym} 61410 -13310 0 0 {name=p61125 lab=_83940_/CLK }
C {devices/lab_pin.sym} 61410 -13290 0 0 {name=p61126 lab=_76961_/Y }
C {devices/lab_pin.sym} 61590 -13310 0 1 {name=p61127 lab=_81366_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -13300 0 0 {name=X_81366_ }
C {devices/lab_pin.sym} 61460 -13170 0 0 {name=p61128 lab=_69088_/A }
C {devices/lab_pin.sym} 61540 -13170 0 1 {name=p61129 lab=_69088_/X }
C {sky130_stdcells/buf_2.sym} 61500 -13170 0 0 {name=X_69088_ }
C {devices/lab_pin.sym} 61460 -13050 0 0 {name=p61130 lab=clkbuf_9_3_0_CLK/X }
C {devices/lab_pin.sym} 61540 -13050 0 1 {name=p61131 lab=_85279_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 61500 -13050 0 0 {name=Xclkbuf_10_7_0_CLK }
C {devices/lab_pin.sym} 61410 -12930 0 0 {name=p61132 lab=_83095_/CLK }
C {devices/lab_pin.sym} 61410 -12910 0 0 {name=p61133 lab=_74307_/X }
C {devices/lab_pin.sym} 61590 -12930 0 1 {name=p61134 lab=_83105_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -12920 0 0 {name=X_83105_ }
C {devices/lab_pin.sym} 61460 -12790 0 0 {name=p61135 lab=clkbuf_9_409_0_CLK/A }
C {devices/lab_pin.sym} 61540 -12790 0 1 {name=p61136 lab=clkbuf_9_409_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 61500 -12790 0 0 {name=Xclkbuf_9_409_0_CLK }
C {devices/lab_pin.sym} 61420 -12690 0 0 {name=p61137 lab=_56029_/X }
C {devices/lab_pin.sym} 61420 -12650 0 0 {name=p61138 lab=_56050_/X }
C {devices/lab_pin.sym} 61420 -12610 0 0 {name=p61139 lab=_56052_/Y }
C {devices/lab_pin.sym} 61580 -12650 0 1 {name=p61140 lab=_85305_/D }
C {sky130_stdcells/o21ai_4.sym} 61500 -12650 0 0 {name=X_56053_ }
C {devices/lab_pin.sym} 61440 -12530 0 0 {name=p61141 lab=_80306_/Y }
C {devices/lab_pin.sym} 61440 -12490 0 0 {name=p61142 lab=_80317_/B }
C {devices/lab_pin.sym} 61440 -12450 0 0 {name=p61143 lab=_80318_/A }
C {devices/lab_pin.sym} 61560 -12490 0 1 {name=p61144 lab=_80320_/A }
C {sky130_stdcells/nand3_4.sym} 61500 -12490 0 0 {name=X_80317_ }
C {devices/lab_pin.sym} 61420 -12370 0 0 {name=p61145 lab=_84044_/Q }
C {devices/lab_pin.sym} 61420 -12330 0 0 {name=p61146 lab=_67925_/X }
C {devices/lab_pin.sym} 61420 -12290 0 0 {name=p61147 lab=_68038_/X }
C {devices/lab_pin.sym} 61580 -12330 0 1 {name=p61148 lab=_84044_/D }
C {sky130_stdcells/a21bo_4.sym} 61500 -12330 0 0 {name=X_68039_ }
C {devices/lab_pin.sym} 61460 -12190 0 0 {name=p61149 lab=_51843_/A }
C {devices/lab_pin.sym} 61540 -12190 0 1 {name=p61150 lab=_53274_/B }
C {sky130_stdcells/buf_2.sym} 61500 -12190 0 0 {name=X_53265_ }
C {devices/lab_pin.sym} 61410 -12070 0 0 {name=p61151 lab=_84087_/CLK }
C {devices/lab_pin.sym} 61410 -12050 0 0 {name=p61152 lab=_67068_/X }
C {devices/lab_pin.sym} 61590 -12070 0 1 {name=p61153 lab=_84085_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -12060 0 0 {name=X_84085_ }
C {devices/lab_pin.sym} 61440 -11940 0 0 {name=p61154 lab=_50465_/X }
C {devices/lab_pin.sym} 61440 -11900 0 0 {name=p61155 lab=_48540_/B }
C {devices/lab_pin.sym} 61560 -11920 0 1 {name=p61156 lab=_50477_/Y }
C {sky130_stdcells/nand2_4.sym} 61500 -11920 0 0 {name=X_50477_ }
C {devices/lab_pin.sym} 61410 -11790 0 0 {name=p61157 lab=_81811_/CLK }
C {devices/lab_pin.sym} 61410 -11770 0 0 {name=p61158 lab=_76985_/X }
C {devices/lab_pin.sym} 61590 -11790 0 1 {name=p61159 lab=_81265_/D }
C {sky130_stdcells/dfxtp_4.sym} 61500 -11780 0 0 {name=X_81297_ }
C {devices/lab_pin.sym} 61460 -11650 0 0 {name=p61160 lab=_54927_/A }
C {devices/lab_pin.sym} 61540 -11650 0 1 {name=p61161 lab=_55026_/B }
C {sky130_stdcells/buf_2.sym} 61500 -11650 0 0 {name=X_55004_ }
C {devices/lab_pin.sym} 61440 -11540 0 0 {name=p61162 lab=_52220_/A }
C {devices/lab_pin.sym} 61440 -11500 0 0 {name=p61163 lab=_52216_/B }
C {devices/lab_pin.sym} 61560 -11520 0 1 {name=p61164 lab=_52216_/Y }
C {sky130_stdcells/nand2_4.sym} 61500 -11520 0 0 {name=X_52216_ }
C {devices/lab_pin.sym} 61440 -11410 0 0 {name=p61165 lab=_71055_/A }
C {devices/lab_pin.sym} 61440 -11370 0 0 {name=p61166 lab=_71073_/B }
C {devices/lab_pin.sym} 61440 -11330 0 0 {name=p61167 lab=_71055_/C }
C {devices/lab_pin.sym} 61560 -11370 0 1 {name=p61168 lab=_71050_/Y }
C {sky130_stdcells/nand3_4.sym} 61500 -11370 0 0 {name=X_71050_ }
C {devices/lab_pin.sym} 61410 -11230 0 0 {name=p61169 lab=_87188_/CLK }
C {devices/lab_pin.sym} 61410 -11210 0 0 {name=p61170 lab=_42340_/Y }
C {devices/lab_pin.sym} 61590 -11230 0 1 {name=p61171 lab=_87913_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -11220 0 0 {name=X_87913_ }
C {devices/lab_pin.sym} 61410 -11090 0 0 {name=p61172 lab=_85213_/CLK }
C {devices/lab_pin.sym} 61410 -11070 0 0 {name=p61173 lab=_74558_/Y }
C {devices/lab_pin.sym} 61590 -11090 0 1 {name=p61174 lab=_44989_/A }
C {sky130_stdcells/dfxtp_4.sym} 61500 -11080 0 0 {name=X_83036_ }
C {devices/lab_pin.sym} 61440 -10960 0 0 {name=p61175 lab=_80243_/X }
C {devices/lab_pin.sym} 61440 -10920 0 0 {name=p61176 lab=_80247_/Y }
C {devices/lab_pin.sym} 61560 -10940 0 1 {name=p61177 lab=_80248_/X }
C {sky130_stdcells/xor2_4.sym} 61500 -10940 0 0 {name=X_80248_ }
C {devices/lab_pin.sym} 61440 -10840 0 0 {name=p61178 lab=_53211_/A }
C {devices/lab_pin.sym} 61440 -10800 0 0 {name=p61179 lab=_53181_/B }
C {devices/lab_pin.sym} 61440 -10760 0 0 {name=p61180 lab=_53195_/X }
C {devices/lab_pin.sym} 61440 -10720 0 0 {name=p61181 lab=_53196_/D }
C {devices/lab_pin.sym} 61560 -10780 0 1 {name=p61182 lab=_53196_/X }
C {sky130_stdcells/and4_4.sym} 61500 -10780 0 0 {name=X_53196_ }
C {devices/lab_pin.sym} 61460 -10630 0 0 {name=p61183 lab=_70001_/A }
C {devices/lab_pin.sym} 61540 -10630 0 1 {name=p61184 lab=_70001_/X }
C {sky130_stdcells/buf_2.sym} 61500 -10630 0 0 {name=X_70001_ }
C {devices/lab_pin.sym} 61440 -10530 0 0 {name=p61185 lab=_59758_/X }
C {devices/lab_pin.sym} 61440 -10490 0 0 {name=p61186 lab=_59654_/X }
C {devices/lab_pin.sym} 61440 -10450 0 0 {name=p61187 lab=_59811_/Y }
C {devices/lab_pin.sym} 61560 -10490 0 1 {name=p61188 lab=_59812_/Y }
C {sky130_stdcells/nand3_4.sym} 61500 -10490 0 0 {name=X_59812_ }
C {devices/lab_pin.sym} 61420 -10370 0 0 {name=p61189 lab=_52144_/Y }
C {devices/lab_pin.sym} 61420 -10330 0 0 {name=p61190 lab=_52145_/X }
C {devices/lab_pin.sym} 61420 -10290 0 0 {name=p61191 lab=_52146_/X }
C {devices/lab_pin.sym} 61580 -10330 0 1 {name=p61192 lab=_85880_/D }
C {sky130_stdcells/a21oi_4.sym} 61500 -10330 0 0 {name=X_52147_ }
C {devices/lab_pin.sym} 61410 -10190 0 0 {name=p61193 lab=_87588_/CLK }
C {devices/lab_pin.sym} 61410 -10170 0 0 {name=p61194 lab=_87844_/D }
C {devices/lab_pin.sym} 61590 -10190 0 1 {name=p61195 lab=_42499_/A }
C {sky130_stdcells/dfxtp_4.sym} 61500 -10180 0 0 {name=X_87844_ }
C {devices/lab_pin.sym} 61420 -10080 0 0 {name=p61196 lab=_80151_/Y }
C {devices/lab_pin.sym} 61420 -10040 0 0 {name=p61197 lab=_80169_/B }
C {devices/lab_pin.sym} 61420 -10000 0 0 {name=p61198 lab=_80164_/Y }
C {devices/lab_pin.sym} 61420 -9960 0 0 {name=p61199 lab=_80167_/Y }
C {devices/lab_pin.sym} 61580 -10020 0 1 {name=p61200 lab=_80179_/X }
C {sky130_stdcells/o22a_4.sym} 61500 -10020 0 0 {name=X_80179_ }
C {devices/lab_pin.sym} 61440 -9880 0 0 {name=p61201 lab=_59608_/A }
C {devices/lab_pin.sym} 61440 -9840 0 0 {name=p61202 lab=_59743_/B }
C {devices/lab_pin.sym} 61560 -9860 0 1 {name=p61203 lab=_59743_/Y }
C {sky130_stdcells/nor2_4.sym} 61500 -9860 0 0 {name=X_59743_ }
C {devices/lab_pin.sym} 61420 -9750 0 0 {name=p61204 lab=_85893_/Q }
C {devices/lab_pin.sym} 61420 -9710 0 0 {name=p61205 lab=_52075_/X }
C {devices/lab_pin.sym} 61420 -9670 0 0 {name=p61206 lab=_52077_/Y }
C {devices/lab_pin.sym} 61580 -9710 0 1 {name=p61207 lab=_52078_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -9710 0 0 {name=X_52078_ }
C {devices/lab_pin.sym} 61420 -9590 0 0 {name=p61208 lab=_56600_/X }
C {devices/lab_pin.sym} 61420 -9550 0 0 {name=p61209 lab=_56952_/X }
C {devices/lab_pin.sym} 61420 -9510 0 0 {name=p61210 lab=_56954_/Y }
C {devices/lab_pin.sym} 61580 -9550 0 1 {name=p61211 lab=_85115_/D }
C {sky130_stdcells/a21oi_4.sym} 61500 -9550 0 0 {name=X_56955_ }
C {devices/lab_pin.sym} 61410 -9410 0 0 {name=p61212 lab=_87789_/CLK }
C {devices/lab_pin.sym} 61410 -9390 0 0 {name=p61213 lab=_87775_/D }
C {devices/lab_pin.sym} 61590 -9410 0 1 {name=p61214 lab=_69409_/B }
C {sky130_stdcells/dfxtp_4.sym} 61500 -9400 0 0 {name=X_87775_ }
C {devices/lab_pin.sym} 61410 -9270 0 0 {name=p61215 lab=_84991_/CLK }
C {devices/lab_pin.sym} 61410 -9250 0 0 {name=p61216 lab=_57522_/Y }
C {devices/lab_pin.sym} 61590 -9270 0 1 {name=p61217 lab=_84987_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -9260 0 0 {name=X_84987_ }
C {devices/lab_pin.sym} 61420 -9160 0 0 {name=p61218 lab=_41393_/X }
C {devices/lab_pin.sym} 61420 -9120 0 0 {name=p61219 lab=_43907_/X }
C {devices/lab_pin.sym} 61420 -9080 0 0 {name=p61220 lab=_67810_/B }
C {devices/lab_pin.sym} 61420 -9040 0 0 {name=p61221 lab=_43908_/X }
C {devices/lab_pin.sym} 61580 -9100 0 1 {name=p61222 lab=_43920_/X }
C {sky130_stdcells/a2bb2o_4.sym} 61500 -9100 0 0 {name=X_43920_ }
C {devices/lab_pin.sym} 61440 -8980 0 0 {name=p61223 lab=_51029_/A }
C {devices/lab_pin.sym} 61440 -8940 0 0 {name=p61224 lab=_51029_/B }
C {devices/lab_pin.sym} 61440 -8900 0 0 {name=p61225 lab=_51029_/C }
C {devices/lab_pin.sym} 61440 -8860 0 0 {name=p61226 lab=_52720_/D }
C {devices/lab_pin.sym} 61560 -8920 0 1 {name=p61227 lab=_51029_/X }
C {sky130_stdcells/and4_4.sym} 61500 -8920 0 0 {name=X_51029_ }
C {devices/lab_pin.sym} 61420 -8800 0 0 {name=p61228 lab=_85209_/Q }
C {devices/lab_pin.sym} 61420 -8760 0 0 {name=p61229 lab=_44106_/C }
C {devices/lab_pin.sym} 61420 -8720 0 0 {name=p61230 lab=_55627_/X }
C {devices/lab_pin.sym} 61420 -8680 0 0 {name=p61231 lab=_55905_/X }
C {devices/lab_pin.sym} 61580 -8740 0 1 {name=p61232 lab=_55906_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -8740 0 0 {name=X_55906_ }
C {devices/lab_pin.sym} 61440 -8620 0 0 {name=p61233 lab=_71012_/B }
C {devices/lab_pin.sym} 61440 -8580 0 0 {name=p61234 lab=_74740_/B }
C {devices/lab_pin.sym} 61440 -8540 0 0 {name=p61235 lab=_71507_/B }
C {devices/lab_pin.sym} 61440 -8500 0 0 {name=p61236 lab=_74739_/Y }
C {devices/lab_pin.sym} 61560 -8560 0 1 {name=p61237 lab=_74740_/Y }
C {sky130_stdcells/nand4_4.sym} 61500 -8560 0 0 {name=X_74740_ }
C {devices/lab_pin.sym} 61410 -8410 0 0 {name=p61238 lab=_86119_/CLK }
C {devices/lab_pin.sym} 61410 -8390 0 0 {name=p61239 lab=_86726_/D }
C {devices/lab_pin.sym} 61590 -8410 0 1 {name=p61240 lab=_86726_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -8400 0 0 {name=X_86726_ }
C {devices/lab_pin.sym} 61420 -8290 0 0 {name=p61241 lab=_71942_/Y }
C {devices/lab_pin.sym} 61420 -8250 0 0 {name=p61242 lab=_83316_/Q }
C {devices/lab_pin.sym} 61420 -8210 0 0 {name=p61243 lab=_71951_/Y }
C {devices/lab_pin.sym} 61580 -8250 0 1 {name=p61244 lab=_83316_/D }
C {sky130_stdcells/a21o_4.sym} 61500 -8250 0 0 {name=X_71952_ }
C {devices/lab_pin.sym} 61460 -8110 0 0 {name=p61245 lab=_60036_/A }
C {devices/lab_pin.sym} 61540 -8110 0 1 {name=p61246 lab=_66262_/A }
C {sky130_stdcells/buf_2.sym} 61500 -8110 0 0 {name=X_59674_ }
C {devices/lab_pin.sym} 61410 -7990 0 0 {name=p61247 lab=_83932_/CLK }
C {devices/lab_pin.sym} 61410 -7970 0 0 {name=p61248 lab=_69244_/X }
C {devices/lab_pin.sym} 61590 -7990 0 1 {name=p61249 lab=_83938_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -7980 0 0 {name=X_83938_ }
C {devices/lab_pin.sym} 61440 -7860 0 0 {name=p61250 lab=_56880_/X }
C {devices/lab_pin.sym} 61440 -7820 0 0 {name=p61251 lab=_56886_/B }
C {devices/lab_pin.sym} 61560 -7840 0 1 {name=p61252 lab=_56886_/Y }
C {sky130_stdcells/xnor2_4.sym} 61500 -7840 0 0 {name=X_56886_ }
C {devices/lab_pin.sym} 61460 -7710 0 0 {name=p61253 lab=clkbuf_6_9_0_CLK/A }
C {devices/lab_pin.sym} 61540 -7710 0 1 {name=p61254 lab=clkbuf_6_9_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 61500 -7710 0 0 {name=Xclkbuf_6_9_0_CLK }
C {devices/lab_pin.sym} 61460 -7590 0 0 {name=p61255 lab=_58858_/A }
C {devices/lab_pin.sym} 61540 -7590 0 1 {name=p61256 lab=_58625_/X }
C {sky130_stdcells/buf_2.sym} 61500 -7590 0 0 {name=X_58625_ }
C {devices/lab_pin.sym} 61440 -7500 0 0 {name=p61257 lab=_70903_/A }
C {devices/lab_pin.sym} 61440 -7460 0 0 {name=p61258 lab=_70903_/B }
C {devices/lab_pin.sym} 61440 -7420 0 0 {name=p61259 lab=_70899_/C }
C {devices/lab_pin.sym} 61440 -7380 0 0 {name=p61260 lab=_70899_/D }
C {devices/lab_pin.sym} 61560 -7440 0 1 {name=p61261 lab=_70903_/Y }
C {sky130_stdcells/nand4_4.sym} 61500 -7440 0 0 {name=X_70903_ }
C {devices/lab_pin.sym} 61420 -7320 0 0 {name=p61262 lab=_85264_/Q }
C {devices/lab_pin.sym} 61420 -7280 0 0 {name=p61263 lab=_55475_/X }
C {devices/lab_pin.sym} 61420 -7240 0 0 {name=p61264 lab=_44048_/X }
C {devices/lab_pin.sym} 61420 -7200 0 0 {name=p61265 lab=_55836_/X }
C {devices/lab_pin.sym} 61580 -7260 0 1 {name=p61266 lab=_55837_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -7260 0 0 {name=X_55837_ }
C {devices/lab_pin.sym} 61420 -7140 0 0 {name=p61267 lab=_41203_/X }
C {devices/lab_pin.sym} 61420 -7100 0 0 {name=p61268 lab=_43842_/X }
C {devices/lab_pin.sym} 61420 -7060 0 0 {name=p61269 lab=_68793_/B }
C {devices/lab_pin.sym} 61420 -7020 0 0 {name=p61270 lab=_43843_/X }
C {devices/lab_pin.sym} 61580 -7080 0 1 {name=p61271 lab=_87234_/D }
C {sky130_stdcells/a2bb2o_4.sym} 61500 -7080 0 0 {name=X_43851_ }
C {devices/lab_pin.sym} 61420 -6950 0 0 {name=p61272 lab=_74673_/A }
C {devices/lab_pin.sym} 61420 -6910 0 0 {name=p61273 lab=_56752_/A }
C {devices/lab_pin.sym} 61420 -6870 0 0 {name=p61274 lab=_74670_/Y }
C {devices/lab_pin.sym} 61580 -6910 0 1 {name=p61275 lab=_74672_/A }
C {sky130_stdcells/o21ai_4.sym} 61500 -6910 0 0 {name=X_74671_ }
C {devices/lab_pin.sym} 61410 -6770 0 0 {name=p61276 lab=_85727_/CLK }
C {devices/lab_pin.sym} 61410 -6750 0 0 {name=p61277 lab=_86657_/D }
C {devices/lab_pin.sym} 61590 -6770 0 1 {name=p61278 lab=_57698_/A }
C {sky130_stdcells/dfxtp_4.sym} 61500 -6760 0 0 {name=X_86657_ }
C {devices/lab_pin.sym} 61440 -6660 0 0 {name=p61279 lab=_71883_/A }
C {devices/lab_pin.sym} 61440 -6620 0 0 {name=p61280 lab=_71883_/B }
C {devices/lab_pin.sym} 61440 -6580 0 0 {name=p61281 lab=_71873_/X }
C {devices/lab_pin.sym} 61440 -6540 0 0 {name=p61282 lab=_71883_/D }
C {devices/lab_pin.sym} 61560 -6600 0 1 {name=p61283 lab=_71883_/Y }
C {sky130_stdcells/nor4_4.sym} 61500 -6600 0 0 {name=X_71883_ }
C {devices/lab_pin.sym} 61410 -6450 0 0 {name=p61284 lab=_82553_/CLK }
C {devices/lab_pin.sym} 61410 -6430 0 0 {name=p61285 lab=_70028_/X }
C {devices/lab_pin.sym} 61590 -6450 0 1 {name=p61286 lab=_82549_/D }
C {sky130_stdcells/dfxtp_4.sym} 61500 -6440 0 0 {name=X_83869_ }
C {devices/lab_pin.sym} 61440 -6320 0 0 {name=p61287 lab=_76410_/A }
C {devices/lab_pin.sym} 61440 -6280 0 0 {name=p61288 lab=_81568_/Q }
C {devices/lab_pin.sym} 61560 -6300 0 1 {name=p61289 lab=_76410_/Y }
C {sky130_stdcells/nand2_4.sym} 61500 -6300 0 0 {name=X_76410_ }
C {devices/lab_pin.sym} 61460 -6170 0 0 {name=p61290 lab=_42745_/A }
C {devices/lab_pin.sym} 61540 -6170 0 1 {name=p61291 lab=_42802_/X }
C {sky130_stdcells/buf_2.sym} 61500 -6170 0 0 {name=X_42802_ }
C {devices/lab_pin.sym} 61420 -6070 0 0 {name=p61292 lab=_73620_/X }
C {devices/lab_pin.sym} 61420 -6030 0 0 {name=p61293 lab=_73621_/Y }
C {devices/lab_pin.sym} 61420 -5990 0 0 {name=p61294 lab=_73546_/X }
C {devices/lab_pin.sym} 61580 -6030 0 1 {name=p61295 lab=_73622_/X }
C {sky130_stdcells/a21o_4.sym} 61500 -6030 0 0 {name=X_73622_ }
C {devices/lab_pin.sym} 61410 -5890 0 0 {name=p61296 lab=_85601_/CLK }
C {devices/lab_pin.sym} 61410 -5870 0 0 {name=p61297 lab=_85608_/D }
C {devices/lab_pin.sym} 61590 -5890 0 1 {name=p61298 lab=_85608_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -5880 0 0 {name=X_85608_ }
C {devices/lab_pin.sym} 61440 -5760 0 0 {name=p61299 lab=_46531_/A }
C {devices/lab_pin.sym} 61440 -5720 0 0 {name=p61300 lab=_54079_/B }
C {devices/lab_pin.sym} 61560 -5740 0 1 {name=p61301 lab=_46570_/Y }
C {sky130_stdcells/nand2_4.sym} 61500 -5740 0 0 {name=X_46570_ }
C {devices/lab_pin.sym} 61420 -5630 0 0 {name=p61302 lab=_51744_/B }
C {devices/lab_pin.sym} 61420 -5590 0 0 {name=p61303 lab=_70831_/X }
C {devices/lab_pin.sym} 61420 -5550 0 0 {name=p61304 lab=_70833_/Y }
C {devices/lab_pin.sym} 61580 -5590 0 1 {name=p61305 lab=_83689_/D }
C {sky130_stdcells/o21ai_4.sym} 61500 -5590 0 0 {name=X_70834_ }
C {devices/lab_pin.sym} 61460 -5450 0 0 {name=p61306 lab=_84819_/Q }
C {devices/lab_pin.sym} 61540 -5450 0 1 {name=p61307 lab=_58557_/A }
C {sky130_stdcells/inv_2.sym} 61500 -5450 0 0 {name=X_58556_ }
C {devices/lab_pin.sym} 61440 -5340 0 0 {name=p61308 lab=_77390_/A }
C {devices/lab_pin.sym} 61440 -5300 0 0 {name=p61309 lab=_82189_/D }
C {devices/lab_pin.sym} 61560 -5320 0 1 {name=p61310 lab=_77390_/X }
C {sky130_stdcells/xor2_4.sym} 61500 -5320 0 0 {name=X_77390_ }
C {devices/lab_pin.sym} 61420 -5230 0 0 {name=p61311 lab=_43774_/X }
C {devices/lab_pin.sym} 61420 -5190 0 0 {name=p61312 lab=_43781_/X }
C {devices/lab_pin.sym} 61420 -5150 0 0 {name=p61313 lab=_41009_/X }
C {devices/lab_pin.sym} 61420 -5110 0 0 {name=p61314 lab=_69318_/B }
C {devices/lab_pin.sym} 61420 -5070 0 0 {name=p61315 lab=_43776_/X }
C {devices/lab_pin.sym} 61580 -5150 0 1 {name=p61316 lab=_43782_/Y }
C {sky130_stdcells/o32ai_4.sym} 61500 -5150 0 0 {name=X_43782_ }
C {devices/lab_pin.sym} 61420 -5010 0 0 {name=p61317 lab=_55765_/X }
C {devices/lab_pin.sym} 61420 -4970 0 0 {name=p61318 lab=_55767_/X }
C {devices/lab_pin.sym} 61420 -4930 0 0 {name=p61319 lab=_44108_/X }
C {devices/lab_pin.sym} 61580 -4970 0 1 {name=p61320 lab=_55768_/X }
C {sky130_stdcells/a21o_4.sym} 61500 -4970 0 0 {name=X_55768_ }
C {devices/lab_pin.sym} 61410 -4830 0 0 {name=p61321 lab=_86237_/CLK }
C {devices/lab_pin.sym} 61410 -4810 0 0 {name=p61322 lab=_47896_/Y }
C {devices/lab_pin.sym} 61590 -4830 0 1 {name=p61323 lab=_65977_/B }
C {sky130_stdcells/dfxtp_4.sym} 61500 -4820 0 0 {name=X_86588_ }
C {devices/lab_pin.sym} 61460 -4690 0 0 {name=p61324 lab=_40994_/A }
C {devices/lab_pin.sym} 61540 -4690 0 1 {name=p61325 lab=_40994_/X }
C {sky130_stdcells/buf_2.sym} 61500 -4690 0 0 {name=X_40994_ }
C {devices/lab_pin.sym} 61440 -4580 0 0 {name=p61326 lab=_57254_/B }
C {devices/lab_pin.sym} 61440 -4540 0 0 {name=p61327 lab=_45490_/B }
C {devices/lab_pin.sym} 61560 -4560 0 1 {name=p61328 lab=_45521_/Y }
C {sky130_stdcells/nor2_4.sym} 61500 -4560 0 0 {name=X_45521_ }
C {devices/lab_pin.sym} 61440 -4450 0 0 {name=p61329 lab=_47871_/A }
C {devices/lab_pin.sym} 61440 -4410 0 0 {name=p61330 lab=_49317_/X }
C {devices/lab_pin.sym} 61440 -4370 0 0 {name=p61331 lab=_46603_/X }
C {devices/lab_pin.sym} 61560 -4410 0 1 {name=p61332 lab=_57507_/X }
C {sky130_stdcells/and3_4.sym} 61500 -4410 0 0 {name=X_57507_ }
C {devices/lab_pin.sym} 61420 -4290 0 0 {name=p61333 lab=_76324_/Y }
C {devices/lab_pin.sym} 61420 -4250 0 0 {name=p61334 lab=_76339_/X }
C {devices/lab_pin.sym} 61420 -4210 0 0 {name=p61335 lab=_76340_/X }
C {devices/lab_pin.sym} 61580 -4250 0 1 {name=p61336 lab=_76342_/B }
C {sky130_stdcells/a21boi_4.sym} 61500 -4250 0 0 {name=X_76341_ }
C {devices/lab_pin.sym} 61420 -4150 0 0 {name=p61337 lab=_42721_/X }
C {devices/lab_pin.sym} 61420 -4110 0 0 {name=p61338 lab=_42723_/X }
C {devices/lab_pin.sym} 61420 -4070 0 0 {name=p61339 lab=_41209_/X }
C {devices/lab_pin.sym} 61420 -4030 0 0 {name=p61340 lab=_87745_/Q }
C {devices/lab_pin.sym} 61420 -3990 0 0 {name=p61341 lab=_42732_/X }
C {devices/lab_pin.sym} 61580 -4070 0 1 {name=p61342 lab=_42734_/A }
C {sky130_stdcells/o32ai_4.sym} 61500 -4070 0 0 {name=X_42733_ }
C {devices/lab_pin.sym} 61410 -3910 0 0 {name=p61343 lab=_88327_/CLK }
C {devices/lab_pin.sym} 61410 -3890 0 0 {name=p61344 lab=_40828_/Y }
C {devices/lab_pin.sym} 61590 -3910 0 1 {name=p61345 lab=_69725_/B }
C {sky130_stdcells/dfxtp_4.sym} 61500 -3900 0 0 {name=X_88327_ }
C {devices/lab_pin.sym} 61420 -3790 0 0 {name=p61346 lab=_85390_/Q }
C {devices/lab_pin.sym} 61420 -3750 0 0 {name=p61347 lab=_54703_/X }
C {devices/lab_pin.sym} 61420 -3710 0 0 {name=p61348 lab=_54718_/Y }
C {devices/lab_pin.sym} 61580 -3750 0 1 {name=p61349 lab=_54719_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -3750 0 0 {name=X_54719_ }
C {devices/lab_pin.sym} 61420 -3640 0 0 {name=p61350 lab=_68361_/Y }
C {devices/lab_pin.sym} 61420 -3600 0 0 {name=p61351 lab=_73319_/X }
C {devices/lab_pin.sym} 61420 -3560 0 0 {name=p61352 lab=_73551_/X }
C {devices/lab_pin.sym} 61420 -3520 0 0 {name=p61353 lab=_73552_/Y }
C {devices/lab_pin.sym} 61580 -3580 0 1 {name=p61354 lab=_73553_/X }
C {sky130_stdcells/a211o_4.sym} 61500 -3580 0 0 {name=X_73553_ }
C {devices/lab_pin.sym} 61410 -3430 0 0 {name=p61355 lab=_85826_/CLK }
C {devices/lab_pin.sym} 61410 -3410 0 0 {name=p61356 lab=_85539_/D }
C {devices/lab_pin.sym} 61590 -3430 0 1 {name=p61357 lab=_85539_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -3420 0 0 {name=X_85539_ }
C {devices/lab_pin.sym} 61460 -3290 0 0 {name=p61358 lab=_70772_/A }
C {devices/lab_pin.sym} 61540 -3290 0 1 {name=p61359 lab=_70766_/C }
C {sky130_stdcells/buf_2.sym} 61500 -3290 0 0 {name=X_70765_ }
C {devices/lab_pin.sym} 61440 -3180 0 0 {name=p61360 lab=_58487_/A }
C {devices/lab_pin.sym} 61440 -3140 0 0 {name=p61361 lab=_58502_/B }
C {devices/lab_pin.sym} 61560 -3160 0 1 {name=p61362 lab=_58487_/Y }
C {sky130_stdcells/nor2_4.sym} 61500 -3160 0 0 {name=X_58487_ }
C {devices/lab_pin.sym} 61420 -3060 0 0 {name=p61363 lab=_74541_/C }
C {devices/lab_pin.sym} 61420 -3020 0 0 {name=p61364 lab=_55690_/X }
C {devices/lab_pin.sym} 61420 -2980 0 0 {name=p61365 lab=_44102_/X }
C {devices/lab_pin.sym} 61420 -2940 0 0 {name=p61366 lab=_55698_/X }
C {devices/lab_pin.sym} 61580 -3000 0 1 {name=p61367 lab=_55700_/B }
C {sky130_stdcells/a211o_4.sym} 61500 -3000 0 0 {name=X_55699_ }
C {devices/lab_pin.sym} 61420 -2870 0 0 {name=p61368 lab=_48237_/Y }
C {devices/lab_pin.sym} 61420 -2830 0 0 {name=p61369 lab=_48226_/X }
C {devices/lab_pin.sym} 61420 -2790 0 0 {name=p61370 lab=_48239_/Y }
C {devices/lab_pin.sym} 61580 -2830 0 1 {name=p61371 lab=_86550_/D }
C {sky130_stdcells/a21boi_4.sym} 61500 -2830 0 0 {name=X_48240_ }
C {devices/lab_pin.sym} 61460 -2690 0 0 {name=p61372 lab=_72516_/B }
C {devices/lab_pin.sym} 61540 -2690 0 1 {name=p61373 lab=_72535_/A }
C {sky130_stdcells/inv_2.sym} 61500 -2690 0 0 {name=X_72504_ }
C {devices/lab_pin.sym} 61440 -2590 0 0 {name=p61374 lab=_79058_/A }
C {devices/lab_pin.sym} 61440 -2550 0 0 {name=p61375 lab=_82749_/Q }
C {devices/lab_pin.sym} 61440 -2510 0 0 {name=p61376 lab=_79058_/B }
C {devices/lab_pin.sym} 61560 -2550 0 1 {name=p61377 lab=_79060_/Y }
C {sky130_stdcells/nand3_4.sym} 61500 -2550 0 0 {name=X_79060_ }
C {devices/lab_pin.sym} 61420 -2430 0 0 {name=p61378 lab=_57408_/X }
C {devices/lab_pin.sym} 61420 -2390 0 0 {name=p61379 lab=_57436_/X }
C {devices/lab_pin.sym} 61420 -2350 0 0 {name=p61380 lab=_57437_/Y }
C {devices/lab_pin.sym} 61580 -2390 0 1 {name=p61381 lab=_57439_/A }
C {sky130_stdcells/o21ai_4.sym} 61500 -2390 0 0 {name=X_57438_ }
C {devices/lab_pin.sym} 61460 -2250 0 0 {name=p61382 lab=_45452_/A }
C {devices/lab_pin.sym} 61540 -2250 0 1 {name=p61383 lab=_45452_/X }
C {sky130_stdcells/buf_2.sym} 61500 -2250 0 0 {name=X_45452_ }
C {devices/lab_pin.sym} 61420 -2150 0 0 {name=p61384 lab=_76268_/Y }
C {devices/lab_pin.sym} 61420 -2110 0 0 {name=p61385 lab=_76211_/Y }
C {devices/lab_pin.sym} 61420 -2070 0 0 {name=p61386 lab=_76271_/X }
C {devices/lab_pin.sym} 61580 -2110 0 1 {name=p61387 lab=_76272_/Y }
C {sky130_stdcells/o21ai_4.sym} 61500 -2110 0 0 {name=X_76272_ }
C {devices/lab_pin.sym} 61410 -1970 0 0 {name=p61388 lab=_87103_/CLK }
C {devices/lab_pin.sym} 61410 -1950 0 0 {name=p61389 lab=_41204_/X }
C {devices/lab_pin.sym} 61590 -1970 0 1 {name=p61390 lab=_68796_/B }
C {sky130_stdcells/dfxtp_4.sym} 61500 -1960 0 0 {name=X_88258_ }
C {devices/lab_pin.sym} 61460 -1830 0 0 {name=p61391 lab=_42663_/Y }
C {devices/lab_pin.sym} 61540 -1830 0 1 {name=p61392 lab=_42664_/Y }
C {sky130_stdcells/inv_2.sym} 61500 -1830 0 0 {name=X_42664_ }
C {devices/lab_pin.sym} 61440 -1720 0 0 {name=p61393 lab=_73484_/A }
C {devices/lab_pin.sym} 61440 -1680 0 0 {name=p61394 lab=_72892_/B }
C {devices/lab_pin.sym} 61560 -1700 0 1 {name=p61395 lab=_73484_/Y }
C {sky130_stdcells/nor2_4.sym} 61500 -1700 0 0 {name=X_73484_ }
C {devices/lab_pin.sym} 61440 -1590 0 0 {name=p61396 lab=_70758_/A }
C {devices/lab_pin.sym} 61440 -1550 0 0 {name=p61397 lab=_70696_/B }
C {devices/lab_pin.sym} 61440 -1510 0 0 {name=p61398 lab=_70758_/B }
C {devices/lab_pin.sym} 61560 -1550 0 1 {name=p61399 lab=_70935_/A }
C {sky130_stdcells/nor3_4.sym} 61500 -1550 0 0 {name=X_70696_ }
C {devices/lab_pin.sym} 61460 -1410 0 0 {name=p61400 lab=_78011_/A }
C {devices/lab_pin.sym} 61540 -1410 0 1 {name=p61401 lab=_78011_/Y }
C {sky130_stdcells/inv_2.sym} 61500 -1410 0 0 {name=X_78011_ }
C {devices/lab_pin.sym} 61420 -1320 0 0 {name=p61402 lab=_41511_/X }
C {devices/lab_pin.sym} 61420 -1280 0 0 {name=p61403 lab=_44394_/X }
C {devices/lab_pin.sym} 61420 -1240 0 0 {name=p61404 lab=_87125_/Q }
C {devices/lab_pin.sym} 61420 -1200 0 0 {name=p61405 lab=_44395_/X }
C {devices/lab_pin.sym} 61580 -1260 0 1 {name=p61406 lab=_44403_/X }
C {sky130_stdcells/a2bb2o_4.sym} 61500 -1260 0 0 {name=X_44403_ }
C {devices/lab_pin.sym} 61410 -1110 0 0 {name=p61407 lab=_87210_/CLK }
C {devices/lab_pin.sym} 61410 -1090 0 0 {name=p61408 lab=_43901_/Y }
C {devices/lab_pin.sym} 61590 -1110 0 1 {name=p61409 lab=_87209_/Q }
C {sky130_stdcells/dfxtp_4.sym} 61500 -1100 0 0 {name=X_87209_ }
C {devices/lab_pin.sym} 61420 -990 0 0 {name=p61410 lab=_75214_/B }
C {devices/lab_pin.sym} 61420 -950 0 0 {name=p61411 lab=_81068_/Q }
C {devices/lab_pin.sym} 61420 -910 0 0 {name=p61412 lab=_75222_/Y }
C {devices/lab_pin.sym} 61580 -950 0 1 {name=p61413 lab=_75223_/Y }
C {sky130_stdcells/a21boi_4.sym} 61500 -950 0 0 {name=X_75223_ }
C {devices/lab_pin.sym} 61420 -830 0 0 {name=p61414 lab=_41533_/X }
C {devices/lab_pin.sym} 61420 -790 0 0 {name=p61415 lab=_82308_/Q }
C {devices/lab_pin.sym} 61420 -750 0 0 {name=p61416 lab=_41614_/X }
C {devices/lab_pin.sym} 61580 -790 0 1 {name=p61417 lab=_41615_/X }
C {sky130_stdcells/o21a_4.sym} 61500 -790 0 0 {name=X_41615_ }
C {devices/lab_pin.sym} 61460 -650 0 0 {name=p61418 lab=_48186_/A }
C {devices/lab_pin.sym} 61540 -650 0 1 {name=p61419 lab=_48171_/X }
C {sky130_stdcells/buf_2.sym} 61500 -650 0 0 {name=X_48171_ }
C {devices/lab_pin.sym} 62340 -42180 0 0 {name=p61420 lab=_83255_/Q }
C {devices/lab_pin.sym} 62340 -42140 0 0 {name=p61421 lab=_72381_/X }
C {devices/lab_pin.sym} 62340 -42100 0 0 {name=p61422 lab=_72429_/X }
C {devices/lab_pin.sym} 62340 -42060 0 0 {name=p61423 lab=_72434_/X }
C {devices/lab_pin.sym} 62500 -42120 0 1 {name=p61424 lab=_83255_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 62420 -42120 0 0 {name=X_72435_ }
C {devices/lab_pin.sym} 62380 -41970 0 0 {name=p61425 lab=_62629_/A }
C {devices/lab_pin.sym} 62460 -41970 0 1 {name=p61426 lab=_61692_/B }
C {sky130_stdcells/buf_2.sym} 62420 -41970 0 0 {name=X_45383_ }
C {devices/lab_pin.sym} 62360 -41860 0 0 {name=p61427 lab=_57244_/X }
C {devices/lab_pin.sym} 62360 -41820 0 0 {name=p61428 lab=_45870_/Y }
C {devices/lab_pin.sym} 62480 -41840 0 1 {name=p61429 lab=_57369_/Y }
C {sky130_stdcells/nand2_4.sym} 62420 -41840 0 0 {name=X_57369_ }
C {devices/lab_pin.sym} 62330 -41710 0 0 {name=p61430 lab=_87116_/CLK }
C {devices/lab_pin.sym} 62330 -41690 0 0 {name=p61431 lab=_41576_/Y }
C {devices/lab_pin.sym} 62510 -41710 0 1 {name=p61432 lab=_67100_/B }
C {sky130_stdcells/dfxtp_4.sym} 62420 -41700 0 0 {name=X_88189_ }
C {devices/lab_pin.sym} 62340 -41610 0 0 {name=p61433 lab=_42590_/X }
C {devices/lab_pin.sym} 62340 -41570 0 0 {name=p61434 lab=_42592_/X }
C {devices/lab_pin.sym} 62340 -41530 0 0 {name=p61435 lab=_40866_/X }
C {devices/lab_pin.sym} 62340 -41490 0 0 {name=p61436 lab=_87808_/Q }
C {devices/lab_pin.sym} 62340 -41450 0 0 {name=p61437 lab=_42580_/X }
C {devices/lab_pin.sym} 62500 -41530 0 1 {name=p61438 lab=_42596_/A }
C {sky130_stdcells/o32ai_4.sym} 62420 -41530 0 0 {name=X_42595_ }
C {devices/lab_pin.sym} 62340 -41390 0 0 {name=p61439 lab=_47118_/Y }
C {devices/lab_pin.sym} 62340 -41350 0 0 {name=p61440 lab=_47081_/X }
C {devices/lab_pin.sym} 62340 -41310 0 0 {name=p61441 lab=_47121_/X }
C {devices/lab_pin.sym} 62500 -41350 0 1 {name=p61442 lab=_47122_/Y }
C {sky130_stdcells/a21oi_4.sym} 62420 -41350 0 0 {name=X_47122_ }
C {devices/lab_pin.sym} 62340 -41230 0 0 {name=p61443 lab=_59085_/X }
C {devices/lab_pin.sym} 62340 -41190 0 0 {name=p61444 lab=_86072_/Q }
C {devices/lab_pin.sym} 62340 -41150 0 0 {name=p61445 lab=_59107_/X }
C {devices/lab_pin.sym} 62500 -41190 0 1 {name=p61446 lab=_59108_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -41190 0 0 {name=X_59108_ }
C {devices/lab_pin.sym} 62380 -41050 0 0 {name=p61447 lab=_44333_/Y }
C {devices/lab_pin.sym} 62460 -41050 0 1 {name=p61448 lab=_87162_/D }
C {sky130_stdcells/inv_2.sym} 62420 -41050 0 0 {name=X_44334_ }
C {devices/lab_pin.sym} 62380 -40930 0 0 {name=p61449 lab=_75157_/B }
C {devices/lab_pin.sym} 62460 -40930 0 1 {name=p61450 lab=_75154_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -40930 0 0 {name=X_75154_ }
C {devices/lab_pin.sym} 62340 -40850 0 0 {name=p61451 lab=_41540_/X }
C {devices/lab_pin.sym} 62340 -40810 0 0 {name=p61452 lab=_41541_/X }
C {devices/lab_pin.sym} 62340 -40770 0 0 {name=p61453 lab=_41545_/X }
C {devices/lab_pin.sym} 62340 -40730 0 0 {name=p61454 lab=_66966_/B }
C {devices/lab_pin.sym} 62340 -40690 0 0 {name=p61455 lab=_41537_/X }
C {devices/lab_pin.sym} 62500 -40770 0 1 {name=p61456 lab=_41547_/A }
C {sky130_stdcells/o32ai_4.sym} 62420 -40770 0 0 {name=X_41546_ }
C {devices/lab_pin.sym} 62360 -40640 0 0 {name=p61457 lab=_59775_/X }
C {devices/lab_pin.sym} 62360 -40600 0 0 {name=p61458 lab=_60380_/B }
C {devices/lab_pin.sym} 62360 -40560 0 0 {name=p61459 lab=_60392_/A }
C {devices/lab_pin.sym} 62360 -40520 0 0 {name=p61460 lab=_60392_/C }
C {devices/lab_pin.sym} 62480 -40580 0 1 {name=p61461 lab=_60381_/A }
C {sky130_stdcells/and4_4.sym} 62420 -40580 0 0 {name=X_60380_ }
C {devices/lab_pin.sym} 62360 -40440 0 0 {name=p61462 lab=_72366_/A }
C {devices/lab_pin.sym} 62360 -40400 0 0 {name=p61463 lab=_72366_/B }
C {devices/lab_pin.sym} 62480 -40420 0 1 {name=p61464 lab=_72366_/Y }
C {sky130_stdcells/nor2_4.sym} 62420 -40420 0 0 {name=X_72366_ }
C {devices/lab_pin.sym} 62340 -40320 0 0 {name=p61465 lab=_74080_/X }
C {devices/lab_pin.sym} 62340 -40280 0 0 {name=p61466 lab=_86218_/Q }
C {devices/lab_pin.sym} 62340 -40240 0 0 {name=p61467 lab=_74103_/X }
C {devices/lab_pin.sym} 62340 -40200 0 0 {name=p61468 lab=_74104_/X }
C {devices/lab_pin.sym} 62500 -40260 0 1 {name=p61469 lab=_74105_/X }
C {sky130_stdcells/a211o_4.sym} 62420 -40260 0 0 {name=X_74105_ }
C {devices/lab_pin.sym} 62380 -40110 0 0 {name=p61470 lab=_47053_/A }
C {devices/lab_pin.sym} 62460 -40110 0 1 {name=p61471 lab=_52829_/B }
C {sky130_stdcells/buf_2.sym} 62420 -40110 0 0 {name=X_47053_ }
C {devices/lab_pin.sym} 62340 -40010 0 0 {name=p61472 lab=_48073_/B }
C {devices/lab_pin.sym} 62340 -39970 0 0 {name=p61473 lab=_71289_/Y }
C {devices/lab_pin.sym} 62340 -39930 0 0 {name=p61474 lab=_71316_/Y }
C {devices/lab_pin.sym} 62500 -39970 0 1 {name=p61475 lab=_83538_/D }
C {sky130_stdcells/o21ai_4.sym} 62420 -39970 0 0 {name=X_71317_ }
C {devices/lab_pin.sym} 62340 -39850 0 0 {name=p61476 lab=_59001_/X }
C {devices/lab_pin.sym} 62340 -39810 0 0 {name=p61477 lab=_86078_/Q }
C {devices/lab_pin.sym} 62340 -39770 0 0 {name=p61478 lab=_59038_/X }
C {devices/lab_pin.sym} 62500 -39810 0 1 {name=p61479 lab=_59039_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -39810 0 0 {name=X_59039_ }
C {devices/lab_pin.sym} 62360 -39700 0 0 {name=p61480 lab=_65880_/A }
C {devices/lab_pin.sym} 62360 -39660 0 0 {name=p61481 lab=_44261_/X }
C {devices/lab_pin.sym} 62360 -39620 0 0 {name=p61482 lab=_57837_/A }
C {devices/lab_pin.sym} 62360 -39580 0 0 {name=p61483 lab=_44265_/D }
C {devices/lab_pin.sym} 62480 -39640 0 1 {name=p61484 lab=_44265_/Y }
C {sky130_stdcells/nor4_4.sym} 62420 -39640 0 0 {name=X_44265_ }
C {devices/lab_pin.sym} 62380 -39490 0 0 {name=p61485 lab=_79960_/Y }
C {devices/lab_pin.sym} 62460 -39490 0 1 {name=p61486 lab=_79963_/A }
C {sky130_stdcells/inv_2.sym} 62420 -39490 0 0 {name=X_79962_ }
C {devices/lab_pin.sym} 62360 -39390 0 0 {name=p61487 lab=_75082_/X }
C {devices/lab_pin.sym} 62360 -39350 0 0 {name=p61488 lab=_75085_/B }
C {devices/lab_pin.sym} 62360 -39310 0 0 {name=p61489 lab=_75102_/B }
C {devices/lab_pin.sym} 62480 -39350 0 1 {name=p61490 lab=_75102_/A }
C {sky130_stdcells/nand3_4.sym} 62420 -39350 0 0 {name=X_75085_ }
C {devices/lab_pin.sym} 62360 -39220 0 0 {name=p61491 lab=_81181_/Q }
C {devices/lab_pin.sym} 62360 -39180 0 0 {name=p61492 lab=_41459_/B }
C {devices/lab_pin.sym} 62480 -39200 0 1 {name=p61493 lab=_41477_/X }
C {sky130_stdcells/or2_4.sym} 62420 -39200 0 0 {name=X_41477_ }
C {devices/lab_pin.sym} 62340 -39110 0 0 {name=p61494 lab=_72270_/X }
C {devices/lab_pin.sym} 62340 -39070 0 0 {name=p61495 lab=_72294_/Y }
C {devices/lab_pin.sym} 62340 -39030 0 0 {name=p61496 lab=_72295_/Y }
C {devices/lab_pin.sym} 62340 -38990 0 0 {name=p61497 lab=_72296_/X }
C {devices/lab_pin.sym} 62340 -38950 0 0 {name=p61498 lab=_72274_/X }
C {devices/lab_pin.sym} 62500 -39030 0 1 {name=p61499 lab=_72297_/X }
C {sky130_stdcells/o32a_4.sym} 62420 -39030 0 0 {name=X_72297_ }
C {devices/lab_pin.sym} 62340 -38900 0 0 {name=p61500 lab=_40484_/Y }
C {devices/lab_pin.sym} 62340 -38860 0 0 {name=p61501 lab=_45974_/X }
C {devices/lab_pin.sym} 62340 -38820 0 0 {name=p61502 lab=_67023_/B }
C {devices/lab_pin.sym} 62340 -38780 0 0 {name=p61503 lab=_45976_/X }
C {devices/lab_pin.sym} 62500 -38840 0 1 {name=p61504 lab=_86819_/D }
C {sky130_stdcells/a2bb2o_4.sym} 62420 -38840 0 0 {name=X_46004_ }
C {devices/lab_pin.sym} 62380 -38690 0 0 {name=p61505 lab=_43180_/A }
C {devices/lab_pin.sym} 62460 -38690 0 1 {name=p61506 lab=_43216_/X }
C {sky130_stdcells/buf_2.sym} 62420 -38690 0 0 {name=X_43216_ }
C {devices/lab_pin.sym} 62380 -38570 0 0 {name=p61507 lab=_61722_/A }
C {devices/lab_pin.sym} 62460 -38570 0 1 {name=p61508 lab=_62050_/X }
C {sky130_stdcells/buf_2.sym} 62420 -38570 0 0 {name=X_62050_ }
C {devices/lab_pin.sym} 62340 -38470 0 0 {name=p61509 lab=_88351_/Q }
C {devices/lab_pin.sym} 62340 -38430 0 0 {name=p61510 lab=_72899_/X }
C {devices/lab_pin.sym} 62340 -38390 0 0 {name=p61511 lab=_73898_/X }
C {devices/lab_pin.sym} 62500 -38430 0 1 {name=p61512 lab=_74036_/X }
C {sky130_stdcells/o21a_4.sym} 62420 -38430 0 0 {name=X_74036_ }
C {devices/lab_pin.sym} 62360 -38300 0 0 {name=p61513 lab=_78900_/A }
C {devices/lab_pin.sym} 62360 -38260 0 0 {name=p61514 lab=_78908_/A }
C {devices/lab_pin.sym} 62480 -38280 0 1 {name=p61515 lab=_78913_/X }
C {sky130_stdcells/and2_4.sym} 62420 -38280 0 0 {name=X_78913_ }
C {devices/lab_pin.sym} 62380 -38150 0 0 {name=p61516 lab=_40428_/A }
C {devices/lab_pin.sym} 62460 -38150 0 1 {name=p61517 lab=_40428_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -38150 0 0 {name=X_40428_ }
C {devices/lab_pin.sym} 62360 -38050 0 0 {name=p61518 lab=_71252_/A }
C {devices/lab_pin.sym} 62360 -38010 0 0 {name=p61519 lab=_71223_/B }
C {devices/lab_pin.sym} 62360 -37970 0 0 {name=p61520 lab=_71248_/C }
C {devices/lab_pin.sym} 62480 -38010 0 1 {name=p61521 lab=_71248_/Y }
C {sky130_stdcells/nand3_4.sym} 62420 -38010 0 0 {name=X_71248_ }
C {devices/lab_pin.sym} 62360 -37900 0 0 {name=p61522 lab=_44196_/A }
C {devices/lab_pin.sym} 62360 -37860 0 0 {name=p61523 lab=_44196_/B }
C {devices/lab_pin.sym} 62360 -37820 0 0 {name=p61524 lab=_72899_/A }
C {devices/lab_pin.sym} 62360 -37780 0 0 {name=p61525 lab=_44196_/D }
C {devices/lab_pin.sym} 62480 -37840 0 1 {name=p61526 lab=_44196_/X }
C {sky130_stdcells/and4_4.sym} 62420 -37840 0 0 {name=X_44196_ }
C {devices/lab_pin.sym} 62360 -37700 0 0 {name=p61527 lab=_79547_/A }
C {devices/lab_pin.sym} 62360 -37660 0 0 {name=p61528 lab=_79546_/Y }
C {devices/lab_pin.sym} 62480 -37680 0 1 {name=p61529 lab=_79893_/X }
C {sky130_stdcells/xor2_4.sym} 62420 -37680 0 0 {name=X_79893_ }
C {devices/lab_pin.sym} 62380 -37550 0 0 {name=p61530 lab=clkbuf_2_1_0_CLK/X }
C {devices/lab_pin.sym} 62460 -37550 0 1 {name=p61531 lab=clkbuf_2_1_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 62420 -37550 0 0 {name=Xclkbuf_2_1_1_CLK }
C {devices/lab_pin.sym} 62360 -37450 0 0 {name=p61532 lab=_60969_/X }
C {devices/lab_pin.sym} 62360 -37410 0 0 {name=p61533 lab=_61000_/X }
C {devices/lab_pin.sym} 62360 -37370 0 0 {name=p61534 lab=_84543_/Q }
C {devices/lab_pin.sym} 62480 -37410 0 1 {name=p61535 lab=_61001_/X }
C {sky130_stdcells/or3_4.sym} 62420 -37410 0 0 {name=X_61001_ }
C {devices/lab_pin.sym} 62340 -37310 0 0 {name=p61536 lab=_43146_/X }
C {devices/lab_pin.sym} 62340 -37270 0 0 {name=p61537 lab=_43110_/X }
C {devices/lab_pin.sym} 62340 -37230 0 0 {name=p61538 lab=_40831_/X }
C {devices/lab_pin.sym} 62340 -37190 0 0 {name=p61539 lab=_73108_/A }
C {devices/lab_pin.sym} 62340 -37150 0 0 {name=p61540 lab=_43121_/X }
C {devices/lab_pin.sym} 62500 -37230 0 1 {name=p61541 lab=_43147_/Y }
C {sky130_stdcells/o32ai_4.sym} 62420 -37230 0 0 {name=X_43147_ }
C {devices/lab_pin.sym} 62360 -37080 0 0 {name=p61542 lab=_78874_/A }
C {devices/lab_pin.sym} 62360 -37040 0 0 {name=p61543 lab=_78854_/B }
C {devices/lab_pin.sym} 62480 -37060 0 1 {name=p61544 lab=_78845_/B }
C {sky130_stdcells/xor2_4.sym} 62420 -37060 0 0 {name=X_78844_ }
C {devices/lab_pin.sym} 62380 -36930 0 0 {name=p61545 lab=_44587_/A }
C {devices/lab_pin.sym} 62460 -36930 0 1 {name=p61546 lab=_44528_/A }
C {sky130_stdcells/buf_2.sym} 62420 -36930 0 0 {name=X_40359_ }
C {devices/lab_pin.sym} 62340 -36830 0 0 {name=p61547 lab=_52158_/B }
C {devices/lab_pin.sym} 62340 -36790 0 0 {name=p61548 lab=_71165_/X }
C {devices/lab_pin.sym} 62340 -36750 0 0 {name=p61549 lab=_71178_/Y }
C {devices/lab_pin.sym} 62500 -36790 0 1 {name=p61550 lab=_71179_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -36790 0 0 {name=X_71179_ }
C {devices/lab_pin.sym} 62360 -36660 0 0 {name=p61551 lab=_47955_/A }
C {devices/lab_pin.sym} 62360 -36620 0 0 {name=p61552 lab=_47963_/B }
C {devices/lab_pin.sym} 62480 -36640 0 1 {name=p61553 lab=_47955_/X }
C {sky130_stdcells/or2_4.sym} 62420 -36640 0 0 {name=X_47955_ }
C {devices/lab_pin.sym} 62380 -36510 0 0 {name=p61554 lab=_87584_/Q }
C {devices/lab_pin.sym} 62460 -36510 0 1 {name=p61555 lab=_43078_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -36510 0 0 {name=X_43078_ }
C {devices/lab_pin.sym} 62380 -36390 0 0 {name=p61556 lab=_82816_/Q }
C {devices/lab_pin.sym} 62460 -36390 0 1 {name=p61557 lab=_78775_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -36390 0 0 {name=X_78775_ }
C {devices/lab_pin.sym} 62360 -36280 0 0 {name=p61558 lab=_81515_/Q }
C {devices/lab_pin.sym} 62360 -36240 0 0 {name=p61559 lab=_81739_/D }
C {devices/lab_pin.sym} 62480 -36260 0 1 {name=p61560 lab=_75987_/X }
C {sky130_stdcells/xor2_4.sym} 62420 -36260 0 0 {name=X_75987_ }
C {devices/lab_pin.sym} 62360 -36160 0 0 {name=p61561 lab=_46868_/A }
C {devices/lab_pin.sym} 62360 -36120 0 0 {name=p61562 lab=_46896_/B }
C {devices/lab_pin.sym} 62360 -36080 0 0 {name=p61563 lab=_46926_/C }
C {devices/lab_pin.sym} 62360 -36040 0 0 {name=p61564 lab=_52742_/D }
C {devices/lab_pin.sym} 62480 -36100 0 1 {name=p61565 lab=_46906_/X }
C {sky130_stdcells/and4_4.sym} 62420 -36100 0 0 {name=X_46906_ }
C {devices/lab_pin.sym} 62340 -35990 0 0 {name=p61566 lab=_42028_/X }
C {devices/lab_pin.sym} 62340 -35950 0 0 {name=p61567 lab=_42024_/X }
C {devices/lab_pin.sym} 62340 -35910 0 0 {name=p61568 lab=_40861_/X }
C {devices/lab_pin.sym} 62340 -35870 0 0 {name=p61569 lab=_73225_/A }
C {devices/lab_pin.sym} 62340 -35830 0 0 {name=p61570 lab=_42025_/X }
C {devices/lab_pin.sym} 62500 -35910 0 1 {name=p61571 lab=_42029_/Y }
C {sky130_stdcells/o32ai_4.sym} 62420 -35910 0 0 {name=X_42029_ }
C {devices/lab_pin.sym} 62340 -35780 0 0 {name=p61572 lab=_64599_/X }
C {devices/lab_pin.sym} 62340 -35740 0 0 {name=p61573 lab=_83061_/Q }
C {devices/lab_pin.sym} 62340 -35700 0 0 {name=p61574 lab=_65015_/X }
C {devices/lab_pin.sym} 62340 -35660 0 0 {name=p61575 lab=_65739_/X }
C {devices/lab_pin.sym} 62500 -35720 0 1 {name=p61576 lab=_65740_/X }
C {sky130_stdcells/a211o_4.sym} 62420 -35720 0 0 {name=X_65740_ }
C {devices/lab_pin.sym} 62360 -35580 0 0 {name=p61577 lab=_82258_/Q }
C {devices/lab_pin.sym} 62360 -35540 0 0 {name=p61578 lab=_77732_/B }
C {devices/lab_pin.sym} 62480 -35560 0 1 {name=p61579 lab=_78044_/A }
C {sky130_stdcells/xnor2_4.sym} 62420 -35560 0 0 {name=X_77726_ }
C {devices/lab_pin.sym} 62380 -35430 0 0 {name=p61580 lab=_63306_/A }
C {devices/lab_pin.sym} 62460 -35430 0 1 {name=p61581 lab=_62988_/B }
C {sky130_stdcells/buf_2.sym} 62420 -35430 0 0 {name=X_62952_ }
C {devices/lab_pin.sym} 62340 -35330 0 0 {name=p61582 lab=_74933_/Y }
C {devices/lab_pin.sym} 62340 -35290 0 0 {name=p61583 lab=_74942_/A }
C {devices/lab_pin.sym} 62340 -35250 0 0 {name=p61584 lab=_74937_/Y }
C {devices/lab_pin.sym} 62500 -35290 0 1 {name=p61585 lab=_74939_/B }
C {sky130_stdcells/a21boi_4.sym} 62420 -35290 0 0 {name=X_74938_ }
C {devices/lab_pin.sym} 62380 -35150 0 0 {name=p61586 lab=_47886_/A }
C {devices/lab_pin.sym} 62460 -35150 0 1 {name=p61587 lab=_47886_/X }
C {sky130_stdcells/buf_2.sym} 62420 -35150 0 0 {name=X_47886_ }
C {devices/lab_pin.sym} 62380 -35030 0 0 {name=p61588 lab=_59684_/X }
C {devices/lab_pin.sym} 62460 -35030 0 1 {name=p61589 lab=_61949_/B }
C {sky130_stdcells/buf_2.sym} 62420 -35030 0 0 {name=X_61903_ }
C {devices/lab_pin.sym} 62360 -34940 0 0 {name=p61590 lab=_49625_/A }
C {devices/lab_pin.sym} 62360 -34900 0 0 {name=p61591 lab=_49614_/X }
C {devices/lab_pin.sym} 62360 -34860 0 0 {name=p61592 lab=_49615_/C }
C {devices/lab_pin.sym} 62360 -34820 0 0 {name=p61593 lab=_52841_/D }
C {devices/lab_pin.sym} 62480 -34880 0 1 {name=p61594 lab=_49625_/X }
C {sky130_stdcells/and4_4.sym} 62420 -34880 0 0 {name=X_49625_ }
C {devices/lab_pin.sym} 62380 -34730 0 0 {name=p61595 lab=_54395_/D }
C {devices/lab_pin.sym} 62460 -34730 0 1 {name=p61596 lab=_52704_/D }
C {sky130_stdcells/buf_2.sym} 62420 -34730 0 0 {name=X_46837_ }
C {devices/lab_pin.sym} 62340 -34640 0 0 {name=p61597 lab=_65638_/X }
C {devices/lab_pin.sym} 62340 -34600 0 0 {name=p61598 lab=_85585_/Q }
C {devices/lab_pin.sym} 62340 -34560 0 0 {name=p61599 lab=_65669_/X }
C {devices/lab_pin.sym} 62340 -34520 0 0 {name=p61600 lab=_65670_/X }
C {devices/lab_pin.sym} 62500 -34580 0 1 {name=p61601 lab=_65671_/X }
C {sky130_stdcells/a211o_4.sym} 62420 -34580 0 0 {name=X_65671_ }
C {devices/lab_pin.sym} 62340 -34450 0 0 {name=p61602 lab=_77629_/Y }
C {devices/lab_pin.sym} 62340 -34410 0 0 {name=p61603 lab=_77633_/B }
C {devices/lab_pin.sym} 62340 -34370 0 0 {name=p61604 lab=_77632_/A }
C {devices/lab_pin.sym} 62500 -34410 0 1 {name=p61605 lab=_77657_/X }
C {sky130_stdcells/o21a_4.sym} 62420 -34410 0 0 {name=X_77657_ }
C {devices/lab_pin.sym} 62340 -34290 0 0 {name=p61606 lab=_62881_/X }
C {devices/lab_pin.sym} 62340 -34250 0 0 {name=p61607 lab=_62838_/X }
C {devices/lab_pin.sym} 62340 -34210 0 0 {name=p61608 lab=_62882_/Y }
C {devices/lab_pin.sym} 62500 -34250 0 1 {name=p61609 lab=_84374_/D }
C {sky130_stdcells/a21oi_4.sym} 62420 -34250 0 0 {name=X_62883_ }
C {devices/lab_pin.sym} 62360 -34120 0 0 {name=p61610 lab=_81126_/D }
C {devices/lab_pin.sym} 62360 -34080 0 0 {name=p61611 lab=_74869_/B }
C {devices/lab_pin.sym} 62480 -34100 0 1 {name=p61612 lab=_74897_/A }
C {sky130_stdcells/xor2_4.sym} 62420 -34100 0 0 {name=X_74869_ }
C {devices/lab_pin.sym} 62340 -33990 0 0 {name=p61613 lab=_67407_/X }
C {devices/lab_pin.sym} 62340 -33950 0 0 {name=p61614 lab=_67409_/X }
C {devices/lab_pin.sym} 62340 -33910 0 0 {name=p61615 lab=_67383_/X }
C {devices/lab_pin.sym} 62500 -33950 0 1 {name=p61616 lab=_67410_/X }
C {sky130_stdcells/a21o_4.sym} 62420 -33950 0 0 {name=X_67410_ }
C {devices/lab_pin.sym} 62340 -33840 0 0 {name=p61617 lab=_64577_/X }
C {devices/lab_pin.sym} 62340 -33800 0 0 {name=p61618 lab=_86752_/Q }
C {devices/lab_pin.sym} 62340 -33760 0 0 {name=p61619 lab=_64579_/X }
C {devices/lab_pin.sym} 62340 -33720 0 0 {name=p61620 lab=_64621_/X }
C {devices/lab_pin.sym} 62500 -33780 0 1 {name=p61621 lab=_64622_/X }
C {sky130_stdcells/a211o_4.sym} 62420 -33780 0 0 {name=X_64622_ }
C {devices/lab_pin.sym} 62360 -33640 0 0 {name=p61622 lab=_76608_/A }
C {devices/lab_pin.sym} 62360 -33600 0 0 {name=p61623 lab=_76603_/X }
C {devices/lab_pin.sym} 62480 -33620 0 1 {name=p61624 lab=_76611_/A }
C {sky130_stdcells/nand2_4.sym} 62420 -33620 0 0 {name=X_76608_ }
C {devices/lab_pin.sym} 62360 -33520 0 0 {name=p61625 lab=_49561_/A }
C {devices/lab_pin.sym} 62360 -33480 0 0 {name=p61626 lab=_49537_/B }
C {devices/lab_pin.sym} 62360 -33440 0 0 {name=p61627 lab=_49548_/X }
C {devices/lab_pin.sym} 62360 -33400 0 0 {name=p61628 lab=_52771_/D }
C {devices/lab_pin.sym} 62480 -33460 0 1 {name=p61629 lab=_49556_/X }
C {sky130_stdcells/and4_4.sym} 62420 -33460 0 0 {name=X_49556_ }
C {devices/lab_pin.sym} 62340 -33350 0 0 {name=p61630 lab=_61823_/X }
C {devices/lab_pin.sym} 62340 -33310 0 0 {name=p61631 lab=_61828_/X }
C {devices/lab_pin.sym} 62340 -33270 0 0 {name=p61632 lab=_61833_/Y }
C {devices/lab_pin.sym} 62340 -33230 0 0 {name=p61633 lab=_84915_/Q }
C {devices/lab_pin.sym} 62340 -33190 0 0 {name=p61634 lab=_61815_/X }
C {devices/lab_pin.sym} 62500 -33270 0 1 {name=p61635 lab=_61834_/Y }
C {sky130_stdcells/o32ai_4.sym} 62420 -33270 0 0 {name=X_61834_ }
C {devices/lab_pin.sym} 62380 -33110 0 0 {name=p61636 lab=_69678_/A }
C {devices/lab_pin.sym} 62460 -33110 0 1 {name=p61637 lab=_68390_/X }
C {sky130_stdcells/buf_2.sym} 62420 -33110 0 0 {name=X_68390_ }
C {devices/lab_pin.sym} 62380 -32990 0 0 {name=p61638 lab=_46720_/A }
C {devices/lab_pin.sym} 62460 -32990 0 1 {name=p61639 lab=_46806_/A }
C {sky130_stdcells/buf_2.sym} 62420 -32990 0 0 {name=X_46768_ }
C {devices/lab_pin.sym} 62340 -32890 0 0 {name=p61640 lab=_77584_/X }
C {devices/lab_pin.sym} 62340 -32850 0 0 {name=p61641 lab=_77585_/Y }
C {devices/lab_pin.sym} 62340 -32810 0 0 {name=p61642 lab=_77587_/Y }
C {devices/lab_pin.sym} 62500 -32850 0 1 {name=p61643 lab=_77590_/A }
C {sky130_stdcells/a21o_4.sym} 62420 -32850 0 0 {name=X_77588_ }
C {devices/lab_pin.sym} 62380 -32710 0 0 {name=p61644 lab=_81780_/Q }
C {devices/lab_pin.sym} 62460 -32710 0 1 {name=p61645 lab=_48508_/A }
C {sky130_stdcells/inv_2.sym} 62420 -32710 0 0 {name=X_48507_ }
C {devices/lab_pin.sym} 62380 -32590 0 0 {name=p61646 lab=_67222_/A }
C {devices/lab_pin.sym} 62460 -32590 0 1 {name=p61647 lab=_67342_/A }
C {sky130_stdcells/buf_2.sym} 62420 -32590 0 0 {name=X_67341_ }
C {devices/lab_pin.sym} 62360 -32480 0 0 {name=p61648 lab=_79320_/X }
C {devices/lab_pin.sym} 62360 -32440 0 0 {name=p61649 lab=_79322_/B }
C {devices/lab_pin.sym} 62480 -32460 0 1 {name=p61650 lab=_79327_/Y }
C {sky130_stdcells/nand2_4.sym} 62420 -32460 0 0 {name=X_79327_ }
C {devices/lab_pin.sym} 62380 -32330 0 0 {name=p61651 lab=_45719_/A }
C {devices/lab_pin.sym} 62460 -32330 0 1 {name=p61652 lab=_45719_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -32330 0 0 {name=X_45719_ }
C {devices/lab_pin.sym} 62360 -32230 0 0 {name=p61653 lab=_64474_/X }
C {devices/lab_pin.sym} 62360 -32190 0 0 {name=p61654 lab=_64525_/B }
C {devices/lab_pin.sym} 62360 -32150 0 0 {name=p61655 lab=_84882_/Q }
C {devices/lab_pin.sym} 62480 -32190 0 1 {name=p61656 lab=_64553_/Y }
C {sky130_stdcells/nand3_4.sym} 62420 -32190 0 0 {name=X_64553_ }
C {devices/lab_pin.sym} 62340 -32070 0 0 {name=p61657 lab=_76535_/X }
C {devices/lab_pin.sym} 62340 -32030 0 0 {name=p61658 lab=_76540_/C }
C {devices/lab_pin.sym} 62340 -31990 0 0 {name=p61659 lab=_76540_/B }
C {devices/lab_pin.sym} 62500 -32030 0 1 {name=p61660 lab=_76541_/A }
C {sky130_stdcells/a21o_4.sym} 62420 -32030 0 0 {name=X_76539_ }
C {devices/lab_pin.sym} 62360 -31920 0 0 {name=p61661 lab=_61762_/X }
C {devices/lab_pin.sym} 62360 -31880 0 0 {name=p61662 lab=_61765_/B }
C {devices/lab_pin.sym} 62360 -31840 0 0 {name=p61663 lab=_61765_/C }
C {devices/lab_pin.sym} 62360 -31800 0 0 {name=p61664 lab=_61748_/X }
C {devices/lab_pin.sym} 62480 -31860 0 1 {name=p61665 lab=_61766_/D }
C {sky130_stdcells/nand4_4.sym} 62420 -31860 0 0 {name=X_61765_ }
C {devices/lab_pin.sym} 62380 -31710 0 0 {name=p61666 lab=_49434_/A }
C {devices/lab_pin.sym} 62460 -31710 0 1 {name=p61667 lab=_49487_/X }
C {sky130_stdcells/buf_2.sym} 62420 -31710 0 0 {name=X_49487_ }
C {devices/lab_pin.sym} 62340 -31610 0 0 {name=p61668 lab=_46695_/Y }
C {devices/lab_pin.sym} 62340 -31570 0 0 {name=p61669 lab=_46654_/X }
C {devices/lab_pin.sym} 62340 -31530 0 0 {name=p61670 lab=_46698_/X }
C {devices/lab_pin.sym} 62500 -31570 0 1 {name=p61671 lab=_86713_/D }
C {sky130_stdcells/a21oi_4.sym} 62420 -31570 0 0 {name=X_46699_ }
C {devices/lab_pin.sym} 62380 -31430 0 0 {name=p61672 lab=_63443_/A }
C {devices/lab_pin.sym} 62460 -31430 0 1 {name=p61673 lab=_63514_/C }
C {sky130_stdcells/buf_2.sym} 62420 -31430 0 0 {name=X_63504_ }
C {devices/lab_pin.sym} 62380 -31310 0 0 {name=p61674 lab=_60715_/X }
C {devices/lab_pin.sym} 62460 -31310 0 1 {name=p61675 lab=_60752_/B }
C {sky130_stdcells/buf_2.sym} 62420 -31310 0 0 {name=X_60716_ }
C {devices/lab_pin.sym} 62360 -31200 0 0 {name=p61676 lab=_48642_/A }
C {devices/lab_pin.sym} 62360 -31160 0 0 {name=p61677 lab=_48438_/B }
C {devices/lab_pin.sym} 62480 -31180 0 1 {name=p61678 lab=_48438_/Y }
C {sky130_stdcells/nand2_4.sym} 62420 -31180 0 0 {name=X_48438_ }
C {devices/lab_pin.sym} 62360 -31060 0 0 {name=p61679 lab=_84793_/Q }
C {devices/lab_pin.sym} 62360 -31020 0 0 {name=p61680 lab=_66490_/C }
C {devices/lab_pin.sym} 62480 -31040 0 1 {name=p61681 lab=_79258_/X }
C {sky130_stdcells/xor2_4.sym} 62420 -31040 0 0 {name=X_79258_ }
C {devices/lab_pin.sym} 62360 -30920 0 0 {name=p61682 lab=_67248_/A }
C {devices/lab_pin.sym} 62360 -30880 0 0 {name=p61683 lab=_87670_/Q }
C {devices/lab_pin.sym} 62480 -30900 0 1 {name=p61684 lab=_67272_/X }
C {sky130_stdcells/and2_4.sym} 62420 -30900 0 0 {name=X_67272_ }
C {devices/lab_pin.sym} 62360 -30790 0 0 {name=p61685 lab=_64474_/X }
C {devices/lab_pin.sym} 62360 -30750 0 0 {name=p61686 lab=_61169_/X }
C {devices/lab_pin.sym} 62360 -30710 0 0 {name=p61687 lab=_62097_/X }
C {devices/lab_pin.sym} 62480 -30750 0 1 {name=p61688 lab=_64484_/Y }
C {sky130_stdcells/nand3_4.sym} 62420 -30750 0 0 {name=X_64484_ }
C {devices/lab_pin.sym} 62360 -30620 0 0 {name=p61689 lab=_84866_/Q }
C {devices/lab_pin.sym} 62360 -30580 0 0 {name=p61690 lab=_61321_/Y }
C {devices/lab_pin.sym} 62480 -30600 0 1 {name=p61691 lab=_61697_/A }
C {sky130_stdcells/or2_4.sym} 62420 -30600 0 0 {name=X_61696_ }
C {devices/lab_pin.sym} 62360 -30480 0 0 {name=p61692 lab=_69011_/A }
C {devices/lab_pin.sym} 62360 -30440 0 0 {name=p61693 lab=_69011_/B }
C {devices/lab_pin.sym} 62480 -30460 0 1 {name=p61694 lab=_69011_/X }
C {sky130_stdcells/and2_4.sym} 62420 -30460 0 0 {name=X_69011_ }
C {devices/lab_pin.sym} 62340 -30360 0 0 {name=p61695 lab=_66053_/X }
C {devices/lab_pin.sym} 62340 -30320 0 0 {name=p61696 lab=_85611_/Q }
C {devices/lab_pin.sym} 62340 -30280 0 0 {name=p61697 lab=_66096_/X }
C {devices/lab_pin.sym} 62340 -30240 0 0 {name=p61698 lab=_66222_/X }
C {devices/lab_pin.sym} 62500 -30300 0 1 {name=p61699 lab=_66223_/X }
C {sky130_stdcells/a211o_4.sym} 62420 -30300 0 0 {name=X_66223_ }
C {devices/lab_pin.sym} 62360 -30160 0 0 {name=p61700 lab=_78209_/A }
C {devices/lab_pin.sym} 62360 -30120 0 0 {name=p61701 lab=_78208_/X }
C {devices/lab_pin.sym} 62480 -30140 0 1 {name=p61702 lab=_78210_/B }
C {sky130_stdcells/nand2_4.sym} 62420 -30140 0 0 {name=X_78209_ }
C {devices/lab_pin.sym} 62360 -30040 0 0 {name=p61703 lab=_63448_/A }
C {devices/lab_pin.sym} 62360 -30000 0 0 {name=p61704 lab=_59501_/X }
C {devices/lab_pin.sym} 62360 -29960 0 0 {name=p61705 lab=_63410_/C }
C {devices/lab_pin.sym} 62360 -29920 0 0 {name=p61706 lab=_63410_/D }
C {devices/lab_pin.sym} 62480 -29980 0 1 {name=p61707 lab=_63435_/X }
C {sky130_stdcells/and4_4.sym} 62420 -29980 0 0 {name=X_63435_ }
C {devices/lab_pin.sym} 62360 -29840 0 0 {name=p61708 lab=_48392_/A }
C {devices/lab_pin.sym} 62360 -29800 0 0 {name=p61709 lab=_48368_/X }
C {devices/lab_pin.sym} 62480 -29820 0 1 {name=p61710 lab=_48369_/Y }
C {sky130_stdcells/nand2_4.sym} 62420 -29820 0 0 {name=X_48369_ }
C {devices/lab_pin.sym} 62340 -29710 0 0 {name=p61711 lab=_60820_/B }
C {devices/lab_pin.sym} 62340 -29670 0 0 {name=p61712 lab=_60646_/Y }
C {devices/lab_pin.sym} 62340 -29630 0 0 {name=p61713 lab=_59787_/X }
C {devices/lab_pin.sym} 62500 -29670 0 1 {name=p61714 lab=_60647_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -29670 0 0 {name=X_60647_ }
C {devices/lab_pin.sym} 62360 -29540 0 0 {name=p61715 lab=_79189_/A }
C {devices/lab_pin.sym} 62360 -29500 0 0 {name=p61716 lab=_79189_/B }
C {devices/lab_pin.sym} 62480 -29520 0 1 {name=p61717 lab=_79189_/Y }
C {sky130_stdcells/nor2_4.sym} 62420 -29520 0 0 {name=X_79189_ }
C {devices/lab_pin.sym} 62380 -29390 0 0 {name=p61718 lab=_53511_/A }
C {devices/lab_pin.sym} 62460 -29390 0 1 {name=p61719 lab=_50430_/B }
C {sky130_stdcells/buf_2.sym} 62420 -29390 0 0 {name=X_50400_ }
C {devices/lab_pin.sym} 62380 -29270 0 0 {name=p61720 lab=clkbuf_9_20_0_CLK/X }
C {devices/lab_pin.sym} 62460 -29270 0 1 {name=p61721 lab=_83095_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 62420 -29270 0 0 {name=Xclkbuf_10_41_0_CLK }
C {devices/lab_pin.sym} 62330 -29150 0 0 {name=p61722 lab=_85317_/CLK }
C {devices/lab_pin.sym} 62330 -29130 0 0 {name=p61723 lab=_81028_/Q }
C {devices/lab_pin.sym} 62510 -29150 0 1 {name=p61724 lab=_81220_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -29140 0 0 {name=X_81220_ }
C {devices/lab_pin.sym} 62340 -29040 0 0 {name=p61725 lab=_64589_/X }
C {devices/lab_pin.sym} 62340 -29000 0 0 {name=p61726 lab=_86224_/Q }
C {devices/lab_pin.sym} 62340 -28960 0 0 {name=p61727 lab=_45922_/X }
C {devices/lab_pin.sym} 62340 -28920 0 0 {name=p61728 lab=_66153_/X }
C {devices/lab_pin.sym} 62500 -28980 0 1 {name=p61729 lab=_66154_/X }
C {sky130_stdcells/a211o_4.sym} 62420 -28980 0 0 {name=X_66154_ }
C {devices/lab_pin.sym} 62360 -28840 0 0 {name=p61730 lab=_51367_/X }
C {devices/lab_pin.sym} 62360 -28800 0 0 {name=p61731 lab=_51380_/B }
C {devices/lab_pin.sym} 62480 -28820 0 1 {name=p61732 lab=_51380_/X }
C {sky130_stdcells/and2_4.sym} 62420 -28820 0 0 {name=X_51380_ }
C {devices/lab_pin.sym} 62340 -28710 0 0 {name=p61733 lab=_63364_/Y }
C {devices/lab_pin.sym} 62340 -28670 0 0 {name=p61734 lab=_63284_/X }
C {devices/lab_pin.sym} 62340 -28630 0 0 {name=p61735 lab=_63365_/Y }
C {devices/lab_pin.sym} 62500 -28670 0 1 {name=p61736 lab=_63366_/Y }
C {sky130_stdcells/a21oi_4.sym} 62420 -28670 0 0 {name=X_63366_ }
C {devices/lab_pin.sym} 62380 -28530 0 0 {name=p61737 lab=clkbuf_8_190_0_CLK/X }
C {devices/lab_pin.sym} 62460 -28530 0 1 {name=p61738 lab=clkbuf_9_380_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 62420 -28530 0 0 {name=Xclkbuf_9_380_0_CLK }
C {devices/lab_pin.sym} 62360 -28430 0 0 {name=p61739 lab=_60515_/B }
C {devices/lab_pin.sym} 62360 -28390 0 0 {name=p61740 lab=_60476_/C }
C {devices/lab_pin.sym} 62360 -28350 0 0 {name=p61741 lab=_63280_/C }
C {devices/lab_pin.sym} 62480 -28390 0 1 {name=p61742 lab=_60578_/Y }
C {sky130_stdcells/nand3_4.sym} 62420 -28390 0 0 {name=X_60578_ }
C {devices/lab_pin.sym} 62360 -28260 0 0 {name=p61743 lab=_65002_/A }
C {devices/lab_pin.sym} 62360 -28220 0 0 {name=p61744 lab=_65105_/B }
C {devices/lab_pin.sym} 62480 -28240 0 1 {name=p61745 lab=_65105_/X }
C {sky130_stdcells/and2_4.sym} 62420 -28240 0 0 {name=X_65105_ }
C {devices/lab_pin.sym} 62360 -28130 0 0 {name=p61746 lab=_48287_/A }
C {devices/lab_pin.sym} 62360 -28090 0 0 {name=p61747 lab=_50331_/B }
C {devices/lab_pin.sym} 62360 -28050 0 0 {name=p61748 lab=_50247_/X }
C {devices/lab_pin.sym} 62480 -28090 0 1 {name=p61749 lab=_50331_/X }
C {sky130_stdcells/and3_4.sym} 62420 -28090 0 0 {name=X_50331_ }
C {devices/lab_pin.sym} 62330 -27950 0 0 {name=p61750 lab=_82327_/CLK }
C {devices/lab_pin.sym} 62330 -27930 0 0 {name=p61751 lab=_75062_/A }
C {devices/lab_pin.sym} 62510 -27950 0 1 {name=p61752 lab=_40579_/A }
C {sky130_stdcells/dfxtp_4.sym} 62420 -27940 0 0 {name=X_81151_ }
C {devices/lab_pin.sym} 62360 -27840 0 0 {name=p61753 lab=_61421_/A }
C {devices/lab_pin.sym} 62360 -27800 0 0 {name=p61754 lab=_62631_/B }
C {devices/lab_pin.sym} 62360 -27760 0 0 {name=p61755 lab=_62631_/C }
C {devices/lab_pin.sym} 62360 -27720 0 0 {name=p61756 lab=_62332_/D }
C {devices/lab_pin.sym} 62480 -27780 0 1 {name=p61757 lab=_62317_/Y }
C {sky130_stdcells/nand4_4.sym} 62420 -27780 0 0 {name=X_62317_ }
C {devices/lab_pin.sym} 62340 -27660 0 0 {name=p61758 lab=_65733_/X }
C {devices/lab_pin.sym} 62340 -27620 0 0 {name=p61759 lab=_85621_/Q }
C {devices/lab_pin.sym} 62340 -27580 0 0 {name=p61760 lab=_65734_/X }
C {devices/lab_pin.sym} 62340 -27540 0 0 {name=p61761 lab=_66084_/X }
C {devices/lab_pin.sym} 62500 -27600 0 1 {name=p61762 lab=_66085_/X }
C {sky130_stdcells/a211o_4.sym} 62420 -27600 0 0 {name=X_66085_ }
C {devices/lab_pin.sym} 62380 -27450 0 0 {name=p61763 lab=clkbuf_9_137_0_CLK/X }
C {devices/lab_pin.sym} 62460 -27450 0 1 {name=p61764 lab=_83414_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 62420 -27450 0 0 {name=Xclkbuf_10_274_0_CLK }
C {devices/lab_pin.sym} 62340 -27350 0 0 {name=p61765 lab=_79245_/A }
C {devices/lab_pin.sym} 62340 -27310 0 0 {name=p61766 lab=_63258_/X }
C {devices/lab_pin.sym} 62340 -27270 0 0 {name=p61767 lab=_63296_/Y }
C {devices/lab_pin.sym} 62500 -27310 0 1 {name=p61768 lab=_84336_/D }
C {sky130_stdcells/a21o_4.sym} 62420 -27310 0 0 {name=X_63297_ }
C {devices/lab_pin.sym} 62360 -27180 0 0 {name=p61769 lab=_60067_/C }
C {devices/lab_pin.sym} 62360 -27140 0 0 {name=p61770 lab=_80102_/B }
C {devices/lab_pin.sym} 62480 -27160 0 1 {name=p61771 lab=_80108_/B }
C {sky130_stdcells/xor2_4.sym} 62420 -27160 0 0 {name=X_80102_ }
C {devices/lab_pin.sym} 62360 -27040 0 0 {name=p61772 lab=_53040_/X }
C {devices/lab_pin.sym} 62360 -27000 0 0 {name=p61773 lab=_53050_/B }
C {devices/lab_pin.sym} 62480 -27020 0 1 {name=p61774 lab=_53050_/Y }
C {sky130_stdcells/nand2_4.sym} 62420 -27020 0 0 {name=X_53050_ }
C {devices/lab_pin.sym} 62380 -26890 0 0 {name=p61775 lab=_64679_/A }
C {devices/lab_pin.sym} 62460 -26890 0 1 {name=p61776 lab=_65036_/X }
C {sky130_stdcells/buf_2.sym} 62420 -26890 0 0 {name=X_65036_ }
C {devices/lab_pin.sym} 62340 -26790 0 0 {name=p61777 lab=_69910_/X }
C {devices/lab_pin.sym} 62340 -26750 0 0 {name=p61778 lab=_69912_/X }
C {devices/lab_pin.sym} 62340 -26710 0 0 {name=p61779 lab=_69742_/X }
C {devices/lab_pin.sym} 62500 -26750 0 1 {name=p61780 lab=_69913_/Y }
C {sky130_stdcells/a21oi_4.sym} 62420 -26750 0 0 {name=X_69913_ }
C {devices/lab_pin.sym} 62360 -26620 0 0 {name=p61781 lab=_50230_/A }
C {devices/lab_pin.sym} 62360 -26580 0 0 {name=p61782 lab=_48207_/X }
C {devices/lab_pin.sym} 62480 -26600 0 1 {name=p61783 lab=_50262_/Y }
C {sky130_stdcells/nand2_4.sym} 62420 -26600 0 0 {name=X_50262_ }
C {devices/lab_pin.sym} 62360 -26500 0 0 {name=p61784 lab=_61358_/A }
C {devices/lab_pin.sym} 62360 -26460 0 0 {name=p61785 lab=_62247_/X }
C {devices/lab_pin.sym} 62360 -26420 0 0 {name=p61786 lab=_62576_/C }
C {devices/lab_pin.sym} 62360 -26380 0 0 {name=p61787 lab=_62560_/D }
C {devices/lab_pin.sym} 62480 -26440 0 1 {name=p61788 lab=_62251_/B }
C {sky130_stdcells/nand4_4.sym} 62420 -26440 0 0 {name=X_62248_ }
C {devices/lab_pin.sym} 62330 -26290 0 0 {name=p61789 lab=_81082_/CLK }
C {devices/lab_pin.sym} 62330 -26270 0 0 {name=p61790 lab=_75637_/A }
C {devices/lab_pin.sym} 62510 -26290 0 1 {name=p61791 lab=_81082_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -26280 0 0 {name=X_81082_ }
C {devices/lab_pin.sym} 62380 -26150 0 0 {name=p61792 lab=clkbuf_9_28_0_CLK/X }
C {devices/lab_pin.sym} 62460 -26150 0 1 {name=p61793 lab=_85075_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 62420 -26150 0 0 {name=Xclkbuf_10_56_0_CLK }
C {devices/lab_pin.sym} 62360 -26040 0 0 {name=p61794 lab=_52027_/A }
C {devices/lab_pin.sym} 62360 -26000 0 0 {name=p61795 lab=_47969_/B }
C {devices/lab_pin.sym} 62480 -26020 0 1 {name=p61796 lab=_52001_/Y }
C {sky130_stdcells/nand2_4.sym} 62420 -26020 0 0 {name=X_52001_ }
C {devices/lab_pin.sym} 62360 -25900 0 0 {name=p61797 lab=_80019_/Y }
C {devices/lab_pin.sym} 62360 -25860 0 0 {name=p61798 lab=_80016_/Y }
C {devices/lab_pin.sym} 62480 -25880 0 1 {name=p61799 lab=_80033_/X }
C {sky130_stdcells/and2_4.sym} 62420 -25880 0 0 {name=X_80033_ }
C {devices/lab_pin.sym} 62330 -25750 0 0 {name=p61800 lab=_84714_/CLK }
C {devices/lab_pin.sym} 62330 -25730 0 0 {name=p61801 lab=_58199_/Y }
C {devices/lab_pin.sym} 62510 -25750 0 1 {name=p61802 lab=_84910_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -25740 0 0 {name=X_84910_ }
C {devices/lab_pin.sym} 62360 -25620 0 0 {name=p61803 lab=_69840_/X }
C {devices/lab_pin.sym} 62360 -25580 0 0 {name=p61804 lab=_69843_/X }
C {devices/lab_pin.sym} 62480 -25600 0 1 {name=p61805 lab=_69844_/Y }
C {sky130_stdcells/nand2_4.sym} 62420 -25600 0 0 {name=X_69844_ }
C {devices/lab_pin.sym} 62380 -25470 0 0 {name=p61806 lab=clkbuf_9_395_0_CLK/A }
C {devices/lab_pin.sym} 62460 -25470 0 1 {name=p61807 lab=clkbuf_9_395_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 62420 -25470 0 0 {name=Xclkbuf_9_395_0_CLK }
C {devices/lab_pin.sym} 62360 -25360 0 0 {name=p61808 lab=_51242_/A }
C {devices/lab_pin.sym} 62360 -25320 0 0 {name=p61809 lab=_53919_/B }
C {devices/lab_pin.sym} 62480 -25340 0 1 {name=p61810 lab=_50193_/X }
C {sky130_stdcells/and2_4.sym} 62420 -25340 0 0 {name=X_50193_ }
C {devices/lab_pin.sym} 62330 -25210 0 0 {name=p61811 lab=_85888_/CLK }
C {devices/lab_pin.sym} 62330 -25190 0 0 {name=p61812 lab=_85890_/D }
C {devices/lab_pin.sym} 62510 -25210 0 1 {name=p61813 lab=_85890_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -25200 0 0 {name=X_85890_ }
C {devices/lab_pin.sym} 62380 -25070 0 0 {name=p61814 lab=_62851_/A }
C {devices/lab_pin.sym} 62460 -25070 0 1 {name=p61815 lab=_62179_/X }
C {sky130_stdcells/buf_2.sym} 62420 -25070 0 0 {name=X_62179_ }
C {devices/lab_pin.sym} 62380 -24950 0 0 {name=p61816 lab=clkbuf_8_203_0_CLK/A }
C {devices/lab_pin.sym} 62460 -24950 0 1 {name=p61817 lab=clkbuf_8_202_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 62420 -24950 0 0 {name=Xclkbuf_8_202_0_CLK }
C {devices/lab_pin.sym} 62380 -24830 0 0 {name=p61818 lab=clkbuf_9_144_0_CLK/X }
C {devices/lab_pin.sym} 62460 -24830 0 1 {name=p61819 lab=_84727_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 62420 -24830 0 0 {name=Xclkbuf_10_289_0_CLK }
C {devices/lab_pin.sym} 62330 -24710 0 0 {name=p61820 lab=_84841_/CLK }
C {devices/lab_pin.sym} 62330 -24690 0 0 {name=p61821 lab=_84841_/D }
C {devices/lab_pin.sym} 62510 -24710 0 1 {name=p61822 lab=_84841_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -24700 0 0 {name=X_84841_ }
C {devices/lab_pin.sym} 62340 -24590 0 0 {name=p61823 lab=_83898_/Q }
C {devices/lab_pin.sym} 62340 -24550 0 0 {name=p61824 lab=_69763_/X }
C {devices/lab_pin.sym} 62340 -24510 0 0 {name=p61825 lab=_69774_/X }
C {devices/lab_pin.sym} 62500 -24550 0 1 {name=p61826 lab=_69775_/X }
C {sky130_stdcells/a21bo_4.sym} 62420 -24550 0 0 {name=X_69775_ }
C {devices/lab_pin.sym} 62340 -24430 0 0 {name=p61827 lab=_66983_/X }
C {devices/lab_pin.sym} 62340 -24390 0 0 {name=p61828 lab=_66986_/X }
C {devices/lab_pin.sym} 62340 -24350 0 0 {name=p61829 lab=_66964_/X }
C {devices/lab_pin.sym} 62500 -24390 0 1 {name=p61830 lab=_66987_/X }
C {sky130_stdcells/a21o_4.sym} 62420 -24390 0 0 {name=X_66987_ }
C {devices/lab_pin.sym} 62380 -24250 0 0 {name=p61831 lab=_56735_/X }
C {devices/lab_pin.sym} 62460 -24250 0 1 {name=p61832 lab=_56740_/X }
C {sky130_stdcells/buf_2.sym} 62420 -24250 0 0 {name=X_56740_ }
C {devices/lab_pin.sym} 62380 -24130 0 0 {name=p61833 lab=_44148_/A }
C {devices/lab_pin.sym} 62460 -24130 0 1 {name=p61834 lab=_69735_/A }
C {sky130_stdcells/buf_2.sym} 62420 -24130 0 0 {name=X_68726_ }
C {devices/lab_pin.sym} 62330 -24010 0 0 {name=p61835 lab=_87820_/CLK }
C {devices/lab_pin.sym} 62330 -23990 0 0 {name=p61836 lab=_87560_/D }
C {devices/lab_pin.sym} 62510 -24010 0 1 {name=p61837 lab=_43141_/A }
C {sky130_stdcells/dfxtp_4.sym} 62420 -24000 0 0 {name=X_87560_ }
C {devices/lab_pin.sym} 62340 -23890 0 0 {name=p61838 lab=_85535_/Q }
C {devices/lab_pin.sym} 62340 -23850 0 0 {name=p61839 lab=_53921_/X }
C {devices/lab_pin.sym} 62340 -23810 0 0 {name=p61840 lab=_53951_/Y }
C {devices/lab_pin.sym} 62500 -23850 0 1 {name=p61841 lab=_53952_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -23850 0 0 {name=X_53952_ }
C {devices/lab_pin.sym} 62340 -23730 0 0 {name=p61842 lab=_65933_/X }
C {devices/lab_pin.sym} 62340 -23690 0 0 {name=p61843 lab=_65936_/X }
C {devices/lab_pin.sym} 62340 -23650 0 0 {name=p61844 lab=_65937_/X }
C {devices/lab_pin.sym} 62500 -23690 0 1 {name=p61845 lab=_65938_/X }
C {sky130_stdcells/a21o_4.sym} 62420 -23690 0 0 {name=X_65938_ }
C {devices/lab_pin.sym} 62330 -23550 0 0 {name=p61846 lab=_86686_/CLK }
C {devices/lab_pin.sym} 62330 -23530 0 0 {name=p61847 lab=_84772_/D }
C {devices/lab_pin.sym} 62510 -23550 0 1 {name=p61848 lab=_84772_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -23540 0 0 {name=X_84772_ }
C {devices/lab_pin.sym} 62330 -23410 0 0 {name=p61849 lab=_81975_/CLK }
C {devices/lab_pin.sym} 62330 -23390 0 0 {name=p61850 lab=_83912_/Q }
C {devices/lab_pin.sym} 62510 -23410 0 1 {name=p61851 lab=_81984_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -23400 0 0 {name=X_81984_ }
C {devices/lab_pin.sym} 62330 -23270 0 0 {name=p61852 lab=_86500_/CLK }
C {devices/lab_pin.sym} 62330 -23250 0 0 {name=p61853 lab=_86511_/D }
C {devices/lab_pin.sym} 62510 -23270 0 1 {name=p61854 lab=_86511_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -23260 0 0 {name=X_86511_ }
C {devices/lab_pin.sym} 62380 -23130 0 0 {name=p61855 lab=_52630_/A }
C {devices/lab_pin.sym} 62460 -23130 0 1 {name=p61856 lab=_52903_/X }
C {sky130_stdcells/buf_2.sym} 62420 -23130 0 0 {name=X_52903_ }
C {devices/lab_pin.sym} 62330 -23010 0 0 {name=p61857 lab=_85372_/CLK }
C {devices/lab_pin.sym} 62330 -22990 0 0 {name=p61858 lab=_83723_/D }
C {devices/lab_pin.sym} 62510 -23010 0 1 {name=p61859 lab=_47505_/A }
C {sky130_stdcells/dfxtp_4.sym} 62420 -23000 0 0 {name=X_83723_ }
C {devices/lab_pin.sym} 62380 -22870 0 0 {name=p61860 lab=clkbuf_8_217_0_CLK/A }
C {devices/lab_pin.sym} 62460 -22870 0 1 {name=p61861 lab=clkbuf_9_435_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 62420 -22870 0 0 {name=Xclkbuf_8_217_0_CLK }
C {devices/lab_pin.sym} 62380 -22750 0 0 {name=p61862 lab=_56852_/A }
C {devices/lab_pin.sym} 62460 -22750 0 1 {name=p61863 lab=_56671_/X }
C {sky130_stdcells/buf_2.sym} 62420 -22750 0 0 {name=X_56671_ }
C {devices/lab_pin.sym} 62330 -22630 0 0 {name=p61864 lab=_81061_/CLK }
C {devices/lab_pin.sym} 62330 -22610 0 0 {name=p61865 lab=_75138_/B }
C {devices/lab_pin.sym} 62510 -22630 0 1 {name=p61866 lab=_74879_/A }
C {sky130_stdcells/dfxtp_4.sym} 62420 -22620 0 0 {name=X_80935_ }
C {devices/lab_pin.sym} 62380 -22490 0 0 {name=p61867 lab=_69014_/A }
C {devices/lab_pin.sym} 62460 -22490 0 1 {name=p61868 lab=_68735_/A }
C {sky130_stdcells/buf_2.sym} 62420 -22490 0 0 {name=X_68657_ }
C {devices/lab_pin.sym} 62330 -22370 0 0 {name=p61869 lab=_87749_/CLK }
C {devices/lab_pin.sym} 62330 -22350 0 0 {name=p61870 lab=_43299_/X }
C {devices/lab_pin.sym} 62510 -22370 0 1 {name=p61871 lab=_87491_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -22360 0 0 {name=X_87491_ }
C {devices/lab_pin.sym} 62380 -22230 0 0 {name=p61872 lab=_53763_/A }
C {devices/lab_pin.sym} 62460 -22230 0 1 {name=p61873 lab=_53888_/C }
C {sky130_stdcells/buf_2.sym} 62420 -22230 0 0 {name=X_53883_ }
C {devices/lab_pin.sym} 62340 -22130 0 0 {name=p61874 lab=_65789_/X }
C {devices/lab_pin.sym} 62340 -22090 0 0 {name=p61875 lab=_65359_/Y }
C {devices/lab_pin.sym} 62340 -22050 0 0 {name=p61876 lab=_65868_/Y }
C {devices/lab_pin.sym} 62500 -22090 0 1 {name=p61877 lab=_65869_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -22090 0 0 {name=X_65869_ }
C {devices/lab_pin.sym} 62380 -21950 0 0 {name=p61878 lab=clkbuf_9_106_0_CLK/X }
C {devices/lab_pin.sym} 62460 -21950 0 1 {name=p61879 lab=_84649_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 62420 -21950 0 0 {name=Xclkbuf_10_212_0_CLK }
C {devices/lab_pin.sym} 62340 -21850 0 0 {name=p61880 lab=_58406_/X }
C {devices/lab_pin.sym} 62340 -21810 0 0 {name=p61881 lab=_83368_/Q }
C {devices/lab_pin.sym} 62340 -21770 0 0 {name=p61882 lab=_58409_/Y }
C {devices/lab_pin.sym} 62500 -21810 0 1 {name=p61883 lab=_84856_/D }
C {sky130_stdcells/o21a_4.sym} 62420 -21810 0 0 {name=X_58410_ }
C {devices/lab_pin.sym} 62360 -21680 0 0 {name=p61884 lab=_55691_/A }
C {devices/lab_pin.sym} 62360 -21640 0 0 {name=p61885 lab=_55622_/B }
C {devices/lab_pin.sym} 62480 -21660 0 1 {name=p61886 lab=_55622_/X }
C {sky130_stdcells/and2_4.sym} 62420 -21660 0 0 {name=X_55622_ }
C {devices/lab_pin.sym} 62360 -21540 0 0 {name=p61887 lab=_67539_/X }
C {devices/lab_pin.sym} 62360 -21500 0 0 {name=p61888 lab=_67608_/B }
C {devices/lab_pin.sym} 62480 -21520 0 1 {name=p61889 lab=_67608_/X }
C {sky130_stdcells/and2_4.sym} 62420 -21520 0 0 {name=X_67608_ }
C {devices/lab_pin.sym} 62330 -21390 0 0 {name=p61890 lab=_86154_/CLK }
C {devices/lab_pin.sym} 62330 -21370 0 0 {name=p61891 lab=_86442_/D }
C {devices/lab_pin.sym} 62510 -21390 0 1 {name=p61892 lab=_86442_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -21380 0 0 {name=X_86442_ }
C {devices/lab_pin.sym} 62340 -21270 0 0 {name=p61893 lab=_85746_/Q }
C {devices/lab_pin.sym} 62340 -21230 0 0 {name=p61894 lab=_52821_/X }
C {devices/lab_pin.sym} 62340 -21190 0 0 {name=p61895 lab=_52833_/Y }
C {devices/lab_pin.sym} 62500 -21230 0 1 {name=p61896 lab=_52834_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -21230 0 0 {name=X_52834_ }
C {devices/lab_pin.sym} 62380 -21090 0 0 {name=p61897 lab=clkbuf_9_421_0_CLK/X }
C {devices/lab_pin.sym} 62460 -21090 0 1 {name=p61898 lab=_84161_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 62420 -21090 0 0 {name=Xclkbuf_10_842_0_CLK }
C {devices/lab_pin.sym} 62380 -20970 0 0 {name=p61899 lab=_84744_/Q }
C {devices/lab_pin.sym} 62460 -20970 0 1 {name=p61900 lab=_59390_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -20970 0 0 {name=X_59390_ }
C {devices/lab_pin.sym} 62330 -20850 0 0 {name=p61901 lab=_85822_/CLK }
C {devices/lab_pin.sym} 62330 -20830 0 0 {name=p61902 lab=_70948_/Y }
C {devices/lab_pin.sym} 62510 -20850 0 1 {name=p61903 lab=_83654_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -20840 0 0 {name=X_83654_ }
C {devices/lab_pin.sym} 62330 -20710 0 0 {name=p61904 lab=_80818_/CLK }
C {devices/lab_pin.sym} 62330 -20690 0 0 {name=p61905 lab=_75571_/B }
C {devices/lab_pin.sym} 62510 -20710 0 1 {name=p61906 lab=_80834_/D }
C {sky130_stdcells/dfxtp_4.sym} 62420 -20700 0 0 {name=X_80866_ }
C {devices/lab_pin.sym} 62380 -20570 0 0 {name=p61907 lab=_68588_/A }
C {devices/lab_pin.sym} 62460 -20570 0 1 {name=p61908 lab=_68588_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -20570 0 0 {name=X_68588_ }
C {devices/lab_pin.sym} 62380 -20450 0 0 {name=p61909 lab=_58341_/A }
C {devices/lab_pin.sym} 62460 -20450 0 1 {name=p61910 lab=_58341_/X }
C {sky130_stdcells/buf_2.sym} 62420 -20450 0 0 {name=X_58341_ }
C {devices/lab_pin.sym} 62330 -20330 0 0 {name=p61911 lab=_82604_/CLK }
C {devices/lab_pin.sym} 62330 -20310 0 0 {name=p61912 lab=_78909_/B }
C {devices/lab_pin.sym} 62510 -20330 0 1 {name=p61913 lab=_82605_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -20320 0 0 {name=X_82605_ }
C {devices/lab_pin.sym} 62360 -20200 0 0 {name=p61914 lab=_55524_/A }
C {devices/lab_pin.sym} 62360 -20160 0 0 {name=p61915 lab=_45500_/Y }
C {devices/lab_pin.sym} 62480 -20180 0 1 {name=p61916 lab=_55553_/Y }
C {sky130_stdcells/nor2_4.sym} 62420 -20180 0 0 {name=X_55553_ }
C {devices/lab_pin.sym} 62380 -20050 0 0 {name=p61917 lab=_67062_/X }
C {devices/lab_pin.sym} 62460 -20050 0 1 {name=p61918 lab=_67539_/X }
C {sky130_stdcells/buf_2.sym} 62420 -20050 0 0 {name=X_67539_ }
C {devices/lab_pin.sym} 62330 -19930 0 0 {name=p61919 lab=_83660_/CLK }
C {devices/lab_pin.sym} 62330 -19910 0 0 {name=p61920 lab=_86373_/D }
C {devices/lab_pin.sym} 62510 -19930 0 1 {name=p61921 lab=_58920_/B }
C {sky130_stdcells/dfxtp_4.sym} 62420 -19920 0 0 {name=X_86373_ }
C {devices/lab_pin.sym} 62380 -19790 0 0 {name=p61922 lab=clkbuf_8_166_0_CLK/X }
C {devices/lab_pin.sym} 62460 -19790 0 1 {name=p61923 lab=clkbuf_9_333_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 62420 -19790 0 0 {name=Xclkbuf_9_333_0_CLK }
C {devices/lab_pin.sym} 62380 -19670 0 0 {name=p61924 lab=_52684_/A }
C {devices/lab_pin.sym} 62460 -19670 0 1 {name=p61925 lab=_52765_/X }
C {sky130_stdcells/buf_2.sym} 62420 -19670 0 0 {name=X_52765_ }
C {devices/lab_pin.sym} 62330 -19550 0 0 {name=p61926 lab=_83584_/CLK }
C {devices/lab_pin.sym} 62330 -19530 0 0 {name=p61927 lab=_71169_/Y }
C {devices/lab_pin.sym} 62510 -19550 0 1 {name=p61928 lab=_48444_/A }
C {sky130_stdcells/dfxtp_4.sym} 62420 -19540 0 0 {name=X_83585_ }
C {devices/lab_pin.sym} 62330 -19410 0 0 {name=p61929 lab=_81111_/CLK }
C {devices/lab_pin.sym} 62330 -19390 0 0 {name=p61930 lab=_75886_/Y }
C {devices/lab_pin.sym} 62510 -19410 0 1 {name=p61931 lab=_75491_/B }
C {sky130_stdcells/dfxtp_4.sym} 62420 -19400 0 0 {name=X_80797_ }
C {devices/lab_pin.sym} 62330 -19270 0 0 {name=p61932 lab=_87070_/CLK }
C {devices/lab_pin.sym} 62330 -19250 0 0 {name=p61933 lab=_41892_/Y }
C {devices/lab_pin.sym} 62510 -19270 0 1 {name=p61934 lab=_88112_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -19260 0 0 {name=X_88112_ }
C {devices/lab_pin.sym} 62340 -19150 0 0 {name=p61935 lab=_54501_/Y }
C {devices/lab_pin.sym} 62340 -19110 0 0 {name=p61936 lab=_54502_/X }
C {devices/lab_pin.sym} 62340 -19070 0 0 {name=p61937 lab=_54503_/X }
C {devices/lab_pin.sym} 62500 -19110 0 1 {name=p61938 lab=_54504_/Y }
C {sky130_stdcells/a21oi_4.sym} 62420 -19110 0 0 {name=X_54504_ }
C {devices/lab_pin.sym} 62330 -18970 0 0 {name=p61939 lab=_85354_/CLK }
C {devices/lab_pin.sym} 62330 -18950 0 0 {name=p61940 lab=_85324_/D }
C {devices/lab_pin.sym} 62510 -18970 0 1 {name=p61941 lab=_85324_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -18960 0 0 {name=X_85324_ }
C {devices/lab_pin.sym} 62340 -18850 0 0 {name=p61942 lab=_51713_/Y }
C {devices/lab_pin.sym} 62340 -18810 0 0 {name=p61943 lab=_51693_/X }
C {devices/lab_pin.sym} 62340 -18770 0 0 {name=p61944 lab=_51715_/X }
C {devices/lab_pin.sym} 62500 -18810 0 1 {name=p61945 lab=_51716_/Y }
C {sky130_stdcells/a21oi_4.sym} 62420 -18810 0 0 {name=X_51716_ }
C {devices/lab_pin.sym} 62360 -18700 0 0 {name=p61946 lab=_71698_/A }
C {devices/lab_pin.sym} 62360 -18660 0 0 {name=p61947 lab=_70549_/X }
C {devices/lab_pin.sym} 62360 -18620 0 0 {name=p61948 lab=_70538_/X }
C {devices/lab_pin.sym} 62360 -18580 0 0 {name=p61949 lab=_70550_/D }
C {devices/lab_pin.sym} 62480 -18640 0 1 {name=p61950 lab=_70550_/Y }
C {sky130_stdcells/nor4_4.sym} 62420 -18640 0 0 {name=X_70550_ }
C {devices/lab_pin.sym} 62380 -18490 0 0 {name=p61951 lab=_84891_/Q }
C {devices/lab_pin.sym} 62460 -18490 0 1 {name=p61952 lab=_58274_/A }
C {sky130_stdcells/inv_2.sym} 62420 -18490 0 0 {name=X_58272_ }
C {devices/lab_pin.sym} 62330 -18370 0 0 {name=p61953 lab=_82536_/CLK }
C {devices/lab_pin.sym} 62330 -18350 0 0 {name=p61954 lab=_82536_/D }
C {devices/lab_pin.sym} 62510 -18370 0 1 {name=p61955 lab=_82536_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -18360 0 0 {name=X_82536_ }
C {devices/lab_pin.sym} 62380 -18230 0 0 {name=p61956 lab=clkbuf_9_113_0_CLK/X }
C {devices/lab_pin.sym} 62460 -18230 0 1 {name=p61957 lab=_80676_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 62420 -18230 0 0 {name=Xclkbuf_10_227_0_CLK }
C {devices/lab_pin.sym} 62360 -18120 0 0 {name=p61958 lab=_55453_/X }
C {devices/lab_pin.sym} 62360 -18080 0 0 {name=p61959 lab=_55483_/Y }
C {devices/lab_pin.sym} 62480 -18100 0 1 {name=p61960 lab=_55484_/Y }
C {sky130_stdcells/nor2_4.sym} 62420 -18100 0 0 {name=X_55484_ }
C {devices/lab_pin.sym} 62360 -17980 0 0 {name=p61961 lab=_52706_/A }
C {devices/lab_pin.sym} 62360 -17940 0 0 {name=p61962 lab=_52696_/B }
C {devices/lab_pin.sym} 62480 -17960 0 1 {name=p61963 lab=_52696_/Y }
C {sky130_stdcells/nand2_4.sym} 62420 -17960 0 0 {name=X_52696_ }
C {devices/lab_pin.sym} 62380 -17830 0 0 {name=p61964 lab=clkbuf_9_428_0_CLK/X }
C {devices/lab_pin.sym} 62460 -17830 0 1 {name=p61965 lab=_85514_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 62420 -17830 0 0 {name=Xclkbuf_10_857_0_CLK }
C {devices/lab_pin.sym} 62360 -17740 0 0 {name=p61966 lab=_57222_/Y }
C {devices/lab_pin.sym} 62360 -17700 0 0 {name=p61967 lab=_45904_/X }
C {devices/lab_pin.sym} 62360 -17660 0 0 {name=p61968 lab=_46237_/A }
C {devices/lab_pin.sym} 62360 -17620 0 0 {name=p61969 lab=_57223_/D }
C {devices/lab_pin.sym} 62480 -17680 0 1 {name=p61970 lab=_57223_/X }
C {sky130_stdcells/and4_4.sym} 62420 -17680 0 0 {name=X_57223_ }
C {devices/lab_pin.sym} 62360 -17540 0 0 {name=p61971 lab=_69073_/A }
C {devices/lab_pin.sym} 62360 -17500 0 0 {name=p61972 lab=_69209_/B }
C {devices/lab_pin.sym} 62480 -17520 0 1 {name=p61973 lab=_69209_/X }
C {sky130_stdcells/and2_4.sym} 62420 -17520 0 0 {name=X_69209_ }
C {devices/lab_pin.sym} 62330 -17390 0 0 {name=p61974 lab=_88044_/CLK }
C {devices/lab_pin.sym} 62330 -17370 0 0 {name=p61975 lab=_42085_/Y }
C {devices/lab_pin.sym} 62510 -17390 0 1 {name=p61976 lab=_88043_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -17380 0 0 {name=X_88043_ }
C {devices/lab_pin.sym} 62360 -17280 0 0 {name=p61977 lab=_54435_/A }
C {devices/lab_pin.sym} 62360 -17240 0 0 {name=p61978 lab=_54417_/B }
C {devices/lab_pin.sym} 62360 -17200 0 0 {name=p61979 lab=_54429_/C }
C {devices/lab_pin.sym} 62360 -17160 0 0 {name=p61980 lab=_54435_/D }
C {devices/lab_pin.sym} 62480 -17220 0 1 {name=p61981 lab=_54435_/X }
C {sky130_stdcells/and4_4.sym} 62420 -17220 0 0 {name=X_54435_ }
C {devices/lab_pin.sym} 62330 -17070 0 0 {name=p61982 lab=_85221_/CLK }
C {devices/lab_pin.sym} 62330 -17050 0 0 {name=p61983 lab=_85255_/D }
C {devices/lab_pin.sym} 62510 -17070 0 1 {name=p61984 lab=_85255_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -17060 0 0 {name=X_85255_ }
C {devices/lab_pin.sym} 62380 -16930 0 0 {name=p61985 lab=_51621_/A }
C {devices/lab_pin.sym} 62460 -16930 0 1 {name=p61986 lab=_51647_/X }
C {sky130_stdcells/buf_2.sym} 62420 -16930 0 0 {name=X_51647_ }
C {devices/lab_pin.sym} 62340 -16830 0 0 {name=p61987 lab=_70466_/Y }
C {devices/lab_pin.sym} 62340 -16790 0 0 {name=p61988 lab=_83765_/Q }
C {devices/lab_pin.sym} 62340 -16750 0 0 {name=p61989 lab=_70480_/X }
C {devices/lab_pin.sym} 62500 -16790 0 1 {name=p61990 lab=_70481_/X }
C {sky130_stdcells/a21o_4.sym} 62420 -16790 0 0 {name=X_70481_ }
C {devices/lab_pin.sym} 62330 -16650 0 0 {name=p61991 lab=_82924_/CLK }
C {devices/lab_pin.sym} 62330 -16630 0 0 {name=p61992 lab=_82467_/D }
C {devices/lab_pin.sym} 62510 -16650 0 1 {name=p61993 lab=_82467_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -16640 0 0 {name=X_82467_ }
C {devices/lab_pin.sym} 62380 -16510 0 0 {name=p61994 lab=_41490_/A }
C {devices/lab_pin.sym} 62460 -16510 0 1 {name=p61995 lab=_41400_/X }
C {sky130_stdcells/buf_2.sym} 62420 -16510 0 0 {name=X_41400_ }
C {devices/lab_pin.sym} 62360 -16400 0 0 {name=p61996 lab=_72220_/A }
C {devices/lab_pin.sym} 62360 -16360 0 0 {name=p61997 lab=_72220_/B }
C {devices/lab_pin.sym} 62480 -16380 0 1 {name=p61998 lab=_72220_/Y }
C {sky130_stdcells/nor2_4.sym} 62420 -16380 0 0 {name=X_72220_ }
C {devices/lab_pin.sym} 62330 -16250 0 0 {name=p61999 lab=_85315_/CLK }
C {devices/lab_pin.sym} 62330 -16230 0 0 {name=p62000 lab=_84206_/D }
C {devices/lab_pin.sym} 62510 -16250 0 1 {name=p62001 lab=_84206_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -16240 0 0 {name=X_84206_ }
C {devices/lab_pin.sym} 62380 -16110 0 0 {name=p62002 lab=clkbuf_8_174_0_CLK/X }
C {devices/lab_pin.sym} 62460 -16110 0 1 {name=p62003 lab=clkbuf_9_348_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 62420 -16110 0 0 {name=Xclkbuf_9_348_0_CLK }
C {devices/lab_pin.sym} 62330 -15990 0 0 {name=p62004 lab=_81532_/CLK }
C {devices/lab_pin.sym} 62330 -15970 0 0 {name=p62005 lab=_81418_/D }
C {devices/lab_pin.sym} 62510 -15990 0 1 {name=p62006 lab=_75972_/B }
C {sky130_stdcells/dfxtp_4.sym} 62420 -15980 0 0 {name=X_81418_ }
C {devices/lab_pin.sym} 62340 -15870 0 0 {name=p62007 lab=_44256_/A }
C {devices/lab_pin.sym} 62340 -15830 0 0 {name=p62008 lab=_57152_/X }
C {devices/lab_pin.sym} 62340 -15790 0 0 {name=p62009 lab=_57153_/Y }
C {devices/lab_pin.sym} 62500 -15830 0 1 {name=p62010 lab=_85071_/D }
C {sky130_stdcells/o21ai_4.sym} 62420 -15830 0 0 {name=X_57154_ }
C {devices/lab_pin.sym} 62380 -15690 0 0 {name=p62011 lab=_42379_/Y }
C {devices/lab_pin.sym} 62460 -15690 0 1 {name=p62012 lab=_87893_/D }
C {sky130_stdcells/inv_2.sym} 62420 -15690 0 0 {name=X_42380_ }
C {devices/lab_pin.sym} 62380 -15570 0 0 {name=p62013 lab=_54366_/A }
C {devices/lab_pin.sym} 62460 -15570 0 1 {name=p62014 lab=_54366_/X }
C {sky130_stdcells/buf_2.sym} 62420 -15570 0 0 {name=X_54366_ }
C {devices/lab_pin.sym} 62330 -15450 0 0 {name=p62015 lab=_85186_/CLK }
C {devices/lab_pin.sym} 62330 -15430 0 0 {name=p62016 lab=_56459_/Y }
C {devices/lab_pin.sym} 62510 -15450 0 1 {name=p62017 lab=_56458_/C }
C {sky130_stdcells/dfxtp_4.sym} 62420 -15440 0 0 {name=X_85186_ }
C {devices/lab_pin.sym} 62340 -15330 0 0 {name=p62018 lab=_85984_/Q }
C {devices/lab_pin.sym} 62340 -15290 0 0 {name=p62019 lab=_51566_/X }
C {devices/lab_pin.sym} 62340 -15250 0 0 {name=p62020 lab=_51577_/Y }
C {devices/lab_pin.sym} 62500 -15290 0 1 {name=p62021 lab=_51578_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -15290 0 0 {name=X_51578_ }
C {devices/lab_pin.sym} 62330 -15150 0 0 {name=p62022 lab=_82965_/CLK }
C {devices/lab_pin.sym} 62330 -15130 0 0 {name=p62023 lab=_82206_/Q }
C {devices/lab_pin.sym} 62510 -15150 0 1 {name=p62024 lab=_82398_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -15140 0 0 {name=X_82398_ }
C {devices/lab_pin.sym} 62360 -15030 0 0 {name=p62025 lab=_56131_/A }
C {devices/lab_pin.sym} 62360 -14990 0 0 {name=p62026 lab=_56115_/B }
C {devices/lab_pin.sym} 62360 -14950 0 0 {name=p62027 lab=_55826_/B }
C {devices/lab_pin.sym} 62480 -14990 0 1 {name=p62028 lab=_56105_/Y }
C {sky130_stdcells/nand3_4.sym} 62420 -14990 0 0 {name=X_56105_ }
C {devices/lab_pin.sym} 62340 -14870 0 0 {name=p62029 lab=_41242_/X }
C {devices/lab_pin.sym} 62340 -14830 0 0 {name=p62030 lab=_41679_/A }
C {devices/lab_pin.sym} 62340 -14790 0 0 {name=p62031 lab=_41330_/X }
C {devices/lab_pin.sym} 62500 -14830 0 1 {name=p62032 lab=_41331_/X }
C {sky130_stdcells/o21a_4.sym} 62420 -14830 0 0 {name=X_41331_ }
C {devices/lab_pin.sym} 62340 -14710 0 0 {name=p62033 lab=_53315_/Y }
C {devices/lab_pin.sym} 62340 -14670 0 0 {name=p62034 lab=_53301_/X }
C {devices/lab_pin.sym} 62340 -14630 0 0 {name=p62035 lab=_53316_/X }
C {devices/lab_pin.sym} 62500 -14670 0 1 {name=p62036 lab=_53317_/Y }
C {sky130_stdcells/a21oi_4.sym} 62420 -14670 0 0 {name=X_53317_ }
C {devices/lab_pin.sym} 62380 -14530 0 0 {name=p62037 lab=_83278_/Q }
C {devices/lab_pin.sym} 62460 -14530 0 1 {name=p62038 lab=_72151_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -14530 0 0 {name=X_72151_ }
C {devices/lab_pin.sym} 62330 -14410 0 0 {name=p62039 lab=_82177_/CLK }
C {devices/lab_pin.sym} 62330 -14390 0 0 {name=p62040 lab=_84137_/D }
C {devices/lab_pin.sym} 62510 -14410 0 1 {name=p62041 lab=_66364_/C }
C {sky130_stdcells/dfxtp_4.sym} 62420 -14400 0 0 {name=X_84137_ }
C {devices/lab_pin.sym} 62340 -14290 0 0 {name=p62042 lab=_86183_/Q }
C {devices/lab_pin.sym} 62340 -14250 0 0 {name=p62043 lab=_50506_/X }
C {devices/lab_pin.sym} 62340 -14210 0 0 {name=p62044 lab=_50528_/Y }
C {devices/lab_pin.sym} 62500 -14250 0 1 {name=p62045 lab=_50529_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -14250 0 0 {name=X_50529_ }
C {devices/lab_pin.sym} 62340 -14130 0 0 {name=p62046 lab=_56989_/A }
C {devices/lab_pin.sym} 62340 -14090 0 0 {name=p62047 lab=_57083_/X }
C {devices/lab_pin.sym} 62340 -14050 0 0 {name=p62048 lab=_57084_/Y }
C {devices/lab_pin.sym} 62500 -14090 0 1 {name=p62049 lab=_57085_/X }
C {sky130_stdcells/o21a_4.sym} 62420 -14090 0 0 {name=X_57085_ }
C {devices/lab_pin.sym} 62330 -13950 0 0 {name=p62050 lab=_84105_/CLK }
C {devices/lab_pin.sym} 62330 -13930 0 0 {name=p62051 lab=_81349_/D }
C {devices/lab_pin.sym} 62510 -13950 0 1 {name=p62052 lab=_81349_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -13940 0 0 {name=X_81349_ }
C {devices/lab_pin.sym} 62340 -13830 0 0 {name=p62053 lab=_85468_/Q }
C {devices/lab_pin.sym} 62340 -13790 0 0 {name=p62054 lab=_54294_/X }
C {devices/lab_pin.sym} 62340 -13750 0 0 {name=p62055 lab=_54296_/Y }
C {devices/lab_pin.sym} 62500 -13790 0 1 {name=p62056 lab=_54297_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -13790 0 0 {name=X_54297_ }
C {devices/lab_pin.sym} 62360 -13670 0 0 {name=p62057 lab=_71101_/X }
C {devices/lab_pin.sym} 62360 -13630 0 0 {name=p62058 lab=_71055_/B }
C {devices/lab_pin.sym} 62360 -13590 0 0 {name=p62059 lab=_71099_/C }
C {devices/lab_pin.sym} 62480 -13630 0 1 {name=p62060 lab=_71102_/Y }
C {sky130_stdcells/nand3_4.sym} 62420 -13630 0 0 {name=X_71102_ }
C {devices/lab_pin.sym} 62380 -13490 0 0 {name=p62061 lab=_44049_/X }
C {devices/lab_pin.sym} 62460 -13490 0 1 {name=p62062 lab=_44051_/A }
C {sky130_stdcells/buf_2.sym} 62420 -13490 0 0 {name=X_44050_ }
C {devices/lab_pin.sym} 62380 -13370 0 0 {name=p62063 lab=_45765_/A }
C {devices/lab_pin.sym} 62460 -13370 0 1 {name=p62064 lab=_56052_/B }
C {sky130_stdcells/buf_2.sym} 62420 -13370 0 0 {name=X_56036_ }
C {devices/lab_pin.sym} 62380 -13250 0 0 {name=p62065 lab=_53302_/A }
C {devices/lab_pin.sym} 62460 -13250 0 1 {name=p62066 lab=_53266_/C }
C {sky130_stdcells/buf_2.sym} 62420 -13250 0 0 {name=X_53248_ }
C {devices/lab_pin.sym} 62360 -13140 0 0 {name=p62067 lab=_41159_/A }
C {devices/lab_pin.sym} 62360 -13100 0 0 {name=p62068 lab=_40737_/A }
C {devices/lab_pin.sym} 62480 -13120 0 1 {name=p62069 lab=_41262_/X }
C {sky130_stdcells/or2_4.sym} 62420 -13120 0 0 {name=X_41262_ }
C {devices/lab_pin.sym} 62340 -13010 0 0 {name=p62070 lab=_83288_/Q }
C {devices/lab_pin.sym} 62340 -12970 0 0 {name=p62071 lab=_72051_/X }
C {devices/lab_pin.sym} 62340 -12930 0 0 {name=p62072 lab=_72081_/Y }
C {devices/lab_pin.sym} 62500 -12970 0 1 {name=p62073 lab=_72082_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -12970 0 0 {name=X_72082_ }
C {devices/lab_pin.sym} 62330 -12830 0 0 {name=p62074 lab=_82648_/CLK }
C {devices/lab_pin.sym} 62330 -12810 0 0 {name=p62075 lab=_84068_/D }
C {devices/lab_pin.sym} 62510 -12830 0 1 {name=p62076 lab=_81500_/D }
C {sky130_stdcells/dfxtp_4.sym} 62420 -12820 0 0 {name=X_84068_ }
C {devices/lab_pin.sym} 62380 -12690 0 0 {name=p62077 lab=_43001_/A }
C {devices/lab_pin.sym} 62460 -12690 0 1 {name=p62078 lab=_43001_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -12690 0 0 {name=X_43001_ }
C {devices/lab_pin.sym} 62360 -12600 0 0 {name=p62079 lab=_71178_/A }
C {devices/lab_pin.sym} 62360 -12560 0 0 {name=p62080 lab=_71030_/B }
C {devices/lab_pin.sym} 62360 -12520 0 0 {name=p62081 lab=_71030_/C }
C {devices/lab_pin.sym} 62360 -12480 0 0 {name=p62082 lab=_71018_/D }
C {devices/lab_pin.sym} 62480 -12540 0 1 {name=p62083 lab=_71033_/Y }
C {sky130_stdcells/nand4_4.sym} 62420 -12540 0 0 {name=X_71033_ }
C {devices/lab_pin.sym} 62360 -12400 0 0 {name=p62084 lab=_61203_/C }
C {devices/lab_pin.sym} 62360 -12360 0 0 {name=p62085 lab=_62816_/C }
C {devices/lab_pin.sym} 62480 -12380 0 1 {name=p62086 lab=_75910_/X }
C {sky130_stdcells/xor2_4.sym} 62420 -12380 0 0 {name=X_75910_ }
C {devices/lab_pin.sym} 62330 -12250 0 0 {name=p62087 lab=_80670_/CLK }
C {devices/lab_pin.sym} 62330 -12230 0 0 {name=p62088 lab=_74604_/Y }
C {devices/lab_pin.sym} 62510 -12250 0 1 {name=p62089 lab=_45244_/A }
C {sky130_stdcells/dfxtp_4.sym} 62420 -12240 0 0 {name=X_83019_ }
C {devices/lab_pin.sym} 62380 -12110 0 0 {name=p62090 lab=_41192_/X }
C {devices/lab_pin.sym} 62460 -12110 0 1 {name=p62091 lab=_41193_/X }
C {sky130_stdcells/buf_2.sym} 62420 -12110 0 0 {name=X_41193_ }
C {devices/lab_pin.sym} 62360 -12000 0 0 {name=p62092 lab=_53187_/A }
C {devices/lab_pin.sym} 62360 -11960 0 0 {name=p62093 lab=_53179_/B }
C {devices/lab_pin.sym} 62480 -11980 0 1 {name=p62094 lab=_53179_/Y }
C {sky130_stdcells/nand2_4.sym} 62420 -11980 0 0 {name=X_53179_ }
C {devices/lab_pin.sym} 62380 -11850 0 0 {name=p62095 lab=_76889_/X }
C {devices/lab_pin.sym} 62460 -11850 0 1 {name=p62096 lab=_81468_/D }
C {sky130_stdcells/buf_2.sym} 62420 -11850 0 0 {name=X_76890_ }
C {devices/lab_pin.sym} 62380 -11730 0 0 {name=p62097 lab=_75841_/A }
C {devices/lab_pin.sym} 62460 -11730 0 1 {name=p62098 lab=_75841_/Y }
C {sky130_stdcells/inv_2.sym} 62420 -11730 0 0 {name=X_75841_ }
C {devices/lab_pin.sym} 62330 -11610 0 0 {name=p62099 lab=_87826_/CLK }
C {devices/lab_pin.sym} 62330 -11590 0 0 {name=p62100 lab=_87827_/D }
C {devices/lab_pin.sym} 62510 -11610 0 1 {name=p62101 lab=_72728_/A }
C {sky130_stdcells/dfxtp_4.sym} 62420 -11600 0 0 {name=X_87827_ }
C {devices/lab_pin.sym} 62340 -11490 0 0 {name=p62102 lab=_57926_/X }
C {devices/lab_pin.sym} 62340 -11450 0 0 {name=p62103 lab=_85998_/Q }
C {devices/lab_pin.sym} 62340 -11410 0 0 {name=p62104 lab=_57986_/X }
C {devices/lab_pin.sym} 62500 -11450 0 1 {name=p62105 lab=_57987_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -11450 0 0 {name=X_57987_ }
C {devices/lab_pin.sym} 62340 -11330 0 0 {name=p62106 lab=_47736_/Y }
C {devices/lab_pin.sym} 62340 -11290 0 0 {name=p62107 lab=_47698_/X }
C {devices/lab_pin.sym} 62340 -11250 0 0 {name=p62108 lab=_47739_/X }
C {devices/lab_pin.sym} 62500 -11290 0 1 {name=p62109 lab=_47740_/Y }
C {sky130_stdcells/a21oi_4.sym} 62420 -11290 0 0 {name=X_47740_ }
C {devices/lab_pin.sym} 62380 -11150 0 0 {name=p62110 lab=_66064_/A }
C {devices/lab_pin.sym} 62460 -11150 0 1 {name=p62111 lab=_66377_/A }
C {sky130_stdcells/buf_2.sym} 62420 -11150 0 0 {name=X_59726_ }
C {devices/lab_pin.sym} 62360 -11040 0 0 {name=p62112 lab=_78560_/A }
C {devices/lab_pin.sym} 62360 -11000 0 0 {name=p62113 lab=_78560_/B }
C {devices/lab_pin.sym} 62480 -11020 0 1 {name=p62114 lab=_78563_/A }
C {sky130_stdcells/nand2_4.sym} 62420 -11020 0 0 {name=X_78560_ }
C {devices/lab_pin.sym} 62360 -10900 0 0 {name=p62115 lab=_44950_/Y }
C {devices/lab_pin.sym} 62360 -10860 0 0 {name=p62116 lab=_45590_/B }
C {devices/lab_pin.sym} 62480 -10880 0 1 {name=p62117 lab=_44952_/X }
C {sky130_stdcells/and2_4.sym} 62420 -10880 0 0 {name=X_44952_ }
C {devices/lab_pin.sym} 62380 -10750 0 0 {name=p62118 lab=_72771_/A }
C {devices/lab_pin.sym} 62460 -10750 0 1 {name=p62119 lab=_72732_/B }
C {sky130_stdcells/buf_2.sym} 62420 -10750 0 0 {name=X_56938_ }
C {devices/lab_pin.sym} 62360 -10640 0 0 {name=p62120 lab=_75759_/A }
C {devices/lab_pin.sym} 62360 -10600 0 0 {name=p62121 lab=_75766_/A }
C {devices/lab_pin.sym} 62480 -10620 0 1 {name=p62122 lab=_75772_/X }
C {sky130_stdcells/and2_4.sym} 62420 -10620 0 0 {name=X_75772_ }
C {devices/lab_pin.sym} 62330 -10490 0 0 {name=p62123 lab=_87758_/CLK }
C {devices/lab_pin.sym} 62330 -10470 0 0 {name=p62124 lab=_42709_/Y }
C {devices/lab_pin.sym} 62510 -10490 0 1 {name=p62125 lab=_87758_/Q }
C {sky130_stdcells/dfxtp_4.sym} 62420 -10480 0 0 {name=X_87758_ }
C {devices/lab_pin.sym} 62340 -10370 0 0 {name=p62126 lab=_72973_/Y }
C {devices/lab_pin.sym} 62340 -10330 0 0 {name=p62127 lab=_72975_/Y }
C {devices/lab_pin.sym} 62340 -10290 0 0 {name=p62128 lab=_72983_/X }
C {devices/lab_pin.sym} 62500 -10330 0 1 {name=p62129 lab=_72984_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -10330 0 0 {name=X_72984_ }
C {devices/lab_pin.sym} 62360 -10200 0 0 {name=p62130 lab=_77511_/A }
C {devices/lab_pin.sym} 62360 -10160 0 0 {name=p62131 lab=_77510_/Y }
C {devices/lab_pin.sym} 62480 -10180 0 1 {name=p62132 lab=_77512_/B }
C {sky130_stdcells/and2_4.sym} 62420 -10180 0 0 {name=X_77511_ }
C {devices/lab_pin.sym} 62340 -10090 0 0 {name=p62133 lab=_43895_/X }
C {devices/lab_pin.sym} 62340 -10050 0 0 {name=p62134 lab=_43902_/X }
C {devices/lab_pin.sym} 62340 -10010 0 0 {name=p62135 lab=_41347_/X }
C {devices/lab_pin.sym} 62340 -9970 0 0 {name=p62136 lab=_67596_/B }
C {devices/lab_pin.sym} 62340 -9930 0 0 {name=p62137 lab=_43897_/X }
C {devices/lab_pin.sym} 62500 -10010 0 1 {name=p62138 lab=_43903_/Y }
C {sky130_stdcells/o32ai_4.sym} 62420 -10010 0 0 {name=X_43903_ }
C {devices/lab_pin.sym} 62330 -9850 0 0 {name=p62139 lab=_86711_/CLK }
C {devices/lab_pin.sym} 62330 -9830 0 0 {name=p62140 lab=_86709_/D }
C {devices/lab_pin.sym} 62510 -9850 0 1 {name=p62141 lab=_58722_/A }
C {sky130_stdcells/dfxtp_4.sym} 62420 -9840 0 0 {name=X_86709_ }
C {devices/lab_pin.sym} 62380 -9710 0 0 {name=p62142 lab=_70576_/X }
C {devices/lab_pin.sym} 62460 -9710 0 1 {name=p62143 lab=_74723_/X }
C {sky130_stdcells/buf_2.sym} 62420 -9710 0 0 {name=X_74723_ }
C {devices/lab_pin.sym} 62340 -9610 0 0 {name=p62144 lab=_72302_/A }
C {devices/lab_pin.sym} 62340 -9570 0 0 {name=p62145 lab=_47666_/X }
C {devices/lab_pin.sym} 62340 -9530 0 0 {name=p62146 lab=_47670_/Y }
C {devices/lab_pin.sym} 62500 -9570 0 1 {name=p62147 lab=_47671_/Y }
C {sky130_stdcells/o21ai_4.sym} 62420 -9570 0 0 {name=X_47671_ }
C {devices/lab_pin.sym} 62380 -9430 0 0 {name=p62148 lab=_71170_/A }
C {devices/lab_pin.sym} 62460 -9430 0 1 {name=p62149 lab=_74518_/B }
C {sky130_stdcells/buf_2.sym} 62420 -9430 0 0 {name=X_71935_ }
