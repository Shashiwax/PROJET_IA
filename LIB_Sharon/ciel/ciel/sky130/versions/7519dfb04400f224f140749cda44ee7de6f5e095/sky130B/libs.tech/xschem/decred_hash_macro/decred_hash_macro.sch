C {devices/lab_pin.sym} 40430 -10610 0 1 {name=p40039 lab=_81139_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -10600 0 0 {name=X_81139_ }
C {devices/lab_pin.sym} 40260 -10490 0 0 {name=p40040 lab=_58904_/X }
C {devices/lab_pin.sym} 40260 -10450 0 0 {name=p40041 lab=_85762_/Q }
C {devices/lab_pin.sym} 40260 -10410 0 0 {name=p40042 lab=_58928_/X }
C {devices/lab_pin.sym} 40420 -10450 0 1 {name=p40043 lab=_58964_/X }
C {sky130_stdcells/o21a_4.sym} 40340 -10450 0 0 {name=X_58964_ }
C {devices/lab_pin.sym} 40280 -10320 0 0 {name=p40044 lab=_53801_/B }
C {devices/lab_pin.sym} 40280 -10280 0 0 {name=p40045 lab=_54087_/B }
C {devices/lab_pin.sym} 40400 -10300 0 1 {name=p40046 lab=_54087_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -10300 0 0 {name=X_54087_ }
C {devices/lab_pin.sym} 40260 -10190 0 0 {name=p40047 lab=_51297_/Y }
C {devices/lab_pin.sym} 40260 -10150 0 0 {name=p40048 lab=_51289_/X }
C {devices/lab_pin.sym} 40260 -10110 0 0 {name=p40049 lab=_51298_/X }
C {devices/lab_pin.sym} 40420 -10150 0 1 {name=p40050 lab=_51299_/Y }
C {sky130_stdcells/a21oi_4.sym} 40340 -10150 0 0 {name=X_51299_ }
C {devices/lab_pin.sym} 40250 -10010 0 0 {name=p40051 lab=_88363_/CLK }
C {devices/lab_pin.sym} 40250 -9990 0 0 {name=p40052 lab=_44698_/Y }
C {devices/lab_pin.sym} 40430 -10010 0 1 {name=p40053 lab=_44697_/A }
C {sky130_stdcells/dfxtp_4.sym} 40340 -10000 0 0 {name=X_86996_ }
C {devices/lab_pin.sym} 40280 -9880 0 0 {name=p40054 lab=_40879_/B }
C {devices/lab_pin.sym} 40280 -9840 0 0 {name=p40055 lab=_41019_/B }
C {devices/lab_pin.sym} 40400 -9860 0 1 {name=p40056 lab=_41052_/X }
C {sky130_stdcells/or2_4.sym} 40340 -9860 0 0 {name=X_41052_ }
C {devices/lab_pin.sym} 40300 -9730 0 0 {name=p40057 lab=_53065_/A }
C {devices/lab_pin.sym} 40380 -9730 0 1 {name=p40058 lab=_53038_/X }
C {sky130_stdcells/buf_2.sym} 40340 -9730 0 0 {name=X_53038_ }
C {devices/lab_pin.sym} 40260 -9630 0 0 {name=p40059 lab=_57773_/X }
C {devices/lab_pin.sym} 40260 -9590 0 0 {name=p40060 lab=_85716_/Q }
C {devices/lab_pin.sym} 40260 -9550 0 0 {name=p40061 lab=_44177_/X }
C {devices/lab_pin.sym} 40420 -9590 0 1 {name=p40062 lab=_57915_/X }
C {sky130_stdcells/o21a_4.sym} 40340 -9590 0 0 {name=X_57915_ }
C {devices/lab_pin.sym} 40260 -9470 0 0 {name=p40063 lab=_70117_/C }
C {devices/lab_pin.sym} 40260 -9430 0 0 {name=p40064 lab=_73939_/X }
C {devices/lab_pin.sym} 40260 -9390 0 0 {name=p40065 lab=_73960_/X }
C {devices/lab_pin.sym} 40420 -9430 0 1 {name=p40066 lab=_83129_/D }
C {sky130_stdcells/o21ai_4.sym} 40340 -9430 0 0 {name=X_73961_ }
C {devices/lab_pin.sym} 40250 -9290 0 0 {name=p40067 lab=_82206_/CLK }
C {devices/lab_pin.sym} 40250 -9270 0 0 {name=p40068 lab=_85947_/D }
C {devices/lab_pin.sym} 40430 -9290 0 1 {name=p40069 lab=_85947_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -9280 0 0 {name=X_85947_ }
C {devices/lab_pin.sym} 40260 -9180 0 0 {name=p40070 lab=_84792_/Q }
C {devices/lab_pin.sym} 40260 -9140 0 0 {name=p40071 lab=_58871_/X }
C {devices/lab_pin.sym} 40260 -9100 0 0 {name=p40072 lab=_58888_/X }
C {devices/lab_pin.sym} 40260 -9060 0 0 {name=p40073 lab=_58894_/X }
C {devices/lab_pin.sym} 40420 -9120 0 1 {name=p40074 lab=_58895_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 40340 -9120 0 0 {name=X_58895_ }
C {devices/lab_pin.sym} 40300 -8970 0 0 {name=p40075 lab=_75677_/Y }
C {devices/lab_pin.sym} 40380 -8970 0 1 {name=p40076 lab=_80782_/D }
C {sky130_stdcells/inv_2.sym} 40340 -8970 0 0 {name=X_75700_ }
C {devices/lab_pin.sym} 40260 -8880 0 0 {name=p40077 lab=_72908_/X }
C {devices/lab_pin.sym} 40260 -8840 0 0 {name=p40078 lab=_85596_/Q }
C {devices/lab_pin.sym} 40260 -8800 0 0 {name=p40079 lab=_72909_/X }
C {devices/lab_pin.sym} 40260 -8760 0 0 {name=p40080 lab=_72911_/X }
C {devices/lab_pin.sym} 40420 -8820 0 1 {name=p40081 lab=_72912_/X }
C {sky130_stdcells/a211o_4.sym} 40340 -8820 0 0 {name=X_72912_ }
C {devices/lab_pin.sym} 40280 -8680 0 0 {name=p40082 lab=_57846_/A }
C {devices/lab_pin.sym} 40280 -8640 0 0 {name=p40083 lab=_57845_/X }
C {devices/lab_pin.sym} 40400 -8660 0 1 {name=p40084 lab=_57846_/Y }
C {sky130_stdcells/nor2_4.sym} 40340 -8660 0 0 {name=X_57846_ }
C {devices/lab_pin.sym} 40260 -8550 0 0 {name=p40085 lab=_56920_/B }
C {devices/lab_pin.sym} 40260 -8510 0 0 {name=p40086 lab=_45798_/X }
C {devices/lab_pin.sym} 40260 -8470 0 0 {name=p40087 lab=_44889_/A }
C {devices/lab_pin.sym} 40420 -8510 0 1 {name=p40088 lab=_45860_/X }
C {sky130_stdcells/o21a_4.sym} 40340 -8510 0 0 {name=X_45860_ }
C {devices/lab_pin.sym} 40260 -8390 0 0 {name=p40089 lab=_76679_/Y }
C {devices/lab_pin.sym} 40260 -8350 0 0 {name=p40090 lab=_76666_/Y }
C {devices/lab_pin.sym} 40260 -8310 0 0 {name=p40091 lab=_76673_/A }
C {devices/lab_pin.sym} 40420 -8350 0 1 {name=p40092 lab=_76680_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -8350 0 0 {name=X_76680_ }
C {devices/lab_pin.sym} 40280 -8220 0 0 {name=p40093 lab=_73892_/A }
C {devices/lab_pin.sym} 40280 -8180 0 0 {name=p40094 lab=_73869_/X }
C {devices/lab_pin.sym} 40400 -8200 0 1 {name=p40095 lab=_73892_/Y }
C {sky130_stdcells/nor2_4.sym} 40340 -8200 0 0 {name=X_73892_ }
C {devices/lab_pin.sym} 40250 -8070 0 0 {name=p40096 lab=_86196_/CLK }
C {devices/lab_pin.sym} 40250 -8050 0 0 {name=p40097 lab=_52157_/Y }
C {devices/lab_pin.sym} 40430 -8070 0 1 {name=p40098 lab=_85878_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -8060 0 0 {name=X_85878_ }
C {devices/lab_pin.sym} 40260 -7960 0 0 {name=p40099 lab=_41635_/Y }
C {devices/lab_pin.sym} 40260 -7920 0 0 {name=p40100 lab=_43939_/X }
C {devices/lab_pin.sym} 40260 -7880 0 0 {name=p40101 lab=_67361_/B }
C {devices/lab_pin.sym} 40260 -7840 0 0 {name=p40102 lab=_43941_/X }
C {devices/lab_pin.sym} 40420 -7900 0 1 {name=p40103 lab=_86942_/D }
C {sky130_stdcells/a2bb2o_4.sym} 40340 -7900 0 0 {name=X_44811_ }
C {devices/lab_pin.sym} 40280 -7760 0 0 {name=p40104 lab=_80776_/D }
C {devices/lab_pin.sym} 40280 -7720 0 0 {name=p40105 lab=_75619_/A }
C {devices/lab_pin.sym} 40400 -7740 0 1 {name=p40106 lab=_75631_/X }
C {sky130_stdcells/and2_4.sym} 40340 -7740 0 0 {name=X_75631_ }
C {devices/lab_pin.sym} 40250 -7610 0 0 {name=p40107 lab=_88387_/CLK }
C {devices/lab_pin.sym} 40250 -7590 0 0 {name=p40108 lab=_87617_/D }
C {devices/lab_pin.sym} 40430 -7610 0 1 {name=p40109 lab=_66995_/B }
C {sky130_stdcells/dfxtp_4.sym} 40340 -7600 0 0 {name=X_87617_ }
C {devices/lab_pin.sym} 40280 -7480 0 0 {name=p40110 lab=_72816_/X }
C {devices/lab_pin.sym} 40280 -7440 0 0 {name=p40111 lab=_72843_/B }
C {devices/lab_pin.sym} 40400 -7460 0 1 {name=p40112 lab=_72843_/X }
C {sky130_stdcells/and2_4.sym} 40340 -7460 0 0 {name=X_72843_ }
C {devices/lab_pin.sym} 40250 -7330 0 0 {name=p40113 lab=_84829_/CLK }
C {devices/lab_pin.sym} 40250 -7310 0 0 {name=p40114 lab=_58521_/Y }
C {devices/lab_pin.sym} 40430 -7330 0 1 {name=p40115 lab=_84829_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -7320 0 0 {name=X_84829_ }
C {devices/lab_pin.sym} 40260 -7210 0 0 {name=p40116 lab=_45784_/X }
C {devices/lab_pin.sym} 40260 -7170 0 0 {name=p40117 lab=_45788_/Y }
C {devices/lab_pin.sym} 40260 -7130 0 0 {name=p40118 lab=_45790_/Y }
C {devices/lab_pin.sym} 40420 -7170 0 1 {name=p40119 lab=_86854_/D }
C {sky130_stdcells/a21oi_4.sym} 40340 -7170 0 0 {name=X_45791_ }
C {devices/lab_pin.sym} 40300 -7030 0 0 {name=p40120 lab=_69768_/A }
C {devices/lab_pin.sym} 40380 -7030 0 1 {name=p40121 lab=_58002_/A }
C {sky130_stdcells/buf_2.sym} 40340 -7030 0 0 {name=X_57777_ }
C {devices/lab_pin.sym} 40280 -6920 0 0 {name=p40122 lab=_54985_/A }
C {devices/lab_pin.sym} 40280 -6880 0 0 {name=p40123 lab=_47582_/A }
C {devices/lab_pin.sym} 40400 -6900 0 1 {name=p40124 lab=_54989_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -6900 0 0 {name=X_54989_ }
C {devices/lab_pin.sym} 40300 -6770 0 0 {name=p40125 lab=_47530_/A }
C {devices/lab_pin.sym} 40380 -6770 0 1 {name=p40126 lab=_47530_/X }
C {sky130_stdcells/buf_2.sym} 40340 -6770 0 0 {name=X_47530_ }
C {devices/lab_pin.sym} 40300 -6650 0 0 {name=p40127 lab=_59516_/A }
C {devices/lab_pin.sym} 40380 -6650 0 1 {name=p40128 lab=_59562_/B }
C {sky130_stdcells/buf_2.sym} 40340 -6650 0 0 {name=X_59516_ }
C {devices/lab_pin.sym} 40280 -6550 0 0 {name=p40129 lab=_78350_/A }
C {devices/lab_pin.sym} 40280 -6510 0 0 {name=p40130 lab=_78345_/X }
C {devices/lab_pin.sym} 40280 -6470 0 0 {name=p40131 lab=_78346_/Y }
C {devices/lab_pin.sym} 40400 -6510 0 1 {name=p40132 lab=_78353_/B }
C {sky130_stdcells/nand3_4.sym} 40340 -6510 0 0 {name=X_78350_ }
C {devices/lab_pin.sym} 40300 -6370 0 0 {name=p40133 lab=_44532_/A }
C {devices/lab_pin.sym} 40380 -6370 0 1 {name=p40134 lab=_44742_/X }
C {sky130_stdcells/buf_2.sym} 40340 -6370 0 0 {name=X_44742_ }
C {devices/lab_pin.sym} 40280 -6270 0 0 {name=p40135 lab=_56842_/A }
C {devices/lab_pin.sym} 40280 -6230 0 0 {name=p40136 lab=_56700_/C }
C {devices/lab_pin.sym} 40280 -6190 0 0 {name=p40137 lab=_56676_/Y }
C {devices/lab_pin.sym} 40400 -6230 0 1 {name=p40138 lab=_57140_/A }
C {sky130_stdcells/nor3_4.sym} 40340 -6230 0 0 {name=X_56728_ }
C {devices/lab_pin.sym} 40280 -6110 0 0 {name=p40139 lab=_75562_/A }
C {devices/lab_pin.sym} 40280 -6070 0 0 {name=p40140 lab=_75552_/X }
C {devices/lab_pin.sym} 40280 -6030 0 0 {name=p40141 lab=_75559_/X }
C {devices/lab_pin.sym} 40400 -6070 0 1 {name=p40142 lab=_75563_/B }
C {sky130_stdcells/nand3_4.sym} 40340 -6070 0 0 {name=X_75562_ }
C {devices/lab_pin.sym} 40250 -5930 0 0 {name=p40143 lab=_88087_/CLK }
C {devices/lab_pin.sym} 40250 -5910 0 0 {name=p40144 lab=_43186_/X }
C {devices/lab_pin.sym} 40430 -5930 0 1 {name=p40145 lab=_73341_/A }
C {sky130_stdcells/dfxtp_4.sym} 40340 -5920 0 0 {name=X_87548_ }
C {devices/lab_pin.sym} 40260 -5830 0 0 {name=p40146 lab=_41932_/X }
C {devices/lab_pin.sym} 40260 -5790 0 0 {name=p40147 lab=_41951_/X }
C {devices/lab_pin.sym} 40260 -5750 0 0 {name=p40148 lab=_40707_/X }
C {devices/lab_pin.sym} 40260 -5710 0 0 {name=p40149 lab=_74051_/A }
C {devices/lab_pin.sym} 40260 -5670 0 0 {name=p40150 lab=_41953_/X }
C {devices/lab_pin.sym} 40420 -5750 0 1 {name=p40151 lab=_41955_/A }
C {sky130_stdcells/o32ai_4.sym} 40340 -5750 0 0 {name=X_41954_ }
C {devices/lab_pin.sym} 40260 -5610 0 0 {name=p40152 lab=_72770_/X }
C {devices/lab_pin.sym} 40260 -5570 0 0 {name=p40153 lab=_72773_/X }
C {devices/lab_pin.sym} 40260 -5530 0 0 {name=p40154 lab=_72737_/X }
C {devices/lab_pin.sym} 40420 -5570 0 1 {name=p40155 lab=_72774_/X }
C {sky130_stdcells/a21o_4.sym} 40340 -5570 0 0 {name=X_72774_ }
C {devices/lab_pin.sym} 40280 -5440 0 0 {name=p40156 lab=_77301_/A }
C {devices/lab_pin.sym} 40280 -5400 0 0 {name=p40157 lab=_77301_/B }
C {devices/lab_pin.sym} 40400 -5420 0 1 {name=p40158 lab=_77318_/B }
C {sky130_stdcells/nor2_4.sym} 40340 -5420 0 0 {name=X_77301_ }
C {devices/lab_pin.sym} 40280 -5300 0 0 {name=p40159 lab=_46347_/A }
C {devices/lab_pin.sym} 40280 -5260 0 0 {name=p40160 lab=_50556_/B }
C {devices/lab_pin.sym} 40400 -5280 0 1 {name=p40161 lab=_74513_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -5280 0 0 {name=X_74513_ }
C {devices/lab_pin.sym} 40300 -5150 0 0 {name=p40162 lab=_40756_/A }
C {devices/lab_pin.sym} 40380 -5150 0 1 {name=p40163 lab=_40905_/X }
C {sky130_stdcells/buf_2.sym} 40340 -5150 0 0 {name=X_40905_ }
C {devices/lab_pin.sym} 40260 -5050 0 0 {name=p40164 lab=_86632_/Q }
C {devices/lab_pin.sym} 40260 -5010 0 0 {name=p40165 lab=_47429_/X }
C {devices/lab_pin.sym} 40260 -4970 0 0 {name=p40166 lab=_47460_/Y }
C {devices/lab_pin.sym} 40420 -5010 0 1 {name=p40167 lab=_47461_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -5010 0 0 {name=X_47461_ }
C {devices/lab_pin.sym} 40280 -4890 0 0 {name=p40168 lab=_71729_/A }
C {devices/lab_pin.sym} 40280 -4850 0 0 {name=p40169 lab=_71302_/X }
C {devices/lab_pin.sym} 40280 -4810 0 0 {name=p40170 lab=_71724_/X }
C {devices/lab_pin.sym} 40400 -4850 0 1 {name=p40171 lab=_71725_/Y }
C {sky130_stdcells/nand3_4.sym} 40340 -4850 0 0 {name=X_71725_ }
C {devices/lab_pin.sym} 40300 -4710 0 0 {name=p40172 lab=_84730_/Q }
C {devices/lab_pin.sym} 40380 -4710 0 1 {name=p40173 lab=_59448_/A }
C {sky130_stdcells/inv_2.sym} 40340 -4710 0 0 {name=X_59447_ }
C {devices/lab_pin.sym} 40280 -4610 0 0 {name=p40174 lab=_78262_/X }
C {devices/lab_pin.sym} 40280 -4570 0 0 {name=p40175 lab=_78274_/A }
C {devices/lab_pin.sym} 40280 -4530 0 0 {name=p40176 lab=_78284_/B }
C {devices/lab_pin.sym} 40400 -4570 0 1 {name=p40177 lab=_78281_/Y }
C {sky130_stdcells/nand3_4.sym} 40340 -4570 0 0 {name=X_78281_ }
C {devices/lab_pin.sym} 40260 -4470 0 0 {name=p40178 lab=_44658_/X }
C {devices/lab_pin.sym} 40260 -4430 0 0 {name=p40179 lab=_44659_/X }
C {devices/lab_pin.sym} 40260 -4390 0 0 {name=p40180 lab=_40581_/X }
C {devices/lab_pin.sym} 40260 -4350 0 0 {name=p40181 lab=_87005_/Q }
C {devices/lab_pin.sym} 40260 -4310 0 0 {name=p40182 lab=_44660_/X }
C {devices/lab_pin.sym} 40420 -4390 0 1 {name=p40183 lab=_44674_/A }
C {sky130_stdcells/o32ai_4.sym} 40340 -4390 0 0 {name=X_44673_ }
C {devices/lab_pin.sym} 40300 -4230 0 0 {name=p40184 lab=_56700_/C }
C {devices/lab_pin.sym} 40380 -4230 0 1 {name=p40185 lab=_56659_/Y }
C {sky130_stdcells/inv_2.sym} 40340 -4230 0 0 {name=X_56659_ }
C {devices/lab_pin.sym} 40280 -4120 0 0 {name=p40186 lab=_75493_/A }
C {devices/lab_pin.sym} 40280 -4080 0 0 {name=p40187 lab=_75492_/Y }
C {devices/lab_pin.sym} 40400 -4100 0 1 {name=p40188 lab=_75493_/Y }
C {sky130_stdcells/nor2_4.sym} 40340 -4100 0 0 {name=X_75493_ }
C {devices/lab_pin.sym} 40250 -3970 0 0 {name=p40189 lab=_87749_/CLK }
C {devices/lab_pin.sym} 40250 -3950 0 0 {name=p40190 lab=_87479_/D }
C {devices/lab_pin.sym} 40430 -3970 0 1 {name=p40191 lab=_87479_/Q }
C {sky130_stdcells/dfxtp_4.sym} 40340 -3960 0 0 {name=X_87479_ }
C {devices/lab_pin.sym} 40300 -3830 0 0 {name=p40192 lab=_42081_/A }
C {devices/lab_pin.sym} 40380 -3830 0 1 {name=p40193 lab=_42059_/A }
C {sky130_stdcells/buf_2.sym} 40340 -3830 0 0 {name=X_41885_ }
C {devices/lab_pin.sym} 40260 -3730 0 0 {name=p40194 lab=_40380_/X }
C {devices/lab_pin.sym} 40260 -3690 0 0 {name=p40195 lab=_81762_/Q }
C {devices/lab_pin.sym} 40260 -3650 0 0 {name=p40196 lab=_49199_/Y }
C {devices/lab_pin.sym} 40420 -3690 0 1 {name=p40197 lab=_72113_/A }
C {sky130_stdcells/o21ai_4.sym} 40340 -3690 0 0 {name=X_49200_ }
C {devices/lab_pin.sym} 40280 -3560 0 0 {name=p40198 lab=_46387_/A }
C {devices/lab_pin.sym} 40280 -3520 0 0 {name=p40199 lab=_46412_/B }
C {devices/lab_pin.sym} 40400 -3540 0 1 {name=p40200 lab=_46412_/Y }
C {sky130_stdcells/nand2_4.sym} 40340 -3540 0 0 {name=X_46412_ }
C {devices/lab_pin.sym} 40280 -3420 0 0 {name=p40201 lab=_77229_/Y }
C {devices/lab_pin.sym} 40280 -3380 0 0 {name=p40202 lab=_77231_/Y }
C {devices/lab_pin.sym} 40400 -3400 0 1 {name=p40203 lab=_77232_/Y }
C {sky130_stdcells/nor2_4.sym} 40340 -3400 0 0 {name=X_77232_ }
C {devices/lab_pin.sym} 40300 -3270 0 0 {name=p40204 lab=_55102_/A }
C {devices/lab_pin.sym} 40380 -3270 0 1 {name=p40205 lab=_43624_/X }
C {sky130_stdcells/buf_2.sym} 40340 -3270 0 0 {name=X_43624_ }
C {devices/lab_pin.sym} 40260 -3170 0 0 {name=p40206 lab=_83065_/Q }
C {devices/lab_pin.sym} 40260 -3130 0 0 {name=p40207 lab=_74441_/X }
C {devices/lab_pin.sym} 40260 -3090 0 0 {name=p40208 lab=_74443_/Y }
C {devices/lab_pin.sym} 40420 -3130 0 1 {name=p40209 lab=_74444_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -3130 0 0 {name=X_74444_ }
C {devices/lab_pin.sym} 40300 -2990 0 0 {name=p40210 lab=_40836_/A }
C {devices/lab_pin.sym} 40380 -2990 0 1 {name=p40211 lab=_40836_/X }
C {sky130_stdcells/buf_2.sym} 40340 -2990 0 0 {name=X_40836_ }
C {devices/lab_pin.sym} 40280 -2900 0 0 {name=p40212 lab=_47418_/A }
C {devices/lab_pin.sym} 40280 -2860 0 0 {name=p40213 lab=_47408_/B }
C {devices/lab_pin.sym} 40280 -2820 0 0 {name=p40214 lab=_47377_/X }
C {devices/lab_pin.sym} 40280 -2780 0 0 {name=p40215 lab=_53019_/D }
C {devices/lab_pin.sym} 40400 -2840 0 1 {name=p40216 lab=_47392_/X }
C {sky130_stdcells/and4_4.sym} 40340 -2840 0 0 {name=X_47392_ }
C {devices/lab_pin.sym} 40260 -2730 0 0 {name=p40217 lab=_59325_/X }
C {devices/lab_pin.sym} 40260 -2690 0 0 {name=p40218 lab=_59376_/Y }
C {devices/lab_pin.sym} 40260 -2650 0 0 {name=p40219 lab=_59377_/Y }
C {devices/lab_pin.sym} 40260 -2610 0 0 {name=p40220 lab=_59342_/X }
C {devices/lab_pin.sym} 40260 -2570 0 0 {name=p40221 lab=_59329_/X }
C {devices/lab_pin.sym} 40420 -2650 0 1 {name=p40222 lab=_59378_/X }
C {sky130_stdcells/o32a_4.sym} 40340 -2650 0 0 {name=X_59378_ }
C {devices/lab_pin.sym} 40280 -2510 0 0 {name=p40223 lab=_71660_/A }
C {devices/lab_pin.sym} 40280 -2470 0 0 {name=p40224 lab=_71223_/B }
C {devices/lab_pin.sym} 40280 -2430 0 0 {name=p40225 lab=_71660_/C }
C {devices/lab_pin.sym} 40400 -2470 0 1 {name=p40226 lab=_71656_/Y }
C {sky130_stdcells/nand3_4.sym} 40340 -2470 0 0 {name=X_71656_ }
C {devices/lab_pin.sym} 40300 -2330 0 0 {name=p40227 lab=_52385_/B }
C {devices/lab_pin.sym} 40380 -2330 0 1 {name=p40228 lab=_72079_/B }
C {sky130_stdcells/buf_2.sym} 40340 -2330 0 0 {name=X_49131_ }
C {devices/lab_pin.sym} 40300 -2210 0 0 {name=p40229 lab=_53980_/B }
C {devices/lab_pin.sym} 40380 -2210 0 1 {name=p40230 lab=_49245_/B }
C {sky130_stdcells/buf_2.sym} 40340 -2210 0 0 {name=X_46343_ }
C {devices/lab_pin.sym} 40260 -2110 0 0 {name=p40231 lab=_52986_/B }
C {devices/lab_pin.sym} 40260 -2070 0 0 {name=p40232 lab=_70584_/X }
C {devices/lab_pin.sym} 40260 -2030 0 0 {name=p40233 lab=_70606_/Y }
C {devices/lab_pin.sym} 40420 -2070 0 1 {name=p40234 lab=_70607_/Y }
C {sky130_stdcells/o21ai_4.sym} 40340 -2070 0 0 {name=X_70607_ }
C {devices/lab_pin.sym} 40300 -1930 0 0 {name=p40235 lab=_58329_/A }
C {devices/lab_pin.sym} 40380 -1930 0 1 {name=p40236 lab=_58331_/A }
C {sky130_stdcells/inv_2.sym} 40340 -1930 0 0 {name=X_58329_ }
C {devices/lab_pin.sym} 40280 -1820 0 0 {name=p40237 lab=_77163_/A }
C {devices/lab_pin.sym} 40280 -1780 0 0 {name=p40238 lab=_81921_/Q }
C {devices/lab_pin.sym} 40400 -1800 0 1 {name=p40239 lab=_77173_/C }
C {sky130_stdcells/nand2_4.sym} 40340 -1800 0 0 {name=X_77163_ }
C {devices/lab_pin.sym} 40260 -1710 0 0 {name=p40240 lab=_43542_/X }
C {devices/lab_pin.sym} 40260 -1670 0 0 {name=p40241 lab=_43546_/X }
C {devices/lab_pin.sym} 40260 -1630 0 0 {name=p40242 lab=_40474_/X }
C {devices/lab_pin.sym} 40260 -1590 0 0 {name=p40243 lab=_87362_/Q }
C {devices/lab_pin.sym} 40260 -1550 0 0 {name=p40244 lab=_43549_/X }
C {devices/lab_pin.sym} 40420 -1630 0 1 {name=p40245 lab=_43555_/Y }
C {sky130_stdcells/o32ai_4.sym} 40340 -1630 0 0 {name=X_43555_ }
C {devices/lab_pin.sym} 40280 -1490 0 0 {name=p40246 lab=_74375_/A }
C {devices/lab_pin.sym} 40280 -1450 0 0 {name=p40247 lab=_72113_/B }
C {devices/lab_pin.sym} 40280 -1410 0 0 {name=p40248 lab=_74366_/C }
C {devices/lab_pin.sym} 40400 -1450 0 1 {name=p40249 lab=_74375_/X }
C {sky130_stdcells/and3_4.sym} 40340 -1450 0 0 {name=X_74375_ }
C {devices/lab_pin.sym} 40300 -1310 0 0 {name=p40250 lab=_40767_/A }
C {devices/lab_pin.sym} 40380 -1310 0 1 {name=p40251 lab=_40767_/X }
C {sky130_stdcells/buf_2.sym} 40340 -1310 0 0 {name=X_40767_ }
C {devices/lab_pin.sym} 40260 -1210 0 0 {name=p40252 lab=_71581_/X }
C {devices/lab_pin.sym} 40260 -1170 0 0 {name=p40253 lab=_83448_/Q }
C {devices/lab_pin.sym} 40260 -1130 0 0 {name=p40254 lab=_71586_/Y }
C {devices/lab_pin.sym} 40420 -1170 0 1 {name=p40255 lab=_83448_/D }
C {sky130_stdcells/a21o_4.sym} 40340 -1170 0 0 {name=X_71587_ }
C {devices/lab_pin.sym} 40280 -1040 0 0 {name=p40256 lab=_81725_/D }
C {devices/lab_pin.sym} 40280 -1000 0 0 {name=p40257 lab=_76116_/B }
C {devices/lab_pin.sym} 40400 -1020 0 1 {name=p40258 lab=_76114_/X }
C {sky130_stdcells/or2_4.sym} 40340 -1020 0 0 {name=X_76114_ }
C {devices/lab_pin.sym} 40300 -890 0 0 {name=p40259 lab=_42612_/A }
C {devices/lab_pin.sym} 40380 -890 0 1 {name=p40260 lab=_42506_/X }
C {sky130_stdcells/buf_2.sym} 40340 -890 0 0 {name=X_42506_ }
C {devices/lab_pin.sym} 40300 -770 0 0 {name=p40261 lab=_61340_/A }
C {devices/lab_pin.sym} 40380 -770 0 1 {name=p40262 lab=_61368_/B }
C {sky130_stdcells/buf_2.sym} 40340 -770 0 0 {name=X_61340_ }
C {devices/lab_pin.sym} 41180 -42170 0 0 {name=p40263 lab=_49057_/Y }
C {devices/lab_pin.sym} 41180 -42130 0 0 {name=p40264 lab=_49038_/X }
C {devices/lab_pin.sym} 41180 -42090 0 0 {name=p40265 lab=_49061_/X }
C {devices/lab_pin.sym} 41340 -42130 0 1 {name=p40266 lab=_49062_/Y }
C {sky130_stdcells/a21oi_4.sym} 41260 -42130 0 0 {name=X_49062_ }
C {devices/lab_pin.sym} 41180 -42010 0 0 {name=p40267 lab=_69865_/B }
C {devices/lab_pin.sym} 41180 -41970 0 0 {name=p40268 lab=_72865_/X }
C {devices/lab_pin.sym} 41180 -41930 0 0 {name=p40269 lab=_72866_/X }
C {devices/lab_pin.sym} 41340 -41970 0 1 {name=p40270 lab=_73326_/X }
C {sky130_stdcells/o21a_4.sym} 41260 -41970 0 0 {name=X_73326_ }
C {devices/lab_pin.sym} 41220 -41830 0 0 {name=p40271 lab=_70554_/A }
C {devices/lab_pin.sym} 41300 -41830 0 1 {name=p40272 lab=_70538_/X }
C {sky130_stdcells/buf_2.sym} 41260 -41830 0 0 {name=X_70538_ }
C {devices/lab_pin.sym} 41200 -41720 0 0 {name=p40273 lab=_46274_/A }
C {devices/lab_pin.sym} 41200 -41680 0 0 {name=p40274 lab=_46328_/B }
C {devices/lab_pin.sym} 41320 -41700 0 1 {name=p40275 lab=_46274_/X }
C {sky130_stdcells/or2_4.sym} 41260 -41700 0 0 {name=X_46274_ }
C {devices/lab_pin.sym} 41200 -41580 0 0 {name=p40276 lab=_82095_/Q }
C {devices/lab_pin.sym} 41200 -41540 0 0 {name=p40277 lab=_77094_/B }
C {devices/lab_pin.sym} 41320 -41560 0 1 {name=p40278 lab=_77094_/X }
C {sky130_stdcells/xor2_4.sym} 41260 -41560 0 0 {name=X_77094_ }
C {devices/lab_pin.sym} 41180 -41460 0 0 {name=p40279 lab=_41701_/X }
C {devices/lab_pin.sym} 41180 -41420 0 0 {name=p40280 lab=_43484_/X }
C {devices/lab_pin.sym} 41180 -41380 0 0 {name=p40281 lab=_87398_/Q }
C {devices/lab_pin.sym} 41180 -41340 0 0 {name=p40282 lab=_43485_/X }
C {devices/lab_pin.sym} 41340 -41400 0 1 {name=p40283 lab=_87398_/D }
C {sky130_stdcells/a2bb2o_4.sym} 41260 -41400 0 0 {name=X_43486_ }
C {devices/lab_pin.sym} 41220 -41250 0 0 {name=p40284 lab=_49048_/A }
C {devices/lab_pin.sym} 41300 -41250 0 1 {name=p40285 lab=_40698_/X }
C {sky130_stdcells/buf_2.sym} 41260 -41250 0 0 {name=X_40698_ }
C {devices/lab_pin.sym} 41180 -41150 0 0 {name=p40286 lab=_48005_/Y }
C {devices/lab_pin.sym} 41180 -41110 0 0 {name=p40287 lab=_48007_/X }
C {devices/lab_pin.sym} 41180 -41070 0 0 {name=p40288 lab=_48012_/X }
C {devices/lab_pin.sym} 41340 -41110 0 1 {name=p40289 lab=_86577_/D }
C {sky130_stdcells/a21oi_4.sym} 41260 -41110 0 0 {name=X_48013_ }
C {devices/lab_pin.sym} 41180 -40990 0 0 {name=p40290 lab=_85164_/Q }
C {devices/lab_pin.sym} 41180 -40950 0 0 {name=p40291 lab=_45209_/X }
C {devices/lab_pin.sym} 41180 -40910 0 0 {name=p40292 lab=_45189_/X }
C {devices/lab_pin.sym} 41340 -40950 0 1 {name=p40293 lab=_45225_/X }
C {sky130_stdcells/o21a_4.sym} 41260 -40950 0 0 {name=X_45225_ }
C {devices/lab_pin.sym} 41200 -40820 0 0 {name=p40294 lab=_81523_/Q }
C {devices/lab_pin.sym} 41200 -40780 0 0 {name=p40295 lab=_81747_/D }
C {devices/lab_pin.sym} 41320 -40800 0 1 {name=p40296 lab=_81772_/D }
C {sky130_stdcells/xor2_4.sym} 41260 -40800 0 0 {name=X_76045_ }
C {devices/lab_pin.sym} 41180 -40700 0 0 {name=p40297 lab=_40528_/X }
C {devices/lab_pin.sym} 41180 -40660 0 0 {name=p40298 lab=_42434_/X }
C {devices/lab_pin.sym} 41180 -40620 0 0 {name=p40299 lab=_87864_/Q }
C {devices/lab_pin.sym} 41180 -40580 0 0 {name=p40300 lab=_42435_/X }
C {devices/lab_pin.sym} 41340 -40640 0 1 {name=p40301 lab=_87864_/D }
C {sky130_stdcells/a2bb2o_4.sym} 41260 -40640 0 0 {name=X_42437_ }
C {devices/lab_pin.sym} 41200 -40520 0 0 {name=p40302 lab=_61271_/A }
C {devices/lab_pin.sym} 41200 -40480 0 0 {name=p40303 lab=_61096_/X }
C {devices/lab_pin.sym} 41200 -40440 0 0 {name=p40304 lab=_61153_/C }
C {devices/lab_pin.sym} 41200 -40400 0 0 {name=p40305 lab=_61103_/X }
C {devices/lab_pin.sym} 41320 -40460 0 1 {name=p40306 lab=_61271_/Y }
C {sky130_stdcells/nand4_4.sym} 41260 -40460 0 0 {name=X_61271_ }
C {devices/lab_pin.sym} 41220 -40310 0 0 {name=p40307 lab=_73257_/A }
C {devices/lab_pin.sym} 41300 -40310 0 1 {name=p40308 lab=_73257_/X }
C {sky130_stdcells/buf_2.sym} 41260 -40310 0 0 {name=X_73257_ }
C {devices/lab_pin.sym} 41220 -40190 0 0 {name=p40309 lab=DATA_TO_HASH[6] }
C {devices/lab_pin.sym} 41300 -40190 0 1 {name=p40310 lab=_71424_/C }
C {sky130_stdcells/buf_2.sym} 41260 -40190 0 0 {name=X_70469_ }
C {devices/lab_pin.sym} 41220 -40070 0 0 {name=p40311 lab=_63010_/A }
C {devices/lab_pin.sym} 41300 -40070 0 1 {name=p40312 lab=_63010_/X }
C {sky130_stdcells/buf_2.sym} 41260 -40070 0 0 {name=X_63010_ }
C {devices/lab_pin.sym} 41200 -39970 0 0 {name=p40313 lab=_59640_/A }
C {devices/lab_pin.sym} 41200 -39930 0 0 {name=p40314 lab=_59615_/A }
C {devices/lab_pin.sym} 41200 -39890 0 0 {name=p40315 lab=_60222_/C }
C {devices/lab_pin.sym} 41320 -39930 0 1 {name=p40316 lab=_60222_/X }
C {sky130_stdcells/and3_4.sym} 41260 -39930 0 0 {name=X_60222_ }
C {devices/lab_pin.sym} 41180 -39810 0 0 {name=p40317 lab=_72143_/X }
C {devices/lab_pin.sym} 41180 -39770 0 0 {name=p40318 lab=_85370_/Q }
C {devices/lab_pin.sym} 41180 -39730 0 0 {name=p40319 lab=_72207_/X }
C {devices/lab_pin.sym} 41340 -39770 0 1 {name=p40320 lab=_72208_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -39770 0 0 {name=X_72208_ }
C {devices/lab_pin.sym} 41200 -39640 0 0 {name=p40321 lab=_45156_/A }
C {devices/lab_pin.sym} 41200 -39600 0 0 {name=p40322 lab=_45182_/B }
C {devices/lab_pin.sym} 41320 -39620 0 1 {name=p40323 lab=_45156_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -39620 0 0 {name=X_45156_ }
C {devices/lab_pin.sym} 41180 -39520 0 0 {name=p40324 lab=_41768_/X }
C {devices/lab_pin.sym} 41180 -39480 0 0 {name=p40325 lab=_42356_/X }
C {devices/lab_pin.sym} 41180 -39440 0 0 {name=p40326 lab=_87897_/Q }
C {devices/lab_pin.sym} 41180 -39400 0 0 {name=p40327 lab=_42357_/X }
C {devices/lab_pin.sym} 41340 -39460 0 1 {name=p40328 lab=_87897_/D }
C {sky130_stdcells/a2bb2o_4.sym} 41260 -39460 0 0 {name=X_42368_ }
C {devices/lab_pin.sym} 41200 -39320 0 0 {name=p40329 lab=_73188_/A }
C {devices/lab_pin.sym} 41200 -39280 0 0 {name=p40330 lab=_73188_/B }
C {devices/lab_pin.sym} 41320 -39300 0 1 {name=p40331 lab=_73188_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -39300 0 0 {name=X_73188_ }
C {devices/lab_pin.sym} 41200 -39190 0 0 {name=p40332 lab=_43990_/Y }
C {devices/lab_pin.sym} 41200 -39150 0 0 {name=p40333 lab=_45938_/A }
C {devices/lab_pin.sym} 41200 -39110 0 0 {name=p40334 lab=_44107_/C }
C {devices/lab_pin.sym} 41320 -39150 0 1 {name=p40335 lab=_44107_/X }
C {sky130_stdcells/or3_4.sym} 41260 -39150 0 0 {name=X_44107_ }
C {devices/lab_pin.sym} 41180 -39030 0 0 {name=p40336 lab=_64841_/Y }
C {devices/lab_pin.sym} 41180 -38990 0 0 {name=p40337 lab=_72214_/Y }
C {devices/lab_pin.sym} 41180 -38950 0 0 {name=p40338 lab=_79803_/Y }
C {devices/lab_pin.sym} 41340 -38990 0 1 {name=p40339 lab=_79804_/X }
C {sky130_stdcells/o21a_4.sym} 41260 -38990 0 0 {name=X_79804_ }
C {devices/lab_pin.sym} 41200 -38860 0 0 {name=p40340 lab=_41513_/A }
C {devices/lab_pin.sym} 41200 -38820 0 0 {name=p40341 lab=_41319_/B }
C {devices/lab_pin.sym} 41320 -38840 0 1 {name=p40342 lab=_41319_/X }
C {sky130_stdcells/or2_4.sym} 41260 -38840 0 0 {name=X_41319_ }
C {devices/lab_pin.sym} 41200 -38720 0 0 {name=p40343 lab=_72277_/A }
C {devices/lab_pin.sym} 41200 -38680 0 0 {name=p40344 lab=_72139_/B }
C {devices/lab_pin.sym} 41320 -38700 0 1 {name=p40345 lab=_72139_/Y }
C {sky130_stdcells/nor2_4.sym} 41260 -38700 0 0 {name=X_72139_ }
C {devices/lab_pin.sym} 41200 -38590 0 0 {name=p40346 lab=_60151_/X }
C {devices/lab_pin.sym} 41200 -38550 0 0 {name=p40347 lab=_64638_/B }
C {devices/lab_pin.sym} 41200 -38510 0 0 {name=p40348 lab=_60153_/C }
C {devices/lab_pin.sym} 41320 -38550 0 1 {name=p40349 lab=_60153_/Y }
C {sky130_stdcells/nand3_4.sym} 41260 -38550 0 0 {name=X_60153_ }
C {devices/lab_pin.sym} 41200 -38440 0 0 {name=p40350 lab=_49973_/A }
C {devices/lab_pin.sym} 41200 -38400 0 0 {name=p40351 lab=_49943_/B }
C {devices/lab_pin.sym} 41200 -38360 0 0 {name=p40352 lab=_49973_/C }
C {devices/lab_pin.sym} 41200 -38320 0 0 {name=p40353 lab=_53177_/D }
C {devices/lab_pin.sym} 41320 -38380 0 1 {name=p40354 lab=_49964_/X }
C {sky130_stdcells/and4_4.sym} 41260 -38380 0 0 {name=X_49964_ }
C {devices/lab_pin.sym} 41220 -38230 0 0 {name=p40355 lab=_45237_/A }
C {devices/lab_pin.sym} 41300 -38230 0 1 {name=p40356 lab=_45087_/X }
C {sky130_stdcells/buf_2.sym} 41260 -38230 0 0 {name=X_45087_ }
C {devices/lab_pin.sym} 41180 -38150 0 0 {name=p40357 lab=_42279_/X }
C {devices/lab_pin.sym} 41180 -38110 0 0 {name=p40358 lab=_42297_/X }
C {devices/lab_pin.sym} 41180 -38070 0 0 {name=p40359 lab=_41574_/X }
C {devices/lab_pin.sym} 41180 -38030 0 0 {name=p40360 lab=_87933_/Q }
C {devices/lab_pin.sym} 41180 -37990 0 0 {name=p40361 lab=_42298_/X }
C {devices/lab_pin.sym} 41340 -38070 0 1 {name=p40362 lab=_42300_/A }
C {sky130_stdcells/o32ai_4.sym} 41260 -38070 0 0 {name=X_42299_ }
C {devices/lab_pin.sym} 41200 -37920 0 0 {name=p40363 lab=_82255_/Q }
C {devices/lab_pin.sym} 41200 -37880 0 0 {name=p40364 lab=_81967_/Q }
C {devices/lab_pin.sym} 41320 -37900 0 1 {name=p40365 lab=_78012_/A }
C {sky130_stdcells/xnor2_4.sym} 41260 -37900 0 0 {name=X_77996_ }
C {devices/lab_pin.sym} 41200 -37780 0 0 {name=p40366 lab=_48915_/A }
C {devices/lab_pin.sym} 41200 -37740 0 0 {name=p40367 lab=_48959_/B }
C {devices/lab_pin.sym} 41320 -37760 0 1 {name=p40368 lab=_50578_/B }
C {sky130_stdcells/nor2_4.sym} 41260 -37760 0 0 {name=X_48915_ }
C {devices/lab_pin.sym} 41220 -37630 0 0 {name=p40369 lab=_44037_/X }
C {devices/lab_pin.sym} 41300 -37630 0 1 {name=p40370 lab=_44038_/X }
C {sky130_stdcells/buf_2.sym} 41260 -37630 0 0 {name=X_44038_ }
C {devices/lab_pin.sym} 41200 -37520 0 0 {name=p40371 lab=_79731_/Y }
C {devices/lab_pin.sym} 41200 -37480 0 0 {name=p40372 lab=_79734_/Y }
C {devices/lab_pin.sym} 41320 -37500 0 1 {name=p40373 lab=_79735_/X }
C {sky130_stdcells/xor2_4.sym} 41260 -37500 0 0 {name=X_79735_ }
C {devices/lab_pin.sym} 41220 -37370 0 0 {name=p40374 lab=_64961_/A }
C {devices/lab_pin.sym} 41300 -37370 0 1 {name=p40375 lab=_65984_/A }
C {sky130_stdcells/buf_2.sym} 41260 -37370 0 0 {name=X_64961_ }
C {devices/lab_pin.sym} 41200 -37280 0 0 {name=p40376 lab=_60084_/A }
C {devices/lab_pin.sym} 41200 -37240 0 0 {name=p40377 lab=_62198_/B }
C {devices/lab_pin.sym} 41200 -37200 0 0 {name=p40378 lab=_59976_/A }
C {devices/lab_pin.sym} 41200 -37160 0 0 {name=p40379 lab=_59985_/X }
C {devices/lab_pin.sym} 41320 -37220 0 1 {name=p40380 lab=_60085_/A }
C {sky130_stdcells/and4_4.sym} 41260 -37220 0 0 {name=X_60084_ }
C {devices/lab_pin.sym} 41220 -37070 0 0 {name=p40381 lab=_76946_/X }
C {devices/lab_pin.sym} 41300 -37070 0 1 {name=p40382 lab=_76953_/B }
C {sky130_stdcells/inv_2.sym} 41260 -37070 0 0 {name=X_76947_ }
C {devices/lab_pin.sym} 41200 -36960 0 0 {name=p40383 lab=_49901_/A }
C {devices/lab_pin.sym} 41200 -36920 0 0 {name=p40384 lab=_53109_/B }
C {devices/lab_pin.sym} 41320 -36940 0 1 {name=p40385 lab=_49895_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -36940 0 0 {name=X_49895_ }
C {devices/lab_pin.sym} 41200 -36820 0 0 {name=p40386 lab=_66602_/A }
C {devices/lab_pin.sym} 41200 -36780 0 0 {name=p40387 lab=_66700_/B }
C {devices/lab_pin.sym} 41320 -36800 0 1 {name=p40388 lab=_66700_/X }
C {sky130_stdcells/and2_4.sym} 41260 -36800 0 0 {name=X_66700_ }
C {devices/lab_pin.sym} 41220 -36670 0 0 {name=p40389 lab=_64328_/A }
C {devices/lab_pin.sym} 41300 -36670 0 1 {name=p40390 lab=_63912_/X }
C {sky130_stdcells/buf_2.sym} 41260 -36670 0 0 {name=X_63912_ }
C {devices/lab_pin.sym} 41180 -36570 0 0 {name=p40391 lab=_48844_/Y }
C {devices/lab_pin.sym} 41180 -36530 0 0 {name=p40392 lab=_48840_/X }
C {devices/lab_pin.sym} 41180 -36490 0 0 {name=p40393 lab=_48845_/X }
C {devices/lab_pin.sym} 41340 -36530 0 1 {name=p40394 lab=_86472_/D }
C {sky130_stdcells/a21oi_4.sym} 41260 -36530 0 0 {name=X_48846_ }
C {devices/lab_pin.sym} 41180 -36420 0 0 {name=p40395 lab=_87397_/Q }
C {devices/lab_pin.sym} 41180 -36380 0 0 {name=p40396 lab=_67628_/X }
C {devices/lab_pin.sym} 41180 -36340 0 0 {name=p40397 lab=_67581_/X }
C {devices/lab_pin.sym} 41180 -36300 0 0 {name=p40398 lab=_67679_/X }
C {devices/lab_pin.sym} 41340 -36360 0 1 {name=p40399 lab=_67680_/X }
C {sky130_stdcells/a211o_4.sym} 41260 -36360 0 0 {name=X_67680_ }
C {devices/lab_pin.sym} 41180 -36230 0 0 {name=p40400 lab=_79645_/B }
C {devices/lab_pin.sym} 41180 -36190 0 0 {name=p40401 lab=_79662_/X }
C {devices/lab_pin.sym} 41180 -36150 0 0 {name=p40402 lab=_79665_/Y }
C {devices/lab_pin.sym} 41340 -36190 0 1 {name=p40403 lab=_79666_/Y }
C {sky130_stdcells/a21oi_4.sym} 41260 -36190 0 0 {name=X_79666_ }
C {devices/lab_pin.sym} 41180 -36070 0 0 {name=p40404 lab=_64889_/Y }
C {devices/lab_pin.sym} 41180 -36030 0 0 {name=p40405 lab=_64814_/X }
C {devices/lab_pin.sym} 41180 -35990 0 0 {name=p40406 lab=_64891_/Y }
C {devices/lab_pin.sym} 41340 -36030 0 1 {name=p40407 lab=_84223_/D }
C {sky130_stdcells/a21o_4.sym} 41260 -36030 0 0 {name=X_64892_ }
C {devices/lab_pin.sym} 41200 -35900 0 0 {name=p40408 lab=_76910_/C }
C {devices/lab_pin.sym} 41200 -35860 0 0 {name=p40409 lab=_76877_/Y }
C {devices/lab_pin.sym} 41320 -35880 0 1 {name=p40410 lab=_76879_/B }
C {sky130_stdcells/xnor2_4.sym} 41260 -35880 0 0 {name=X_76878_ }
C {devices/lab_pin.sym} 41200 -35760 0 0 {name=p40411 lab=_78616_/Y }
C {devices/lab_pin.sym} 41200 -35720 0 0 {name=p40412 lab=_78617_/B }
C {devices/lab_pin.sym} 41320 -35740 0 1 {name=p40413 lab=_78617_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -35740 0 0 {name=X_78617_ }
C {devices/lab_pin.sym} 41180 -35640 0 0 {name=p40414 lab=_87441_/Q }
C {devices/lab_pin.sym} 41180 -35600 0 0 {name=p40415 lab=_66571_/X }
C {devices/lab_pin.sym} 41180 -35560 0 0 {name=p40416 lab=_66629_/X }
C {devices/lab_pin.sym} 41180 -35520 0 0 {name=p40417 lab=_66630_/X }
C {devices/lab_pin.sym} 41340 -35580 0 1 {name=p40418 lab=_66631_/X }
C {sky130_stdcells/a211o_4.sym} 41260 -35580 0 0 {name=X_66631_ }
C {devices/lab_pin.sym} 41200 -35460 0 0 {name=p40419 lab=_61831_/X }
C {devices/lab_pin.sym} 41200 -35420 0 0 {name=p40420 lab=_63860_/B }
C {devices/lab_pin.sym} 41200 -35380 0 0 {name=p40421 lab=_63860_/C }
C {devices/lab_pin.sym} 41200 -35340 0 0 {name=p40422 lab=_63860_/D }
C {devices/lab_pin.sym} 41320 -35400 0 1 {name=p40423 lab=_63843_/Y }
C {sky130_stdcells/nand4_4.sym} 41260 -35400 0 0 {name=X_63843_ }
C {devices/lab_pin.sym} 41200 -35260 0 0 {name=p40424 lab=_81102_/Q }
C {devices/lab_pin.sym} 41200 -35220 0 0 {name=p40425 lab=_75829_/B }
C {devices/lab_pin.sym} 41320 -35240 0 1 {name=p40426 lab=_75830_/B }
C {sky130_stdcells/xnor2_4.sym} 41260 -35240 0 0 {name=X_75829_ }
C {devices/lab_pin.sym} 41200 -35120 0 0 {name=p40427 lab=_48777_/A }
C {devices/lab_pin.sym} 41200 -35080 0 0 {name=p40428 lab=_52163_/B }
C {devices/lab_pin.sym} 41320 -35100 0 1 {name=p40429 lab=_48777_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -35100 0 0 {name=X_48777_ }
C {devices/lab_pin.sym} 41200 -34980 0 0 {name=p40430 lab=_79597_/A }
C {devices/lab_pin.sym} 41200 -34940 0 0 {name=p40431 lab=_79596_/Y }
C {devices/lab_pin.sym} 41320 -34960 0 1 {name=p40432 lab=_79598_/A }
C {sky130_stdcells/xor2_4.sym} 41260 -34960 0 0 {name=X_79597_ }
C {devices/lab_pin.sym} 41220 -34830 0 0 {name=p40433 lab=_45989_/A }
C {devices/lab_pin.sym} 41300 -34830 0 1 {name=p40434 lab=_45989_/Y }
C {sky130_stdcells/inv_2.sym} 41260 -34830 0 0 {name=X_45989_ }
C {devices/lab_pin.sym} 41180 -34730 0 0 {name=p40435 lab=_69347_/X }
C {devices/lab_pin.sym} 41180 -34690 0 0 {name=p40436 lab=_69349_/X }
C {devices/lab_pin.sym} 41180 -34650 0 0 {name=p40437 lab=_69171_/X }
C {devices/lab_pin.sym} 41340 -34690 0 1 {name=p40438 lab=_69350_/Y }
C {sky130_stdcells/a21oi_4.sym} 41260 -34690 0 0 {name=X_69350_ }
C {devices/lab_pin.sym} 41180 -34570 0 0 {name=p40439 lab=_72378_/A }
C {devices/lab_pin.sym} 41180 -34530 0 0 {name=p40440 lab=_47714_/X }
C {devices/lab_pin.sym} 41180 -34490 0 0 {name=p40441 lab=_47727_/Y }
C {devices/lab_pin.sym} 41340 -34530 0 1 {name=p40442 lab=_47728_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -34530 0 0 {name=X_47728_ }
C {devices/lab_pin.sym} 41220 -34390 0 0 {name=p40443 lab=_69582_/A }
C {devices/lab_pin.sym} 41300 -34390 0 1 {name=p40444 lab=_66562_/X }
C {sky130_stdcells/buf_2.sym} 41260 -34390 0 0 {name=X_66562_ }
C {devices/lab_pin.sym} 41180 -34290 0 0 {name=p40445 lab=_78534_/Y }
C {devices/lab_pin.sym} 41180 -34250 0 0 {name=p40446 lab=_78546_/Y }
C {devices/lab_pin.sym} 41180 -34210 0 0 {name=p40447 lab=_78547_/Y }
C {devices/lab_pin.sym} 41340 -34250 0 1 {name=p40448 lab=_78548_/X }
C {sky130_stdcells/o21a_4.sym} 41260 -34250 0 0 {name=X_78548_ }
C {devices/lab_pin.sym} 41220 -34110 0 0 {name=p40449 lab=_64026_/A }
C {devices/lab_pin.sym} 41300 -34110 0 1 {name=p40450 lab=_63820_/B }
C {sky130_stdcells/buf_2.sym} 41260 -34110 0 0 {name=X_63774_ }
C {devices/lab_pin.sym} 41180 -34020 0 0 {name=p40451 lab=_84545_/Q }
C {devices/lab_pin.sym} 41180 -33980 0 0 {name=p40452 lab=_60979_/X }
C {devices/lab_pin.sym} 41180 -33940 0 0 {name=p40453 lab=_60980_/Y }
C {devices/lab_pin.sym} 41180 -33900 0 0 {name=p40454 lab=_60985_/Y }
C {devices/lab_pin.sym} 41340 -33960 0 1 {name=p40455 lab=_60986_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 41260 -33960 0 0 {name=X_60986_ }
C {devices/lab_pin.sym} 41220 -33810 0 0 {name=p40456 lab=_68300_/X }
C {devices/lab_pin.sym} 41300 -33810 0 1 {name=p40457 lab=_68301_/X }
C {sky130_stdcells/buf_2.sym} 41260 -33810 0 0 {name=X_68301_ }
C {devices/lab_pin.sym} 41200 -33710 0 0 {name=p40458 lab=_65449_/A }
C {devices/lab_pin.sym} 41200 -33670 0 0 {name=p40459 lab=_65546_/B }
C {devices/lab_pin.sym} 41200 -33630 0 0 {name=p40460 lab=_84196_/Q }
C {devices/lab_pin.sym} 41320 -33670 0 1 {name=p40461 lab=_65513_/X }
C {sky130_stdcells/and3_4.sym} 41260 -33670 0 0 {name=X_65513_ }
C {devices/lab_pin.sym} 41200 -33560 0 0 {name=p40462 lab=_62711_/A }
C {devices/lab_pin.sym} 41200 -33520 0 0 {name=p40463 lab=_64286_/C }
C {devices/lab_pin.sym} 41200 -33480 0 0 {name=p40464 lab=_62676_/C }
C {devices/lab_pin.sym} 41200 -33440 0 0 {name=p40465 lab=_62738_/D }
C {devices/lab_pin.sym} 41320 -33500 0 1 {name=p40466 lab=_62725_/X }
C {sky130_stdcells/and4_4.sym} 41260 -33500 0 0 {name=X_62725_ }
C {devices/lab_pin.sym} 41200 -33360 0 0 {name=p40467 lab=_69276_/X }
C {devices/lab_pin.sym} 41200 -33320 0 0 {name=p40468 lab=_69280_/X }
C {devices/lab_pin.sym} 41320 -33340 0 1 {name=p40469 lab=_69281_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -33340 0 0 {name=X_69281_ }
C {devices/lab_pin.sym} 41200 -33220 0 0 {name=p40470 lab=_47649_/A }
C {devices/lab_pin.sym} 41200 -33180 0 0 {name=p40471 lab=_53174_/B }
C {devices/lab_pin.sym} 41320 -33200 0 1 {name=p40472 lab=_47659_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -33200 0 0 {name=X_47659_ }
C {devices/lab_pin.sym} 41200 -33090 0 0 {name=p40473 lab=_65262_/X }
C {devices/lab_pin.sym} 41200 -33050 0 0 {name=p40474 lab=_66521_/B }
C {devices/lab_pin.sym} 41200 -33010 0 0 {name=p40475 lab=_65265_/X }
C {devices/lab_pin.sym} 41320 -33050 0 1 {name=p40476 lab=_66493_/Y }
C {sky130_stdcells/nand3_4.sym} 41260 -33050 0 0 {name=X_66493_ }
C {devices/lab_pin.sym} 41180 -32930 0 0 {name=p40477 lab=_78463_/B }
C {devices/lab_pin.sym} 41180 -32890 0 0 {name=p40478 lab=_78463_/A }
C {devices/lab_pin.sym} 41180 -32850 0 0 {name=p40479 lab=_78465_/A }
C {devices/lab_pin.sym} 41340 -32890 0 1 {name=p40480 lab=_78479_/Y }
C {sky130_stdcells/a21boi_4.sym} 41260 -32890 0 0 {name=X_78479_ }
C {devices/lab_pin.sym} 41220 -32750 0 0 {name=p40481 lab=clkbuf_9_331_0_CLK/X }
C {devices/lab_pin.sym} 41300 -32750 0 1 {name=p40482 lab=_87686_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 41260 -32750 0 0 {name=Xclkbuf_10_662_0_CLK }
C {devices/lab_pin.sym} 41180 -32660 0 0 {name=p40483 lab=_80482_/Y }
C {devices/lab_pin.sym} 41180 -32620 0 0 {name=p40484 lab=_80485_/Y }
C {devices/lab_pin.sym} 41180 -32580 0 0 {name=p40485 lab=_80495_/X }
C {devices/lab_pin.sym} 41180 -32540 0 0 {name=p40486 lab=_80498_/Y }
C {devices/lab_pin.sym} 41340 -32600 0 1 {name=p40487 lab=_80510_/X }
C {sky130_stdcells/o22a_4.sym} 41260 -32600 0 0 {name=X_80510_ }
C {devices/lab_pin.sym} 41180 -32470 0 0 {name=p40488 lab=_67443_/X }
C {devices/lab_pin.sym} 41180 -32430 0 0 {name=p40489 lab=_67445_/X }
C {devices/lab_pin.sym} 41180 -32390 0 0 {name=p40490 lab=_68209_/X }
C {devices/lab_pin.sym} 41340 -32430 0 1 {name=p40491 lab=_68232_/Y }
C {sky130_stdcells/a21oi_4.sym} 41260 -32430 0 0 {name=X_68232_ }
C {devices/lab_pin.sym} 41200 -32300 0 0 {name=p40492 lab=_65753_/A }
C {devices/lab_pin.sym} 41200 -32260 0 0 {name=p40493 lab=_65444_/B }
C {devices/lab_pin.sym} 41320 -32280 0 1 {name=p40494 lab=_65444_/X }
C {sky130_stdcells/and2_4.sym} 41260 -32280 0 0 {name=X_65444_ }
C {devices/lab_pin.sym} 41200 -32160 0 0 {name=p40495 lab=_50657_/A }
C {devices/lab_pin.sym} 41200 -32120 0 0 {name=p40496 lab=_52367_/B }
C {devices/lab_pin.sym} 41320 -32140 0 1 {name=p40497 lab=_50670_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -32140 0 0 {name=X_50670_ }
C {devices/lab_pin.sym} 41220 -32010 0 0 {name=p40498 lab=_62655_/Y }
C {devices/lab_pin.sym} 41300 -32010 0 1 {name=p40499 lab=_62658_/A }
C {sky130_stdcells/buf_2.sym} 41260 -32010 0 0 {name=X_62656_ }
C {devices/lab_pin.sym} 41170 -31890 0 0 {name=p40500 lab=_81265_/CLK }
C {devices/lab_pin.sym} 41170 -31870 0 0 {name=p40501 lab=_81490_/D }
C {devices/lab_pin.sym} 41350 -31890 0 1 {name=p40502 lab=_81490_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -31880 0 0 {name=X_81490_ }
C {devices/lab_pin.sym} 41220 -31750 0 0 {name=p40503 lab=clkbuf_8_76_0_CLK/X }
C {devices/lab_pin.sym} 41300 -31750 0 1 {name=p40504 lab=clkbuf_9_153_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 41260 -31750 0 0 {name=Xclkbuf_9_153_0_CLK }
C {devices/lab_pin.sym} 41180 -31650 0 0 {name=p40505 lab=_49325_/Y }
C {devices/lab_pin.sym} 41180 -31610 0 0 {name=p40506 lab=_49326_/X }
C {devices/lab_pin.sym} 41180 -31570 0 0 {name=p40507 lab=_49328_/Y }
C {devices/lab_pin.sym} 41340 -31610 0 1 {name=p40508 lab=_49329_/Y }
C {sky130_stdcells/a21boi_4.sym} 41260 -31610 0 0 {name=X_49329_ }
C {devices/lab_pin.sym} 41200 -31490 0 0 {name=p40509 lab=_61558_/A }
C {devices/lab_pin.sym} 41200 -31450 0 0 {name=p40510 lab=_61607_/B }
C {devices/lab_pin.sym} 41200 -31410 0 0 {name=p40511 lab=_61590_/C }
C {devices/lab_pin.sym} 41320 -31450 0 1 {name=p40512 lab=_61607_/Y }
C {sky130_stdcells/nand3_4.sym} 41260 -31450 0 0 {name=X_61607_ }
C {devices/lab_pin.sym} 41200 -31320 0 0 {name=p40513 lab=_80441_/A }
C {devices/lab_pin.sym} 41200 -31280 0 0 {name=p40514 lab=_84152_/Q }
C {devices/lab_pin.sym} 41320 -31300 0 1 {name=p40515 lab=_80452_/A }
C {sky130_stdcells/xor2_4.sym} 41260 -31300 0 0 {name=X_80441_ }
C {devices/lab_pin.sym} 41180 -31190 0 0 {name=p40516 lab=_84023_/Q }
C {devices/lab_pin.sym} 41180 -31150 0 0 {name=p40517 lab=_68160_/X }
C {devices/lab_pin.sym} 41180 -31110 0 0 {name=p40518 lab=_68162_/X }
C {devices/lab_pin.sym} 41340 -31150 0 1 {name=p40519 lab=_68163_/X }
C {sky130_stdcells/a21bo_4.sym} 41260 -31150 0 0 {name=X_68163_ }
C {devices/lab_pin.sym} 41220 -31010 0 0 {name=p40520 lab=clkbuf_8_40_0_CLK/X }
C {devices/lab_pin.sym} 41300 -31010 0 1 {name=p40521 lab=clkbuf_9_80_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 41260 -31010 0 0 {name=Xclkbuf_9_80_0_CLK }
C {devices/lab_pin.sym} 41200 -30900 0 0 {name=p40522 lab=_65074_/A }
C {devices/lab_pin.sym} 41200 -30860 0 0 {name=p40523 lab=_65375_/B }
C {devices/lab_pin.sym} 41320 -30880 0 1 {name=p40524 lab=_65375_/X }
C {sky130_stdcells/and2_4.sym} 41260 -30880 0 0 {name=X_65375_ }
C {devices/lab_pin.sym} 41200 -30770 0 0 {name=p40525 lab=_62620_/A }
C {devices/lab_pin.sym} 41200 -30730 0 0 {name=p40526 lab=_63672_/B }
C {devices/lab_pin.sym} 41200 -30690 0 0 {name=p40527 lab=_62532_/X }
C {devices/lab_pin.sym} 41320 -30730 0 1 {name=p40528 lab=_62587_/Y }
C {sky130_stdcells/nand3_4.sym} 41260 -30730 0 0 {name=X_62587_ }
C {devices/lab_pin.sym} 41180 -30610 0 0 {name=p40529 lab=_67109_/X }
C {devices/lab_pin.sym} 41180 -30570 0 0 {name=p40530 lab=_67112_/X }
C {devices/lab_pin.sym} 41180 -30530 0 0 {name=p40531 lab=_67113_/X }
C {devices/lab_pin.sym} 41340 -30570 0 1 {name=p40532 lab=_67114_/Y }
C {sky130_stdcells/a21oi_4.sym} 41260 -30570 0 0 {name=X_67114_ }
C {devices/lab_pin.sym} 41220 -30430 0 0 {name=p40533 lab=_52262_/A }
C {devices/lab_pin.sym} 41300 -30430 0 1 {name=p40534 lab=_52340_/X }
C {sky130_stdcells/buf_2.sym} 41260 -30430 0 0 {name=X_52340_ }
C {devices/lab_pin.sym} 41220 -30310 0 0 {name=p40535 lab=_64267_/A }
C {devices/lab_pin.sym} 41300 -30310 0 1 {name=p40536 lab=_64326_/X }
C {sky130_stdcells/buf_2.sym} 41260 -30310 0 0 {name=X_64326_ }
C {devices/lab_pin.sym} 41170 -30190 0 0 {name=p40537 lab=_85895_/CLK }
C {devices/lab_pin.sym} 41170 -30170 0 0 {name=p40538 lab=_73223_/X }
C {devices/lab_pin.sym} 41350 -30190 0 1 {name=p40539 lab=_83160_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -30180 0 0 {name=X_83160_ }
C {devices/lab_pin.sym} 41200 -30070 0 0 {name=p40540 lab=_61499_/A }
C {devices/lab_pin.sym} 41200 -30030 0 0 {name=p40541 lab=_61538_/B }
C {devices/lab_pin.sym} 41200 -29990 0 0 {name=p40542 lab=_61538_/C }
C {devices/lab_pin.sym} 41320 -30030 0 1 {name=p40543 lab=_61538_/Y }
C {sky130_stdcells/nand3_4.sym} 41260 -30030 0 0 {name=X_61538_ }
C {devices/lab_pin.sym} 41200 -29900 0 0 {name=p40544 lab=_80370_/X }
C {devices/lab_pin.sym} 41200 -29860 0 0 {name=p40545 lab=_80372_/B }
C {devices/lab_pin.sym} 41320 -29880 0 1 {name=p40546 lab=_80372_/X }
C {sky130_stdcells/xor2_4.sym} 41260 -29880 0 0 {name=X_80372_ }
C {devices/lab_pin.sym} 41180 -29780 0 0 {name=p40547 lab=_68088_/X }
C {devices/lab_pin.sym} 41180 -29740 0 0 {name=p40548 lab=_66597_/Y }
C {devices/lab_pin.sym} 41180 -29700 0 0 {name=p40549 lab=_68089_/X }
C {devices/lab_pin.sym} 41180 -29660 0 0 {name=p40550 lab=_68093_/Y }
C {devices/lab_pin.sym} 41340 -29720 0 1 {name=p40551 lab=_68094_/X }
C {sky130_stdcells/a211o_4.sym} 41260 -29720 0 0 {name=X_68094_ }
C {devices/lab_pin.sym} 41220 -29570 0 0 {name=p40552 lab=clkbuf_9_338_0_CLK/X }
C {devices/lab_pin.sym} 41300 -29570 0 1 {name=p40553 lab=_87141_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 41260 -29570 0 0 {name=Xclkbuf_10_677_0_CLK }
C {devices/lab_pin.sym} 41170 -29450 0 0 {name=p40554 lab=_82860_/CLK }
C {devices/lab_pin.sym} 41170 -29430 0 0 {name=p40555 lab=_82123_/Q }
C {devices/lab_pin.sym} 41350 -29450 0 1 {name=p40556 lab=_82111_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -29440 0 0 {name=X_82111_ }
C {devices/lab_pin.sym} 41180 -29330 0 0 {name=p40557 lab=_80910_/D }
C {devices/lab_pin.sym} 41180 -29290 0 0 {name=p40558 lab=_66971_/X }
C {devices/lab_pin.sym} 41180 -29250 0 0 {name=p40559 lab=_67044_/X }
C {devices/lab_pin.sym} 41340 -29290 0 1 {name=p40560 lab=_67045_/X }
C {sky130_stdcells/a21bo_4.sym} 41260 -29290 0 0 {name=X_67045_ }
C {devices/lab_pin.sym} 41220 -29150 0 0 {name=p40561 lab=_52271_/A }
C {devices/lab_pin.sym} 41300 -29150 0 1 {name=p40562 lab=_52293_/A }
C {sky130_stdcells/buf_2.sym} 41260 -29150 0 0 {name=X_52271_ }
C {devices/lab_pin.sym} 41200 -29040 0 0 {name=p40563 lab=_64257_/A }
C {devices/lab_pin.sym} 41200 -29000 0 0 {name=p40564 lab=_64301_/B }
C {devices/lab_pin.sym} 41320 -29020 0 1 {name=p40565 lab=_64257_/Y }
C {sky130_stdcells/nor2_4.sym} 41260 -29020 0 0 {name=X_64257_ }
C {devices/lab_pin.sym} 41170 -28890 0 0 {name=p40566 lab=_81627_/CLK }
C {devices/lab_pin.sym} 41170 -28870 0 0 {name=p40567 lab=_83091_/D }
C {devices/lab_pin.sym} 41350 -28890 0 1 {name=p40568 lab=_70328_/C }
C {sky130_stdcells/dfxtp_4.sym} 41260 -28880 0 0 {name=X_83091_ }
C {devices/lab_pin.sym} 41220 -28750 0 0 {name=p40569 lab=_61686_/A }
C {devices/lab_pin.sym} 41300 -28750 0 1 {name=p40570 lab=_61484_/B }
C {sky130_stdcells/buf_2.sym} 41260 -28750 0 0 {name=X_61469_ }
C {devices/lab_pin.sym} 41220 -28630 0 0 {name=p40571 lab=clkbuf_8_84_0_CLK/X }
C {devices/lab_pin.sym} 41300 -28630 0 1 {name=p40572 lab=clkbuf_9_168_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 41260 -28630 0 0 {name=Xclkbuf_9_168_0_CLK }
C {devices/lab_pin.sym} 41180 -28530 0 0 {name=p40573 lab=_85523_/Q }
C {devices/lab_pin.sym} 41180 -28490 0 0 {name=p40574 lab=_53989_/X }
C {devices/lab_pin.sym} 41180 -28450 0 0 {name=p40575 lab=_54009_/Y }
C {devices/lab_pin.sym} 41340 -28490 0 1 {name=p40576 lab=_54010_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -28490 0 0 {name=X_54010_ }
C {devices/lab_pin.sym} 41200 -28360 0 0 {name=p40577 lab=_51212_/A }
C {devices/lab_pin.sym} 41200 -28320 0 0 {name=p40578 lab=_51222_/B }
C {devices/lab_pin.sym} 41320 -28340 0 1 {name=p40579 lab=_51222_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -28340 0 0 {name=X_51222_ }
C {devices/lab_pin.sym} 41220 -28210 0 0 {name=p40580 lab=clkbuf_9_94_0_CLK/A }
C {devices/lab_pin.sym} 41300 -28210 0 1 {name=p40581 lab=clkbuf_9_95_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 41260 -28210 0 0 {name=Xclkbuf_9_95_0_CLK }
C {devices/lab_pin.sym} 41220 -28090 0 0 {name=p40582 lab=_63247_/A }
C {devices/lab_pin.sym} 41300 -28090 0 1 {name=p40583 lab=_63267_/D }
C {sky130_stdcells/buf_2.sym} 41260 -28090 0 0 {name=X_63208_ }
C {devices/lab_pin.sym} 41170 -27970 0 0 {name=p40584 lab=_82139_/CLK }
C {devices/lab_pin.sym} 41170 -27950 0 0 {name=p40585 lab=_77951_/B }
C {devices/lab_pin.sym} 41350 -27970 0 1 {name=p40586 lab=_82042_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -27960 0 0 {name=X_82042_ }
C {devices/lab_pin.sym} 41180 -27850 0 0 {name=p40587 lab=_64185_/X }
C {devices/lab_pin.sym} 41180 -27810 0 0 {name=p40588 lab=_64186_/X }
C {devices/lab_pin.sym} 41180 -27770 0 0 {name=p40589 lab=_64187_/Y }
C {devices/lab_pin.sym} 41340 -27810 0 1 {name=p40590 lab=_64188_/Y }
C {sky130_stdcells/a21oi_4.sym} 41260 -27810 0 0 {name=X_64188_ }
C {devices/lab_pin.sym} 41220 -27670 0 0 {name=p40591 lab=clkbuf_9_300_0_CLK/X }
C {devices/lab_pin.sym} 41300 -27670 0 1 {name=p40592 lab=_80962_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 41260 -27670 0 0 {name=Xclkbuf_10_600_0_CLK }
C {devices/lab_pin.sym} 41180 -27570 0 0 {name=p40593 lab=_86064_/Q }
C {devices/lab_pin.sym} 41180 -27530 0 0 {name=p40594 lab=_51128_/X }
C {devices/lab_pin.sym} 41180 -27490 0 0 {name=p40595 lab=_51152_/Y }
C {devices/lab_pin.sym} 41340 -27530 0 1 {name=p40596 lab=_51153_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -27530 0 0 {name=X_51153_ }
C {devices/lab_pin.sym} 41200 -27420 0 0 {name=p40597 lab=_63139_/A }
C {devices/lab_pin.sym} 41200 -27380 0 0 {name=p40598 lab=_63113_/B }
C {devices/lab_pin.sym} 41200 -27340 0 0 {name=p40599 lab=_63103_/C }
C {devices/lab_pin.sym} 41200 -27300 0 0 {name=p40600 lab=_63092_/D }
C {devices/lab_pin.sym} 41320 -27360 0 1 {name=p40601 lab=_63139_/X }
C {sky130_stdcells/or4_4.sym} 41260 -27360 0 0 {name=X_63139_ }
C {devices/lab_pin.sym} 41170 -27210 0 0 {name=p40602 lab=_86882_/CLK }
C {devices/lab_pin.sym} 41170 -27190 0 0 {name=p40603 lab=_45852_/Y }
C {devices/lab_pin.sym} 41350 -27210 0 1 {name=p40604 lab=_63333_/B }
C {sky130_stdcells/dfxtp_4.sym} 41260 -27200 0 0 {name=X_86850_ }
C {devices/lab_pin.sym} 41180 -27090 0 0 {name=p40605 lab=_68992_/X }
C {devices/lab_pin.sym} 41180 -27050 0 0 {name=p40606 lab=_68995_/X }
C {devices/lab_pin.sym} 41180 -27010 0 0 {name=p40607 lab=_68737_/X }
C {devices/lab_pin.sym} 41340 -27050 0 1 {name=p40608 lab=_68996_/Y }
C {sky130_stdcells/a21oi_4.sym} 41260 -27050 0 0 {name=X_68996_ }
C {devices/lab_pin.sym} 41180 -26930 0 0 {name=p40609 lab=_86263_/Q }
C {devices/lab_pin.sym} 41180 -26890 0 0 {name=p40610 lab=_50088_/X }
C {devices/lab_pin.sym} 41180 -26850 0 0 {name=p40611 lab=_50103_/Y }
C {devices/lab_pin.sym} 41340 -26890 0 1 {name=p40612 lab=_50104_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -26890 0 0 {name=X_50104_ }
C {devices/lab_pin.sym} 41170 -26750 0 0 {name=p40613 lab=_85514_/CLK }
C {devices/lab_pin.sym} 41170 -26730 0 0 {name=p40614 lab=_52544_/Y }
C {devices/lab_pin.sym} 41350 -26750 0 1 {name=p40615 lab=_65234_/B }
C {sky130_stdcells/dfxtp_4.sym} 41260 -26740 0 0 {name=X_85801_ }
C {devices/lab_pin.sym} 41200 -26640 0 0 {name=p40616 lab=_51084_/A }
C {devices/lab_pin.sym} 41200 -26600 0 0 {name=p40617 lab=_51071_/B }
C {devices/lab_pin.sym} 41200 -26560 0 0 {name=p40618 lab=_51071_/C }
C {devices/lab_pin.sym} 41200 -26520 0 0 {name=p40619 lab=_52775_/D }
C {devices/lab_pin.sym} 41320 -26580 0 1 {name=p40620 lab=_51084_/X }
C {sky130_stdcells/and4_4.sym} 41260 -26580 0 0 {name=X_51084_ }
C {devices/lab_pin.sym} 41180 -26460 0 0 {name=p40621 lab=_56386_/C }
C {devices/lab_pin.sym} 41180 -26420 0 0 {name=p40622 lab=_55689_/A }
C {devices/lab_pin.sym} 41180 -26380 0 0 {name=p40623 lab=_55611_/X }
C {devices/lab_pin.sym} 41180 -26340 0 0 {name=p40624 lab=_55960_/X }
C {devices/lab_pin.sym} 41340 -26400 0 1 {name=p40625 lab=_55961_/X }
C {sky130_stdcells/a211o_4.sym} 41260 -26400 0 0 {name=X_55961_ }
C {devices/lab_pin.sym} 41180 -26270 0 0 {name=p40626 lab=_84048_/Q }
C {devices/lab_pin.sym} 41180 -26230 0 0 {name=p40627 lab=_67925_/X }
C {devices/lab_pin.sym} 41180 -26190 0 0 {name=p40628 lab=_67946_/X }
C {devices/lab_pin.sym} 41340 -26230 0 1 {name=p40629 lab=_67947_/X }
C {sky130_stdcells/a21bo_4.sym} 41260 -26230 0 0 {name=X_67947_ }
C {devices/lab_pin.sym} 41170 -26090 0 0 {name=p40630 lab=_82317_/CLK }
C {devices/lab_pin.sym} 41170 -26070 0 0 {name=p40631 lab=_46073_/X }
C {devices/lab_pin.sym} 41350 -26090 0 1 {name=p40632 lab=_86781_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -26080 0 0 {name=X_86781_ }
C {devices/lab_pin.sym} 41170 -25950 0 0 {name=p40633 lab=_82896_/CLK }
C {devices/lab_pin.sym} 41170 -25930 0 0 {name=p40634 lab=_83993_/D }
C {devices/lab_pin.sym} 41350 -25950 0 1 {name=p40635 lab=_83993_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -25940 0 0 {name=X_83993_ }
C {devices/lab_pin.sym} 41220 -25810 0 0 {name=p40636 lab=_58098_/A }
C {devices/lab_pin.sym} 41300 -25810 0 1 {name=p40637 lab=_57700_/X }
C {sky130_stdcells/buf_2.sym} 41260 -25810 0 0 {name=X_57700_ }
C {devices/lab_pin.sym} 41200 -25700 0 0 {name=p40638 lab=_54893_/X }
C {devices/lab_pin.sym} 41200 -25660 0 0 {name=p40639 lab=_47741_/Y }
C {devices/lab_pin.sym} 41320 -25680 0 1 {name=p40640 lab=_54912_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -25680 0 0 {name=X_54912_ }
C {devices/lab_pin.sym} 41220 -25550 0 0 {name=p40641 lab=_49930_/X }
C {devices/lab_pin.sym} 41300 -25550 0 1 {name=p40642 lab=_51750_/C }
C {sky130_stdcells/buf_2.sym} 41260 -25550 0 0 {name=X_50035_ }
C {devices/lab_pin.sym} 41170 -25430 0 0 {name=p40643 lab=_86342_/CLK }
C {devices/lab_pin.sym} 41170 -25410 0 0 {name=p40644 lab=_52913_/Y }
C {devices/lab_pin.sym} 41350 -25430 0 1 {name=p40645 lab=_85732_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -25420 0 0 {name=X_85732_ }
C {devices/lab_pin.sym} 41180 -25310 0 0 {name=p40646 lab=_58605_/X }
C {devices/lab_pin.sym} 41180 -25270 0 0 {name=p40647 lab=_85944_/Q }
C {devices/lab_pin.sym} 41180 -25230 0 0 {name=p40648 lab=_58679_/X }
C {devices/lab_pin.sym} 41340 -25270 0 1 {name=p40649 lab=_58680_/X }
C {sky130_stdcells/o21a_4.sym} 41260 -25270 0 0 {name=X_58680_ }
C {devices/lab_pin.sym} 41170 -25130 0 0 {name=p40650 lab=_82368_/CLK }
C {devices/lab_pin.sym} 41170 -25110 0 0 {name=p40651 lab=_78112_/X }
C {devices/lab_pin.sym} 41350 -25130 0 1 {name=p40652 lab=_46265_/A }
C {sky130_stdcells/dfxtp_4.sym} 41260 -25120 0 0 {name=X_82944_ }
C {devices/lab_pin.sym} 41200 -25020 0 0 {name=p40653 lab=_55864_/X }
C {devices/lab_pin.sym} 41200 -24980 0 0 {name=p40654 lab=_56073_/A }
C {devices/lab_pin.sym} 41200 -24940 0 0 {name=p40655 lab=_74317_/C }
C {devices/lab_pin.sym} 41200 -24900 0 0 {name=p40656 lab=_55891_/X }
C {devices/lab_pin.sym} 41320 -24960 0 1 {name=p40657 lab=_55892_/X }
C {sky130_stdcells/and4_4.sym} 41260 -24960 0 0 {name=X_55892_ }
C {devices/lab_pin.sym} 41180 -24830 0 0 {name=p40658 lab=_81483_/D }
C {devices/lab_pin.sym} 41180 -24790 0 0 {name=p40659 lab=_67806_/X }
C {devices/lab_pin.sym} 41180 -24750 0 0 {name=p40660 lab=_67877_/X }
C {devices/lab_pin.sym} 41340 -24790 0 1 {name=p40661 lab=_84051_/D }
C {sky130_stdcells/a21bo_4.sym} 41260 -24790 0 0 {name=X_67878_ }
C {devices/lab_pin.sym} 41220 -24650 0 0 {name=p40662 lab=clkbuf_9_307_0_CLK/X }
C {devices/lab_pin.sym} 41300 -24650 0 1 {name=p40663 lab=_80740_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 41260 -24650 0 0 {name=Xclkbuf_10_615_0_CLK }
C {devices/lab_pin.sym} 41180 -24550 0 0 {name=p40664 lab=_84965_/Q }
C {devices/lab_pin.sym} 41180 -24510 0 0 {name=p40665 lab=_57603_/X }
C {devices/lab_pin.sym} 41180 -24470 0 0 {name=p40666 lab=_57630_/Y }
C {devices/lab_pin.sym} 41340 -24510 0 1 {name=p40667 lab=_57631_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -24510 0 0 {name=X_57631_ }
C {devices/lab_pin.sym} 41220 -24370 0 0 {name=p40668 lab=_69567_/A }
C {devices/lab_pin.sym} 41300 -24370 0 1 {name=p40669 lab=_69617_/X }
C {sky130_stdcells/buf_2.sym} 41260 -24370 0 0 {name=X_69617_ }
C {devices/lab_pin.sym} 41200 -24280 0 0 {name=p40670 lab=_54857_/A }
C {devices/lab_pin.sym} 41200 -24240 0 0 {name=p40671 lab=_54843_/B }
C {devices/lab_pin.sym} 41200 -24200 0 0 {name=p40672 lab=_54857_/C }
C {devices/lab_pin.sym} 41200 -24160 0 0 {name=p40673 lab=_53151_/D }
C {devices/lab_pin.sym} 41320 -24220 0 1 {name=p40674 lab=_54843_/X }
C {sky130_stdcells/and4_4.sym} 41260 -24220 0 0 {name=X_54843_ }
C {devices/lab_pin.sym} 41180 -24100 0 0 {name=p40675 lab=_87944_/Q }
C {devices/lab_pin.sym} 41180 -24060 0 0 {name=p40676 lab=_66759_/X }
C {devices/lab_pin.sym} 41180 -24020 0 0 {name=p40677 lab=_66807_/X }
C {devices/lab_pin.sym} 41180 -23980 0 0 {name=p40678 lab=_66828_/X }
C {devices/lab_pin.sym} 41340 -24040 0 1 {name=p40679 lab=_66829_/X }
C {sky130_stdcells/a211o_4.sym} 41260 -24040 0 0 {name=X_66829_ }
C {devices/lab_pin.sym} 41170 -23890 0 0 {name=p40680 lab=_85439_/CLK }
C {devices/lab_pin.sym} 41170 -23870 0 0 {name=p40681 lab=_53279_/Y }
C {devices/lab_pin.sym} 41350 -23890 0 1 {name=p40682 lab=_85663_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -23880 0 0 {name=X_85663_ }
C {devices/lab_pin.sym} 41170 -23750 0 0 {name=p40683 lab=_82596_/CLK }
C {devices/lab_pin.sym} 41170 -23730 0 0 {name=p40684 lab=_82467_/Q }
C {devices/lab_pin.sym} 41350 -23750 0 1 {name=p40685 lab=_82875_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -23740 0 0 {name=X_82875_ }
C {devices/lab_pin.sym} 41220 -23610 0 0 {name=p40686 lab=clkbuf_8_53_0_CLK/X }
C {devices/lab_pin.sym} 41300 -23610 0 1 {name=p40687 lab=clkbuf_9_106_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 41260 -23610 0 0 {name=Xclkbuf_9_106_0_CLK }
C {devices/lab_pin.sym} 41170 -23490 0 0 {name=p40688 lab=_86932_/CLK }
C {devices/lab_pin.sym} 41170 -23470 0 0 {name=p40689 lab=_87402_/D }
C {devices/lab_pin.sym} 41350 -23490 0 1 {name=p40690 lab=_87402_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -23480 0 0 {name=X_87402_ }
C {devices/lab_pin.sym} 41170 -23350 0 0 {name=p40691 lab=_84477_/CLK }
C {devices/lab_pin.sym} 41170 -23330 0 0 {name=p40692 lab=_84614_/D }
C {devices/lab_pin.sym} 41350 -23350 0 1 {name=p40693 lab=_79154_/A }
C {sky130_stdcells/dfxtp_4.sym} 41260 -23340 0 0 {name=X_84614_ }
C {devices/lab_pin.sym} 41220 -23210 0 0 {name=p40694 lab=clkbuf_9_33_0_CLK/A }
C {devices/lab_pin.sym} 41300 -23210 0 1 {name=p40695 lab=clkbuf_9_33_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 41260 -23210 0 0 {name=Xclkbuf_9_33_0_CLK }
C {devices/lab_pin.sym} 41220 -23090 0 0 {name=p40696 lab=_47714_/A }
C {devices/lab_pin.sym} 41300 -23090 0 1 {name=p40697 lab=_57562_/X }
C {sky130_stdcells/buf_2.sym} 41260 -23090 0 0 {name=X_57562_ }
C {devices/lab_pin.sym} 41180 -23000 0 0 {name=p40698 lab=_87009_/Q }
C {devices/lab_pin.sym} 41180 -22960 0 0 {name=p40699 lab=_69414_/X }
C {devices/lab_pin.sym} 41180 -22920 0 0 {name=p40700 lab=_69430_/X }
C {devices/lab_pin.sym} 41180 -22880 0 0 {name=p40701 lab=_69547_/X }
C {devices/lab_pin.sym} 41340 -22940 0 1 {name=p40702 lab=_69548_/X }
C {sky130_stdcells/a211o_4.sym} 41260 -22940 0 0 {name=X_69548_ }
C {devices/lab_pin.sym} 41170 -22790 0 0 {name=p40703 lab=_84441_/CLK }
C {devices/lab_pin.sym} 41170 -22770 0 0 {name=p40704 lab=_81858_/Q }
C {devices/lab_pin.sym} 41350 -22790 0 1 {name=p40705 lab=_77233_/A }
C {sky130_stdcells/dfxtp_4.sym} 41260 -22780 0 0 {name=X_81826_ }
C {devices/lab_pin.sym} 41170 -22650 0 0 {name=p40706 lab=_88128_/CLK }
C {devices/lab_pin.sym} 41170 -22630 0 0 {name=p40707 lab=_40498_/X }
C {devices/lab_pin.sym} 41350 -22650 0 1 {name=p40708 lab=_88382_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -22640 0 0 {name=X_88382_ }
C {devices/lab_pin.sym} 41220 -22510 0 0 {name=p40709 lab=_54693_/X }
C {devices/lab_pin.sym} 41300 -22510 0 1 {name=p40710 lab=_54774_/X }
C {sky130_stdcells/buf_2.sym} 41260 -22510 0 0 {name=X_54774_ }
C {devices/lab_pin.sym} 41170 -22390 0 0 {name=p40711 lab=_85590_/CLK }
C {devices/lab_pin.sym} 41170 -22370 0 0 {name=p40712 lab=_85594_/D }
C {devices/lab_pin.sym} 41350 -22390 0 1 {name=p40713 lab=_85594_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -22380 0 0 {name=X_85594_ }
C {devices/lab_pin.sym} 41180 -22270 0 0 {name=p40714 lab=_85911_/Q }
C {devices/lab_pin.sym} 41180 -22230 0 0 {name=p40715 lab=_51945_/X }
C {devices/lab_pin.sym} 41180 -22190 0 0 {name=p40716 lab=_51985_/Y }
C {devices/lab_pin.sym} 41340 -22230 0 1 {name=p40717 lab=_51986_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -22230 0 0 {name=X_51986_ }
C {devices/lab_pin.sym} 41220 -22090 0 0 {name=p40718 lab=_58766_/A }
C {devices/lab_pin.sym} 41300 -22090 0 1 {name=p40719 lab=_59301_/X }
C {sky130_stdcells/buf_2.sym} 41260 -22090 0 0 {name=X_59301_ }
C {devices/lab_pin.sym} 41200 -21990 0 0 {name=p40720 lab=_56523_/A }
C {devices/lab_pin.sym} 41200 -21950 0 0 {name=p40721 lab=_56520_/B }
C {devices/lab_pin.sym} 41200 -21910 0 0 {name=p40722 lab=_55823_/B }
C {devices/lab_pin.sym} 41320 -21950 0 1 {name=p40723 lab=_56513_/Y }
C {sky130_stdcells/nand3_4.sym} 41260 -21950 0 0 {name=X_56513_ }
C {devices/lab_pin.sym} 41170 -21810 0 0 {name=p40724 lab=_87333_/CLK }
C {devices/lab_pin.sym} 41170 -21790 0 0 {name=p40725 lab=_87333_/D }
C {devices/lab_pin.sym} 41350 -21810 0 1 {name=p40726 lab=_87333_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -21800 0 0 {name=X_87333_ }
C {devices/lab_pin.sym} 41180 -21690 0 0 {name=p40727 lab=_85580_/Q }
C {devices/lab_pin.sym} 41180 -21650 0 0 {name=p40728 lab=_53722_/X }
C {devices/lab_pin.sym} 41180 -21610 0 0 {name=p40729 lab=_53724_/Y }
C {devices/lab_pin.sym} 41340 -21650 0 1 {name=p40730 lab=_53725_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -21650 0 0 {name=X_53725_ }
C {devices/lab_pin.sym} 41170 -21510 0 0 {name=p40731 lab=_84280_/CLK }
C {devices/lab_pin.sym} 41170 -21490 0 0 {name=p40732 lab=_60986_/Y }
C {devices/lab_pin.sym} 41350 -21510 0 1 {name=p40733 lab=_84545_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -21500 0 0 {name=X_84545_ }
C {devices/lab_pin.sym} 41220 -21370 0 0 {name=p40734 lab=_51074_/A }
C {devices/lab_pin.sym} 41300 -21370 0 1 {name=p40735 lab=_51021_/A }
C {sky130_stdcells/buf_2.sym} 41260 -21370 0 0 {name=X_50937_ }
C {devices/lab_pin.sym} 41220 -21250 0 0 {name=p40736 lab=_46542_/X }
C {devices/lab_pin.sym} 41300 -21250 0 1 {name=p40737 lab=_57493_/X }
C {sky130_stdcells/buf_2.sym} 41260 -21250 0 0 {name=X_57493_ }
C {devices/lab_pin.sym} 41170 -21130 0 0 {name=p40738 lab=_81783_/CLK }
C {devices/lab_pin.sym} 41170 -21110 0 0 {name=p40739 lab=_76121_/B }
C {devices/lab_pin.sym} 41350 -21130 0 1 {name=p40740 lab=_41304_/A }
C {sky130_stdcells/dfxtp_4.sym} 41260 -21120 0 0 {name=X_81757_ }
C {devices/lab_pin.sym} 41220 -20990 0 0 {name=p40741 lab=_69233_/A }
C {devices/lab_pin.sym} 41300 -20990 0 1 {name=p40742 lab=_69605_/A }
C {sky130_stdcells/buf_2.sym} 41260 -20990 0 0 {name=X_69479_ }
C {devices/lab_pin.sym} 41180 -20890 0 0 {name=p40743 lab=_59160_/X }
C {devices/lab_pin.sym} 41180 -20850 0 0 {name=p40744 lab=_85646_/Q }
C {devices/lab_pin.sym} 41180 -20810 0 0 {name=p40745 lab=_59205_/X }
C {devices/lab_pin.sym} 41340 -20850 0 1 {name=p40746 lab=_59232_/X }
C {sky130_stdcells/o21a_4.sym} 41260 -20850 0 0 {name=X_59232_ }
C {devices/lab_pin.sym} 41200 -20720 0 0 {name=p40747 lab=_71512_/A }
C {devices/lab_pin.sym} 41200 -20680 0 0 {name=p40748 lab=_70585_/X }
C {devices/lab_pin.sym} 41320 -20700 0 1 {name=p40749 lab=_71510_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -20700 0 0 {name=X_71510_ }
C {devices/lab_pin.sym} 41200 -20590 0 0 {name=p40750 lab=_56446_/A }
C {devices/lab_pin.sym} 41200 -20550 0 0 {name=p40751 lab=_56446_/B }
C {devices/lab_pin.sym} 41200 -20510 0 0 {name=p40752 lab=_56444_/C }
C {devices/lab_pin.sym} 41320 -20550 0 1 {name=p40753 lab=_56444_/Y }
C {sky130_stdcells/nand3_4.sym} 41260 -20550 0 0 {name=X_56444_ }
C {devices/lab_pin.sym} 41170 -20410 0 0 {name=p40754 lab=_80708_/CLK }
C {devices/lab_pin.sym} 41170 -20390 0 0 {name=p40755 lab=_80708_/D }
C {devices/lab_pin.sym} 41350 -20410 0 1 {name=p40756 lab=_80676_/D }
C {sky130_stdcells/dfxtp_4.sym} 41260 -20400 0 0 {name=X_80708_ }
C {devices/lab_pin.sym} 41220 -20270 0 0 {name=p40757 lab=_41670_/A }
C {devices/lab_pin.sym} 41300 -20270 0 1 {name=p40758 lab=_41670_/Y }
C {sky130_stdcells/inv_2.sym} 41260 -20270 0 0 {name=X_41670_ }
C {devices/lab_pin.sym} 41170 -20150 0 0 {name=p40759 lab=_88036_/CLK }
C {devices/lab_pin.sym} 41170 -20130 0 0 {name=p40760 lab=_43795_/Y }
C {devices/lab_pin.sym} 41350 -20150 0 1 {name=p40761 lab=_69397_/B }
C {sky130_stdcells/dfxtp_4.sym} 41260 -20140 0 0 {name=X_87264_ }
C {devices/lab_pin.sym} 41200 -20020 0 0 {name=p40762 lab=_53656_/A }
C {devices/lab_pin.sym} 41200 -19980 0 0 {name=p40763 lab=_74403_/B }
C {devices/lab_pin.sym} 41320 -20000 0 1 {name=p40764 lab=_53656_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -20000 0 0 {name=X_53656_ }
C {devices/lab_pin.sym} 41200 -19880 0 0 {name=p40765 lab=_63586_/A }
C {devices/lab_pin.sym} 41200 -19840 0 0 {name=p40766 lab=_72488_/B }
C {devices/lab_pin.sym} 41320 -19860 0 1 {name=p40767 lab=_72490_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -19860 0 0 {name=X_72490_ }
C {devices/lab_pin.sym} 41170 -19730 0 0 {name=p40768 lab=_84477_/CLK }
C {devices/lab_pin.sym} 41170 -19710 0 0 {name=p40769 lab=_61497_/Y }
C {devices/lab_pin.sym} 41350 -19730 0 1 {name=p40770 lab=_84476_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -19720 0 0 {name=X_84476_ }
C {devices/lab_pin.sym} 41200 -19600 0 0 {name=p40771 lab=_50228_/X }
C {devices/lab_pin.sym} 41200 -19560 0 0 {name=p40772 lab=_54079_/B }
C {devices/lab_pin.sym} 41320 -19580 0 1 {name=p40773 lab=_50868_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -19580 0 0 {name=X_50868_ }
C {devices/lab_pin.sym} 41170 -19450 0 0 {name=p40774 lab=_85003_/CLK }
C {devices/lab_pin.sym} 41170 -19430 0 0 {name=p40775 lab=_80162_/X }
C {devices/lab_pin.sym} 41350 -19450 0 1 {name=p40776 lab=_81688_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -19440 0 0 {name=X_81688_ }
C {devices/lab_pin.sym} 41220 -19310 0 0 {name=p40777 lab=clkbuf_9_49_0_CLK/A }
C {devices/lab_pin.sym} 41300 -19310 0 1 {name=p40778 lab=clkbuf_9_48_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 41260 -19310 0 0 {name=Xclkbuf_9_48_0_CLK }
C {devices/lab_pin.sym} 41170 -19190 0 0 {name=p40779 lab=_86213_/CLK }
C {devices/lab_pin.sym} 41170 -19170 0 0 {name=p40780 lab=_50369_/Y }
C {devices/lab_pin.sym} 41350 -19190 0 1 {name=p40781 lab=_86215_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -19180 0 0 {name=X_86215_ }
C {sky130_stdcells/decap_3.sym} 41260 -19020 0 0 {name=XPHY_101 }
C {devices/lab_pin.sym} 41180 -18890 0 0 {name=p40782 lab=_52604_/Y }
C {devices/lab_pin.sym} 41180 -18850 0 0 {name=p40783 lab=_52592_/X }
C {devices/lab_pin.sym} 41180 -18810 0 0 {name=p40784 lab=_52606_/X }
C {devices/lab_pin.sym} 41340 -18850 0 1 {name=p40785 lab=_85788_/D }
C {sky130_stdcells/a21oi_4.sym} 41260 -18850 0 0 {name=X_52607_ }
C {devices/lab_pin.sym} 41220 -18710 0 0 {name=p40786 lab=_40620_/X }
C {devices/lab_pin.sym} 41300 -18710 0 1 {name=p40787 lab=_40621_/X }
C {sky130_stdcells/buf_2.sym} 41260 -18710 0 0 {name=X_40621_ }
C {devices/lab_pin.sym} 41180 -18610 0 0 {name=p40788 lab=_59105_/X }
C {devices/lab_pin.sym} 41180 -18570 0 0 {name=p40789 lab=_85748_/Q }
C {devices/lab_pin.sym} 41180 -18530 0 0 {name=p40790 lab=_59106_/X }
C {devices/lab_pin.sym} 41340 -18570 0 1 {name=p40791 lab=_59163_/X }
C {sky130_stdcells/o21a_4.sym} 41260 -18570 0 0 {name=X_59163_ }
C {devices/lab_pin.sym} 41200 -18440 0 0 {name=p40792 lab=_71238_/B }
C {devices/lab_pin.sym} 41200 -18400 0 0 {name=p40793 lab=_71485_/B }
C {devices/lab_pin.sym} 41320 -18420 0 1 {name=p40794 lab=_71444_/A }
C {sky130_stdcells/nor2_4.sym} 41260 -18420 0 0 {name=X_71441_ }
C {devices/lab_pin.sym} 41170 -18290 0 0 {name=p40795 lab=_82386_/CLK }
C {devices/lab_pin.sym} 41170 -18270 0 0 {name=p40796 lab=_71645_/Y }
C {devices/lab_pin.sym} 41350 -18290 0 1 {name=p40797 lab=_59500_/A }
C {sky130_stdcells/dfxtp_4.sym} 41260 -18280 0 0 {name=X_83427_ }
C {sky130_stdcells/decap_3.sym} 41260 -18120 0 0 {name=XPHY_112 }
C {devices/lab_pin.sym} 41200 -17990 0 0 {name=p40798 lab=_56458_/A }
C {devices/lab_pin.sym} 41200 -17950 0 0 {name=p40799 lab=_56363_/B }
C {devices/lab_pin.sym} 41200 -17910 0 0 {name=p40800 lab=_85217_/Q }
C {devices/lab_pin.sym} 41320 -17950 0 1 {name=p40801 lab=_56375_/Y }
C {sky130_stdcells/nand3_4.sym} 41260 -17950 0 0 {name=X_56375_ }
C {devices/lab_pin.sym} 41320 -17820 0 1 {name=p40802 lab=THREAD_COUNT[1] }
C {devices/lab_pin.sym} 41320 -17780 0 1 {name=p40803 lab=_80639_/LO }
C {sky130_stdcells/conb_1.sym} 41260 -17800 0 0 {name=X_80639_ }
C {devices/lab_pin.sym} 41170 -17670 0 0 {name=p40804 lab=_87195_/CLK }
C {devices/lab_pin.sym} 41170 -17650 0 0 {name=p40805 lab=_87195_/D }
C {devices/lab_pin.sym} 41350 -17670 0 1 {name=p40806 lab=_87195_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -17660 0 0 {name=X_87195_ }
C {devices/lab_pin.sym} 41220 -17530 0 0 {name=p40807 lab=_53723_/A }
C {devices/lab_pin.sym} 41300 -17530 0 1 {name=p40808 lab=_53601_/A }
C {sky130_stdcells/buf_2.sym} 41260 -17530 0 0 {name=X_53587_ }
C {sky130_stdcells/decap_3.sym} 41260 -17380 0 0 {name=XPHY_123 }
C {devices/lab_pin.sym} 41200 -17240 0 0 {name=p40809 lab=_50799_/A }
C {devices/lab_pin.sym} 41200 -17200 0 0 {name=p40810 lab=_50799_/B }
C {devices/lab_pin.sym} 41320 -17220 0 1 {name=p40811 lab=_50799_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -17220 0 0 {name=X_50799_ }
C {sky130_stdcells/decap_3.sym} 41260 -17060 0 0 {name=XPHY_134 }
C {devices/lab_pin.sym} 41180 -16930 0 0 {name=p40812 lab=_58112_/X }
C {devices/lab_pin.sym} 41180 -16890 0 0 {name=p40813 lab=_85988_/Q }
C {devices/lab_pin.sym} 41180 -16850 0 0 {name=p40814 lab=_58113_/X }
C {devices/lab_pin.sym} 41340 -16890 0 1 {name=p40815 lab=_58114_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -16890 0 0 {name=X_58114_ }
C {sky130_stdcells/decap_3.sym} 41260 -16720 0 0 {name=XPHY_145 }
C {devices/lab_pin.sym} 41180 -16600 0 0 {name=p40816 lab=_41306_/X }
C {devices/lab_pin.sym} 41180 -16560 0 0 {name=p40817 lab=_43336_/X }
C {devices/lab_pin.sym} 41180 -16520 0 0 {name=p40818 lab=_87471_/Q }
C {devices/lab_pin.sym} 41180 -16480 0 0 {name=p40819 lab=_43337_/X }
C {devices/lab_pin.sym} 41340 -16540 0 1 {name=p40820 lab=_43340_/X }
C {sky130_stdcells/a2bb2o_4.sym} 41260 -16540 0 0 {name=X_43340_ }
C {devices/lab_pin.sym} 41200 -16410 0 0 {name=p40821 lab=_55310_/X }
C {devices/lab_pin.sym} 41200 -16370 0 0 {name=p40822 lab=_83751_/Q }
C {devices/lab_pin.sym} 41200 -16330 0 0 {name=p40823 lab=_55315_/X }
C {devices/lab_pin.sym} 41320 -16370 0 1 {name=p40824 lab=_55328_/C }
C {sky130_stdcells/nand3_4.sym} 41260 -16370 0 0 {name=X_55326_ }
C {devices/lab_pin.sym} 41170 -16230 0 0 {name=p40825 lab=_85554_/CLK }
C {devices/lab_pin.sym} 41170 -16210 0 0 {name=p40826 lab=_50726_/Y }
C {devices/lab_pin.sym} 41350 -16230 0 1 {name=p40827 lab=_86146_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -16220 0 0 {name=X_86146_ }
C {devices/lab_pin.sym} 41200 -16100 0 0 {name=p40828 lab=_57617_/B }
C {devices/lab_pin.sym} 41200 -16060 0 0 {name=p40829 lab=_74160_/B }
C {devices/lab_pin.sym} 41320 -16080 0 1 {name=p40830 lab=_74161_/B }
C {sky130_stdcells/xor2_4.sym} 41260 -16080 0 0 {name=X_74160_ }
C {sky130_stdcells/decap_3.sym} 41260 -15920 0 0 {name=XPHY_156 }
C {devices/lab_pin.sym} 41180 -15790 0 0 {name=p40831 lab=_40326_/A }
C {devices/lab_pin.sym} 41180 -15750 0 0 {name=p40832 lab=_86757_/Q }
C {devices/lab_pin.sym} 41180 -15710 0 0 {name=p40833 lab=_40591_/C }
C {devices/lab_pin.sym} 41340 -15750 0 1 {name=p40834 lab=_42446_/A }
C {sky130_stdcells/o21a_4.sym} 41260 -15750 0 0 {name=X_40552_ }
C {devices/lab_pin.sym} 41180 -15630 0 0 {name=p40835 lab=_52536_/Y }
C {devices/lab_pin.sym} 41180 -15590 0 0 {name=p40836 lab=_52486_/X }
C {devices/lab_pin.sym} 41180 -15550 0 0 {name=p40837 lab=_52537_/Y }
C {devices/lab_pin.sym} 41340 -15590 0 1 {name=p40838 lab=_85802_/D }
C {sky130_stdcells/a21boi_4.sym} 41260 -15590 0 0 {name=X_52538_ }
C {devices/lab_pin.sym} 41200 -15460 0 0 {name=p40839 lab=_59094_/A }
C {devices/lab_pin.sym} 41200 -15420 0 0 {name=p40840 lab=_59068_/B }
C {devices/lab_pin.sym} 41320 -15440 0 1 {name=p40841 lab=_59094_/Y }
C {sky130_stdcells/nor2_4.sym} 41260 -15440 0 0 {name=X_59094_ }
C {devices/lab_pin.sym} 41220 -15310 0 0 {name=p40842 lab=_71372_/A }
C {devices/lab_pin.sym} 41300 -15310 0 1 {name=p40843 lab=_71372_/Y }
C {sky130_stdcells/inv_2.sym} 41260 -15310 0 0 {name=X_71372_ }
C {devices/lab_pin.sym} 41170 -15190 0 0 {name=p40844 lab=_83756_/CLK }
C {devices/lab_pin.sym} 41170 -15170 0 0 {name=p40845 lab=_83358_/D }
C {devices/lab_pin.sym} 41350 -15190 0 1 {name=p40846 lab=_58548_/B }
C {sky130_stdcells/dfxtp_4.sym} 41260 -15180 0 0 {name=X_83358_ }
C {devices/lab_pin.sym} 41220 -15050 0 0 {name=p40847 lab=clkbuf_3_6_0_CLK/A }
C {devices/lab_pin.sym} 41300 -15050 0 1 {name=p40848 lab=clkbuf_3_6_1_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 41260 -15050 0 0 {name=Xclkbuf_3_6_0_CLK }
C {sky130_stdcells/decap_3.sym} 41260 -14900 0 0 {name=XPHY_167 }
C {sky130_stdcells/decap_3.sym} 41260 -14720 0 0 {name=XPHY_178 }
C {sky130_stdcells/decap_3.sym} 41260 -14540 0 0 {name=XPHY_189 }
C {devices/lab_pin.sym} 41180 -14410 0 0 {name=p40849 lab=_73104_/Y }
C {devices/lab_pin.sym} 41180 -14370 0 0 {name=p40850 lab=_73105_/Y }
C {devices/lab_pin.sym} 41180 -14330 0 0 {name=p40851 lab=_73110_/X }
C {devices/lab_pin.sym} 41340 -14370 0 1 {name=p40852 lab=_73121_/A }
C {sky130_stdcells/o21ai_4.sym} 41260 -14370 0 0 {name=X_73111_ }
C {devices/lab_pin.sym} 41180 -14250 0 0 {name=p40853 lab=_58043_/X }
C {devices/lab_pin.sym} 41180 -14210 0 0 {name=p40854 lab=_85994_/Q }
C {devices/lab_pin.sym} 41180 -14170 0 0 {name=p40855 lab=_58044_/X }
C {devices/lab_pin.sym} 41340 -14210 0 1 {name=p40856 lab=_58045_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -14210 0 0 {name=X_58045_ }
C {devices/lab_pin.sym} 41200 -14100 0 0 {name=p40857 lab=_70328_/A }
C {devices/lab_pin.sym} 41200 -14060 0 0 {name=p40858 lab=_70328_/B }
C {devices/lab_pin.sym} 41200 -14020 0 0 {name=p40859 lab=_70323_/C }
C {devices/lab_pin.sym} 41200 -13980 0 0 {name=p40860 lab=_70328_/D }
C {devices/lab_pin.sym} 41320 -14040 0 1 {name=p40861 lab=_70323_/X }
C {sky130_stdcells/and4_4.sym} 41260 -14040 0 0 {name=X_70323_ }
C {devices/lab_pin.sym} 41170 -13890 0 0 {name=p40862 lab=_81195_/CLK }
C {devices/lab_pin.sym} 41170 -13870 0 0 {name=p40863 lab=_77022_/B }
C {devices/lab_pin.sym} 41350 -13890 0 1 {name=p40864 lab=_82309_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -13880 0 0 {name=X_82309_ }
C {devices/lab_pin.sym} 41220 -13750 0 0 {name=p40865 lab=_43270_/Y }
C {devices/lab_pin.sym} 41300 -13750 0 1 {name=p40866 lab=_43271_/Y }
C {sky130_stdcells/inv_2.sym} 41260 -13750 0 0 {name=X_43271_ }
C {devices/lab_pin.sym} 41180 -13660 0 0 {name=p40867 lab=_85033_/Q }
C {devices/lab_pin.sym} 41180 -13620 0 0 {name=p40868 lab=_55126_/X }
C {devices/lab_pin.sym} 41180 -13580 0 0 {name=p40869 lab=_55128_/X }
C {devices/lab_pin.sym} 41180 -13540 0 0 {name=p40870 lab=_55256_/X }
C {devices/lab_pin.sym} 41340 -13600 0 1 {name=p40871 lab=_55257_/X }
C {sky130_stdcells/a211o_4.sym} 41260 -13600 0 0 {name=X_55257_ }
C {devices/lab_pin.sym} 41200 -13460 0 0 {name=p40872 lab=_53567_/B }
C {devices/lab_pin.sym} 41200 -13420 0 0 {name=p40873 lab=_74090_/Y }
C {devices/lab_pin.sym} 41320 -13440 0 1 {name=p40874 lab=_74092_/B }
C {sky130_stdcells/xor2_4.sym} 41260 -13440 0 0 {name=X_74091_ }
C {devices/lab_pin.sym} 41170 -13310 0 0 {name=p40875 lab=_85757_/CLK }
C {devices/lab_pin.sym} 41170 -13290 0 0 {name=p40876 lab=_86077_/D }
C {devices/lab_pin.sym} 41350 -13310 0 1 {name=p40877 lab=_86077_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -13300 0 0 {name=X_86077_ }
C {devices/lab_pin.sym} 41180 -13190 0 0 {name=p40878 lab=_52467_/Y }
C {devices/lab_pin.sym} 41180 -13150 0 0 {name=p40879 lab=_52462_/X }
C {devices/lab_pin.sym} 41180 -13110 0 0 {name=p40880 lab=_52468_/Y }
C {devices/lab_pin.sym} 41340 -13150 0 1 {name=p40881 lab=_52469_/Y }
C {sky130_stdcells/a21boi_4.sym} 41260 -13150 0 0 {name=X_52469_ }
C {devices/lab_pin.sym} 41200 -13020 0 0 {name=p40882 lab=_40416_/A }
C {devices/lab_pin.sym} 41200 -12980 0 0 {name=p40883 lab=_81166_/Q }
C {devices/lab_pin.sym} 41320 -13000 0 1 {name=p40884 lab=_40483_/X }
C {sky130_stdcells/or2_4.sym} 41260 -13000 0 0 {name=X_40483_ }
C {devices/lab_pin.sym} 41170 -12870 0 0 {name=p40885 lab=_85536_/CLK }
C {devices/lab_pin.sym} 41170 -12850 0 0 {name=p40886 lab=_83289_/D }
C {devices/lab_pin.sym} 41350 -12870 0 1 {name=p40887 lab=_83289_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -12860 0 0 {name=X_83289_ }
C {devices/lab_pin.sym} 41180 -12750 0 0 {name=p40888 lab=_44975_/X }
C {devices/lab_pin.sym} 41180 -12710 0 0 {name=p40889 lab=_61398_/B }
C {devices/lab_pin.sym} 41180 -12670 0 0 {name=p40890 lab=_44995_/X }
C {devices/lab_pin.sym} 41340 -12710 0 1 {name=p40891 lab=_45010_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -12710 0 0 {name=X_45010_ }
C {devices/lab_pin.sym} 41220 -12570 0 0 {name=p40892 lab=_54316_/A }
C {devices/lab_pin.sym} 41300 -12570 0 1 {name=p40893 lab=_54208_/X }
C {sky130_stdcells/buf_2.sym} 41260 -12570 0 0 {name=X_54208_ }
C {devices/lab_pin.sym} 41220 -12450 0 0 {name=p40894 lab=_42258_/A }
C {devices/lab_pin.sym} 41300 -12450 0 1 {name=p40895 lab=_42222_/X }
C {sky130_stdcells/buf_2.sym} 41260 -12450 0 0 {name=X_42222_ }
C {devices/lab_pin.sym} 41200 -12340 0 0 {name=p40896 lab=_73381_/A }
C {devices/lab_pin.sym} 41200 -12300 0 0 {name=p40897 lab=_73042_/B }
C {devices/lab_pin.sym} 41320 -12320 0 1 {name=p40898 lab=_73042_/X }
C {sky130_stdcells/and2_4.sym} 41260 -12320 0 0 {name=X_73042_ }
C {devices/lab_pin.sym} 41170 -12190 0 0 {name=p40899 lab=_85034_/CLK }
C {devices/lab_pin.sym} 41170 -12170 0 0 {name=p40900 lab=_85028_/D }
C {devices/lab_pin.sym} 41350 -12190 0 1 {name=p40901 lab=_85028_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -12180 0 0 {name=X_85028_ }
C {devices/lab_pin.sym} 41180 -12070 0 0 {name=p40902 lab=_70238_/X }
C {devices/lab_pin.sym} 41180 -12030 0 0 {name=p40903 lab=_74778_/B }
C {devices/lab_pin.sym} 41180 -11990 0 0 {name=p40904 lab=_70253_/X }
C {devices/lab_pin.sym} 41340 -12030 0 1 {name=p40905 lab=_83822_/D }
C {sky130_stdcells/a21o_4.sym} 41260 -12030 0 0 {name=X_70254_ }
C {devices/lab_pin.sym} 41180 -11910 0 0 {name=p40906 lab=_55185_/X }
C {devices/lab_pin.sym} 41180 -11870 0 0 {name=p40907 lab=_55187_/X }
C {devices/lab_pin.sym} 41180 -11830 0 0 {name=p40908 lab=_44109_/X }
C {devices/lab_pin.sym} 41340 -11870 0 1 {name=p40909 lab=_55188_/X }
C {sky130_stdcells/a21o_4.sym} 41260 -11870 0 0 {name=X_55188_ }
C {devices/lab_pin.sym} 41180 -11760 0 0 {name=p40910 lab=_41169_/X }
C {devices/lab_pin.sym} 41180 -11720 0 0 {name=p40911 lab=_42148_/X }
C {devices/lab_pin.sym} 41180 -11680 0 0 {name=p40912 lab=_88008_/Q }
C {devices/lab_pin.sym} 41180 -11640 0 0 {name=p40913 lab=_42150_/X }
C {devices/lab_pin.sym} 41340 -11700 0 1 {name=p40914 lab=_42153_/X }
C {sky130_stdcells/a2bb2o_4.sym} 41260 -11700 0 0 {name=X_42153_ }
C {devices/lab_pin.sym} 41220 -11550 0 0 {name=p40915 lab=_48755_/A }
C {devices/lab_pin.sym} 41300 -11550 0 1 {name=p40916 lab=_54249_/A }
C {sky130_stdcells/buf_2.sym} 41260 -11550 0 0 {name=X_54139_ }
C {devices/lab_pin.sym} 41200 -11440 0 0 {name=p40917 lab=_82159_/Q }
C {devices/lab_pin.sym} 41200 -11400 0 0 {name=p40918 lab=_77850_/B }
C {devices/lab_pin.sym} 41320 -11420 0 1 {name=p40919 lab=_77850_/X }
C {sky130_stdcells/xor2_4.sym} 41260 -11420 0 0 {name=X_77850_ }
C {devices/lab_pin.sym} 41220 -11290 0 0 {name=p40920 lab=_70231_/A }
C {devices/lab_pin.sym} 41300 -11290 0 1 {name=p40921 lab=_70200_/A }
C {sky130_stdcells/buf_2.sym} 41260 -11290 0 0 {name=X_70185_ }
C {devices/lab_pin.sym} 41220 -11170 0 0 {name=p40922 lab=_59950_/C }
C {devices/lab_pin.sym} 41300 -11170 0 1 {name=p40923 lab=_60091_/B }
C {sky130_stdcells/buf_2.sym} 41260 -11170 0 0 {name=X_59996_ }
C {devices/lab_pin.sym} 41220 -11050 0 0 {name=p40924 lab=_41104_/A }
C {devices/lab_pin.sym} 41300 -11050 0 1 {name=p40925 lab=_41104_/X }
C {sky130_stdcells/buf_2.sym} 41260 -11050 0 0 {name=X_41104_ }
C {devices/lab_pin.sym} 41200 -10940 0 0 {name=p40926 lab=_76801_/A }
C {devices/lab_pin.sym} 41200 -10900 0 0 {name=p40927 lab=_76801_/B }
C {devices/lab_pin.sym} 41320 -10920 0 1 {name=p40928 lab=_76802_/B }
C {sky130_stdcells/xor2_4.sym} 41260 -10920 0 0 {name=X_76801_ }
C {devices/lab_pin.sym} 41180 -10810 0 0 {name=p40929 lab=_58934_/X }
C {devices/lab_pin.sym} 41180 -10770 0 0 {name=p40930 lab=_85923_/Q }
C {devices/lab_pin.sym} 41180 -10730 0 0 {name=p40931 lab=_58793_/X }
C {devices/lab_pin.sym} 41340 -10770 0 1 {name=p40932 lab=_58947_/X }
C {sky130_stdcells/o21a_4.sym} 41260 -10770 0 0 {name=X_58947_ }
C {devices/lab_pin.sym} 41220 -10630 0 0 {name=p40933 lab=_46725_/A }
C {devices/lab_pin.sym} 41300 -10630 0 1 {name=p40934 lab=_46961_/X }
C {sky130_stdcells/buf_2.sym} 41260 -10630 0 0 {name=X_46961_ }
C {devices/lab_pin.sym} 41180 -10550 0 0 {name=p40935 lab=_42083_/X }
C {devices/lab_pin.sym} 41180 -10510 0 0 {name=p40936 lab=_42077_/X }
C {devices/lab_pin.sym} 41180 -10470 0 0 {name=p40937 lab=_40977_/X }
C {devices/lab_pin.sym} 41180 -10430 0 0 {name=p40938 lab=_88043_/Q }
C {devices/lab_pin.sym} 41180 -10390 0 0 {name=p40939 lab=_42078_/X }
C {devices/lab_pin.sym} 41340 -10470 0 1 {name=p40940 lab=_42084_/Y }
C {sky130_stdcells/o32ai_4.sym} 41260 -10470 0 0 {name=X_42084_ }
C {devices/lab_pin.sym} 41180 -10330 0 0 {name=p40941 lab=_77778_/X }
C {devices/lab_pin.sym} 41180 -10290 0 0 {name=p40942 lab=_77779_/Y }
C {devices/lab_pin.sym} 41180 -10250 0 0 {name=p40943 lab=_77780_/X }
C {devices/lab_pin.sym} 41340 -10290 0 1 {name=p40944 lab=_77782_/A }
C {sky130_stdcells/a21oi_4.sym} 41260 -10290 0 0 {name=X_77781_ }
C {devices/lab_pin.sym} 41200 -10160 0 0 {name=p40945 lab=_74993_/A }
C {devices/lab_pin.sym} 41200 -10120 0 0 {name=p40946 lab=_74993_/B }
C {devices/lab_pin.sym} 41320 -10140 0 1 {name=p40947 lab=_81199_/D }
C {sky130_stdcells/xor2_4.sym} 41260 -10140 0 0 {name=X_74993_ }
C {devices/lab_pin.sym} 41170 -10010 0 0 {name=p40948 lab=_87333_/CLK }
C {devices/lab_pin.sym} 41170 -9990 0 0 {name=p40949 lab=_44744_/Y }
C {devices/lab_pin.sym} 41350 -10010 0 1 {name=p40950 lab=_86979_/Q }
C {sky130_stdcells/dfxtp_4.sym} 41260 -10000 0 0 {name=X_86979_ }
C {devices/lab_pin.sym} 41180 -9890 0 0 {name=p40951 lab=_48652_/X }
C {devices/lab_pin.sym} 41180 -9850 0 0 {name=p40952 lab=_48146_/A }
C {devices/lab_pin.sym} 41180 -9810 0 0 {name=p40953 lab=_48699_/Y }
C {devices/lab_pin.sym} 41340 -9850 0 1 {name=p40954 lab=_74509_/A }
C {sky130_stdcells/o21ai_4.sym} 41260 -9850 0 0 {name=X_48700_ }
C {devices/lab_pin.sym} 41200 -9720 0 0 {name=p40955 lab=_79520_/A }
C {devices/lab_pin.sym} 41200 -9680 0 0 {name=p40956 lab=_79520_/B }
C {devices/lab_pin.sym} 41320 -9700 0 1 {name=p40957 lab=_79522_/A }
C {sky130_stdcells/nand2_4.sym} 41260 -9700 0 0 {name=X_79520_ }
C {devices/lab_pin.sym} 41220 -9570 0 0 {name=p40958 lab=_57673_/A }
C {devices/lab_pin.sym} 41300 -9570 0 1 {name=p40959 lab=_59498_/A }
C {sky130_stdcells/buf_2.sym} 41260 -9570 0 0 {name=X_45912_ }
C {devices/lab_pin.sym} 41180 -9470 0 0 {name=p40960 lab=_40991_/X }
C {devices/lab_pin.sym} 41180 -9430 0 0 {name=p40961 lab=_41207_/A }
C {devices/lab_pin.sym} 41180 -9390 0 0 {name=p40962 lab=_41034_/X }
C {devices/lab_pin.sym} 41340 -9430 0 1 {name=p40963 lab=_41035_/X }
C {sky130_stdcells/o21a_4.sym} 41260 -9430 0 0 {name=X_41035_ }
C {devices/lab_pin.sym} 41200 -9300 0 0 {name=p40964 lab=_76732_/A }
C {devices/lab_pin.sym} 41200 -9260 0 0 {name=p40965 lab=_76731_/Y }
C {devices/lab_pin.sym} 41320 -9280 0 1 {name=p40966 lab=_76733_/B }
C {sky130_stdcells/xnor2_4.sym} 41260 -9280 0 0 {name=X_76732_ }
C {devices/lab_pin.sym} 41200 -9180 0 0 {name=p40967 lab=_49685_/A }
C {devices/lab_pin.sym} 41200 -9140 0 0 {name=p40968 lab=_49669_/B }
C {devices/lab_pin.sym} 41200 -9100 0 0 {name=p40969 lab=_49669_/C }
C {devices/lab_pin.sym} 41200 -9060 0 0 {name=p40970 lab=_52895_/D }
C {devices/lab_pin.sym} 41320 -9120 0 1 {name=p40971 lab=_49680_/X }
C {sky130_stdcells/and4_4.sym} 41260 -9120 0 0 {name=X_49680_ }
C {devices/lab_pin.sym} 41220 -8970 0 0 {name=p40972 lab=_56548_/X }
C {devices/lab_pin.sym} 41300 -8970 0 1 {name=p40973 lab=_73944_/X }
C {sky130_stdcells/buf_2.sym} 41260 -8970 0 0 {name=X_73944_ }
C {devices/lab_pin.sym} 41220 -8850 0 0 {name=p40974 lab=_46892_/A }
C {devices/lab_pin.sym} 41300 -8850 0 1 {name=p40975 lab=_46941_/A }
C {sky130_stdcells/buf_2.sym} 41260 -8850 0 0 {name=X_46892_ }
C {devices/lab_pin.sym} 41180 -8750 0 0 {name=p40976 lab=_58877_/X }
C {devices/lab_pin.sym} 41180 -8710 0 0 {name=p40977 lab=_85929_/Q }
C {devices/lab_pin.sym} 41180 -8670 0 0 {name=p40978 lab=_58810_/X }
C {devices/lab_pin.sym} 41340 -8710 0 1 {name=p40979 lab=_58878_/X }
C {sky130_stdcells/o21a_4.sym} 41260 -8710 0 0 {name=X_58878_ }
C {devices/lab_pin.sym} 41220 -8570 0 0 {name=p40980 lab=_48631_/A }
C {devices/lab_pin.sym} 41300 -8570 0 1 {name=p40981 lab=_48632_/B }
C {sky130_stdcells/buf_2.sym} 41260 -8570 0 0 {name=X_48631_ }
C {devices/lab_pin.sym} 41180 -8470 0 0 {name=p40982 lab=_79442_/Y }
C {devices/lab_pin.sym} 41180 -8430 0 0 {name=p40983 lab=_79459_/A }
C {devices/lab_pin.sym} 41180 -8390 0 0 {name=p40984 lab=_79450_/Y }
C {devices/lab_pin.sym} 41340 -8430 0 1 {name=p40985 lab=_79451_/Y }
C {sky130_stdcells/a21oi_4.sym} 41260 -8430 0 0 {name=X_79451_ }
C {devices/lab_pin.sym} 41200 -8300 0 0 {name=p40986 lab=_85060_/Q }
C {devices/lab_pin.sym} 41200 -8260 0 0 {name=p40987 lab=_45740_/B }
C {devices/lab_pin.sym} 41320 -8280 0 1 {name=p40988 lab=_45843_/Y }
C {sky130_stdcells/nor2_4.sym} 41260 -8280 0 0 {name=X_45843_ }
C {devices/lab_pin.sym} 41220 -8150 0 0 {name=p40989 lab=_57718_/A }
C {devices/lab_pin.sym} 41300 -8150 0 1 {name=p40990 lab=_57829_/X }
C {sky130_stdcells/buf_2.sym} 41260 -8150 0 0 {name=X_57829_ }
C {devices/lab_pin.sym} 41200 -8040 0 0 {name=p40991 lab=_76663_/A }
C {devices/lab_pin.sym} 41200 -8000 0 0 {name=p40992 lab=_76662_/Y }
C {devices/lab_pin.sym} 41320 -8020 0 1 {name=p40993 lab=_76663_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -8020 0 0 {name=X_76663_ }
C {devices/lab_pin.sym} 41180 -7910 0 0 {name=p40994 lab=_73871_/X }
C {devices/lab_pin.sym} 41180 -7870 0 0 {name=p40995 lab=_73874_/X }
C {devices/lab_pin.sym} 41180 -7830 0 0 {name=p40996 lab=_73799_/X }
C {devices/lab_pin.sym} 41340 -7870 0 1 {name=p40997 lab=_73888_/B }
C {sky130_stdcells/a21o_4.sym} 41260 -7870 0 0 {name=X_73875_ }
C {devices/lab_pin.sym} 41200 -7740 0 0 {name=p40998 lab=_78403_/A }
C {devices/lab_pin.sym} 41200 -7700 0 0 {name=p40999 lab=_82709_/Q }
C {devices/lab_pin.sym} 41320 -7720 0 1 {name=p41000 lab=_78402_/Y }
C {sky130_stdcells/nor2_4.sym} 41260 -7720 0 0 {name=X_78402_ }
C {devices/lab_pin.sym} 41200 -7600 0 0 {name=p41001 lab=_80774_/D }
C {devices/lab_pin.sym} 41200 -7560 0 0 {name=p41002 lab=_75606_/A }
C {devices/lab_pin.sym} 41320 -7580 0 1 {name=p41003 lab=_75622_/A }
C {sky130_stdcells/nand2_4.sym} 41260 -7580 0 0 {name=X_75614_ }
C {devices/lab_pin.sym} 41180 -7490 0 0 {name=p41004 lab=_60671_/C }
C {devices/lab_pin.sym} 41180 -7450 0 0 {name=p41005 lab=_60675_/Y }
C {devices/lab_pin.sym} 41180 -7410 0 0 {name=p41006 lab=_60820_/B }
C {devices/lab_pin.sym} 41180 -7370 0 0 {name=p41007 lab=_60820_/A }
C {devices/lab_pin.sym} 41180 -7340 0 0 {name=p41008 lab=_60839_/Y }
C {devices/lab_pin.sym} 41340 -7410 0 1 {name=p41009 lab=_84554_/D }
C {sky130_stdcells/a41oi_4.sym} 41260 -7410 0 0 {name=X_60840_ }
C {devices/lab_pin.sym} 41180 -7270 0 0 {name=p41010 lab=_86511_/Q }
C {devices/lab_pin.sym} 41180 -7230 0 0 {name=p41011 lab=_48536_/X }
C {devices/lab_pin.sym} 41180 -7190 0 0 {name=p41012 lab=_48561_/Y }
C {devices/lab_pin.sym} 41340 -7230 0 1 {name=p41013 lab=_48562_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -7230 0 0 {name=X_48562_ }
C {devices/lab_pin.sym} 41180 -7120 0 0 {name=p41014 lab=_41988_/Y }
C {devices/lab_pin.sym} 41180 -7080 0 0 {name=p41015 lab=_72723_/X }
C {devices/lab_pin.sym} 41180 -7040 0 0 {name=p41016 lab=_72725_/X }
C {devices/lab_pin.sym} 41180 -7000 0 0 {name=p41017 lab=_72825_/Y }
C {devices/lab_pin.sym} 41340 -7060 0 1 {name=p41018 lab=_72826_/X }
C {sky130_stdcells/a211o_4.sym} 41260 -7060 0 0 {name=X_72826_ }
C {devices/lab_pin.sym} 41200 -6920 0 0 {name=p41019 lab=_84804_/Q }
C {devices/lab_pin.sym} 41200 -6880 0 0 {name=p41020 lab=_66433_/C }
C {devices/lab_pin.sym} 41320 -6900 0 1 {name=p41021 lab=_79382_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -6900 0 0 {name=X_79382_ }
C {devices/lab_pin.sym} 41180 -6790 0 0 {name=p41022 lab=_85129_/Q }
C {devices/lab_pin.sym} 41180 -6750 0 0 {name=p41023 lab=_45507_/X }
C {devices/lab_pin.sym} 41180 -6710 0 0 {name=p41024 lab=_45153_/A }
C {devices/lab_pin.sym} 41340 -6750 0 1 {name=p41025 lab=_45774_/X }
C {sky130_stdcells/o21a_4.sym} 41260 -6750 0 0 {name=X_45774_ }
C {devices/lab_pin.sym} 41200 -6620 0 0 {name=p41026 lab=_76595_/A }
C {devices/lab_pin.sym} 41200 -6580 0 0 {name=p41027 lab=_76595_/B }
C {devices/lab_pin.sym} 41320 -6600 0 1 {name=p41028 lab=_76597_/B }
C {sky130_stdcells/nor2_4.sym} 41260 -6600 0 0 {name=X_76594_ }
C {devices/lab_pin.sym} 41180 -6510 0 0 {name=p41029 lab=_42984_/X }
C {devices/lab_pin.sym} 41180 -6470 0 0 {name=p41030 lab=_42985_/X }
C {devices/lab_pin.sym} 41180 -6430 0 0 {name=p41031 lab=_40474_/X }
C {devices/lab_pin.sym} 41180 -6390 0 0 {name=p41032 lab=_87618_/Q }
C {devices/lab_pin.sym} 41180 -6350 0 0 {name=p41033 lab=_42976_/X }
C {devices/lab_pin.sym} 41340 -6430 0 1 {name=p41034 lab=_42986_/Y }
C {sky130_stdcells/o32ai_4.sym} 41260 -6430 0 0 {name=X_42986_ }
C {devices/lab_pin.sym} 41200 -6300 0 0 {name=p41035 lab=_47513_/A }
C {devices/lab_pin.sym} 41200 -6260 0 0 {name=p41036 lab=_47549_/B }
C {devices/lab_pin.sym} 41200 -6220 0 0 {name=p41037 lab=_47513_/C }
C {devices/lab_pin.sym} 41200 -6180 0 0 {name=p41038 lab=_53090_/D }
C {devices/lab_pin.sym} 41320 -6240 0 1 {name=p41039 lab=_47513_/X }
C {sky130_stdcells/and4_4.sym} 41260 -6240 0 0 {name=X_47513_ }
C {devices/lab_pin.sym} 41220 -6090 0 0 {name=p41040 lab=_78331_/B }
C {devices/lab_pin.sym} 41300 -6090 0 1 {name=p41041 lab=_78333_/Y }
C {sky130_stdcells/inv_2.sym} 41260 -6090 0 0 {name=X_78333_ }
C {devices/lab_pin.sym} 41220 -5970 0 0 {name=p41042 lab=_44725_/A }
C {devices/lab_pin.sym} 41300 -5970 0 1 {name=p41043 lab=_44725_/Y }
C {sky130_stdcells/inv_2.sym} 41260 -5970 0 0 {name=X_44725_ }
C {devices/lab_pin.sym} 41220 -5850 0 0 {name=p41044 lab=_75544_/X }
C {devices/lab_pin.sym} 41300 -5850 0 1 {name=p41045 lab=_75546_/C }
C {sky130_stdcells/inv_2.sym} 41260 -5850 0 0 {name=X_75545_ }
C {devices/lab_pin.sym} 41220 -5730 0 0 {name=p41046 lab=_41998_/A }
C {devices/lab_pin.sym} 41300 -5730 0 1 {name=p41047 lab=_41937_/X }
C {sky130_stdcells/buf_2.sym} 41260 -5730 0 0 {name=X_41937_ }
C {devices/lab_pin.sym} 41200 -5620 0 0 {name=p41048 lab=_48515_/A }
C {devices/lab_pin.sym} 41200 -5580 0 0 {name=p41049 lab=_52158_/B }
C {devices/lab_pin.sym} 41320 -5600 0 1 {name=p41050 lab=_48493_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -5600 0 0 {name=X_48493_ }
C {devices/lab_pin.sym} 41220 -5470 0 0 {name=p41051 lab=_63696_/A }
C {devices/lab_pin.sym} 41300 -5470 0 1 {name=p41052 lab=_63374_/A }
C {sky130_stdcells/buf_2.sym} 41260 -5470 0 0 {name=X_60771_ }
C {devices/lab_pin.sym} 41220 -5350 0 0 {name=p41053 lab=_72757_/A }
C {devices/lab_pin.sym} 41300 -5350 0 1 {name=p41054 lab=_73638_/A }
C {sky130_stdcells/buf_2.sym} 41260 -5350 0 0 {name=X_72757_ }
C {devices/lab_pin.sym} 41180 -5270 0 0 {name=p41055 lab=_61568_/B }
C {devices/lab_pin.sym} 41180 -5230 0 0 {name=p41056 lab=_62462_/X }
C {devices/lab_pin.sym} 41180 -5190 0 0 {name=p41057 lab=_62507_/X }
C {devices/lab_pin.sym} 41180 -5150 0 0 {name=p41058 lab=_62478_/X }
C {devices/lab_pin.sym} 41180 -5120 0 0 {name=p41059 lab=_62509_/X }
C {devices/lab_pin.sym} 41340 -5190 0 1 {name=p41060 lab=_62510_/X }
C {sky130_stdcells/a41o_4.sym} 41260 -5190 0 0 {name=X_62510_ }
C {devices/lab_pin.sym} 41200 -5040 0 0 {name=p41061 lab=_47444_/A }
C {devices/lab_pin.sym} 41200 -5000 0 0 {name=p41062 lab=_53050_/B }
C {devices/lab_pin.sym} 41320 -5020 0 1 {name=p41063 lab=_47444_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -5020 0 0 {name=X_47444_ }
C {devices/lab_pin.sym} 41200 -4910 0 0 {name=p41064 lab=_71576_/X }
C {devices/lab_pin.sym} 41200 -4870 0 0 {name=p41065 lab=_71690_/A }
C {devices/lab_pin.sym} 41200 -4830 0 0 {name=p41066 lab=_71874_/D }
C {devices/lab_pin.sym} 41320 -4870 0 1 {name=p41067 lab=_71708_/Y }
C {sky130_stdcells/nor3_4.sym} 41260 -4870 0 0 {name=X_71708_ }
C {devices/lab_pin.sym} 41220 -4730 0 0 {name=p41068 lab=_78280_/B }
C {devices/lab_pin.sym} 41300 -4730 0 1 {name=p41069 lab=_78264_/Y }
C {sky130_stdcells/inv_2.sym} 41260 -4730 0 0 {name=X_78264_ }
C {devices/lab_pin.sym} 41180 -4650 0 0 {name=p41070 lab=_44638_/X }
C {devices/lab_pin.sym} 41180 -4610 0 0 {name=p41071 lab=_44639_/X }
C {devices/lab_pin.sym} 41180 -4570 0 0 {name=p41072 lab=_41081_/X }
C {devices/lab_pin.sym} 41180 -4530 0 0 {name=p41073 lab=_87013_/Q }
C {devices/lab_pin.sym} 41180 -4490 0 0 {name=p41074 lab=_44640_/X }
C {devices/lab_pin.sym} 41340 -4570 0 1 {name=p41075 lab=_44657_/A }
C {sky130_stdcells/o32ai_4.sym} 41260 -4570 0 0 {name=X_44656_ }
C {devices/lab_pin.sym} 41180 -4440 0 0 {name=p41076 lab=_61447_/B }
C {devices/lab_pin.sym} 41180 -4400 0 0 {name=p41077 lab=_63487_/X }
C {devices/lab_pin.sym} 41180 -4360 0 0 {name=p41078 lab=_63488_/X }
C {devices/lab_pin.sym} 41180 -4320 0 0 {name=p41079 lab=_63489_/X }
C {devices/lab_pin.sym} 41340 -4380 0 1 {name=p41080 lab=_63490_/X }
C {sky130_stdcells/a211o_4.sym} 41260 -4380 0 0 {name=X_63490_ }
C {devices/lab_pin.sym} 41220 -4230 0 0 {name=p41081 lab=_75475_/Y }
C {devices/lab_pin.sym} 41300 -4230 0 1 {name=p41082 lab=_75477_/C }
C {sky130_stdcells/inv_2.sym} 41260 -4230 0 0 {name=X_75476_ }
C {devices/lab_pin.sym} 41220 -4110 0 0 {name=p41083 lab=_41992_/A }
C {devices/lab_pin.sym} 41300 -4110 0 1 {name=p41084 lab=_50731_/A }
C {sky130_stdcells/buf_2.sym} 41260 -4110 0 0 {name=X_41868_ }
C {devices/lab_pin.sym} 41220 -3990 0 0 {name=p41085 lab=_72688_/A }
C {devices/lab_pin.sym} 41300 -3990 0 1 {name=p41086 lab=_72697_/B }
C {sky130_stdcells/buf_2.sym} 41260 -3990 0 0 {name=X_72688_ }
C {sky130_stdcells/decap_3.sym} 41260 -3840 0 0 {name=XPHY_3 }
C {devices/lab_pin.sym} 41200 -3700 0 0 {name=p41087 lab=_77222_/A }
C {devices/lab_pin.sym} 41200 -3660 0 0 {name=p41088 lab=_77222_/B }
C {devices/lab_pin.sym} 41320 -3680 0 1 {name=p41089 lab=_77219_/A }
C {sky130_stdcells/xor2_4.sym} 41260 -3680 0 0 {name=X_77215_ }
C {devices/lab_pin.sym} 41180 -3590 0 0 {name=p41090 lab=_62429_/X }
C {devices/lab_pin.sym} 41180 -3550 0 0 {name=p41091 lab=_62435_/Y }
C {devices/lab_pin.sym} 41180 -3510 0 0 {name=p41092 lab=_62439_/X }
C {devices/lab_pin.sym} 41180 -3470 0 0 {name=p41093 lab=_84738_/Q }
C {devices/lab_pin.sym} 41180 -3430 0 0 {name=p41094 lab=_62440_/X }
C {devices/lab_pin.sym} 41340 -3510 0 1 {name=p41095 lab=_62441_/Y }
C {sky130_stdcells/o32ai_4.sym} 41260 -3510 0 0 {name=X_62441_ }
C {devices/lab_pin.sym} 41220 -3350 0 0 {name=p41096 lab=_43607_/A }
C {devices/lab_pin.sym} 41300 -3350 0 1 {name=p41097 lab=_43607_/X }
C {sky130_stdcells/buf_2.sym} 41260 -3350 0 0 {name=X_43607_ }
C {devices/lab_pin.sym} 41180 -3250 0 0 {name=p41098 lab=_74424_/Y }
C {devices/lab_pin.sym} 41180 -3210 0 0 {name=p41099 lab=_74405_/X }
C {devices/lab_pin.sym} 41180 -3170 0 0 {name=p41100 lab=_74426_/X }
C {devices/lab_pin.sym} 41340 -3210 0 1 {name=p41101 lab=_74427_/Y }
C {sky130_stdcells/a21oi_4.sym} 41260 -3210 0 0 {name=X_74427_ }
C {devices/lab_pin.sym} 41180 -3090 0 0 {name=p41102 lab=_40817_/X }
C {devices/lab_pin.sym} 41180 -3050 0 0 {name=p41103 lab=_82294_/Q }
C {devices/lab_pin.sym} 41180 -3010 0 0 {name=p41104 lab=_40818_/X }
C {devices/lab_pin.sym} 41340 -3050 0 1 {name=p41105 lab=_40820_/A }
C {sky130_stdcells/o21ai_4.sym} 41260 -3050 0 0 {name=X_40819_ }
C {devices/lab_pin.sym} 41180 -2930 0 0 {name=p41106 lab=_86641_/Q }
C {devices/lab_pin.sym} 41180 -2890 0 0 {name=p41107 lab=_47332_/X }
C {devices/lab_pin.sym} 41180 -2850 0 0 {name=p41108 lab=_47374_/Y }
C {devices/lab_pin.sym} 41340 -2890 0 1 {name=p41109 lab=_47375_/Y }
C {sky130_stdcells/o21ai_4.sym} 41260 -2890 0 0 {name=X_47375_ }
C {devices/lab_pin.sym} 41200 -2770 0 0 {name=p41110 lab=_71637_/A }
C {devices/lab_pin.sym} 41200 -2730 0 0 {name=p41111 lab=_71228_/B }
C {devices/lab_pin.sym} 41200 -2690 0 0 {name=p41112 lab=_71637_/C }
C {devices/lab_pin.sym} 41320 -2730 0 1 {name=p41113 lab=_71639_/Y }
C {sky130_stdcells/nand3_4.sym} 41260 -2730 0 0 {name=X_71639_ }
C {devices/lab_pin.sym} 41200 -2600 0 0 {name=p41114 lab=_78192_/Y }
C {devices/lab_pin.sym} 41200 -2560 0 0 {name=p41115 lab=_78194_/X }
C {devices/lab_pin.sym} 41320 -2580 0 1 {name=p41116 lab=_78205_/A }
C {sky130_stdcells/nand2_4.sym} 41260 -2580 0 0 {name=X_78195_ }
C {devices/lab_pin.sym} 41220 -2450 0 0 {name=p41117 lab=_44587_/A }
C {devices/lab_pin.sym} 41300 -2450 0 1 {name=p41118 lab=_44679_/A }
C {sky130_stdcells/buf_2.sym} 41260 -2450 0 0 {name=X_44587_ }
C {devices/lab_pin.sym} 41220 -2330 0 0 {name=p41119 lab=_41799_/A }
C {devices/lab_pin.sym} 41300 -2330 0 1 {name=p41120 lab=_41799_/X }
C {sky130_stdcells/buf_2.sym} 41260 -2330 0 0 {name=X_41799_ }
C {devices/lab_pin.sym} 41180 -2230 0 0 {name=p41121 lab=_49109_/Y }
C {devices/lab_pin.sym} 41180 -2190 0 0 {name=p41122 lab=_49086_/X }
C {devices/lab_pin.sym} 41180 -2150 0 0 {name=p41123 lab=_49113_/X }
C {devices/lab_pin.sym} 41340 -2190 0 1 {name=p41124 lab=_86443_/D }
C {sky130_stdcells/a21oi_4.sym} 41260 -2190 0 0 {name=X_49114_ }
C {devices/lab_pin.sym} 41200 -2060 0 0 {name=p41125 lab=_46326_/A }
C {devices/lab_pin.sym} 41200 -2020 0 0 {name=p41126 lab=_50757_/B }
C {devices/lab_pin.sym} 41320 -2040 0 1 {name=p41127 lab=_46326_/Y }
C {sky130_stdcells/nand2_4.sym} 41260 -2040 0 0 {name=X_46326_ }
C {devices/lab_pin.sym} 41180 -1940 0 0 {name=p41128 lab=_65035_/X }
C {devices/lab_pin.sym} 41180 -1900 0 0 {name=p41129 lab=_85548_/Q }
C {devices/lab_pin.sym} 41180 -1860 0 0 {name=p41130 lab=_65036_/X }
C {devices/lab_pin.sym} 41180 -1820 0 0 {name=p41131 lab=_65159_/X }
C {devices/lab_pin.sym} 41340 -1880 0 1 {name=p41132 lab=_65160_/X }
C {sky130_stdcells/a211o_4.sym} 41260 -1880 0 0 {name=X_65160_ }
C {devices/lab_pin.sym} 41200 -1740 0 0 {name=p41133 lab=_77154_/A }
C {devices/lab_pin.sym} 41200 -1700 0 0 {name=p41134 lab=_77146_/B }
C {devices/lab_pin.sym} 41320 -1720 0 1 {name=p41135 lab=_77147_/B }
C {sky130_stdcells/xor2_4.sym} 41260 -1720 0 0 {name=X_77146_ }
C {devices/lab_pin.sym} 41180 -1630 0 0 {name=p41136 lab=_43518_/X }
C {devices/lab_pin.sym} 41180 -1590 0 0 {name=p41137 lab=_43523_/X }
C {devices/lab_pin.sym} 41180 -1550 0 0 {name=p41138 lab=_40426_/X }
C {devices/lab_pin.sym} 41180 -1510 0 0 {name=p41139 lab=_87369_/Q }
C {devices/lab_pin.sym} 41180 -1470 0 0 {name=p41140 lab=_43528_/X }
C {devices/lab_pin.sym} 41340 -1550 0 1 {name=p41141 lab=_43538_/Y }
C {sky130_stdcells/o32ai_4.sym} 41260 -1550 0 0 {name=X_43538_ }
C {devices/lab_pin.sym} 41220 -1390 0 0 {name=p41142 lab=_62198_/Y }
C {devices/lab_pin.sym} 41300 -1390 0 1 {name=p41143 lab=_62406_/A }
C {sky130_stdcells/buf_2.sym} 41260 -1390 0 0 {name=X_62372_ }
C {devices/lab_pin.sym} 41180 -1290 0 0 {name=p41144 lab=_70346_/C }
C {devices/lab_pin.sym} 41180 -1250 0 0 {name=p41145 lab=_72699_/X }
C {devices/lab_pin.sym} 41180 -1210 0 0 {name=p41146 lab=_74357_/Y }
C {devices/lab_pin.sym} 41340 -1250 0 1 {name=p41147 lab=_83084_/D }
C {sky130_stdcells/a21bo_4.sym} 41260 -1250 0 0 {name=X_74358_ }
C {devices/lab_pin.sym} 41180 -1140 0 0 {name=p41148 lab=_59423_/Y }
C {devices/lab_pin.sym} 41180 -1100 0 0 {name=p41149 lab=_61003_/Y }
C {devices/lab_pin.sym} 41180 -1060 0 0 {name=p41150 lab=_62097_/X }
C {devices/lab_pin.sym} 41180 -1020 0 0 {name=p41151 lab=_60963_/X }
C {devices/lab_pin.sym} 41340 -1080 0 1 {name=p41152 lab=_64111_/X }
C {sky130_stdcells/a2bb2o_4.sym} 41260 -1080 0 0 {name=X_64111_ }
C {devices/lab_pin.sym} 41220 -930 0 0 {name=p41153 lab=_53860_/B }
C {devices/lab_pin.sym} 41300 -930 0 1 {name=p41154 lab=_50133_/B }
C {sky130_stdcells/buf_2.sym} 41260 -930 0 0 {name=X_49045_ }
C {devices/lab_pin.sym} 41200 -820 0 0 {name=p41155 lab=_61323_/A }
C {devices/lab_pin.sym} 41200 -780 0 0 {name=p41156 lab=_61323_/B }
C {devices/lab_pin.sym} 41320 -800 0 1 {name=p41157 lab=_61323_/X }
C {sky130_stdcells/or2_4.sym} 41260 -800 0 0 {name=X_61323_ }
C {devices/lab_pin.sym} 41180 -690 0 0 {name=p41158 lab=_73305_/X }
C {devices/lab_pin.sym} 41180 -650 0 0 {name=p41159 lab=_73308_/X }
C {devices/lab_pin.sym} 41180 -610 0 0 {name=p41160 lab=_73262_/X }
C {devices/lab_pin.sym} 41340 -650 0 1 {name=p41161 lab=_73312_/A }
C {sky130_stdcells/a21o_4.sym} 41260 -650 0 0 {name=X_73309_ }
C {devices/lab_pin.sym} 42100 -42170 0 0 {name=p41162 lab=_86752_/Q }
C {devices/lab_pin.sym} 42100 -42130 0 0 {name=p41163 lab=_46250_/X }
C {devices/lab_pin.sym} 42100 -42090 0 0 {name=p41164 lab=_46256_/Y }
C {devices/lab_pin.sym} 42260 -42130 0 1 {name=p41165 lab=_46257_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -42130 0 0 {name=X_46257_ }
C {devices/lab_pin.sym} 42140 -41990 0 0 {name=p41166 lab=_64789_/A }
C {devices/lab_pin.sym} 42220 -41990 0 1 {name=p41167 lab=_65268_/B }
C {sky130_stdcells/buf_2.sym} 42180 -41990 0 0 {name=X_65091_ }
C {sky130_stdcells/decap_3.sym} 42180 -41840 0 0 {name=XPHY_690 }
C {devices/lab_pin.sym} 42120 -41700 0 0 {name=p41168 lab=_77077_/A }
C {devices/lab_pin.sym} 42120 -41660 0 0 {name=p41169 lab=_77086_/B }
C {devices/lab_pin.sym} 42240 -41680 0 1 {name=p41170 lab=_77080_/A }
C {sky130_stdcells/nand2_4.sym} 42180 -41680 0 0 {name=X_77077_ }
C {devices/lab_pin.sym} 42100 -41590 0 0 {name=p41171 lab=_43449_/X }
C {devices/lab_pin.sym} 42100 -41550 0 0 {name=p41172 lab=_43452_/X }
C {devices/lab_pin.sym} 42100 -41510 0 0 {name=p41173 lab=_41656_/X }
C {devices/lab_pin.sym} 42100 -41470 0 0 {name=p41174 lab=_87406_/Q }
C {devices/lab_pin.sym} 42100 -41430 0 0 {name=p41175 lab=_43456_/X }
C {devices/lab_pin.sym} 42260 -41510 0 1 {name=p41176 lab=_43470_/A }
C {sky130_stdcells/o32ai_4.sym} 42180 -41510 0 0 {name=X_43469_ }
C {devices/lab_pin.sym} 42140 -41350 0 0 {name=p41177 lab=_72704_/A }
C {devices/lab_pin.sym} 42220 -41350 0 1 {name=p41178 lab=_74297_/A }
C {sky130_stdcells/buf_2.sym} 42180 -41350 0 0 {name=X_74289_ }
C {devices/lab_pin.sym} 42100 -41250 0 0 {name=p41179 lab=_56246_/C }
C {devices/lab_pin.sym} 42100 -41210 0 0 {name=p41180 lab=_45147_/X }
C {devices/lab_pin.sym} 42100 -41170 0 0 {name=p41181 lab=_45207_/X }
C {devices/lab_pin.sym} 42260 -41210 0 1 {name=p41182 lab=_45208_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -41210 0 0 {name=X_45208_ }
C {devices/lab_pin.sym} 42120 -41080 0 0 {name=p41183 lab=_76028_/A }
C {devices/lab_pin.sym} 42120 -41040 0 0 {name=p41184 lab=_76028_/B }
C {devices/lab_pin.sym} 42240 -41060 0 1 {name=p41185 lab=_76031_/A }
C {sky130_stdcells/nand2_4.sym} 42180 -41060 0 0 {name=X_76028_ }
C {devices/lab_pin.sym} 42120 -40960 0 0 {name=p41186 lab=_84838_/Q }
C {devices/lab_pin.sym} 42120 -40920 0 0 {name=p41187 lab=_64091_/B }
C {devices/lab_pin.sym} 42120 -40880 0 0 {name=p41188 lab=_64091_/C }
C {devices/lab_pin.sym} 42120 -40840 0 0 {name=p41189 lab=_64091_/D }
C {devices/lab_pin.sym} 42240 -40900 0 1 {name=p41190 lab=_64042_/Y }
C {sky130_stdcells/nand4_4.sym} 42180 -40900 0 0 {name=X_64042_ }
C {devices/lab_pin.sym} 42120 -40780 0 0 {name=p41191 lab=_60267_/X }
C {devices/lab_pin.sym} 42120 -40740 0 0 {name=p41192 lab=_61254_/B }
C {devices/lab_pin.sym} 42120 -40700 0 0 {name=p41193 lab=_61254_/C }
C {devices/lab_pin.sym} 42120 -40660 0 0 {name=p41194 lab=_61254_/D }
C {devices/lab_pin.sym} 42240 -40720 0 1 {name=p41195 lab=_61254_/Y }
C {sky130_stdcells/nand4_4.sym} 42180 -40720 0 0 {name=X_61254_ }
C {devices/lab_pin.sym} 42120 -40580 0 0 {name=p41196 lab=_46188_/A }
C {devices/lab_pin.sym} 42120 -40540 0 0 {name=p41197 lab=_46114_/A }
C {devices/lab_pin.sym} 42240 -40560 0 1 {name=p41198 lab=_46217_/B }
C {sky130_stdcells/nor2_4.sym} 42180 -40560 0 0 {name=X_46188_ }
C {devices/lab_pin.sym} 42140 -40430 0 0 {name=p41199 lab=_60288_/C }
C {devices/lab_pin.sym} 42220 -40430 0 1 {name=p41200 lab=_60205_/X }
C {sky130_stdcells/buf_2.sym} 42180 -40430 0 0 {name=X_60205_ }
C {devices/lab_pin.sym} 42100 -40330 0 0 {name=p41201 lab=_55851_/B }
C {devices/lab_pin.sym} 42100 -40290 0 0 {name=p41202 lab=_45120_/X }
C {devices/lab_pin.sym} 42100 -40250 0 0 {name=p41203 lab=_45079_/X }
C {devices/lab_pin.sym} 42260 -40290 0 1 {name=p41204 lab=_45139_/X }
C {sky130_stdcells/o21a_4.sym} 42180 -40290 0 0 {name=X_45139_ }
C {devices/lab_pin.sym} 42120 -40160 0 0 {name=p41205 lab=_68759_/A }
C {devices/lab_pin.sym} 42120 -40120 0 0 {name=p41206 lab=_87232_/Q }
C {devices/lab_pin.sym} 42240 -40140 0 1 {name=p41207 lab=_68850_/X }
C {sky130_stdcells/and2_4.sym} 42180 -40140 0 0 {name=X_68850_ }
C {devices/lab_pin.sym} 42120 -40030 0 0 {name=p41208 lab=_61165_/A }
C {devices/lab_pin.sym} 42120 -39990 0 0 {name=p41209 lab=_61165_/B }
C {devices/lab_pin.sym} 42120 -39950 0 0 {name=p41210 lab=_61185_/C }
C {devices/lab_pin.sym} 42240 -39990 0 1 {name=p41211 lab=_61185_/Y }
C {sky130_stdcells/nor3_4.sym} 42180 -39990 0 0 {name=X_61185_ }
C {devices/lab_pin.sym} 42120 -39860 0 0 {name=p41212 lab=_67873_/A }
C {devices/lab_pin.sym} 42120 -39820 0 0 {name=p41213 lab=_67801_/B }
C {devices/lab_pin.sym} 42240 -39840 0 1 {name=p41214 lab=_67801_/X }
C {sky130_stdcells/and2_4.sym} 42180 -39840 0 0 {name=X_67801_ }
C {devices/lab_pin.sym} 42120 -39730 0 0 {name=p41215 lab=_60125_/A }
C {devices/lab_pin.sym} 42120 -39690 0 0 {name=p41216 lab=_60214_/B }
C {devices/lab_pin.sym} 42120 -39650 0 0 {name=p41217 lab=_60136_/C }
C {devices/lab_pin.sym} 42240 -39690 0 1 {name=p41218 lab=_60136_/Y }
C {sky130_stdcells/nor3_4.sym} 42180 -39690 0 0 {name=X_60136_ }
C {devices/lab_pin.sym} 42120 -39580 0 0 {name=p41219 lab=_49925_/X }
C {devices/lab_pin.sym} 42120 -39540 0 0 {name=p41220 lab=_49943_/B }
C {devices/lab_pin.sym} 42120 -39500 0 0 {name=p41221 lab=_49953_/C }
C {devices/lab_pin.sym} 42120 -39460 0 0 {name=p41222 lab=_53159_/D }
C {devices/lab_pin.sym} 42240 -39520 0 1 {name=p41223 lab=_49947_/X }
C {sky130_stdcells/and4_4.sym} 42180 -39520 0 0 {name=X_49947_ }
C {devices/lab_pin.sym} 42120 -39380 0 0 {name=p41224 lab=_68366_/X }
C {devices/lab_pin.sym} 42120 -39340 0 0 {name=p41225 lab=_42502_/Y }
C {devices/lab_pin.sym} 42240 -39360 0 1 {name=p41226 lab=_68781_/Y }
C {sky130_stdcells/nor2_4.sym} 42180 -39360 0 0 {name=X_68781_ }
C {devices/lab_pin.sym} 42100 -39260 0 0 {name=p41227 lab=_65990_/X }
C {devices/lab_pin.sym} 42100 -39220 0 0 {name=p41228 lab=_86235_/Q }
C {devices/lab_pin.sym} 42100 -39180 0 0 {name=p41229 lab=_65701_/X }
C {devices/lab_pin.sym} 42100 -39140 0 0 {name=p41230 lab=_65992_/X }
C {devices/lab_pin.sym} 42260 -39200 0 1 {name=p41231 lab=_65993_/X }
C {sky130_stdcells/a211o_4.sym} 42180 -39200 0 0 {name=X_65993_ }
C {devices/lab_pin.sym} 42100 -39070 0 0 {name=p41232 lab=_77980_/A }
C {devices/lab_pin.sym} 42100 -39030 0 0 {name=p41233 lab=_77972_/Y }
C {devices/lab_pin.sym} 42100 -38990 0 0 {name=p41234 lab=_77980_/C }
C {devices/lab_pin.sym} 42260 -39030 0 1 {name=p41235 lab=_77983_/A }
C {sky130_stdcells/a21o_4.sym} 42180 -39030 0 0 {name=X_77979_ }
C {devices/lab_pin.sym} 42120 -38900 0 0 {name=p41236 lab=_79715_/X }
C {devices/lab_pin.sym} 42120 -38860 0 0 {name=p41237 lab=_79717_/Y }
C {devices/lab_pin.sym} 42240 -38880 0 1 {name=p41238 lab=_79718_/X }
C {sky130_stdcells/xor2_4.sym} 42180 -38880 0 0 {name=X_79718_ }
C {devices/lab_pin.sym} 42120 -38760 0 0 {name=p41239 lab=_67658_/X }
C {devices/lab_pin.sym} 42120 -38720 0 0 {name=p41240 lab=_67732_/B }
C {devices/lab_pin.sym} 42240 -38740 0 1 {name=p41241 lab=_67732_/X }
C {sky130_stdcells/and2_4.sym} 42180 -38740 0 0 {name=X_67732_ }
C {devices/lab_pin.sym} 42140 -38610 0 0 {name=p41242 lab=_64666_/A }
C {devices/lab_pin.sym} 42220 -38610 0 1 {name=p41243 lab=_64944_/X }
C {sky130_stdcells/buf_2.sym} 42180 -38610 0 0 {name=X_64944_ }
C {devices/lab_pin.sym} 42120 -38510 0 0 {name=p41244 lab=_60081_/A }
C {devices/lab_pin.sym} 42120 -38470 0 0 {name=p41245 lab=_60081_/B }
C {devices/lab_pin.sym} 42120 -38430 0 0 {name=p41246 lab=_60067_/C }
C {devices/lab_pin.sym} 42240 -38470 0 1 {name=p41247 lab=_60067_/Y }
C {sky130_stdcells/nor3_4.sym} 42180 -38470 0 0 {name=X_60067_ }
C {devices/lab_pin.sym} 42100 -38350 0 0 {name=p41248 lab=_49875_/Y }
C {devices/lab_pin.sym} 42100 -38310 0 0 {name=p41249 lab=_49870_/X }
C {devices/lab_pin.sym} 42100 -38270 0 0 {name=p41250 lab=_49877_/X }
C {devices/lab_pin.sym} 42260 -38310 0 1 {name=p41251 lab=_86307_/D }
C {sky130_stdcells/a21oi_4.sym} 42180 -38310 0 0 {name=X_49878_ }
C {devices/lab_pin.sym} 42090 -38170 0 0 {name=p41252 lab=_80813_/CLK }
C {devices/lab_pin.sym} 42090 -38150 0 0 {name=p41253 lab=_80990_/D }
C {devices/lab_pin.sym} 42270 -38170 0 1 {name=p41254 lab=_80990_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -38160 0 0 {name=X_80990_ }
C {devices/lab_pin.sym} 42120 -38050 0 0 {name=p41255 lab=_50511_/A }
C {devices/lab_pin.sym} 42120 -38010 0 0 {name=p41256 lab=_48829_/B }
C {devices/lab_pin.sym} 42120 -37970 0 0 {name=p41257 lab=_48849_/C }
C {devices/lab_pin.sym} 42240 -38010 0 1 {name=p41258 lab=_48829_/X }
C {sky130_stdcells/and3_4.sym} 42180 -38010 0 0 {name=X_48829_ }
C {devices/lab_pin.sym} 42100 -37890 0 0 {name=p41259 lab=_81492_/D }
C {devices/lab_pin.sym} 42100 -37850 0 0 {name=p41260 lab=_67568_/X }
C {devices/lab_pin.sym} 42100 -37810 0 0 {name=p41261 lab=_67662_/X }
C {devices/lab_pin.sym} 42260 -37850 0 1 {name=p41262 lab=_67663_/X }
C {sky130_stdcells/a21bo_4.sym} 42180 -37850 0 0 {name=X_67663_ }
C {devices/lab_pin.sym} 42120 -37720 0 0 {name=p41263 lab=_79649_/A }
C {devices/lab_pin.sym} 42120 -37680 0 0 {name=p41264 lab=_79649_/B }
C {devices/lab_pin.sym} 42240 -37700 0 1 {name=p41265 lab=_79650_/B }
C {sky130_stdcells/xor2_4.sym} 42180 -37700 0 0 {name=X_79649_ }
C {devices/lab_pin.sym} 42100 -37600 0 0 {name=p41266 lab=_64858_/X }
C {devices/lab_pin.sym} 42100 -37560 0 0 {name=p41267 lab=_85527_/Q }
C {devices/lab_pin.sym} 42100 -37520 0 0 {name=p41268 lab=_64859_/X }
C {devices/lab_pin.sym} 42100 -37480 0 0 {name=p41269 lab=_64874_/X }
C {devices/lab_pin.sym} 42260 -37540 0 1 {name=p41270 lab=_64875_/X }
C {sky130_stdcells/a211o_4.sym} 42180 -37540 0 0 {name=X_64875_ }
C {devices/lab_pin.sym} 42100 -37420 0 0 {name=p41271 lab=_87020_/Q }
C {devices/lab_pin.sym} 42100 -37380 0 0 {name=p41272 lab=_69277_/X }
C {devices/lab_pin.sym} 42100 -37340 0 0 {name=p41273 lab=_69278_/X }
C {devices/lab_pin.sym} 42100 -37300 0 0 {name=p41274 lab=_69401_/X }
C {devices/lab_pin.sym} 42260 -37360 0 1 {name=p41275 lab=_69402_/X }
C {sky130_stdcells/a211o_4.sym} 42180 -37360 0 0 {name=X_69402_ }
C {devices/lab_pin.sym} 42140 -37210 0 0 {name=p41276 lab=_59802_/X }
C {devices/lab_pin.sym} 42220 -37210 0 1 {name=p41277 lab=_66614_/X }
C {sky130_stdcells/buf_2.sym} 42180 -37210 0 0 {name=X_66614_ }
C {devices/lab_pin.sym} 42120 -37100 0 0 {name=p41278 lab=_51820_/A }
C {devices/lab_pin.sym} 42120 -37060 0 0 {name=p41279 lab=_50976_/B }
C {devices/lab_pin.sym} 42240 -37080 0 1 {name=p41280 lab=_51840_/Y }
C {sky130_stdcells/nand2_4.sym} 42180 -37080 0 0 {name=X_51840_ }
C {devices/lab_pin.sym} 42140 -36950 0 0 {name=p41281 lab=_64172_/B }
C {devices/lab_pin.sym} 42220 -36950 0 1 {name=p41282 lab=_63877_/B }
C {sky130_stdcells/buf_2.sym} 42180 -36950 0 0 {name=X_63826_ }
C {devices/lab_pin.sym} 42090 -36830 0 0 {name=p41283 lab=_82596_/CLK }
C {devices/lab_pin.sym} 42090 -36810 0 0 {name=p41284 lab=_78330_/B }
C {devices/lab_pin.sym} 42270 -36830 0 1 {name=p41285 lab=_82660_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -36820 0 0 {name=X_82660_ }
C {devices/lab_pin.sym} 42140 -36690 0 0 {name=p41286 lab=_67120_/X }
C {devices/lab_pin.sym} 42220 -36690 0 1 {name=p41287 lab=_67594_/X }
C {sky130_stdcells/buf_2.sym} 42180 -36690 0 0 {name=X_67594_ }
C {devices/lab_pin.sym} 42090 -36570 0 0 {name=p41288 lab=_81632_/CLK }
C {devices/lab_pin.sym} 42090 -36550 0 0 {name=p41289 lab=_81611_/D }
C {devices/lab_pin.sym} 42270 -36570 0 1 {name=p41290 lab=_81803_/D }
C {sky130_stdcells/dfxtp_4.sym} 42180 -36560 0 0 {name=X_81611_ }
C {devices/lab_pin.sym} 42100 -36460 0 0 {name=p41291 lab=_87525_/Q }
C {devices/lab_pin.sym} 42100 -36420 0 0 {name=p41292 lab=_69098_/X }
C {devices/lab_pin.sym} 42100 -36380 0 0 {name=p41293 lab=_69124_/X }
C {devices/lab_pin.sym} 42100 -36340 0 0 {name=p41294 lab=_69332_/X }
C {devices/lab_pin.sym} 42260 -36400 0 1 {name=p41295 lab=_69333_/X }
C {sky130_stdcells/a211o_4.sym} 42180 -36400 0 0 {name=X_69333_ }
C {devices/lab_pin.sym} 42100 -36280 0 0 {name=p41296 lab=_87443_/Q }
C {devices/lab_pin.sym} 42100 -36240 0 0 {name=p41297 lab=_66538_/X }
C {devices/lab_pin.sym} 42100 -36200 0 0 {name=p41298 lab=_66540_/X }
C {devices/lab_pin.sym} 42100 -36160 0 0 {name=p41299 lab=_66544_/X }
C {devices/lab_pin.sym} 42260 -36220 0 1 {name=p41300 lab=_66545_/X }
C {sky130_stdcells/a211o_4.sym} 42180 -36220 0 0 {name=X_66545_ }
C {devices/lab_pin.sym} 42100 -36090 0 0 {name=p41301 lab=_85949_/Q }
C {devices/lab_pin.sym} 42100 -36050 0 0 {name=p41302 lab=_51763_/X }
C {devices/lab_pin.sym} 42100 -36010 0 0 {name=p41303 lab=_51770_/Y }
C {devices/lab_pin.sym} 42260 -36050 0 1 {name=p41304 lab=_51771_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -36050 0 0 {name=X_51771_ }
C {devices/lab_pin.sym} 42120 -35940 0 0 {name=p41305 lab=_64223_/B }
C {devices/lab_pin.sym} 42120 -35900 0 0 {name=p41306 lab=_64192_/B }
C {devices/lab_pin.sym} 42120 -35860 0 0 {name=p41307 lab=_63757_/C }
C {devices/lab_pin.sym} 42120 -35820 0 0 {name=p41308 lab=_64192_/D }
C {devices/lab_pin.sym} 42240 -35880 0 1 {name=p41309 lab=_63757_/Y }
C {sky130_stdcells/nand4_4.sym} 42180 -35880 0 0 {name=X_63757_ }
C {devices/lab_pin.sym} 42090 -35730 0 0 {name=p41310 lab=_82671_/CLK }
C {devices/lab_pin.sym} 42090 -35710 0 0 {name=p41311 lab=_82623_/Q }
C {devices/lab_pin.sym} 42270 -35730 0 1 {name=p41312 lab=_78296_/A }
C {sky130_stdcells/dfxtp_4.sym} 42180 -35720 0 0 {name=X_82591_ }
C {devices/lab_pin.sym} 42140 -35590 0 0 {name=p41313 lab=_59831_/X }
C {devices/lab_pin.sym} 42220 -35590 0 1 {name=p41314 lab=_60969_/X }
C {sky130_stdcells/buf_2.sym} 42180 -35590 0 0 {name=X_60969_ }
C {devices/lab_pin.sym} 42100 -35490 0 0 {name=p41315 lab=_85623_/Q }
C {devices/lab_pin.sym} 42100 -35450 0 0 {name=p41316 lab=_53506_/X }
C {devices/lab_pin.sym} 42100 -35410 0 0 {name=p41317 lab=_53509_/Y }
C {devices/lab_pin.sym} 42260 -35450 0 1 {name=p41318 lab=_53510_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -35450 0 0 {name=X_53510_ }
C {devices/lab_pin.sym} 42090 -35310 0 0 {name=p41319 lab=_84350_/CLK }
C {devices/lab_pin.sym} 42090 -35290 0 0 {name=p41320 lab=_63353_/Y }
C {devices/lab_pin.sym} 42270 -35310 0 1 {name=p41321 lab=_79158_/B }
C {sky130_stdcells/dfxtp_4.sym} 42180 -35300 0 0 {name=X_84330_ }
C {devices/lab_pin.sym} 42100 -35190 0 0 {name=p41322 lab=_86146_/Q }
C {devices/lab_pin.sym} 42100 -35150 0 0 {name=p41323 lab=_50654_/X }
C {devices/lab_pin.sym} 42100 -35110 0 0 {name=p41324 lab=_50721_/Y }
C {devices/lab_pin.sym} 42260 -35150 0 1 {name=p41325 lab=_50722_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -35150 0 0 {name=X_50722_ }
C {devices/lab_pin.sym} 42140 -35010 0 0 {name=p41326 lab=_60309_/D }
C {devices/lab_pin.sym} 42220 -35010 0 1 {name=p41327 lab=_62708_/X }
C {sky130_stdcells/buf_2.sym} 42180 -35010 0 0 {name=X_62708_ }
C {devices/lab_pin.sym} 42090 -34890 0 0 {name=p41328 lab=_82053_/CLK }
C {devices/lab_pin.sym} 42090 -34870 0 0 {name=p41329 lab=_76689_/X }
C {devices/lab_pin.sym} 42270 -34890 0 1 {name=p41330 lab=_81542_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -34880 0 0 {name=X_81542_ }
C {devices/lab_pin.sym} 42100 -34770 0 0 {name=p41331 lab=_69260_/X }
C {devices/lab_pin.sym} 42100 -34730 0 0 {name=p41332 lab=_69263_/X }
C {devices/lab_pin.sym} 42100 -34690 0 0 {name=p41333 lab=_69251_/X }
C {devices/lab_pin.sym} 42260 -34730 0 1 {name=p41334 lab=_69264_/X }
C {sky130_stdcells/a21o_4.sym} 42180 -34730 0 0 {name=X_69264_ }
C {devices/lab_pin.sym} 42100 -34610 0 0 {name=p41335 lab=_54488_/Y }
C {devices/lab_pin.sym} 42100 -34570 0 0 {name=p41336 lab=_54475_/X }
C {devices/lab_pin.sym} 42100 -34530 0 0 {name=p41337 lab=_54489_/X }
C {devices/lab_pin.sym} 42260 -34570 0 1 {name=p41338 lab=_54490_/Y }
C {sky130_stdcells/a21oi_4.sym} 42180 -34570 0 0 {name=X_54490_ }
C {devices/lab_pin.sym} 42120 -34450 0 0 {name=p41339 lab=_65177_/X }
C {devices/lab_pin.sym} 42120 -34410 0 0 {name=p41340 lab=_66476_/B }
C {devices/lab_pin.sym} 42120 -34370 0 0 {name=p41341 lab=_65180_/X }
C {devices/lab_pin.sym} 42240 -34410 0 1 {name=p41342 lab=_66476_/Y }
C {sky130_stdcells/nand3_4.sym} 42180 -34410 0 0 {name=X_66476_ }
C {devices/lab_pin.sym} 42100 -34310 0 0 {name=p41343 lab=_63624_/X }
C {devices/lab_pin.sym} 42100 -34270 0 0 {name=p41344 lab=_63682_/X }
C {devices/lab_pin.sym} 42100 -34230 0 0 {name=p41345 lab=_63683_/X }
C {devices/lab_pin.sym} 42100 -34190 0 0 {name=p41346 lab=_63686_/X }
C {devices/lab_pin.sym} 42100 -34150 0 0 {name=p41347 lab=_63687_/Y }
C {devices/lab_pin.sym} 42260 -34230 0 1 {name=p41348 lab=_63688_/Y }
C {sky130_stdcells/o41ai_4.sym} 42180 -34230 0 0 {name=X_63688_ }
C {devices/lab_pin.sym} 42100 -34090 0 0 {name=p41349 lab=_82050_/D }
C {devices/lab_pin.sym} 42100 -34050 0 0 {name=p41350 lab=_68200_/X }
C {devices/lab_pin.sym} 42100 -34010 0 0 {name=p41351 lab=_68214_/X }
C {devices/lab_pin.sym} 42260 -34050 0 1 {name=p41352 lab=_68215_/X }
C {sky130_stdcells/a21bo_4.sym} 42180 -34050 0 0 {name=X_68215_ }
C {devices/lab_pin.sym} 42140 -33910 0 0 {name=p41353 lab=_53441_/A }
C {devices/lab_pin.sym} 42220 -33910 0 1 {name=p41354 lab=_53817_/A }
C {sky130_stdcells/buf_2.sym} 42180 -33910 0 0 {name=X_53441_ }
C {devices/lab_pin.sym} 42100 -33810 0 0 {name=p41355 lab=_65424_/X }
C {devices/lab_pin.sym} 42100 -33770 0 0 {name=p41356 lab=_65426_/X }
C {devices/lab_pin.sym} 42100 -33730 0 0 {name=p41357 lab=_65277_/X }
C {devices/lab_pin.sym} 42260 -33770 0 1 {name=p41358 lab=_65427_/X }
C {sky130_stdcells/a21o_4.sym} 42180 -33770 0 0 {name=X_65427_ }
C {devices/lab_pin.sym} 42090 -33630 0 0 {name=p41359 lab=_84314_/CLK }
C {devices/lab_pin.sym} 42090 -33610 0 0 {name=p41360 lab=_64271_/X }
C {devices/lab_pin.sym} 42270 -33630 0 1 {name=p41361 lab=_79837_/B }
C {sky130_stdcells/dfxtp_4.sym} 42180 -33620 0 0 {name=X_84261_ }
C {devices/lab_pin.sym} 42100 -33510 0 0 {name=p41362 lab=_50650_/Y }
C {devices/lab_pin.sym} 42100 -33470 0 0 {name=p41363 lab=_50609_/X }
C {devices/lab_pin.sym} 42100 -33430 0 0 {name=p41364 lab=_50652_/X }
C {devices/lab_pin.sym} 42260 -33470 0 1 {name=p41365 lab=_50653_/Y }
C {sky130_stdcells/a21oi_4.sym} 42180 -33470 0 0 {name=X_50653_ }
C {devices/lab_pin.sym} 42140 -33330 0 0 {name=p41366 lab=_60271_/X }
C {devices/lab_pin.sym} 42220 -33330 0 1 {name=p41367 lab=_62910_/A }
C {sky130_stdcells/inv_2.sym} 42180 -33330 0 0 {name=X_62639_ }
C {devices/lab_pin.sym} 42090 -33210 0 0 {name=p41368 lab=_81473_/CLK }
C {devices/lab_pin.sym} 42090 -33190 0 0 {name=p41369 lab=_76956_/A }
C {devices/lab_pin.sym} 42270 -33210 0 1 {name=p41370 lab=_81473_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -33200 0 0 {name=X_81473_ }
C {devices/lab_pin.sym} 42100 -33090 0 0 {name=p41371 lab=_69192_/X }
C {devices/lab_pin.sym} 42100 -33050 0 0 {name=p41372 lab=_69194_/X }
C {devices/lab_pin.sym} 42100 -33010 0 0 {name=p41373 lab=_69025_/X }
C {devices/lab_pin.sym} 42260 -33050 0 1 {name=p41374 lab=_69195_/X }
C {sky130_stdcells/a21o_4.sym} 42180 -33050 0 0 {name=X_69195_ }
C {devices/lab_pin.sym} 42090 -32910 0 0 {name=p41375 lab=_85712_/CLK }
C {devices/lab_pin.sym} 42090 -32890 0 0 {name=p41376 lab=_86000_/D }
C {devices/lab_pin.sym} 42270 -32910 0 1 {name=p41377 lab=_86000_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -32900 0 0 {name=X_86000_ }
C {devices/lab_pin.sym} 42090 -32770 0 0 {name=p41378 lab=_82272_/CLK }
C {devices/lab_pin.sym} 42090 -32750 0 0 {name=p41379 lab=_83212_/D }
C {devices/lab_pin.sym} 42270 -32770 0 1 {name=p41380 lab=_79184_/B }
C {sky130_stdcells/dfxtp_4.sym} 42180 -32760 0 0 {name=X_83212_ }
C {devices/lab_pin.sym} 42120 -32650 0 0 {name=p41381 lab=_56169_/A }
C {devices/lab_pin.sym} 42120 -32610 0 0 {name=p41382 lab=_56150_/B }
C {devices/lab_pin.sym} 42120 -32570 0 0 {name=p41383 lab=_85285_/Q }
C {devices/lab_pin.sym} 42240 -32610 0 1 {name=p41384 lab=_56160_/Y }
C {sky130_stdcells/nand3_4.sym} 42180 -32610 0 0 {name=X_56160_ }
C {devices/lab_pin.sym} 42120 -32480 0 0 {name=p41385 lab=_80436_/A }
C {devices/lab_pin.sym} 42120 -32440 0 0 {name=p41386 lab=_80436_/B }
C {devices/lab_pin.sym} 42240 -32460 0 1 {name=p41387 lab=_80446_/B }
C {sky130_stdcells/xor2_4.sym} 42180 -32460 0 0 {name=X_80424_ }
C {devices/lab_pin.sym} 42100 -32360 0 0 {name=p41388 lab=_68144_/X }
C {devices/lab_pin.sym} 42100 -32320 0 0 {name=p41389 lab=_66909_/Y }
C {devices/lab_pin.sym} 42100 -32280 0 0 {name=p41390 lab=_68128_/X }
C {devices/lab_pin.sym} 42100 -32240 0 0 {name=p41391 lab=_68145_/Y }
C {devices/lab_pin.sym} 42260 -32300 0 1 {name=p41392 lab=_68146_/X }
C {sky130_stdcells/a211o_4.sym} 42180 -32300 0 0 {name=X_68146_ }
C {devices/lab_pin.sym} 42100 -32170 0 0 {name=p41393 lab=_53370_/Y }
C {devices/lab_pin.sym} 42100 -32130 0 0 {name=p41394 lab=_53355_/X }
C {devices/lab_pin.sym} 42100 -32090 0 0 {name=p41395 lab=_53371_/X }
C {devices/lab_pin.sym} 42260 -32130 0 1 {name=p41396 lab=_85646_/D }
C {sky130_stdcells/a21oi_4.sym} 42180 -32130 0 0 {name=X_53372_ }
C {devices/lab_pin.sym} 42100 -32020 0 0 {name=p41397 lab=_65252_/X }
C {devices/lab_pin.sym} 42100 -31980 0 0 {name=p41398 lab=_83284_/Q }
C {devices/lab_pin.sym} 42100 -31940 0 0 {name=p41399 lab=_65230_/X }
C {devices/lab_pin.sym} 42100 -31900 0 0 {name=p41400 lab=_65357_/X }
C {devices/lab_pin.sym} 42260 -31960 0 1 {name=p41401 lab=_65358_/X }
C {sky130_stdcells/a211o_4.sym} 42180 -31960 0 0 {name=X_65358_ }
C {devices/lab_pin.sym} 42090 -31810 0 0 {name=p41402 lab=_84192_/CLK }
C {devices/lab_pin.sym} 42090 -31790 0 0 {name=p41403 lab=_84192_/D }
C {devices/lab_pin.sym} 42270 -31810 0 1 {name=p41404 lab=_84192_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -31800 0 0 {name=X_84192_ }
C {devices/lab_pin.sym} 42120 -31690 0 0 {name=p41405 lab=_48928_/A }
C {devices/lab_pin.sym} 42120 -31650 0 0 {name=p41406 lab=_50560_/X }
C {devices/lab_pin.sym} 42120 -31610 0 0 {name=p41407 lab=_50568_/C }
C {devices/lab_pin.sym} 42240 -31650 0 1 {name=p41408 lab=_50584_/X }
C {sky130_stdcells/and3_4.sym} 42180 -31650 0 0 {name=X_50584_ }
C {devices/lab_pin.sym} 42100 -31530 0 0 {name=p41409 lab=_85316_/Q }
C {devices/lab_pin.sym} 42100 -31490 0 0 {name=p41410 lab=_55098_/X }
C {devices/lab_pin.sym} 42100 -31450 0 0 {name=p41411 lab=_55110_/Y }
C {devices/lab_pin.sym} 42260 -31490 0 1 {name=p41412 lab=_55111_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -31490 0 0 {name=X_55111_ }
C {devices/lab_pin.sym} 42140 -31350 0 0 {name=p41413 lab=_52515_/A }
C {devices/lab_pin.sym} 42220 -31350 0 1 {name=p41414 lab=_52324_/A }
C {sky130_stdcells/buf_2.sym} 42180 -31350 0 0 {name=X_52323_ }
C {devices/lab_pin.sym} 42120 -31250 0 0 {name=p41415 lab=_64287_/A }
C {devices/lab_pin.sym} 42120 -31210 0 0 {name=p41416 lab=_58535_/A }
C {devices/lab_pin.sym} 42120 -31170 0 0 {name=p41417 lab=_64287_/C }
C {devices/lab_pin.sym} 42240 -31210 0 1 {name=p41418 lab=_64309_/Y }
C {sky130_stdcells/nand3_4.sym} 42180 -31210 0 0 {name=X_64309_ }
C {devices/lab_pin.sym} 42090 -31070 0 0 {name=p41419 lab=_83115_/CLK }
C {devices/lab_pin.sym} 42090 -31050 0 0 {name=p41420 lab=_83143_/D }
C {devices/lab_pin.sym} 42270 -31070 0 1 {name=p41421 lab=_70121_/A }
C {sky130_stdcells/dfxtp_4.sym} 42180 -31060 0 0 {name=X_83143_ }
C {devices/lab_pin.sym} 42120 -30940 0 0 {name=p41422 lab=_80353_/Y }
C {devices/lab_pin.sym} 42120 -30900 0 0 {name=p41423 lab=_80354_/Y }
C {devices/lab_pin.sym} 42240 -30920 0 1 {name=p41424 lab=_80355_/X }
C {sky130_stdcells/xor2_4.sym} 42180 -30920 0 0 {name=X_80355_ }
C {devices/lab_pin.sym} 42120 -30800 0 0 {name=p41425 lab=_68077_/A }
C {devices/lab_pin.sym} 42120 -30760 0 0 {name=p41426 lab=_68077_/B }
C {devices/lab_pin.sym} 42240 -30780 0 1 {name=p41427 lab=_68077_/Y }
C {sky130_stdcells/nand2_4.sym} 42180 -30780 0 0 {name=X_68077_ }
C {devices/lab_pin.sym} 42120 -30670 0 0 {name=p41428 lab=_55993_/Y }
C {devices/lab_pin.sym} 42120 -30630 0 0 {name=p41429 lab=_55994_/X }
C {devices/lab_pin.sym} 42120 -30590 0 0 {name=p41430 lab=_56098_/A }
C {devices/lab_pin.sym} 42240 -30630 0 1 {name=p41431 lab=_56091_/X }
C {sky130_stdcells/and3_4.sym} 42180 -30630 0 0 {name=X_56091_ }
C {devices/lab_pin.sym} 42120 -30500 0 0 {name=p41432 lab=_65289_/A }
C {devices/lab_pin.sym} 42120 -30460 0 0 {name=p41433 lab=_65289_/B }
C {devices/lab_pin.sym} 42240 -30480 0 1 {name=p41434 lab=_65289_/X }
C {sky130_stdcells/and2_4.sym} 42180 -30480 0 0 {name=X_65289_ }
C {devices/lab_pin.sym} 42100 -30370 0 0 {name=p41435 lab=_85329_/Q }
C {devices/lab_pin.sym} 42100 -30330 0 0 {name=p41436 lab=_55020_/X }
C {devices/lab_pin.sym} 42100 -30290 0 0 {name=p41437 lab=_55041_/Y }
C {devices/lab_pin.sym} 42260 -30330 0 1 {name=p41438 lab=_55042_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -30330 0 0 {name=X_55042_ }
C {devices/lab_pin.sym} 42140 -30190 0 0 {name=p41439 lab=clkbuf_6_31_0_CLK/A }
C {devices/lab_pin.sym} 42220 -30190 0 1 {name=p41440 lab=clkbuf_7_61_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 42180 -30190 0 0 {name=Xclkbuf_6_30_0_CLK }
C {devices/lab_pin.sym} 42120 -30080 0 0 {name=p41441 lab=_67028_/A }
C {devices/lab_pin.sym} 42120 -30040 0 0 {name=p41442 lab=_67028_/B }
C {devices/lab_pin.sym} 42240 -30060 0 1 {name=p41443 lab=_67028_/X }
C {sky130_stdcells/and2_4.sym} 42180 -30060 0 0 {name=X_67028_ }
C {devices/lab_pin.sym} 42100 -29950 0 0 {name=p41444 lab=_52251_/Y }
C {devices/lab_pin.sym} 42100 -29910 0 0 {name=p41445 lab=_52232_/X }
C {devices/lab_pin.sym} 42100 -29870 0 0 {name=p41446 lab=_52253_/X }
C {devices/lab_pin.sym} 42260 -29910 0 1 {name=p41447 lab=_85859_/D }
C {sky130_stdcells/a21oi_4.sym} 42180 -29910 0 0 {name=X_52254_ }
C {devices/lab_pin.sym} 42090 -29770 0 0 {name=p41448 lab=_85593_/CLK }
C {devices/lab_pin.sym} 42090 -29750 0 0 {name=p41449 lab=_74402_/Y }
C {devices/lab_pin.sym} 42270 -29770 0 1 {name=p41450 lab=_83074_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -29760 0 0 {name=X_83074_ }
C {devices/lab_pin.sym} 42090 -29630 0 0 {name=p41451 lab=_87950_/CLK }
C {devices/lab_pin.sym} 42090 -29610 0 0 {name=p41452 lab=_42264_/X }
C {devices/lab_pin.sym} 42270 -29630 0 1 {name=p41453 lab=_87951_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -29620 0 0 {name=X_87951_ }
C {devices/lab_pin.sym} 42120 -29500 0 0 {name=p41454 lab=_80280_/Y }
C {devices/lab_pin.sym} 42120 -29460 0 0 {name=p41455 lab=_80286_/B }
C {devices/lab_pin.sym} 42240 -29480 0 1 {name=p41456 lab=_80288_/B }
C {sky130_stdcells/nand2_4.sym} 42180 -29480 0 0 {name=X_80286_ }
C {devices/lab_pin.sym} 42120 -29360 0 0 {name=p41457 lab=_51184_/X }
C {devices/lab_pin.sym} 42120 -29320 0 0 {name=p41458 lab=_47174_/X }
C {devices/lab_pin.sym} 42240 -29340 0 1 {name=p41459 lab=_51205_/Y }
C {sky130_stdcells/nand2_4.sym} 42180 -29340 0 0 {name=X_51205_ }
C {devices/lab_pin.sym} 42090 -29210 0 0 {name=p41460 lab=_83022_/CLK }
C {devices/lab_pin.sym} 42090 -29190 0 0 {name=p41461 lab=_45055_/Y }
C {devices/lab_pin.sym} 42270 -29210 0 1 {name=p41462 lab=_64320_/B }
C {sky130_stdcells/dfxtp_4.sym} 42180 -29200 0 0 {name=X_86902_ }
C {devices/lab_pin.sym} 42090 -29070 0 0 {name=p41463 lab=_81989_/CLK }
C {devices/lab_pin.sym} 42090 -29050 0 0 {name=p41464 lab=_77792_/B }
C {devices/lab_pin.sym} 42270 -29070 0 1 {name=p41465 lab=_81993_/D }
C {sky130_stdcells/dfxtp_4.sym} 42180 -29060 0 0 {name=X_82025_ }
C {devices/lab_pin.sym} 42100 -28950 0 0 {name=p41466 lab=_59687_/A }
C {devices/lab_pin.sym} 42100 -28910 0 0 {name=p41467 lab=_59683_/A }
C {devices/lab_pin.sym} 42100 -28870 0 0 {name=p41468 lab=_59666_/A }
C {devices/lab_pin.sym} 42260 -28910 0 1 {name=p41469 lab=_59850_/Y }
C {sky130_stdcells/a21oi_4.sym} 42180 -28910 0 0 {name=X_59850_ }
C {devices/lab_pin.sym} 42140 -28770 0 0 {name=p41470 lab=_52185_/A }
C {devices/lab_pin.sym} 42220 -28770 0 1 {name=p41471 lab=_52185_/X }
C {sky130_stdcells/buf_2.sym} 42180 -28770 0 0 {name=X_52185_ }
C {devices/lab_pin.sym} 42090 -28650 0 0 {name=p41472 lab=_87883_/CLK }
C {devices/lab_pin.sym} 42090 -28630 0 0 {name=p41473 lab=_87882_/D }
C {devices/lab_pin.sym} 42270 -28650 0 1 {name=p41474 lab=_87882_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -28640 0 0 {name=X_87882_ }
C {devices/lab_pin.sym} 42120 -28520 0 0 {name=p41475 lab=_86703_/Q }
C {devices/lab_pin.sym} 42120 -28480 0 0 {name=p41476 lab=_58764_/B }
C {devices/lab_pin.sym} 42240 -28500 0 1 {name=p41477 lab=_58801_/Y }
C {sky130_stdcells/nor2_4.sym} 42180 -28500 0 0 {name=X_58801_ }
C {devices/lab_pin.sym} 42140 -28370 0 0 {name=p41478 lab=_51191_/A }
C {devices/lab_pin.sym} 42220 -28370 0 1 {name=p41479 lab=_51160_/A }
C {sky130_stdcells/buf_2.sym} 42180 -28370 0 0 {name=X_51136_ }
C {devices/lab_pin.sym} 42090 -28250 0 0 {name=p41480 lab=_88398_/CLK }
C {devices/lab_pin.sym} 42090 -28230 0 0 {name=p41481 lab=_86833_/D }
C {devices/lab_pin.sym} 42270 -28250 0 1 {name=p41482 lab=_66700_/B }
C {sky130_stdcells/dfxtp_4.sym} 42180 -28240 0 0 {name=X_86833_ }
C {devices/lab_pin.sym} 42140 -28110 0 0 {name=p41483 lab=_69814_/A }
C {devices/lab_pin.sym} 42220 -28110 0 1 {name=p41484 lab=_70056_/A }
C {sky130_stdcells/buf_2.sym} 42180 -28110 0 0 {name=X_59781_ }
C {devices/lab_pin.sym} 42100 -28030 0 0 {name=p41485 lab=_56737_/X }
C {devices/lab_pin.sym} 42100 -27990 0 0 {name=p41486 lab=_57149_/C }
C {devices/lab_pin.sym} 42100 -27950 0 0 {name=p41487 lab=_56735_/X }
C {devices/lab_pin.sym} 42100 -27910 0 0 {name=p41488 lab=_56994_/D }
C {devices/lab_pin.sym} 42100 -27880 0 0 {name=p41489 lab=_56726_/X }
C {devices/lab_pin.sym} 42260 -27950 0 1 {name=p41490 lab=_56993_/X }
C {sky130_stdcells/a41o_4.sym} 42180 -27950 0 0 {name=X_56993_ }
C {devices/lab_pin.sym} 42140 -27790 0 0 {name=p41491 lab=_68517_/A }
C {devices/lab_pin.sym} 42220 -27790 0 1 {name=p41492 lab=_68979_/X }
C {sky130_stdcells/buf_2.sym} 42180 -27790 0 0 {name=X_68979_ }
C {devices/lab_pin.sym} 42140 -27670 0 0 {name=p41493 lab=clkbuf_9_277_0_CLK/X }
C {devices/lab_pin.sym} 42220 -27670 0 1 {name=p41494 lab=_87472_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 42180 -27670 0 0 {name=Xclkbuf_10_554_0_CLK }
C {devices/lab_pin.sym} 42140 -27550 0 0 {name=p41495 lab=clkbuf_6_45_0_CLK/A }
C {devices/lab_pin.sym} 42220 -27550 0 1 {name=p41496 lab=clkbuf_7_91_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 42180 -27550 0 0 {name=Xclkbuf_6_45_0_CLK }
C {devices/lab_pin.sym} 42100 -27450 0 0 {name=p41497 lab=_58703_/X }
C {devices/lab_pin.sym} 42100 -27410 0 0 {name=p41498 lab=_85460_/Q }
C {devices/lab_pin.sym} 42100 -27370 0 0 {name=p41499 lab=_58731_/X }
C {devices/lab_pin.sym} 42260 -27410 0 1 {name=p41500 lab=_58732_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -27410 0 0 {name=X_58732_ }
C {devices/lab_pin.sym} 42120 -27300 0 0 {name=p41501 lab=_51056_/A }
C {devices/lab_pin.sym} 42120 -27260 0 0 {name=p41502 lab=_51071_/B }
C {devices/lab_pin.sym} 42120 -27220 0 0 {name=p41503 lab=_51071_/C }
C {devices/lab_pin.sym} 42120 -27180 0 0 {name=p41504 lab=_52758_/D }
C {devices/lab_pin.sym} 42240 -27240 0 1 {name=p41505 lab=_51067_/X }
C {sky130_stdcells/and4_4.sym} 42180 -27240 0 0 {name=X_51067_ }
C {devices/lab_pin.sym} 42100 -27120 0 0 {name=p41506 lab=_44989_/A }
C {devices/lab_pin.sym} 42100 -27080 0 0 {name=p41507 lab=_55619_/A }
C {devices/lab_pin.sym} 42100 -27040 0 0 {name=p41508 lab=_44102_/A }
C {devices/lab_pin.sym} 42100 -27000 0 0 {name=p41509 lab=_55943_/X }
C {devices/lab_pin.sym} 42260 -27060 0 1 {name=p41510 lab=_55945_/B }
C {sky130_stdcells/a211o_4.sym} 42180 -27060 0 0 {name=X_55944_ }
C {devices/lab_pin.sym} 42090 -26910 0 0 {name=p41511 lab=_80657_/CLK }
C {devices/lab_pin.sym} 42090 -26890 0 0 {name=p41512 lab=_46185_/X }
C {devices/lab_pin.sym} 42270 -26910 0 1 {name=p41513 lab=_86764_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -26900 0 0 {name=X_86764_ }
C {devices/lab_pin.sym} 42100 -26790 0 0 {name=p41514 lab=_71988_/Y }
C {devices/lab_pin.sym} 42100 -26750 0 0 {name=p41515 lab=_71969_/X }
C {devices/lab_pin.sym} 42100 -26710 0 0 {name=p41516 lab=_71989_/Y }
C {devices/lab_pin.sym} 42260 -26750 0 1 {name=p41517 lab=_71990_/Y }
C {sky130_stdcells/a21boi_4.sym} 42180 -26750 0 0 {name=X_71990_ }
C {devices/lab_pin.sym} 42090 -26610 0 0 {name=p41518 lab=_80961_/CLK }
C {devices/lab_pin.sym} 42090 -26590 0 0 {name=p41519 lab=_68413_/X }
C {devices/lab_pin.sym} 42270 -26610 0 1 {name=p41520 lab=_83976_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -26600 0 0 {name=X_83976_ }
C {devices/lab_pin.sym} 42120 -26480 0 0 {name=p41521 lab=_50027_/A }
C {devices/lab_pin.sym} 42120 -26440 0 0 {name=p41522 lab=_53232_/B }
C {devices/lab_pin.sym} 42240 -26460 0 1 {name=p41523 lab=_50018_/Y }
C {sky130_stdcells/nand2_4.sym} 42180 -26460 0 0 {name=X_50018_ }
C {devices/lab_pin.sym} 42090 -26330 0 0 {name=p41524 lab=_84766_/CLK }
C {devices/lab_pin.sym} 42090 -26310 0 0 {name=p41525 lab=_53004_/Y }
C {devices/lab_pin.sym} 42270 -26330 0 1 {name=p41526 lab=_85715_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -26320 0 0 {name=X_85715_ }
C {devices/lab_pin.sym} 42100 -26210 0 0 {name=p41527 lab=_51235_/B }
C {devices/lab_pin.sym} 42100 -26170 0 0 {name=p41528 lab=_70937_/X }
C {devices/lab_pin.sym} 42100 -26130 0 0 {name=p41529 lab=_70940_/Y }
C {devices/lab_pin.sym} 42260 -26170 0 1 {name=p41530 lab=_83657_/D }
C {sky130_stdcells/o21ai_4.sym} 42180 -26170 0 0 {name=X_70941_ }
C {devices/lab_pin.sym} 42140 -26030 0 0 {name=p41531 lab=_84809_/Q }
C {devices/lab_pin.sym} 42220 -26030 0 1 {name=p41532 lab=_58663_/Y }
C {sky130_stdcells/inv_2.sym} 42180 -26030 0 0 {name=X_58663_ }
C {devices/lab_pin.sym} 42090 -25910 0 0 {name=p41533 lab=_82933_/CLK }
C {devices/lab_pin.sym} 42090 -25890 0 0 {name=p41534 lab=_78226_/X }
C {devices/lab_pin.sym} 42270 -25910 0 1 {name=p41535 lab=_46459_/A }
C {sky130_stdcells/dfxtp_4.sym} 42180 -25900 0 0 {name=X_82927_ }
C {devices/lab_pin.sym} 42100 -25800 0 0 {name=p41536 lab=_56223_/C }
C {devices/lab_pin.sym} 42100 -25760 0 0 {name=p41537 lab=_44064_/X }
C {devices/lab_pin.sym} 42100 -25720 0 0 {name=p41538 lab=_44049_/X }
C {devices/lab_pin.sym} 42100 -25680 0 0 {name=p41539 lab=_55874_/X }
C {devices/lab_pin.sym} 42260 -25740 0 1 {name=p41540 lab=_55875_/X }
C {sky130_stdcells/a211o_4.sym} 42180 -25740 0 0 {name=X_55875_ }
C {devices/lab_pin.sym} 42090 -25590 0 0 {name=p41541 lab=_86695_/CLK }
C {devices/lab_pin.sym} 42090 -25570 0 0 {name=p41542 lab=_86695_/D }
C {devices/lab_pin.sym} 42270 -25590 0 1 {name=p41543 lab=_86695_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -25580 0 0 {name=X_86695_ }
C {devices/lab_pin.sym} 42100 -25470 0 0 {name=p41544 lab=_57612_/Y }
C {devices/lab_pin.sym} 42100 -25430 0 0 {name=p41545 lab=_57581_/X }
C {devices/lab_pin.sym} 42100 -25390 0 0 {name=p41546 lab=_57613_/Y }
C {devices/lab_pin.sym} 42260 -25430 0 1 {name=p41547 lab=_57614_/Y }
C {sky130_stdcells/a21boi_4.sym} 42180 -25430 0 0 {name=X_57614_ }
C {devices/lab_pin.sym} 42140 -25290 0 0 {name=p41548 lab=_42839_/Y }
C {devices/lab_pin.sym} 42220 -25290 0 1 {name=p41549 lab=_87692_/D }
C {sky130_stdcells/inv_2.sym} 42180 -25290 0 0 {name=X_42840_ }
C {devices/lab_pin.sym} 42100 -25190 0 0 {name=p41550 lab=_54824_/Y }
C {devices/lab_pin.sym} 42100 -25150 0 0 {name=p41551 lab=_54802_/X }
C {devices/lab_pin.sym} 42100 -25110 0 0 {name=p41552 lab=_54825_/X }
C {devices/lab_pin.sym} 42260 -25150 0 1 {name=p41553 lab=_54826_/Y }
C {sky130_stdcells/a21oi_4.sym} 42180 -25150 0 0 {name=X_54826_ }
C {devices/lab_pin.sym} 42090 -25010 0 0 {name=p41554 lab=_85648_/CLK }
C {devices/lab_pin.sym} 42090 -24990 0 0 {name=p41555 lab=_85646_/D }
C {devices/lab_pin.sym} 42270 -25010 0 1 {name=p41556 lab=_85646_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -25000 0 0 {name=X_85646_ }
C {devices/lab_pin.sym} 42100 -24900 0 0 {name=p41557 lab=_73605_/X }
C {devices/lab_pin.sym} 42100 -24860 0 0 {name=p41558 lab=_86237_/Q }
C {devices/lab_pin.sym} 42100 -24820 0 0 {name=p41559 lab=_44194_/X }
C {devices/lab_pin.sym} 42100 -24780 0 0 {name=p41560 lab=_73659_/X }
C {devices/lab_pin.sym} 42260 -24840 0 1 {name=p41561 lab=_73660_/X }
C {sky130_stdcells/a211o_4.sym} 42180 -24840 0 0 {name=X_73660_ }
C {devices/lab_pin.sym} 42140 -24690 0 0 {name=p41562 lab=_58928_/A }
C {devices/lab_pin.sym} 42220 -24690 0 1 {name=p41563 lab=_58594_/X }
C {sky130_stdcells/buf_2.sym} 42180 -24690 0 0 {name=X_58594_ }
C {devices/lab_pin.sym} 42100 -24590 0 0 {name=p41564 lab=_51812_/B }
C {devices/lab_pin.sym} 42100 -24550 0 0 {name=p41565 lab=_70855_/X }
C {devices/lab_pin.sym} 42100 -24510 0 0 {name=p41566 lab=_70871_/Y }
C {devices/lab_pin.sym} 42260 -24550 0 1 {name=p41567 lab=_70872_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -24550 0 0 {name=X_70872_ }
C {devices/lab_pin.sym} 42090 -24410 0 0 {name=p41568 lab=_82855_/CLK }
C {devices/lab_pin.sym} 42090 -24390 0 0 {name=p41569 lab=_82858_/D }
C {devices/lab_pin.sym} 42270 -24410 0 1 {name=p41570 lab=_40888_/A }
C {sky130_stdcells/dfxtp_4.sym} 42180 -24400 0 0 {name=X_82858_ }
C {devices/lab_pin.sym} 42140 -24270 0 0 {name=p41571 lab=clkbuf_9_284_0_CLK/X }
C {devices/lab_pin.sym} 42220 -24270 0 1 {name=p41572 lab=_88376_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 42180 -24270 0 0 {name=Xclkbuf_10_569_0_CLK }
C {devices/lab_pin.sym} 42100 -24180 0 0 {name=p41573 lab=_83217_/Q }
C {devices/lab_pin.sym} 42100 -24140 0 0 {name=p41574 lab=_72590_/X }
C {devices/lab_pin.sym} 42100 -24100 0 0 {name=p41575 lab=_72585_/A }
C {devices/lab_pin.sym} 42100 -24060 0 0 {name=p41576 lab=_72610_/X }
C {devices/lab_pin.sym} 42260 -24120 0 1 {name=p41577 lab=_72611_/X }
C {sky130_stdcells/o22a_4.sym} 42180 -24120 0 0 {name=X_72611_ }
C {devices/lab_pin.sym} 42100 -23990 0 0 {name=p41578 lab=_57542_/Y }
C {devices/lab_pin.sym} 42100 -23950 0 0 {name=p41579 lab=_57543_/X }
C {devices/lab_pin.sym} 42100 -23910 0 0 {name=p41580 lab=_57544_/Y }
C {devices/lab_pin.sym} 42260 -23950 0 1 {name=p41581 lab=_57545_/Y }
C {sky130_stdcells/a21boi_4.sym} 42180 -23950 0 0 {name=X_57545_ }
C {devices/lab_pin.sym} 42090 -23810 0 0 {name=p41582 lab=_81260_/CLK }
C {devices/lab_pin.sym} 42090 -23790 0 0 {name=p41583 lab=_81809_/D }
C {devices/lab_pin.sym} 42270 -23810 0 1 {name=p41584 lab=_47378_/A }
C {sky130_stdcells/dfxtp_4.sym} 42180 -23800 0 0 {name=X_81809_ }
C {devices/lab_pin.sym} 42100 -23700 0 0 {name=p41585 lab=_41312_/X }
C {devices/lab_pin.sym} 42100 -23660 0 0 {name=p41586 lab=_42767_/X }
C {devices/lab_pin.sym} 42100 -23620 0 0 {name=p41587 lab=_67451_/B }
C {devices/lab_pin.sym} 42100 -23580 0 0 {name=p41588 lab=_42768_/X }
C {devices/lab_pin.sym} 42260 -23640 0 1 {name=p41589 lab=_42771_/X }
C {sky130_stdcells/a2bb2o_4.sym} 42180 -23640 0 0 {name=X_42771_ }
C {devices/lab_pin.sym} 42090 -23490 0 0 {name=p41590 lab=_83139_/CLK }
C {devices/lab_pin.sym} 42090 -23470 0 0 {name=p41591 lab=_40618_/X }
C {devices/lab_pin.sym} 42270 -23490 0 1 {name=p41592 lab=_88365_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -23480 0 0 {name=X_88365_ }
C {devices/lab_pin.sym} 42140 -23350 0 0 {name=p41593 lab=_54729_/A }
C {devices/lab_pin.sym} 42220 -23350 0 1 {name=p41594 lab=_54757_/X }
C {sky130_stdcells/buf_2.sym} 42180 -23350 0 0 {name=X_54757_ }
C {devices/lab_pin.sym} 42120 -23240 0 0 {name=p41595 lab=_73591_/A }
C {devices/lab_pin.sym} 42120 -23200 0 0 {name=p41596 lab=_73591_/B }
C {devices/lab_pin.sym} 42240 -23220 0 1 {name=p41597 lab=_73591_/X }
C {sky130_stdcells/xor2_4.sym} 42180 -23220 0 0 {name=X_73591_ }
C {devices/lab_pin.sym} 42090 -23090 0 0 {name=p41598 lab=_83564_/CLK }
C {devices/lab_pin.sym} 42090 -23070 0 0 {name=p41599 lab=_53744_/Y }
C {devices/lab_pin.sym} 42270 -23090 0 1 {name=p41600 lab=_85577_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -23080 0 0 {name=X_85577_ }
C {devices/lab_pin.sym} 42100 -22970 0 0 {name=p41601 lab=_51967_/Y }
C {devices/lab_pin.sym} 42100 -22930 0 0 {name=p41602 lab=_51934_/X }
C {devices/lab_pin.sym} 42100 -22890 0 0 {name=p41603 lab=_51968_/Y }
C {devices/lab_pin.sym} 42260 -22930 0 1 {name=p41604 lab=_85915_/D }
C {sky130_stdcells/a21boi_4.sym} 42180 -22930 0 0 {name=X_51969_ }
C {devices/lab_pin.sym} 42090 -22790 0 0 {name=p41605 lab=_82792_/CLK }
C {devices/lab_pin.sym} 42090 -22770 0 0 {name=p41606 lab=_82821_/Q }
C {devices/lab_pin.sym} 42270 -22790 0 1 {name=p41607 lab=_82789_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -22780 0 0 {name=X_82789_ }
C {devices/lab_pin.sym} 42100 -22680 0 0 {name=p41608 lab=_41281_/Y }
C {devices/lab_pin.sym} 42100 -22640 0 0 {name=p41609 lab=_44502_/X }
C {devices/lab_pin.sym} 42100 -22600 0 0 {name=p41610 lab=_87072_/Q }
C {devices/lab_pin.sym} 42100 -22560 0 0 {name=p41611 lab=_44503_/X }
C {devices/lab_pin.sym} 42260 -22620 0 1 {name=p41612 lab=_87072_/D }
C {sky130_stdcells/a2bb2o_4.sym} 42180 -22620 0 0 {name=X_44510_ }
C {devices/lab_pin.sym} 42140 -22470 0 0 {name=p41613 lab=_81076_/Q }
C {devices/lab_pin.sym} 42220 -22470 0 1 {name=p41614 lab=_75330_/Y }
C {sky130_stdcells/inv_2.sym} 42180 -22470 0 0 {name=X_75330_ }
C {devices/lab_pin.sym} 42090 -22350 0 0 {name=p41615 lab=_88084_/CLK }
C {devices/lab_pin.sym} 42090 -22330 0 0 {name=p41616 lab=_43677_/Y }
C {devices/lab_pin.sym} 42270 -22350 0 1 {name=p41617 lab=_87316_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -22340 0 0 {name=X_87316_ }
C {devices/lab_pin.sym} 42100 -22230 0 0 {name=p41618 lab=_53706_/Y }
C {devices/lab_pin.sym} 42100 -22190 0 0 {name=p41619 lab=_53696_/X }
C {devices/lab_pin.sym} 42100 -22150 0 0 {name=p41620 lab=_53707_/Y }
C {devices/lab_pin.sym} 42260 -22190 0 1 {name=p41621 lab=_85584_/D }
C {sky130_stdcells/a21boi_4.sym} 42180 -22190 0 0 {name=X_53708_ }
C {devices/lab_pin.sym} 42140 -22050 0 0 {name=p41622 lab=_41799_/A }
C {devices/lab_pin.sym} 42220 -22050 0 1 {name=p41623 lab=_41722_/X }
C {sky130_stdcells/buf_2.sym} 42180 -22050 0 0 {name=X_41722_ }
C {devices/lab_pin.sym} 42120 -21950 0 0 {name=p41624 lab=_72579_/B }
C {devices/lab_pin.sym} 42120 -21910 0 0 {name=p41625 lab=_72516_/C }
C {devices/lab_pin.sym} 42120 -21870 0 0 {name=p41626 lab=_72506_/C }
C {devices/lab_pin.sym} 42240 -21910 0 1 {name=p41627 lab=_72584_/A }
C {sky130_stdcells/nand3_4.sym} 42180 -21910 0 0 {name=X_72542_ }
C {devices/lab_pin.sym} 42090 -21770 0 0 {name=p41628 lab=_84400_/CLK }
C {devices/lab_pin.sym} 42090 -21750 0 0 {name=p41629 lab=_61050_/X }
C {devices/lab_pin.sym} 42270 -21770 0 1 {name=p41630 lab=_76976_/A }
C {sky130_stdcells/dfxtp_4.sym} 42180 -21760 0 0 {name=X_84528_ }
C {devices/lab_pin.sym} 42120 -21640 0 0 {name=p41631 lab=_85051_/Q }
C {devices/lab_pin.sym} 42120 -21600 0 0 {name=p41632 lab=_45490_/B }
C {devices/lab_pin.sym} 42240 -21620 0 1 {name=p41633 lab=_45490_/Y }
C {sky130_stdcells/nor2_4.sym} 42180 -21620 0 0 {name=X_45490_ }
C {devices/lab_pin.sym} 42100 -21520 0 0 {name=p41634 lab=_74139_/A }
C {devices/lab_pin.sym} 42100 -21480 0 0 {name=p41635 lab=_57067_/Y }
C {devices/lab_pin.sym} 42100 -21440 0 0 {name=p41636 lab=_57465_/A }
C {devices/lab_pin.sym} 42100 -21400 0 0 {name=p41637 lab=_56892_/B }
C {devices/lab_pin.sym} 42260 -21460 0 1 {name=p41638 lab=_57476_/X }
C {sky130_stdcells/a211o_4.sym} 42180 -21460 0 0 {name=X_57476_ }
C {devices/lab_pin.sym} 42090 -21310 0 0 {name=p41639 lab=_87790_/CLK }
C {devices/lab_pin.sym} 42090 -21290 0 0 {name=p41640 lab=_40997_/Y }
C {devices/lab_pin.sym} 42270 -21310 0 1 {name=p41641 lab=_88296_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -21300 0 0 {name=X_88296_ }
C {devices/lab_pin.sym} 42100 -21190 0 0 {name=p41642 lab=_85396_/Q }
C {devices/lab_pin.sym} 42100 -21150 0 0 {name=p41643 lab=_54676_/X }
C {devices/lab_pin.sym} 42100 -21110 0 0 {name=p41644 lab=_54687_/Y }
C {devices/lab_pin.sym} 42260 -21150 0 1 {name=p41645 lab=_54688_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -21150 0 0 {name=X_54688_ }
C {devices/lab_pin.sym} 42100 -21040 0 0 {name=p41646 lab=_59204_/Y }
C {devices/lab_pin.sym} 42100 -21000 0 0 {name=p41647 lab=_59145_/X }
C {devices/lab_pin.sym} 42100 -20960 0 0 {name=p41648 lab=_59211_/X }
C {devices/lab_pin.sym} 42100 -20920 0 0 {name=p41649 lab=_59214_/X }
C {devices/lab_pin.sym} 42260 -20980 0 1 {name=p41650 lab=_84760_/D }
C {sky130_stdcells/a22oi_4.sym} 42180 -20980 0 0 {name=X_59215_ }
C {devices/lab_pin.sym} 42100 -20870 0 0 {name=p41651 lab=_44425_/X }
C {devices/lab_pin.sym} 42100 -20830 0 0 {name=p41652 lab=_44427_/X }
C {devices/lab_pin.sym} 42100 -20790 0 0 {name=p41653 lab=_41616_/X }
C {devices/lab_pin.sym} 42100 -20750 0 0 {name=p41654 lab=_87106_/Q }
C {devices/lab_pin.sym} 42100 -20710 0 0 {name=p41655 lab=_44428_/X }
C {devices/lab_pin.sym} 42260 -20790 0 1 {name=p41656 lab=_44441_/Y }
C {sky130_stdcells/o32ai_4.sym} 42180 -20790 0 0 {name=X_44441_ }
C {devices/lab_pin.sym} 42120 -20650 0 0 {name=p41657 lab=_56431_/A }
C {devices/lab_pin.sym} 42120 -20610 0 0 {name=p41658 lab=_56433_/B }
C {devices/lab_pin.sym} 42120 -20570 0 0 {name=p41659 lab=_85198_/Q }
C {devices/lab_pin.sym} 42240 -20610 0 1 {name=p41660 lab=_56427_/Y }
C {sky130_stdcells/nand3_4.sym} 42180 -20610 0 0 {name=X_56427_ }
C {devices/lab_pin.sym} 42120 -20480 0 0 {name=p41661 lab=_75261_/A }
C {devices/lab_pin.sym} 42120 -20440 0 0 {name=p41662 lab=_75261_/B }
C {devices/lab_pin.sym} 42240 -20460 0 1 {name=p41663 lab=_75279_/B }
C {sky130_stdcells/xor2_4.sym} 42180 -20460 0 0 {name=X_75261_ }
C {devices/lab_pin.sym} 42140 -20330 0 0 {name=p41664 lab=_40586_/A }
C {devices/lab_pin.sym} 42220 -20330 0 1 {name=p41665 lab=_41653_/X }
C {sky130_stdcells/buf_2.sym} 42180 -20330 0 0 {name=X_41653_ }
C {devices/lab_pin.sym} 42090 -20210 0 0 {name=p41666 lab=_87766_/CLK }
C {devices/lab_pin.sym} 42090 -20190 0 0 {name=p41667 lab=_43828_/X }
C {devices/lab_pin.sym} 42270 -20210 0 1 {name=p41668 lab=_87247_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -20200 0 0 {name=X_87247_ }
C {devices/lab_pin.sym} 42100 -20090 0 0 {name=p41669 lab=_85597_/Q }
C {devices/lab_pin.sym} 42100 -20050 0 0 {name=p41670 lab=_53610_/X }
C {devices/lab_pin.sym} 42100 -20010 0 0 {name=p41671 lab=_53638_/Y }
C {devices/lab_pin.sym} 42260 -20050 0 1 {name=p41672 lab=_53639_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -20050 0 0 {name=X_53639_ }
C {devices/lab_pin.sym} 42100 -19950 0 0 {name=p41673 lab=_57800_/X }
C {devices/lab_pin.sym} 42100 -19910 0 0 {name=p41674 lab=_72471_/Y }
C {devices/lab_pin.sym} 42100 -19870 0 0 {name=p41675 lab=_72472_/Y }
C {devices/lab_pin.sym} 42100 -19830 0 0 {name=p41676 lab=_64761_/B }
C {devices/lab_pin.sym} 42100 -19790 0 0 {name=p41677 lab=_59833_/X }
C {devices/lab_pin.sym} 42260 -19870 0 1 {name=p41678 lab=_72473_/X }
C {sky130_stdcells/o32a_4.sym} 42180 -19870 0 0 {name=X_72473_ }
C {devices/lab_pin.sym} 42090 -19710 0 0 {name=p41679 lab=_84469_/CLK }
C {devices/lab_pin.sym} 42090 -19690 0 0 {name=p41680 lab=_84459_/D }
C {devices/lab_pin.sym} 42270 -19710 0 1 {name=p41681 lab=_61690_/C }
C {sky130_stdcells/dfxtp_4.sym} 42180 -19700 0 0 {name=X_84459_ }
C {devices/lab_pin.sym} 42120 -19580 0 0 {name=p41682 lab=_84552_/Q }
C {devices/lab_pin.sym} 42120 -19540 0 0 {name=p41683 lab=_84424_/Q }
C {devices/lab_pin.sym} 42240 -19560 0 1 {name=p41684 lab=_77000_/X }
C {sky130_stdcells/xor2_4.sym} 42180 -19560 0 0 {name=X_77000_ }
C {devices/lab_pin.sym} 42120 -19440 0 0 {name=p41685 lab=_74232_/A }
C {devices/lab_pin.sym} 42120 -19400 0 0 {name=p41686 lab=_85893_/Q }
C {devices/lab_pin.sym} 42240 -19420 0 1 {name=p41687 lab=_74212_/X }
C {sky130_stdcells/and2_4.sym} 42180 -19420 0 0 {name=X_74212_ }
C {devices/lab_pin.sym} 42100 -19310 0 0 {name=p41688 lab=_40601_/X }
C {devices/lab_pin.sym} 42100 -19270 0 0 {name=p41689 lab=_81149_/Q }
C {devices/lab_pin.sym} 42100 -19230 0 0 {name=p41690 lab=_40603_/X }
C {devices/lab_pin.sym} 42260 -19270 0 1 {name=p41691 lab=_40604_/X }
C {sky130_stdcells/o21a_4.sym} 42180 -19270 0 0 {name=X_40604_ }
C {devices/lab_pin.sym} 42100 -19150 0 0 {name=p41692 lab=_86664_/Q }
C {devices/lab_pin.sym} 42100 -19110 0 0 {name=p41693 lab=_47145_/X }
C {devices/lab_pin.sym} 42100 -19070 0 0 {name=p41694 lab=_47159_/Y }
C {devices/lab_pin.sym} 42260 -19110 0 1 {name=p41695 lab=_47160_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -19110 0 0 {name=X_47160_ }
C {devices/lab_pin.sym} 42140 -18970 0 0 {name=p41696 lab=_58858_/A }
C {devices/lab_pin.sym} 42220 -18970 0 1 {name=p41697 lab=_59146_/X }
C {sky130_stdcells/buf_2.sym} 42180 -18970 0 0 {name=X_59146_ }
C {devices/lab_pin.sym} 42120 -18880 0 0 {name=p41698 lab=_70407_/C }
C {devices/lab_pin.sym} 42120 -18840 0 0 {name=p41699 lab=_71432_/B }
C {devices/lab_pin.sym} 42120 -18800 0 0 {name=p41700 lab=_71424_/C }
C {devices/lab_pin.sym} 42120 -18760 0 0 {name=p41701 lab=_71365_/X }
C {devices/lab_pin.sym} 42240 -18820 0 1 {name=p41702 lab=_71424_/X }
C {sky130_stdcells/and4_4.sym} 42180 -18820 0 0 {name=X_71424_ }
C {devices/lab_pin.sym} 42140 -18670 0 0 {name=p41703 lab=_44372_/A }
C {devices/lab_pin.sym} 42220 -18670 0 1 {name=p41704 lab=_44372_/Y }
C {sky130_stdcells/inv_2.sym} 42180 -18670 0 0 {name=X_44372_ }
C {devices/lab_pin.sym} 42120 -18570 0 0 {name=p41705 lab=_56358_/A }
C {devices/lab_pin.sym} 42120 -18530 0 0 {name=p41706 lab=_56358_/B }
C {devices/lab_pin.sym} 42120 -18490 0 0 {name=p41707 lab=_55702_/B }
C {devices/lab_pin.sym} 42240 -18530 0 1 {name=p41708 lab=_56358_/Y }
C {sky130_stdcells/nand3_4.sym} 42180 -18530 0 0 {name=X_56358_ }
C {devices/lab_pin.sym} 42120 -18420 0 0 {name=p41709 lab=_75133_/Y }
C {devices/lab_pin.sym} 42120 -18380 0 0 {name=p41710 lab=_75147_/Y }
C {devices/lab_pin.sym} 42120 -18340 0 0 {name=p41711 lab=_75163_/X }
C {devices/lab_pin.sym} 42120 -18300 0 0 {name=p41712 lab=_75182_/A }
C {devices/lab_pin.sym} 42240 -18360 0 1 {name=p41713 lab=_75192_/Y }
C {sky130_stdcells/nand4_4.sym} 42180 -18360 0 0 {name=X_75192_ }
C {devices/lab_pin.sym} 42090 -18210 0 0 {name=p41714 lab=_87178_/CLK }
C {devices/lab_pin.sym} 42090 -18190 0 0 {name=p41715 lab=_87178_/D }
C {devices/lab_pin.sym} 42270 -18210 0 1 {name=p41716 lab=_87178_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -18200 0 0 {name=X_87178_ }
C {devices/lab_pin.sym} 42120 -18080 0 0 {name=p41717 lab=_41584_/A }
C {devices/lab_pin.sym} 42120 -18040 0 0 {name=p41718 lab=_41584_/B }
C {devices/lab_pin.sym} 42240 -18060 0 1 {name=p41719 lab=_41584_/X }
C {sky130_stdcells/or2_4.sym} 42180 -18060 0 0 {name=X_41584_ }
C {devices/lab_pin.sym} 42120 -17960 0 0 {name=p41720 lab=_46111_/A }
C {devices/lab_pin.sym} 42120 -17920 0 0 {name=p41721 lab=_46111_/B }
C {devices/lab_pin.sym} 42120 -17880 0 0 {name=p41722 lab=_46099_/X }
C {devices/lab_pin.sym} 42120 -17840 0 0 {name=p41723 lab=_46094_/X }
C {devices/lab_pin.sym} 42240 -17900 0 1 {name=p41724 lab=_46111_/X }
C {sky130_stdcells/or4_4.sym} 42180 -17900 0 0 {name=X_46111_ }
C {devices/lab_pin.sym} 42140 -17750 0 0 {name=p41725 lab=_44110_/X }
C {devices/lab_pin.sym} 42220 -17750 0 1 {name=p41726 lab=_55309_/X }
C {sky130_stdcells/buf_2.sym} 42180 -17750 0 0 {name=X_55309_ }
C {devices/lab_pin.sym} 42100 -17660 0 0 {name=p41727 lab=_41259_/X }
C {devices/lab_pin.sym} 42100 -17620 0 0 {name=p41728 lab=_43300_/X }
C {devices/lab_pin.sym} 42100 -17580 0 0 {name=p41729 lab=_87481_/Q }
C {devices/lab_pin.sym} 42100 -17540 0 0 {name=p41730 lab=_43302_/X }
C {devices/lab_pin.sym} 42260 -17600 0 1 {name=p41731 lab=_87481_/D }
C {sky130_stdcells/a2bb2o_4.sym} 42180 -17600 0 0 {name=X_43323_ }
C {devices/lab_pin.sym} 42120 -17460 0 0 {name=p41732 lab=_74143_/A }
C {devices/lab_pin.sym} 42120 -17420 0 0 {name=p41733 lab=_72795_/A }
C {devices/lab_pin.sym} 42240 -17440 0 1 {name=p41734 lab=_74143_/Y }
C {sky130_stdcells/nor2_4.sym} 42180 -17440 0 0 {name=X_74143_ }
C {devices/lab_pin.sym} 42090 -17310 0 0 {name=p41735 lab=_85527_/CLK }
C {devices/lab_pin.sym} 42090 -17290 0 0 {name=p41736 lab=_50809_/Y }
C {devices/lab_pin.sym} 42270 -17310 0 1 {name=p41737 lab=_86129_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -17300 0 0 {name=X_86129_ }
C {devices/lab_pin.sym} 42140 -17170 0 0 {name=p41738 lab=_40414_/X }
C {devices/lab_pin.sym} 42220 -17170 0 1 {name=p41739 lab=_40937_/A }
C {sky130_stdcells/buf_2.sym} 42180 -17170 0 0 {name=X_40535_ }
C {devices/lab_pin.sym} 42140 -17050 0 0 {name=p41740 lab=_46903_/A }
C {devices/lab_pin.sym} 42220 -17050 0 1 {name=p41741 lab=_47091_/X }
C {sky130_stdcells/buf_2.sym} 42180 -17050 0 0 {name=X_47091_ }
C {devices/lab_pin.sym} 42100 -16960 0 0 {name=p41742 lab=_84771_/Q }
C {devices/lab_pin.sym} 42100 -16920 0 0 {name=p41743 lab=_59043_/X }
C {devices/lab_pin.sym} 42100 -16880 0 0 {name=p41744 lab=_59069_/X }
C {devices/lab_pin.sym} 42100 -16840 0 0 {name=p41745 lab=_59076_/X }
C {devices/lab_pin.sym} 42260 -16900 0 1 {name=p41746 lab=_84771_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 42180 -16900 0 0 {name=X_59077_ }
C {devices/lab_pin.sym} 42100 -16770 0 0 {name=p41747 lab=_71344_/X }
C {devices/lab_pin.sym} 42100 -16730 0 0 {name=p41748 lab=_83528_/Q }
C {devices/lab_pin.sym} 42100 -16690 0 0 {name=p41749 lab=_71354_/X }
C {devices/lab_pin.sym} 42260 -16730 0 1 {name=p41750 lab=_83528_/D }
C {sky130_stdcells/a21o_4.sym} 42180 -16730 0 0 {name=X_71355_ }
C {devices/lab_pin.sym} 42140 -16590 0 0 {name=p41751 lab=_56282_/Y }
C {devices/lab_pin.sym} 42220 -16590 0 1 {name=p41752 lab=_56360_/A }
C {sky130_stdcells/buf_2.sym} 42180 -16590 0 0 {name=X_56289_ }
C {devices/lab_pin.sym} 42140 -16470 0 0 {name=p41753 lab=clkbuf_9_253_0_CLK/X }
C {devices/lab_pin.sym} 42220 -16470 0 1 {name=p41754 lab=_85786_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 42180 -16470 0 0 {name=Xclkbuf_10_507_0_CLK }
C {devices/lab_pin.sym} 42100 -16380 0 0 {name=p41755 lab=_41506_/Y }
C {devices/lab_pin.sym} 42100 -16340 0 0 {name=p41756 lab=_46029_/X }
C {devices/lab_pin.sym} 42100 -16300 0 0 {name=p41757 lab=_66785_/B }
C {devices/lab_pin.sym} 42100 -16260 0 0 {name=p41758 lab=_46030_/X }
C {devices/lab_pin.sym} 42260 -16320 0 1 {name=p41759 lab=_86797_/D }
C {sky130_stdcells/a2bb2o_4.sym} 42180 -16320 0 0 {name=X_46042_ }
C {devices/lab_pin.sym} 42140 -16170 0 0 {name=p41760 lab=_58098_/A }
C {devices/lab_pin.sym} 42220 -16170 0 1 {name=p41761 lab=_58028_/X }
C {sky130_stdcells/buf_2.sym} 42180 -16170 0 0 {name=X_58028_ }
C {devices/lab_pin.sym} 42120 -16080 0 0 {name=p41762 lab=_70296_/X }
C {devices/lab_pin.sym} 42120 -16040 0 0 {name=p41763 lab=_70297_/X }
C {devices/lab_pin.sym} 42120 -16000 0 0 {name=p41764 lab=_70306_/C }
C {devices/lab_pin.sym} 42120 -15960 0 0 {name=p41765 lab=_70301_/D }
C {devices/lab_pin.sym} 42240 -16020 0 1 {name=p41766 lab=_70306_/X }
C {sky130_stdcells/and4_4.sym} 42180 -16020 0 0 {name=X_70306_ }
C {devices/lab_pin.sym} 42100 -15900 0 0 {name=p41767 lab=_41064_/X }
C {devices/lab_pin.sym} 42100 -15860 0 0 {name=p41768 lab=_43247_/X }
C {devices/lab_pin.sym} 42100 -15820 0 0 {name=p41769 lab=_87516_/Q }
C {devices/lab_pin.sym} 42100 -15780 0 0 {name=p41770 lab=_43248_/X }
C {devices/lab_pin.sym} 42260 -15840 0 1 {name=p41771 lab=_87516_/D }
C {sky130_stdcells/a2bb2o_4.sym} 42180 -15840 0 0 {name=X_43254_ }
C {devices/lab_pin.sym} 42120 -15700 0 0 {name=p41772 lab=_78938_/A }
C {devices/lab_pin.sym} 42120 -15660 0 0 {name=p41773 lab=_78946_/A }
C {devices/lab_pin.sym} 42240 -15680 0 1 {name=p41774 lab=_78951_/X }
C {sky130_stdcells/and2_4.sym} 42180 -15680 0 0 {name=X_78951_ }
C {devices/lab_pin.sym} 42120 -15560 0 0 {name=p41775 lab=_87325_/Q }
C {devices/lab_pin.sym} 42120 -15520 0 0 {name=p41776 lab=_74073_/X }
C {devices/lab_pin.sym} 42240 -15540 0 1 {name=p41777 lab=_74074_/Y }
C {sky130_stdcells/nor2_4.sym} 42180 -15540 0 0 {name=X_74074_ }
C {devices/lab_pin.sym} 42140 -15410 0 0 {name=p41778 lab=_40932_/A }
C {devices/lab_pin.sym} 42220 -15410 0 1 {name=p41779 lab=_40467_/B }
C {sky130_stdcells/buf_2.sym} 42180 -15410 0 0 {name=X_40466_ }
C {devices/lab_pin.sym} 42100 -15310 0 0 {name=p41780 lab=_53219_/B }
C {devices/lab_pin.sym} 42100 -15270 0 0 {name=p41781 lab=_71264_/X }
C {devices/lab_pin.sym} 42100 -15230 0 0 {name=p41782 lab=_71285_/Y }
C {devices/lab_pin.sym} 42260 -15270 0 1 {name=p41783 lab=_71286_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -15270 0 0 {name=X_71286_ }
C {devices/lab_pin.sym} 42140 -15130 0 0 {name=p41784 lab=_42204_/X }
C {devices/lab_pin.sym} 42220 -15130 0 1 {name=p41785 lab=_42205_/X }
C {sky130_stdcells/buf_2.sym} 42180 -15130 0 0 {name=X_42205_ }
C {devices/lab_pin.sym} 42120 -15020 0 0 {name=p41786 lab=_77902_/A }
C {devices/lab_pin.sym} 42120 -14980 0 0 {name=p41787 lab=_77902_/B }
C {devices/lab_pin.sym} 42240 -15000 0 1 {name=p41788 lab=_77902_/X }
C {sky130_stdcells/or2_4.sym} 42180 -15000 0 0 {name=X_77902_ }
C {devices/lab_pin.sym} 42140 -14870 0 0 {name=p41789 lab=_72771_/A }
C {devices/lab_pin.sym} 42220 -14870 0 1 {name=p41790 lab=_73530_/B }
C {sky130_stdcells/buf_2.sym} 42180 -14870 0 0 {name=X_73025_ }
C {devices/lab_pin.sym} 42100 -14770 0 0 {name=p41791 lab=_70224_/X }
C {devices/lab_pin.sym} 42100 -14730 0 0 {name=p41792 lab=_74755_/B }
C {devices/lab_pin.sym} 42100 -14690 0 0 {name=p41793 lab=_70236_/X }
C {devices/lab_pin.sym} 42260 -14730 0 1 {name=p41794 lab=_83827_/D }
C {sky130_stdcells/a21o_4.sym} 42180 -14730 0 0 {name=X_70237_ }
C {devices/lab_pin.sym} 42140 -14590 0 0 {name=p41795 lab=_43185_/A }
C {devices/lab_pin.sym} 42220 -14590 0 1 {name=p41796 lab=_43185_/X }
C {sky130_stdcells/buf_2.sym} 42180 -14590 0 0 {name=X_43185_ }
C {devices/lab_pin.sym} 42120 -14480 0 0 {name=p41797 lab=_82730_/Q }
C {devices/lab_pin.sym} 42120 -14440 0 0 {name=p41798 lab=_78882_/B }
C {devices/lab_pin.sym} 42240 -14460 0 1 {name=p41799 lab=_82698_/D }
C {sky130_stdcells/xor2_4.sym} 42180 -14460 0 0 {name=X_78882_ }
C {devices/lab_pin.sym} 42140 -14330 0 0 {name=p41800 lab=_40396_/Y }
C {devices/lab_pin.sym} 42220 -14330 0 1 {name=p41801 lab=_40397_/Y }
C {sky130_stdcells/inv_2.sym} 42180 -14330 0 0 {name=X_40397_ }
C {devices/lab_pin.sym} 42100 -14230 0 0 {name=p41802 lab=_57952_/B }
C {devices/lab_pin.sym} 42100 -14190 0 0 {name=p41803 lab=_49798_/X }
C {devices/lab_pin.sym} 42100 -14150 0 0 {name=p41804 lab=_49800_/Y }
C {devices/lab_pin.sym} 42260 -14190 0 1 {name=p41805 lab=_49801_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -14190 0 0 {name=X_49801_ }
C {devices/lab_pin.sym} 42140 -14050 0 0 {name=p41806 lab=_51584_/A }
C {devices/lab_pin.sym} 42220 -14050 0 1 {name=p41807 lab=_42137_/A }
C {sky130_stdcells/buf_2.sym} 42180 -14050 0 0 {name=X_42136_ }
C {devices/lab_pin.sym} 42120 -13940 0 0 {name=p41808 lab=_82270_/Q }
C {devices/lab_pin.sym} 42120 -13900 0 0 {name=p41809 lab=_77833_/B }
C {devices/lab_pin.sym} 42240 -13920 0 1 {name=p41810 lab=_77833_/Y }
C {sky130_stdcells/xnor2_4.sym} 42180 -13920 0 0 {name=X_77833_ }
C {devices/lab_pin.sym} 42140 -13790 0 0 {name=p41811 lab=_70337_/A }
C {devices/lab_pin.sym} 42220 -13790 0 1 {name=p41812 lab=_70209_/A }
C {sky130_stdcells/buf_2.sym} 42180 -13790 0 0 {name=X_70168_ }
C {devices/lab_pin.sym} 42140 -13670 0 0 {name=p41813 lab=_57567_/A }
C {devices/lab_pin.sym} 42220 -13670 0 1 {name=p41814 lab=_50308_/A }
C {sky130_stdcells/buf_2.sym} 42180 -13670 0 0 {name=X_47993_ }
C {devices/lab_pin.sym} 42140 -13550 0 0 {name=p41815 lab=_59978_/Y }
C {devices/lab_pin.sym} 42220 -13550 0 1 {name=p41816 lab=_59979_/Y }
C {sky130_stdcells/inv_2.sym} 42180 -13550 0 0 {name=X_59979_ }
C {devices/lab_pin.sym} 42140 -13430 0 0 {name=p41817 lab=_49787_/A }
C {devices/lab_pin.sym} 42220 -13430 0 1 {name=p41818 lab=_49732_/X }
C {sky130_stdcells/buf_2.sym} 42180 -13430 0 0 {name=X_49732_ }
C {devices/lab_pin.sym} 42120 -13340 0 0 {name=p41819 lab=_46915_/X }
C {devices/lab_pin.sym} 42120 -13300 0 0 {name=p41820 lab=_46944_/B }
C {devices/lab_pin.sym} 42120 -13260 0 0 {name=p41821 lab=_46926_/C }
C {devices/lab_pin.sym} 42120 -13220 0 0 {name=p41822 lab=_52763_/D }
C {devices/lab_pin.sym} 42240 -13280 0 1 {name=p41823 lab=_46944_/X }
C {sky130_stdcells/and4_4.sym} 42180 -13280 0 0 {name=X_46944_ }
C {devices/lab_pin.sym} 42100 -13170 0 0 {name=p41824 lab=_42052_/X }
C {devices/lab_pin.sym} 42100 -13130 0 0 {name=p41825 lab=_42043_/X }
C {devices/lab_pin.sym} 42100 -13090 0 0 {name=p41826 lab=_40950_/X }
C {devices/lab_pin.sym} 42100 -13050 0 0 {name=p41827 lab=_88049_/Q }
C {devices/lab_pin.sym} 42100 -13010 0 0 {name=p41828 lab=_42044_/X }
C {devices/lab_pin.sym} 42260 -13090 0 1 {name=p41829 lab=_42067_/Y }
C {sky130_stdcells/o32ai_4.sym} 42180 -13090 0 0 {name=X_42067_ }
C {devices/lab_pin.sym} 42120 -12940 0 0 {name=p41830 lab=_77756_/Y }
C {devices/lab_pin.sym} 42120 -12900 0 0 {name=p41831 lab=_77764_/B }
C {devices/lab_pin.sym} 42240 -12920 0 1 {name=p41832 lab=_77764_/Y }
C {sky130_stdcells/nand2_4.sym} 42180 -12920 0 0 {name=X_77764_ }
C {devices/lab_pin.sym} 42100 -12830 0 0 {name=p41833 lab=_63713_/A }
C {devices/lab_pin.sym} 42100 -12790 0 0 {name=p41834 lab=_60159_/A }
C {devices/lab_pin.sym} 42100 -12750 0 0 {name=p41835 lab=_60212_/A }
C {devices/lab_pin.sym} 42100 -12710 0 0 {name=p41836 lab=_63348_/A }
C {devices/lab_pin.sym} 42100 -12670 0 0 {name=p41837 lab=_60304_/A }
C {devices/lab_pin.sym} 42260 -12750 0 1 {name=p41838 lab=_62990_/Y }
C {sky130_stdcells/o32ai_4.sym} 42180 -12750 0 0 {name=X_62990_ }
C {devices/lab_pin.sym} 42140 -12590 0 0 {name=p41839 lab=_83134_/Q }
C {devices/lab_pin.sym} 42220 -12590 0 1 {name=p41840 lab=_70099_/Y }
C {sky130_stdcells/inv_2.sym} 42180 -12590 0 0 {name=X_70099_ }
C {devices/lab_pin.sym} 42120 -12480 0 0 {name=p41841 lab=_74972_/Y }
C {devices/lab_pin.sym} 42120 -12440 0 0 {name=p41842 lab=_74975_/X }
C {devices/lab_pin.sym} 42240 -12460 0 1 {name=p41843 lab=_74988_/A }
C {sky130_stdcells/nand2_4.sym} 42180 -12460 0 0 {name=X_74976_ }
C {devices/lab_pin.sym} 42120 -12340 0 0 {name=p41844 lab=_79503_/A }
C {devices/lab_pin.sym} 42120 -12300 0 0 {name=p41845 lab=_79503_/B }
C {devices/lab_pin.sym} 42240 -12320 0 1 {name=p41846 lab=_79504_/B }
C {sky130_stdcells/xnor2_4.sym} 42180 -12320 0 0 {name=X_79503_ }
C {devices/lab_pin.sym} 42140 -12190 0 0 {name=p41847 lab=_41018_/A }
C {devices/lab_pin.sym} 42220 -12190 0 1 {name=p41848 lab=_41018_/Y }
C {sky130_stdcells/inv_2.sym} 42180 -12190 0 0 {name=X_41018_ }
C {devices/lab_pin.sym} 42120 -12080 0 0 {name=p41849 lab=_81690_/Q }
C {devices/lab_pin.sym} 42120 -12040 0 0 {name=p41850 lab=_76715_/B }
C {devices/lab_pin.sym} 42240 -12060 0 1 {name=p41851 lab=_76715_/Y }
C {sky130_stdcells/xnor2_4.sym} 42180 -12060 0 0 {name=X_76715_ }
C {devices/lab_pin.sym} 42120 -11960 0 0 {name=p41852 lab=_61879_/A }
C {devices/lab_pin.sym} 42120 -11920 0 0 {name=p41853 lab=_61935_/Y }
C {devices/lab_pin.sym} 42120 -11880 0 0 {name=p41854 lab=_61938_/Y }
C {devices/lab_pin.sym} 42120 -11840 0 0 {name=p41855 lab=_61940_/Y }
C {devices/lab_pin.sym} 42240 -11900 0 1 {name=p41856 lab=_61941_/Y }
C {sky130_stdcells/nand4_4.sym} 42180 -11900 0 0 {name=X_61941_ }
C {devices/lab_pin.sym} 42100 -11770 0 0 {name=p41857 lab=_86346_/Q }
C {devices/lab_pin.sym} 42100 -11730 0 0 {name=p41858 lab=_49660_/X }
C {devices/lab_pin.sym} 42100 -11690 0 0 {name=p41859 lab=_49662_/Y }
C {devices/lab_pin.sym} 42260 -11730 0 1 {name=p41860 lab=_49663_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -11730 0 0 {name=X_49663_ }
C {devices/lab_pin.sym} 42120 -11600 0 0 {name=p41861 lab=_44126_/X }
C {devices/lab_pin.sym} 42120 -11560 0 0 {name=p41862 lab=_73927_/B }
C {devices/lab_pin.sym} 42240 -11580 0 1 {name=p41863 lab=_73927_/X }
C {sky130_stdcells/and2_4.sym} 42180 -11580 0 0 {name=X_73927_ }
C {devices/lab_pin.sym} 42140 -11450 0 0 {name=p41864 lab=_54417_/D }
C {devices/lab_pin.sym} 42220 -11450 0 1 {name=p41865 lab=_52724_/D }
C {sky130_stdcells/buf_2.sym} 42180 -11450 0 0 {name=X_46875_ }
C {devices/lab_pin.sym} 42120 -11340 0 0 {name=p41866 lab=_77695_/A }
C {devices/lab_pin.sym} 42120 -11300 0 0 {name=p41867 lab=_77695_/B }
C {devices/lab_pin.sym} 42240 -11320 0 1 {name=p41868 lab=_77703_/A }
C {sky130_stdcells/or2_4.sym} 42180 -11320 0 0 {name=X_77695_ }
C {devices/lab_pin.sym} 42140 -11190 0 0 {name=p41869 lab=_48614_/A }
C {devices/lab_pin.sym} 42220 -11190 0 1 {name=p41870 lab=_48615_/A }
C {sky130_stdcells/inv_2.sym} 42180 -11190 0 0 {name=X_48614_ }
C {devices/lab_pin.sym} 42100 -11090 0 0 {name=p41871 lab=_58663_/Y }
C {devices/lab_pin.sym} 42100 -11050 0 0 {name=p41872 lab=_66407_/C }
C {devices/lab_pin.sym} 42100 -11010 0 0 {name=p41873 lab=_79433_/Y }
C {devices/lab_pin.sym} 42260 -11050 0 1 {name=p41874 lab=_79438_/A }
C {sky130_stdcells/o21a_4.sym} 42180 -11050 0 0 {name=X_79434_ }
C {devices/lab_pin.sym} 42140 -10910 0 0 {name=p41875 lab=_57473_/B }
C {devices/lab_pin.sym} 42220 -10910 0 1 {name=p41876 lab=_45826_/Y }
C {sky130_stdcells/inv_2.sym} 42180 -10910 0 0 {name=X_45826_ }
C {devices/lab_pin.sym} 42120 -10810 0 0 {name=p41877 lab=_64655_/X }
C {devices/lab_pin.sym} 42120 -10770 0 0 {name=p41878 lab=_64633_/B }
C {devices/lab_pin.sym} 42120 -10730 0 0 {name=p41879 lab=_64659_/X }
C {devices/lab_pin.sym} 42240 -10770 0 1 {name=p41880 lab=_64660_/Y }
C {sky130_stdcells/nand3_4.sym} 42180 -10770 0 0 {name=X_64660_ }
C {devices/lab_pin.sym} 42140 -10630 0 0 {name=p41881 lab=_81474_/Q }
C {devices/lab_pin.sym} 42220 -10630 0 1 {name=p41882 lab=_76648_/A }
C {sky130_stdcells/inv_2.sym} 42180 -10630 0 0 {name=X_76646_ }
C {devices/lab_pin.sym} 42120 -10520 0 0 {name=p41883 lab=_49580_/X }
C {devices/lab_pin.sym} 42120 -10480 0 0 {name=p41884 lab=_52807_/B }
C {devices/lab_pin.sym} 42240 -10500 0 1 {name=p41885 lab=_49594_/Y }
C {sky130_stdcells/nand2_4.sym} 42180 -10500 0 0 {name=X_49594_ }
C {devices/lab_pin.sym} 42100 -10410 0 0 {name=p41886 lab=_57656_/X }
C {devices/lab_pin.sym} 42100 -10370 0 0 {name=p41887 lab=_61824_/X }
C {devices/lab_pin.sym} 42100 -10330 0 0 {name=p41888 lab=_61838_/X }
C {devices/lab_pin.sym} 42100 -10290 0 0 {name=p41889 lab=_61870_/X }
C {devices/lab_pin.sym} 42100 -10260 0 0 {name=p41890 lab=_61871_/X }
C {devices/lab_pin.sym} 42260 -10330 0 1 {name=p41891 lab=_61872_/X }
C {sky130_stdcells/a41o_4.sym} 42180 -10330 0 0 {name=X_61872_ }
C {devices/lab_pin.sym} 42100 -10190 0 0 {name=p41892 lab=_73853_/X }
C {devices/lab_pin.sym} 42100 -10150 0 0 {name=p41893 lab=_73856_/X }
C {devices/lab_pin.sym} 42100 -10110 0 0 {name=p41894 lab=_73857_/X }
C {devices/lab_pin.sym} 42260 -10150 0 1 {name=p41895 lab=_73863_/A }
C {sky130_stdcells/a21o_4.sym} 42180 -10150 0 0 {name=X_73858_ }
C {devices/lab_pin.sym} 42120 -10030 0 0 {name=p41896 lab=_63611_/A }
C {devices/lab_pin.sym} 42120 -9990 0 0 {name=p41897 lab=_63630_/B }
C {devices/lab_pin.sym} 42120 -9950 0 0 {name=p41898 lab=_63630_/C }
C {devices/lab_pin.sym} 42240 -9990 0 1 {name=p41899 lab=_63611_/Y }
C {sky130_stdcells/nor3_4.sym} 42180 -9990 0 0 {name=X_63611_ }
C {devices/lab_pin.sym} 42140 -9850 0 0 {name=p41900 lab=_48545_/A }
C {devices/lab_pin.sym} 42220 -9850 0 1 {name=p41901 lab=_48610_/C }
C {sky130_stdcells/buf_2.sym} 42180 -9850 0 0 {name=X_48545_ }
C {devices/lab_pin.sym} 42100 -9770 0 0 {name=p41902 lab=_61202_/A }
C {devices/lab_pin.sym} 42100 -9730 0 0 {name=p41903 lab=_63374_/A }
C {devices/lab_pin.sym} 42100 -9690 0 0 {name=p41904 lab=_61277_/B }
C {devices/lab_pin.sym} 42100 -9650 0 0 {name=p41905 lab=_60820_/Y }
C {devices/lab_pin.sym} 42100 -9610 0 0 {name=p41906 lab=_60822_/X }
C {devices/lab_pin.sym} 42260 -9690 0 1 {name=p41907 lab=_60823_/Y }
C {sky130_stdcells/o41ai_4.sym} 42180 -9690 0 0 {name=X_60823_ }
C {devices/lab_pin.sym} 42120 -9540 0 0 {name=p41908 lab=_73535_/A }
C {devices/lab_pin.sym} 42120 -9500 0 0 {name=p41909 lab=_65455_/B }
C {devices/lab_pin.sym} 42240 -9520 0 1 {name=p41910 lab=_72809_/X }
C {sky130_stdcells/and2_4.sym} 42180 -9520 0 0 {name=X_72809_ }
C {devices/lab_pin.sym} 42120 -9400 0 0 {name=p41911 lab=_79361_/X }
C {devices/lab_pin.sym} 42120 -9360 0 0 {name=p41912 lab=_79364_/Y }
C {devices/lab_pin.sym} 42240 -9380 0 1 {name=p41913 lab=_79365_/X }
C {sky130_stdcells/xor2_4.sym} 42180 -9380 0 0 {name=X_79365_ }
C {devices/lab_pin.sym} 42140 -9250 0 0 {name=p41914 lab=_45757_/A }
C {devices/lab_pin.sym} 42220 -9250 0 1 {name=p41915 lab=_45757_/X }
C {sky130_stdcells/buf_2.sym} 42180 -9250 0 0 {name=X_45757_ }
C {devices/lab_pin.sym} 42140 -9130 0 0 {name=p41916 lab=_64829_/A }
C {devices/lab_pin.sym} 42220 -9130 0 1 {name=p41917 lab=_64591_/X }
C {sky130_stdcells/buf_2.sym} 42180 -9130 0 0 {name=X_64591_ }
C {devices/lab_pin.sym} 42100 -9030 0 0 {name=p41918 lab=_76576_/B }
C {devices/lab_pin.sym} 42100 -8990 0 0 {name=p41919 lab=_76575_/Y }
C {devices/lab_pin.sym} 42100 -8950 0 0 {name=p41920 lab=_76572_/Y }
C {devices/lab_pin.sym} 42260 -8990 0 1 {name=p41921 lab=_76577_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -8990 0 0 {name=X_76577_ }
C {devices/lab_pin.sym} 42140 -8850 0 0 {name=p41922 lab=_40554_/X }
C {devices/lab_pin.sym} 42220 -8850 0 1 {name=p41923 lab=_43774_/A }
C {sky130_stdcells/buf_2.sym} 42180 -8850 0 0 {name=X_42969_ }
C {devices/lab_pin.sym} 42120 -8740 0 0 {name=p41924 lab=_73789_/A }
C {devices/lab_pin.sym} 42120 -8700 0 0 {name=p41925 lab=_73789_/B }
C {devices/lab_pin.sym} 42240 -8720 0 1 {name=p41926 lab=_73789_/Y }
C {sky130_stdcells/nand2_4.sym} 42180 -8720 0 0 {name=X_73789_ }
C {devices/lab_pin.sym} 42100 -8610 0 0 {name=p41927 lab=_66294_/X }
C {devices/lab_pin.sym} 42100 -8570 0 0 {name=p41928 lab=_66328_/Y }
C {devices/lab_pin.sym} 42100 -8530 0 0 {name=p41929 lab=_66329_/Y }
C {devices/lab_pin.sym} 42260 -8570 0 1 {name=p41930 lab=_66330_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -8570 0 0 {name=X_66330_ }
C {devices/lab_pin.sym} 42120 -8440 0 0 {name=p41931 lab=_78316_/A }
C {devices/lab_pin.sym} 42120 -8400 0 0 {name=p41932 lab=_82659_/D }
C {devices/lab_pin.sym} 42240 -8420 0 1 {name=p41933 lab=_78335_/B }
C {sky130_stdcells/nand2_4.sym} 42180 -8420 0 0 {name=X_78316_ }
C {devices/lab_pin.sym} 42140 -8290 0 0 {name=p41934 lab=_43047_/A }
C {devices/lab_pin.sym} 42220 -8290 0 1 {name=p41935 lab=_44708_/X }
C {sky130_stdcells/buf_2.sym} 42180 -8290 0 0 {name=X_44708_ }
C {devices/lab_pin.sym} 42120 -8180 0 0 {name=p41936 lab=_75528_/A }
C {devices/lab_pin.sym} 42120 -8140 0 0 {name=p41937 lab=_75528_/B }
C {devices/lab_pin.sym} 42240 -8160 0 1 {name=p41938 lab=_75528_/X }
C {sky130_stdcells/xor2_4.sym} 42180 -8160 0 0 {name=X_75528_ }
C {devices/lab_pin.sym} 42100 -8070 0 0 {name=p41939 lab=_63495_/X }
C {devices/lab_pin.sym} 42100 -8030 0 0 {name=p41940 lab=_63533_/X }
C {devices/lab_pin.sym} 42100 -7990 0 0 {name=p41941 lab=_63534_/X }
C {devices/lab_pin.sym} 42100 -7950 0 0 {name=p41942 lab=_63538_/X }
C {devices/lab_pin.sym} 42100 -7910 0 0 {name=p41943 lab=_63541_/Y }
C {devices/lab_pin.sym} 42260 -7990 0 1 {name=p41944 lab=_63542_/Y }
C {sky130_stdcells/o41ai_4.sym} 42180 -7990 0 0 {name=X_63542_ }
C {devices/lab_pin.sym} 42120 -7850 0 0 {name=p41945 lab=_50447_/A }
C {devices/lab_pin.sym} 42120 -7810 0 0 {name=p41946 lab=_48489_/B }
C {devices/lab_pin.sym} 42120 -7770 0 0 {name=p41947 lab=_48476_/C }
C {devices/lab_pin.sym} 42240 -7810 0 1 {name=p41948 lab=_48476_/X }
C {sky130_stdcells/and3_4.sym} 42180 -7810 0 0 {name=X_48476_ }
C {devices/lab_pin.sym} 42120 -7680 0 0 {name=p41949 lab=_60820_/A }
C {devices/lab_pin.sym} 42120 -7640 0 0 {name=p41950 lab=_60702_/Y }
C {devices/lab_pin.sym} 42240 -7660 0 1 {name=p41951 lab=_60754_/X }
C {sky130_stdcells/and2_4.sym} 42180 -7660 0 0 {name=X_60754_ }
C {devices/lab_pin.sym} 42100 -7550 0 0 {name=p41952 lab=_79275_/B }
C {devices/lab_pin.sym} 42100 -7510 0 0 {name=p41953 lab=_79292_/X }
C {devices/lab_pin.sym} 42100 -7470 0 0 {name=p41954 lab=_79295_/Y }
C {devices/lab_pin.sym} 42260 -7510 0 1 {name=p41955 lab=_79296_/Y }
C {sky130_stdcells/a21oi_4.sym} 42180 -7510 0 0 {name=X_79296_ }
C {devices/lab_pin.sym} 42140 -7370 0 0 {name=p41956 lab=_85102_/Q }
C {devices/lab_pin.sym} 42220 -7370 0 1 {name=p41957 lab=_45688_/Y }
C {sky130_stdcells/inv_2.sym} 42180 -7370 0 0 {name=X_45688_ }
C {devices/lab_pin.sym} 42120 -7280 0 0 {name=p41958 lab=_47418_/A }
C {devices/lab_pin.sym} 42120 -7240 0 0 {name=p41959 lab=_47415_/X }
C {devices/lab_pin.sym} 42120 -7200 0 0 {name=p41960 lab=_47466_/C }
C {devices/lab_pin.sym} 42120 -7160 0 0 {name=p41961 lab=_53044_/D }
C {devices/lab_pin.sym} 42240 -7220 0 1 {name=p41962 lab=_47427_/X }
C {sky130_stdcells/and4_4.sym} 42180 -7220 0 0 {name=X_47427_ }
C {devices/lab_pin.sym} 42100 -7090 0 0 {name=p41963 lab=_66179_/X }
C {devices/lab_pin.sym} 42100 -7050 0 0 {name=p41964 lab=_66258_/Y }
C {devices/lab_pin.sym} 42100 -7010 0 0 {name=p41965 lab=_66260_/Y }
C {devices/lab_pin.sym} 42260 -7050 0 1 {name=p41966 lab=_66261_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -7050 0 0 {name=X_66261_ }
C {devices/lab_pin.sym} 42120 -6920 0 0 {name=p41967 lab=_78247_/A }
C {devices/lab_pin.sym} 42120 -6880 0 0 {name=p41968 lab=_78247_/B }
C {devices/lab_pin.sym} 42240 -6900 0 1 {name=p41969 lab=_78247_/X }
C {sky130_stdcells/xor2_4.sym} 42180 -6900 0 0 {name=X_78247_ }
C {devices/lab_pin.sym} 42140 -6770 0 0 {name=p41970 lab=_44567_/A }
C {devices/lab_pin.sym} 42220 -6770 0 1 {name=p41971 lab=_44639_/X }
C {sky130_stdcells/buf_2.sym} 42180 -6770 0 0 {name=X_44639_ }
C {devices/lab_pin.sym} 42100 -6680 0 0 {name=p41972 lab=_58541_/A }
C {devices/lab_pin.sym} 42100 -6640 0 0 {name=p41973 lab=_63436_/X }
C {devices/lab_pin.sym} 42100 -6600 0 0 {name=p41974 lab=_61440_/A }
C {devices/lab_pin.sym} 42100 -6560 0 0 {name=p41975 lab=_63437_/X }
C {devices/lab_pin.sym} 42260 -6620 0 1 {name=p41976 lab=_63473_/X }
C {sky130_stdcells/a2bb2o_4.sym} 42180 -6620 0 0 {name=X_63473_ }
C {devices/lab_pin.sym} 42100 -6490 0 0 {name=p41977 lab=_75457_/B }
C {devices/lab_pin.sym} 42100 -6450 0 0 {name=p41978 lab=_75457_/C }
C {devices/lab_pin.sym} 42100 -6410 0 0 {name=p41979 lab=_75457_/A }
C {devices/lab_pin.sym} 42260 -6450 0 1 {name=p41980 lab=_75509_/C }
C {sky130_stdcells/o21ai_4.sym} 42180 -6450 0 0 {name=X_75459_ }
C {devices/lab_pin.sym} 42100 -6340 0 0 {name=p41981 lab=_84584_/Q }
C {devices/lab_pin.sym} 42100 -6300 0 0 {name=p41982 lab=_60673_/X }
C {devices/lab_pin.sym} 42100 -6260 0 0 {name=p41983 lab=_60675_/Y }
C {devices/lab_pin.sym} 42100 -6220 0 0 {name=p41984 lab=_60684_/X }
C {devices/lab_pin.sym} 42260 -6280 0 1 {name=p41985 lab=_60685_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 42180 -6280 0 0 {name=X_60685_ }
C {devices/lab_pin.sym} 42120 -6140 0 0 {name=p41986 lab=_68044_/A }
C {devices/lab_pin.sym} 42120 -6100 0 0 {name=p41987 lab=_68000_/B }
C {devices/lab_pin.sym} 42240 -6120 0 1 {name=p41988 lab=_68000_/X }
C {sky130_stdcells/and2_4.sym} 42180 -6120 0 0 {name=X_68000_ }
C {devices/lab_pin.sym} 42140 -5990 0 0 {name=p41989 lab=_65718_/A }
C {devices/lab_pin.sym} 42220 -5990 0 1 {name=p41990 lab=_65212_/X }
C {sky130_stdcells/buf_2.sym} 42180 -5990 0 0 {name=X_65212_ }
C {devices/lab_pin.sym} 42100 -5910 0 0 {name=p41991 lab=_61499_/B }
C {devices/lab_pin.sym} 42100 -5870 0 0 {name=p41992 lab=_62390_/X }
C {devices/lab_pin.sym} 42100 -5830 0 0 {name=p41993 lab=_62363_/X }
C {devices/lab_pin.sym} 42100 -5790 0 0 {name=p41994 lab=_62407_/X }
C {devices/lab_pin.sym} 42100 -5760 0 0 {name=p41995 lab=_62423_/X }
C {devices/lab_pin.sym} 42260 -5830 0 1 {name=p41996 lab=_62424_/X }
C {sky130_stdcells/a41o_4.sym} 42180 -5830 0 0 {name=X_62424_ }
C {devices/lab_pin.sym} 42100 -5690 0 0 {name=p41997 lab=_47354_/Y }
C {devices/lab_pin.sym} 42100 -5650 0 0 {name=p41998 lab=_47317_/X }
C {devices/lab_pin.sym} 42100 -5610 0 0 {name=p41999 lab=_47357_/X }
C {devices/lab_pin.sym} 42260 -5650 0 1 {name=p42000 lab=_86643_/D }
C {sky130_stdcells/a21oi_4.sym} 42180 -5650 0 0 {name=X_47358_ }
C {devices/lab_pin.sym} 42140 -5510 0 0 {name=p42001 lab=_84150_/Q }
C {devices/lab_pin.sym} 42220 -5510 0 1 {name=p42002 lab=_66193_/C }
C {sky130_stdcells/inv_2.sym} 42180 -5510 0 0 {name=X_66192_ }
C {devices/lab_pin.sym} 42120 -5400 0 0 {name=p42003 lab=_78177_/A }
C {devices/lab_pin.sym} 42120 -5360 0 0 {name=p42004 lab=_78177_/B }
C {devices/lab_pin.sym} 42240 -5380 0 1 {name=p42005 lab=_78178_/Y }
C {sky130_stdcells/nand2_4.sym} 42180 -5380 0 0 {name=X_78178_ }
C {devices/lab_pin.sym} 42140 -5250 0 0 {name=p42006 lab=_46450_/A }
C {devices/lab_pin.sym} 42220 -5250 0 1 {name=p42007 lab=_53511_/A }
C {sky130_stdcells/buf_2.sym} 42180 -5250 0 0 {name=X_46309_ }
C {devices/lab_pin.sym} 42100 -5150 0 0 {name=p42008 lab=_65140_/Y }
C {devices/lab_pin.sym} 42100 -5110 0 0 {name=p42009 lab=_65070_/X }
C {devices/lab_pin.sym} 42100 -5070 0 0 {name=p42010 lab=_65142_/Y }
C {devices/lab_pin.sym} 42260 -5110 0 1 {name=p42011 lab=_65143_/X }
C {sky130_stdcells/a21o_4.sym} 42180 -5110 0 0 {name=X_65143_ }
C {devices/lab_pin.sym} 42100 -4990 0 0 {name=p42012 lab=_77120_/Y }
C {devices/lab_pin.sym} 42100 -4950 0 0 {name=p42013 lab=_77127_/Y }
C {devices/lab_pin.sym} 42100 -4910 0 0 {name=p42014 lab=_77128_/Y }
C {devices/lab_pin.sym} 42260 -4950 0 1 {name=p42015 lab=_77129_/X }
C {sky130_stdcells/o21a_4.sym} 42180 -4950 0 0 {name=X_77129_ }
C {devices/lab_pin.sym} 42140 -4810 0 0 {name=p42016 lab=_62193_/A }
C {devices/lab_pin.sym} 42220 -4810 0 1 {name=p42017 lab=_62355_/X }
C {sky130_stdcells/buf_2.sym} 42180 -4810 0 0 {name=X_62355_ }
C {devices/lab_pin.sym} 42140 -4690 0 0 {name=p42018 lab=_54130_/B }
C {devices/lab_pin.sym} 42220 -4690 0 1 {name=p42019 lab=_52965_/B }
C {sky130_stdcells/buf_2.sym} 42180 -4690 0 0 {name=X_47289_ }
C {devices/lab_pin.sym} 42140 -4570 0 0 {name=p42020 lab=_46349_/A }
C {devices/lab_pin.sym} 42220 -4570 0 1 {name=p42021 lab=_49029_/B }
C {sky130_stdcells/buf_2.sym} 42180 -4570 0 0 {name=X_49028_ }
C {devices/lab_pin.sym} 42140 -4450 0 0 {name=p42022 lab=_61306_/A }
C {devices/lab_pin.sym} 42220 -4450 0 1 {name=p42023 lab=_72503_/A }
C {sky130_stdcells/buf_2.sym} 42180 -4450 0 0 {name=X_61306_ }
C {devices/lab_pin.sym} 42120 -4340 0 0 {name=p42024 lab=_80135_/X }
C {devices/lab_pin.sym} 42120 -4300 0 0 {name=p42025 lab=_80139_/Y }
C {devices/lab_pin.sym} 42240 -4320 0 1 {name=p42026 lab=_81686_/D }
C {sky130_stdcells/xor2_4.sym} 42180 -4320 0 0 {name=X_80140_ }
C {devices/lab_pin.sym} 42120 -4200 0 0 {name=p42027 lab=_65074_/A }
C {devices/lab_pin.sym} 42120 -4160 0 0 {name=p42028 lab=_65074_/B }
C {devices/lab_pin.sym} 42240 -4180 0 1 {name=p42029 lab=_65074_/X }
C {sky130_stdcells/and2_4.sym} 42180 -4180 0 0 {name=X_65074_ }
C {devices/lab_pin.sym} 42120 -4060 0 0 {name=p42030 lab=_69948_/X }
C {devices/lab_pin.sym} 42120 -4020 0 0 {name=p42031 lab=_69950_/X }
C {devices/lab_pin.sym} 42240 -4040 0 1 {name=p42032 lab=_69951_/Y }
C {sky130_stdcells/nand2_4.sym} 42180 -4040 0 0 {name=X_69951_ }
C {devices/lab_pin.sym} 42140 -3910 0 0 {name=p42033 lab=_62285_/X }
C {devices/lab_pin.sym} 42220 -3910 0 1 {name=p42034 lab=_62286_/X }
C {sky130_stdcells/buf_2.sym} 42180 -3910 0 0 {name=X_62286_ }
C {devices/lab_pin.sym} 42120 -3800 0 0 {name=p42035 lab=_68994_/A }
C {devices/lab_pin.sym} 42120 -3760 0 0 {name=p42036 lab=_88254_/Q }
C {devices/lab_pin.sym} 42240 -3780 0 1 {name=p42037 lab=_68902_/X }
C {sky130_stdcells/and2_4.sym} 42180 -3780 0 0 {name=X_68902_ }
C {devices/lab_pin.sym} 42120 -3680 0 0 {name=p42038 lab=_63217_/B }
C {devices/lab_pin.sym} 42120 -3640 0 0 {name=p42039 lab=_64118_/B }
C {devices/lab_pin.sym} 42120 -3600 0 0 {name=p42040 lab=_64040_/C }
C {devices/lab_pin.sym} 42120 -3560 0 0 {name=p42041 lab=_64025_/D }
C {devices/lab_pin.sym} 42240 -3620 0 1 {name=p42042 lab=_64025_/Y }
C {sky130_stdcells/nand4_4.sym} 42180 -3620 0 0 {name=X_64025_ }
C {devices/lab_pin.sym} 42120 -3500 0 0 {name=p42043 lab=_60296_/X }
C {devices/lab_pin.sym} 42120 -3460 0 0 {name=p42044 lab=_61188_/B }
C {devices/lab_pin.sym} 42120 -3420 0 0 {name=p42045 lab=_61188_/C }
C {devices/lab_pin.sym} 42120 -3380 0 0 {name=p42046 lab=_61237_/D }
C {devices/lab_pin.sym} 42240 -3440 0 1 {name=p42047 lab=_61237_/Y }
C {sky130_stdcells/nand4_4.sym} 42180 -3440 0 0 {name=X_61237_ }
C {devices/lab_pin.sym} 42120 -3300 0 0 {name=p42048 lab=_80071_/A }
C {devices/lab_pin.sym} 42120 -3260 0 0 {name=p42049 lab=_80070_/Y }
C {devices/lab_pin.sym} 42240 -3280 0 1 {name=p42050 lab=_80071_/X }
C {sky130_stdcells/xor2_4.sym} 42180 -3280 0 0 {name=X_80071_ }
C {devices/lab_pin.sym} 42140 -3150 0 0 {name=p42051 lab=_69882_/A }
C {devices/lab_pin.sym} 42220 -3150 0 1 {name=p42052 lab=_69883_/B }
C {sky130_stdcells/inv_2.sym} 42180 -3150 0 0 {name=X_69882_ }
C {devices/lab_pin.sym} 42120 -3040 0 0 {name=p42053 lab=_68785_/A }
C {devices/lab_pin.sym} 42120 -3000 0 0 {name=p42054 lab=_88353_/Q }
C {devices/lab_pin.sym} 42240 -3020 0 1 {name=p42055 lab=_68833_/X }
C {sky130_stdcells/and2_4.sym} 42180 -3020 0 0 {name=X_68833_ }
C {devices/lab_pin.sym} 42100 -2930 0 0 {name=p42056 lab=_72527_/A }
C {devices/lab_pin.sym} 42100 -2890 0 0 {name=p42057 lab=_72527_/B }
C {devices/lab_pin.sym} 42100 -2850 0 0 {name=p42058 lab=_84515_/Q }
C {devices/lab_pin.sym} 42100 -2810 0 0 {name=p42059 lab=_61167_/Y }
C {devices/lab_pin.sym} 42100 -2770 0 0 {name=p42060 lab=_61117_/X }
C {devices/lab_pin.sym} 42260 -2850 0 1 {name=p42061 lab=_84515_/D }
C {sky130_stdcells/a32o_4.sym} 42180 -2850 0 0 {name=X_61168_ }
C {devices/lab_pin.sym} 42140 -2690 0 0 {name=p42062 lab=_60118_/X }
C {devices/lab_pin.sym} 42220 -2690 0 1 {name=p42063 lab=_60119_/Y }
C {sky130_stdcells/inv_2.sym} 42180 -2690 0 0 {name=X_60119_ }
C {devices/lab_pin.sym} 42090 -2570 0 0 {name=p42064 lab=_83191_/CLK }
C {devices/lab_pin.sym} 42090 -2550 0 0 {name=p42065 lab=_83830_/D }
C {devices/lab_pin.sym} 42270 -2570 0 1 {name=p42066 lab=_83830_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -2560 0 0 {name=X_83830_ }
C {devices/lab_pin.sym} 42100 -2460 0 0 {name=p42067 lab=_87088_/Q }
C {devices/lab_pin.sym} 42100 -2420 0 0 {name=p42068 lab=_68707_/X }
C {devices/lab_pin.sym} 42100 -2380 0 0 {name=p42069 lab=_68762_/X }
C {devices/lab_pin.sym} 42100 -2340 0 0 {name=p42070 lab=_68763_/X }
C {devices/lab_pin.sym} 42260 -2400 0 1 {name=p42071 lab=_68764_/X }
C {sky130_stdcells/a211o_4.sym} 42180 -2400 0 0 {name=X_68764_ }
C {devices/lab_pin.sym} 42140 -2250 0 0 {name=p42072 lab=_53990_/A }
C {devices/lab_pin.sym} 42220 -2250 0 1 {name=p42073 lab=_53991_/A }
C {sky130_stdcells/buf_2.sym} 42180 -2250 0 0 {name=X_53990_ }
C {devices/lab_pin.sym} 42140 -2130 0 0 {name=p42074 lab=_65976_/A }
C {devices/lab_pin.sym} 42220 -2130 0 1 {name=p42075 lab=_65976_/X }
C {sky130_stdcells/buf_2.sym} 42180 -2130 0 0 {name=X_65976_ }
C {devices/lab_pin.sym} 42140 -2010 0 0 {name=p42076 lab=_61172_/A }
C {devices/lab_pin.sym} 42220 -2010 0 1 {name=p42077 lab=_61230_/C }
C {sky130_stdcells/buf_2.sym} 42180 -2010 0 0 {name=X_61099_ }
C {devices/lab_pin.sym} 42100 -1920 0 0 {name=p42078 lab=_87907_/Q }
C {devices/lab_pin.sym} 42100 -1880 0 0 {name=p42079 lab=_67713_/X }
C {devices/lab_pin.sym} 42100 -1840 0 0 {name=p42080 lab=_67641_/X }
C {devices/lab_pin.sym} 42100 -1800 0 0 {name=p42081 lab=_67714_/X }
C {devices/lab_pin.sym} 42260 -1860 0 1 {name=p42082 lab=_67715_/X }
C {sky130_stdcells/a211o_4.sym} 42180 -1860 0 0 {name=X_67715_ }
C {devices/lab_pin.sym} 42100 -1730 0 0 {name=p42083 lab=_85726_/Q }
C {devices/lab_pin.sym} 42100 -1690 0 0 {name=p42084 lab=_52929_/X }
C {devices/lab_pin.sym} 42100 -1650 0 0 {name=p42085 lab=_52940_/Y }
C {devices/lab_pin.sym} 42260 -1690 0 1 {name=p42086 lab=_52941_/Y }
C {sky130_stdcells/o21ai_4.sym} 42180 -1690 0 0 {name=X_52941_ }
C {devices/lab_pin.sym} 42140 -1550 0 0 {name=p42087 lab=_64776_/A }
C {devices/lab_pin.sym} 42220 -1550 0 1 {name=p42088 lab=_64927_/X }
C {sky130_stdcells/buf_2.sym} 42180 -1550 0 0 {name=X_64927_ }
C {devices/lab_pin.sym} 42090 -1430 0 0 {name=p42089 lab=_83761_/CLK }
C {devices/lab_pin.sym} 42090 -1410 0 0 {name=p42090 lab=_83761_/D }
C {devices/lab_pin.sym} 42270 -1430 0 1 {name=p42091 lab=_83761_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -1420 0 0 {name=X_83761_ }
C {devices/lab_pin.sym} 42090 -1290 0 0 {name=p42092 lab=_81065_/CLK }
C {devices/lab_pin.sym} 42090 -1270 0 0 {name=p42093 lab=_75675_/X }
C {devices/lab_pin.sym} 42270 -1290 0 1 {name=p42094 lab=_80961_/D }
C {sky130_stdcells/dfxtp_4.sym} 42180 -1280 0 0 {name=X_80973_ }
C {devices/lab_pin.sym} 42120 -1160 0 0 {name=p42095 lab=_69661_/A }
C {devices/lab_pin.sym} 42120 -1120 0 0 {name=p42096 lab=_68695_/B }
C {devices/lab_pin.sym} 42240 -1140 0 1 {name=p42097 lab=_68695_/Y }
C {sky130_stdcells/nor2_4.sym} 42180 -1140 0 0 {name=X_68695_ }
C {devices/lab_pin.sym} 42090 -1010 0 0 {name=p42098 lab=_85499_/CLK }
C {devices/lab_pin.sym} 42090 -990 0 0 {name=p42099 lab=_85500_/D }
C {devices/lab_pin.sym} 42270 -1010 0 1 {name=p42100 lab=_85500_/Q }
C {sky130_stdcells/dfxtp_4.sym} 42180 -1000 0 0 {name=X_85500_ }
C {devices/lab_pin.sym} 42090 -870 0 0 {name=p42101 lab=_82803_/CLK }
C {devices/lab_pin.sym} 42090 -850 0 0 {name=p42102 lab=_79011_/X }
C {devices/lab_pin.sym} 42270 -870 0 1 {name=p42103 lab=_82668_/D }
C {sky130_stdcells/dfxtp_4.sym} 42180 -860 0 0 {name=X_82712_ }
C {devices/lab_pin.sym} 42100 -750 0 0 {name=p42104 lab=_55652_/Y }
C {devices/lab_pin.sym} 42100 -710 0 0 {name=p42105 lab=_55654_/X }
C {devices/lab_pin.sym} 42100 -670 0 0 {name=p42106 lab=_55659_/Y }
C {devices/lab_pin.sym} 42260 -710 0 1 {name=p42107 lab=_55660_/Y }
C {sky130_stdcells/a21oi_4.sym} 42180 -710 0 0 {name=X_55660_ }
C {devices/lab_pin.sym} 43020 -42170 0 0 {name=p42108 lab=_67643_/X }
C {devices/lab_pin.sym} 43020 -42130 0 0 {name=p42109 lab=_67645_/X }
C {devices/lab_pin.sym} 43020 -42090 0 0 {name=p42110 lab=_67619_/X }
C {devices/lab_pin.sym} 43180 -42130 0 1 {name=p42111 lab=_67649_/A }
C {sky130_stdcells/a21o_4.sym} 43100 -42130 0 0 {name=X_67646_ }
C {devices/lab_pin.sym} 43010 -41990 0 0 {name=p42112 lab=_86191_/CLK }
C {devices/lab_pin.sym} 43010 -41970 0 0 {name=p42113 lab=_48802_/Y }
C {devices/lab_pin.sym} 43190 -41990 0 1 {name=p42114 lab=_86480_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -41980 0 0 {name=X_86480_ }
C {devices/lab_pin.sym} 43040 -41880 0 0 {name=p42115 lab=_52867_/A }
C {devices/lab_pin.sym} 43040 -41840 0 0 {name=p42116 lab=_52853_/B }
C {devices/lab_pin.sym} 43040 -41800 0 0 {name=p42117 lab=_52872_/C }
C {devices/lab_pin.sym} 43040 -41760 0 0 {name=p42118 lab=_52872_/D }
C {devices/lab_pin.sym} 43160 -41820 0 1 {name=p42119 lab=_52872_/X }
C {sky130_stdcells/and4_4.sym} 43100 -41820 0 0 {name=X_52872_ }
C {devices/lab_pin.sym} 43060 -41670 0 0 {name=p42120 lab=_64678_/A }
C {devices/lab_pin.sym} 43140 -41670 0 1 {name=p42121 lab=_64858_/X }
C {sky130_stdcells/buf_2.sym} 43100 -41670 0 0 {name=X_64858_ }
C {devices/lab_pin.sym} 43010 -41550 0 0 {name=p42122 lab=_85635_/CLK }
C {devices/lab_pin.sym} 43010 -41530 0 0 {name=p42123 lab=_83692_/D }
C {devices/lab_pin.sym} 43190 -41550 0 1 {name=p42124 lab=_47194_/A }
C {sky130_stdcells/dfxtp_4.sym} 43100 -41540 0 0 {name=X_83692_ }
C {devices/lab_pin.sym} 43060 -41410 0 0 {name=p42125 lab=_54558_/A }
C {devices/lab_pin.sym} 43140 -41410 0 1 {name=p42126 lab=_54611_/X }
C {sky130_stdcells/buf_2.sym} 43100 -41410 0 0 {name=X_54611_ }
C {devices/lab_pin.sym} 43010 -41290 0 0 {name=p42127 lab=_85431_/CLK }
C {devices/lab_pin.sym} 43010 -41270 0 0 {name=p42128 lab=_54499_/Y }
C {devices/lab_pin.sym} 43190 -41290 0 1 {name=p42129 lab=_85431_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -41280 0 0 {name=X_85431_ }
C {devices/lab_pin.sym} 43060 -41150 0 0 {name=p42130 lab=_51823_/A }
C {devices/lab_pin.sym} 43140 -41150 0 1 {name=p42131 lab=_51823_/X }
C {sky130_stdcells/buf_2.sym} 43100 -41150 0 0 {name=X_51823_ }
C {devices/lab_pin.sym} 43040 -41060 0 0 {name=p42132 lab=_63809_/A }
C {devices/lab_pin.sym} 43040 -41020 0 0 {name=p42133 lab=_63804_/Y }
C {devices/lab_pin.sym} 43040 -40980 0 0 {name=p42134 lab=_63805_/Y }
C {devices/lab_pin.sym} 43040 -40940 0 0 {name=p42135 lab=_63809_/D }
C {devices/lab_pin.sym} 43160 -41000 0 1 {name=p42136 lab=_63809_/X }
C {sky130_stdcells/and4_4.sym} 43100 -41000 0 0 {name=X_63809_ }
C {devices/lab_pin.sym} 43010 -40850 0 0 {name=p42137 lab=_84003_/CLK }
C {devices/lab_pin.sym} 43010 -40830 0 0 {name=p42138 lab=_82643_/D }
C {devices/lab_pin.sym} 43190 -40850 0 1 {name=p42139 lab=_82643_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -40840 0 0 {name=X_82643_ }
C {devices/lab_pin.sym} 43040 -40720 0 0 {name=p42140 lab=_67577_/A }
C {devices/lab_pin.sym} 43040 -40680 0 0 {name=p42141 lab=_67577_/B }
C {devices/lab_pin.sym} 43160 -40700 0 1 {name=p42142 lab=_67577_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -40700 0 0 {name=X_67577_ }
C {devices/lab_pin.sym} 43020 -40600 0 0 {name=p42143 lab=_83005_/Q }
C {devices/lab_pin.sym} 43020 -40560 0 0 {name=p42144 lab=_55617_/A }
C {devices/lab_pin.sym} 43020 -40520 0 0 {name=p42145 lab=_44099_/X }
C {devices/lab_pin.sym} 43020 -40480 0 0 {name=p42146 lab=_55590_/X }
C {devices/lab_pin.sym} 43180 -40540 0 1 {name=p42147 lab=_55592_/B }
C {sky130_stdcells/a211o_4.sym} 43100 -40540 0 0 {name=X_55591_ }
C {devices/lab_pin.sym} 43060 -40390 0 0 {name=p42148 lab=_64789_/A }
C {devices/lab_pin.sym} 43140 -40390 0 1 {name=p42149 lab=_64913_/B }
C {sky130_stdcells/buf_2.sym} 43100 -40390 0 0 {name=X_64789_ }
C {devices/lab_pin.sym} 43060 -40270 0 0 {name=p42150 lab=_57330_/A }
C {devices/lab_pin.sym} 43140 -40270 0 1 {name=p42151 lab=_57330_/Y }
C {sky130_stdcells/inv_2.sym} 43100 -40270 0 0 {name=X_57330_ }
C {devices/lab_pin.sym} 43040 -40160 0 0 {name=p42152 lab=_69286_/A }
C {devices/lab_pin.sym} 43040 -40120 0 0 {name=p42153 lab=_87782_/Q }
C {devices/lab_pin.sym} 43160 -40140 0 1 {name=p42154 lab=_69316_/X }
C {sky130_stdcells/and2_4.sym} 43100 -40140 0 0 {name=X_69316_ }
C {devices/lab_pin.sym} 43010 -40010 0 0 {name=p42155 lab=_87436_/CLK }
C {devices/lab_pin.sym} 43010 -39990 0 0 {name=p42156 lab=_88150_/D }
C {devices/lab_pin.sym} 43190 -40010 0 1 {name=p42157 lab=_88150_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -40000 0 0 {name=X_88150_ }
C {devices/lab_pin.sym} 43040 -39880 0 0 {name=p42158 lab=_54546_/A }
C {devices/lab_pin.sym} 43040 -39840 0 0 {name=p42159 lab=_53364_/B }
C {devices/lab_pin.sym} 43160 -39860 0 1 {name=p42160 lab=_54542_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -39860 0 0 {name=X_54542_ }
C {devices/lab_pin.sym} 43060 -39730 0 0 {name=p42161 lab=_68386_/A }
C {devices/lab_pin.sym} 43140 -39730 0 1 {name=p42162 lab=_69315_/A }
C {sky130_stdcells/buf_2.sym} 43100 -39730 0 0 {name=X_66528_ }
C {devices/lab_pin.sym} 43010 -39610 0 0 {name=p42163 lab=_86289_/CLK }
C {devices/lab_pin.sym} 43010 -39590 0 0 {name=p42164 lab=_54875_/Y }
C {devices/lab_pin.sym} 43190 -39610 0 1 {name=p42165 lab=_85362_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -39600 0 0 {name=X_85362_ }
C {devices/lab_pin.sym} 43060 -39470 0 0 {name=p42166 lab=_52679_/A }
C {devices/lab_pin.sym} 43140 -39470 0 1 {name=p42167 lab=_51781_/A }
C {sky130_stdcells/buf_2.sym} 43100 -39470 0 0 {name=X_51754_ }
C {devices/lab_pin.sym} 43010 -39350 0 0 {name=p42168 lab=_82575_/CLK }
C {devices/lab_pin.sym} 43010 -39330 0 0 {name=p42169 lab=_82606_/Q }
C {devices/lab_pin.sym} 43190 -39350 0 1 {name=p42170 lab=_78161_/A }
C {sky130_stdcells/dfxtp_4.sym} 43100 -39340 0 0 {name=X_82574_ }
C {devices/lab_pin.sym} 43010 -39210 0 0 {name=p42171 lab=_88288_/CLK }
C {devices/lab_pin.sym} 43010 -39190 0 0 {name=p42172 lab=_44457_/Y }
C {devices/lab_pin.sym} 43190 -39210 0 1 {name=p42173 lab=_87101_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -39200 0 0 {name=X_87101_ }
C {devices/lab_pin.sym} 43010 -39070 0 0 {name=p42174 lab=_84314_/CLK }
C {devices/lab_pin.sym} 43010 -39050 0 0 {name=p42175 lab=_84313_/D }
C {devices/lab_pin.sym} 43190 -39070 0 1 {name=p42176 lab=_80455_/B }
C {sky130_stdcells/dfxtp_4.sym} 43100 -39060 0 0 {name=X_84313_ }
C {devices/lab_pin.sym} 43020 -38950 0 0 {name=p42177 lab=_50703_/Y }
C {devices/lab_pin.sym} 43020 -38910 0 0 {name=p42178 lab=_50699_/X }
C {devices/lab_pin.sym} 43020 -38870 0 0 {name=p42179 lab=_50704_/Y }
C {devices/lab_pin.sym} 43180 -38910 0 1 {name=p42180 lab=_50705_/Y }
C {sky130_stdcells/a21boi_4.sym} 43100 -38910 0 0 {name=X_50705_ }
C {devices/lab_pin.sym} 43060 -38770 0 0 {name=p42181 lab=_44287_/X }
C {devices/lab_pin.sym} 43140 -38770 0 1 {name=p42182 lab=_57261_/X }
C {sky130_stdcells/buf_2.sym} 43100 -38770 0 0 {name=X_57261_ }
C {devices/lab_pin.sym} 43010 -38650 0 0 {name=p42183 lab=_82053_/CLK }
C {devices/lab_pin.sym} 43010 -38630 0 0 {name=p42184 lab=_81525_/D }
C {devices/lab_pin.sym} 43190 -38650 0 1 {name=p42185 lab=_81525_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -38640 0 0 {name=X_81525_ }
C {devices/lab_pin.sym} 43020 -38540 0 0 {name=p42186 lab=_88043_/Q }
C {devices/lab_pin.sym} 43020 -38500 0 0 {name=p42187 lab=_69217_/X }
C {devices/lab_pin.sym} 43020 -38460 0 0 {name=p42188 lab=_69245_/X }
C {devices/lab_pin.sym} 43020 -38420 0 0 {name=p42189 lab=_69246_/X }
C {devices/lab_pin.sym} 43180 -38480 0 1 {name=p42190 lab=_69247_/X }
C {sky130_stdcells/a211o_4.sym} 43100 -38480 0 0 {name=X_69247_ }
C {devices/lab_pin.sym} 43010 -38330 0 0 {name=p42191 lab=_88081_/CLK }
C {devices/lab_pin.sym} 43010 -38310 0 0 {name=p42192 lab=_41987_/Y }
C {devices/lab_pin.sym} 43190 -38330 0 1 {name=p42193 lab=_88081_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -38320 0 0 {name=X_88081_ }
C {devices/lab_pin.sym} 43040 -38200 0 0 {name=p42194 lab=_54478_/A }
C {devices/lab_pin.sym} 43040 -38160 0 0 {name=p42195 lab=_54473_/B }
C {devices/lab_pin.sym} 43160 -38180 0 1 {name=p42196 lab=_54473_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -38180 0 0 {name=X_54473_ }
C {devices/lab_pin.sym} 43040 -38070 0 0 {name=p42197 lab=_65078_/X }
C {devices/lab_pin.sym} 43040 -38030 0 0 {name=p42198 lab=_66518_/B }
C {devices/lab_pin.sym} 43040 -37990 0 0 {name=p42199 lab=_65080_/X }
C {devices/lab_pin.sym} 43160 -38030 0 1 {name=p42200 lab=_66459_/Y }
C {sky130_stdcells/nand3_4.sym} 43100 -38030 0 0 {name=X_66459_ }
C {devices/lab_pin.sym} 43010 -37890 0 0 {name=p42201 lab=_85257_/CLK }
C {devices/lab_pin.sym} 43010 -37870 0 0 {name=p42202 lab=_85293_/D }
C {devices/lab_pin.sym} 43190 -37890 0 1 {name=p42203 lab=_85293_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -37880 0 0 {name=X_85293_ }
C {devices/lab_pin.sym} 43020 -37770 0 0 {name=p42204 lab=_51682_/Y }
C {devices/lab_pin.sym} 43020 -37730 0 0 {name=p42205 lab=_51667_/X }
C {devices/lab_pin.sym} 43020 -37690 0 0 {name=p42206 lab=_51684_/X }
C {devices/lab_pin.sym} 43180 -37730 0 1 {name=p42207 lab=_51685_/Y }
C {sky130_stdcells/a21oi_4.sym} 43100 -37730 0 0 {name=X_51685_ }
C {devices/lab_pin.sym} 43020 -37610 0 0 {name=p42208 lab=_58925_/X }
C {devices/lab_pin.sym} 43020 -37570 0 0 {name=p42209 lab=_85441_/Q }
C {devices/lab_pin.sym} 43020 -37530 0 0 {name=p42210 lab=_58999_/X }
C {devices/lab_pin.sym} 43180 -37570 0 1 {name=p42211 lab=_59000_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -37570 0 0 {name=X_59000_ }
C {devices/lab_pin.sym} 43020 -37450 0 0 {name=p42212 lab=_56040_/X }
C {devices/lab_pin.sym} 43020 -37410 0 0 {name=p42213 lab=_56210_/X }
C {devices/lab_pin.sym} 43020 -37370 0 0 {name=p42214 lab=_56211_/Y }
C {devices/lab_pin.sym} 43180 -37410 0 1 {name=p42215 lab=_56212_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -37410 0 0 {name=X_56212_ }
C {devices/lab_pin.sym} 43010 -37270 0 0 {name=p42216 lab=_87032_/CLK }
C {devices/lab_pin.sym} 43010 -37250 0 0 {name=p42217 lab=_87032_/D }
C {devices/lab_pin.sym} 43190 -37270 0 1 {name=p42218 lab=_87032_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -37260 0 0 {name=X_87032_ }
C {devices/lab_pin.sym} 43040 -37160 0 0 {name=p42219 lab=_53420_/A }
C {devices/lab_pin.sym} 43040 -37120 0 0 {name=p42220 lab=_53402_/B }
C {devices/lab_pin.sym} 43040 -37080 0 0 {name=p42221 lab=_53410_/C }
C {devices/lab_pin.sym} 43040 -37040 0 0 {name=p42222 lab=_51220_/D }
C {devices/lab_pin.sym} 43160 -37100 0 1 {name=p42223 lab=_53424_/X }
C {sky130_stdcells/and4_4.sym} 43100 -37100 0 0 {name=X_53424_ }
C {devices/lab_pin.sym} 43010 -36950 0 0 {name=p42224 lab=_84241_/CLK }
C {devices/lab_pin.sym} 43010 -36930 0 0 {name=p42225 lab=_64463_/Y }
C {devices/lab_pin.sym} 43190 -36950 0 1 {name=p42226 lab=_79658_/B }
C {sky130_stdcells/dfxtp_4.sym} 43100 -36940 0 0 {name=X_84244_ }
C {devices/lab_pin.sym} 43040 -36820 0 0 {name=p42227 lab=_50627_/X }
C {devices/lab_pin.sym} 43040 -36780 0 0 {name=p42228 lab=_52338_/B }
C {devices/lab_pin.sym} 43160 -36800 0 1 {name=p42229 lab=_50636_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -36800 0 0 {name=X_50636_ }
C {devices/lab_pin.sym} 43010 -36670 0 0 {name=p42230 lab=_81492_/CLK }
C {devices/lab_pin.sym} 43010 -36650 0 0 {name=p42231 lab=_76783_/B }
C {devices/lab_pin.sym} 43190 -36670 0 1 {name=p42232 lab=_81456_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -36660 0 0 {name=X_81456_ }
C {devices/lab_pin.sym} 43040 -36540 0 0 {name=p42233 lab=_57192_/A }
C {devices/lab_pin.sym} 43040 -36500 0 0 {name=p42234 lab=_85065_/Q }
C {devices/lab_pin.sym} 43160 -36520 0 1 {name=p42235 lab=_57195_/B }
C {sky130_stdcells/nand2_4.sym} 43100 -36520 0 0 {name=X_57192_ }
C {devices/lab_pin.sym} 43060 -36390 0 0 {name=p42236 lab=_69178_/A }
C {devices/lab_pin.sym} 43140 -36390 0 1 {name=p42237 lab=_69179_/A }
C {sky130_stdcells/buf_2.sym} 43100 -36390 0 0 {name=X_69178_ }
C {devices/lab_pin.sym} 43060 -36270 0 0 {name=p42238 lab=_44267_/A }
C {devices/lab_pin.sym} 43140 -36270 0 1 {name=p42239 lab=_44284_/C }
C {sky130_stdcells/buf_2.sym} 43100 -36270 0 0 {name=Xpsn_inst_psn_buff_4 }
C {devices/lab_pin.sym} 43020 -36170 0 0 {name=p42240 lab=_80394_/X }
C {devices/lab_pin.sym} 43020 -36130 0 0 {name=p42241 lab=_80405_/X }
C {devices/lab_pin.sym} 43020 -36090 0 0 {name=p42242 lab=_80406_/X }
C {devices/lab_pin.sym} 43180 -36130 0 1 {name=p42243 lab=_80407_/Y }
C {sky130_stdcells/a21oi_4.sym} 43100 -36130 0 0 {name=X_80407_ }
C {devices/lab_pin.sym} 43040 -36000 0 0 {name=p42244 lab=_56117_/B }
C {devices/lab_pin.sym} 43040 -35960 0 0 {name=p42245 lab=_56143_/B }
C {devices/lab_pin.sym} 43160 -35980 0 1 {name=p42246 lab=_56144_/A }
C {sky130_stdcells/xnor2_4.sym} 43100 -35980 0 0 {name=X_56143_ }
C {devices/lab_pin.sym} 43060 -35850 0 0 {name=p42247 lab=_68129_/A }
C {devices/lab_pin.sym} 43140 -35850 0 1 {name=p42248 lab=_68129_/X }
C {sky130_stdcells/buf_2.sym} 43100 -35850 0 0 {name=X_68129_ }
C {devices/lab_pin.sym} 43060 -35730 0 0 {name=p42249 lab=_53355_/A }
C {devices/lab_pin.sym} 43140 -35730 0 1 {name=p42250 lab=_53355_/X }
C {sky130_stdcells/buf_2.sym} 43100 -35730 0 0 {name=X_53355_ }
C {devices/lab_pin.sym} 43010 -35610 0 0 {name=p42251 lab=_84175_/CLK }
C {devices/lab_pin.sym} 43010 -35590 0 0 {name=p42252 lab=_65832_/X }
C {devices/lab_pin.sym} 43190 -35610 0 1 {name=p42253 lab=_84175_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -35600 0 0 {name=X_84175_ }
C {devices/lab_pin.sym} 43060 -35470 0 0 {name=p42254 lab=_50538_/A }
C {devices/lab_pin.sym} 43140 -35470 0 1 {name=p42255 lab=_50568_/C }
C {sky130_stdcells/buf_2.sym} 43100 -35470 0 0 {name=X_50567_ }
C {devices/lab_pin.sym} 43010 -35350 0 0 {name=p42256 lab=_81322_/CLK }
C {devices/lab_pin.sym} 43010 -35330 0 0 {name=p42257 lab=_83923_/Q }
C {devices/lab_pin.sym} 43190 -35350 0 1 {name=p42258 lab=_76874_/B }
C {sky130_stdcells/dfxtp_4.sym} 43100 -35340 0 0 {name=X_81387_ }
C {devices/lab_pin.sym} 43060 -35210 0 0 {name=p42259 lab=_40326_/A }
C {devices/lab_pin.sym} 43140 -35210 0 1 {name=p42260 lab=_40321_/A }
C {sky130_stdcells/inv_2.sym} 43100 -35210 0 0 {name=X_40320_ }
C {devices/lab_pin.sym} 43020 -35110 0 0 {name=p42261 lab=_52304_/Y }
C {devices/lab_pin.sym} 43020 -35070 0 0 {name=p42262 lab=_52289_/X }
C {devices/lab_pin.sym} 43020 -35030 0 0 {name=p42263 lab=_52305_/X }
C {devices/lab_pin.sym} 43180 -35070 0 1 {name=p42264 lab=_85849_/D }
C {sky130_stdcells/a21oi_4.sym} 43100 -35070 0 0 {name=X_52306_ }
C {devices/lab_pin.sym} 43060 -34930 0 0 {name=p42265 lab=_70716_/A }
C {devices/lab_pin.sym} 43140 -34930 0 1 {name=p42266 lab=_71152_/C }
C {sky130_stdcells/buf_2.sym} 43100 -34930 0 0 {name=X_71140_ }
C {devices/lab_pin.sym} 43010 -34810 0 0 {name=p42267 lab=_83145_/CLK }
C {devices/lab_pin.sym} 43010 -34790 0 0 {name=p42268 lab=_83126_/D }
C {devices/lab_pin.sym} 43190 -34810 0 1 {name=p42269 lab=_83126_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -34800 0 0 {name=X_83126_ }
C {devices/lab_pin.sym} 43060 -34670 0 0 {name=p42270 lab=_56073_/Y }
C {devices/lab_pin.sym} 43140 -34670 0 1 {name=p42271 lab=_56074_/X }
C {sky130_stdcells/buf_2.sym} 43100 -34670 0 0 {name=X_56074_ }
C {devices/lab_pin.sym} 43020 -34570 0 0 {name=p42272 lab=_80320_/Y }
C {devices/lab_pin.sym} 43020 -34530 0 0 {name=p42273 lab=_80322_/B }
C {devices/lab_pin.sym} 43020 -34490 0 0 {name=p42274 lab=_80320_/A }
C {devices/lab_pin.sym} 43180 -34530 0 1 {name=p42275 lab=_80338_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -34530 0 0 {name=X_80338_ }
C {devices/lab_pin.sym} 43040 -34400 0 0 {name=p42276 lab=_53276_/A }
C {devices/lab_pin.sym} 43040 -34360 0 0 {name=p42277 lab=_54464_/B }
C {devices/lab_pin.sym} 43160 -34380 0 1 {name=p42278 lab=_53286_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -34380 0 0 {name=X_53286_ }
C {devices/lab_pin.sym} 43020 -34270 0 0 {name=p42279 lab=_50495_/Y }
C {devices/lab_pin.sym} 43020 -34230 0 0 {name=p42280 lab=_50491_/X }
C {devices/lab_pin.sym} 43020 -34190 0 0 {name=p42281 lab=_50497_/X }
C {devices/lab_pin.sym} 43180 -34230 0 1 {name=p42282 lab=_86189_/D }
C {sky130_stdcells/a21oi_4.sym} 43100 -34230 0 0 {name=X_50498_ }
C {devices/lab_pin.sym} 43040 -34110 0 0 {name=p42283 lab=_60122_/A }
C {devices/lab_pin.sym} 43040 -34070 0 0 {name=p42284 lab=_59901_/Y }
C {devices/lab_pin.sym} 43040 -34030 0 0 {name=p42285 lab=_60122_/C }
C {devices/lab_pin.sym} 43160 -34070 0 1 {name=p42286 lab=_59903_/A }
C {sky130_stdcells/nand3_4.sym} 43100 -34070 0 0 {name=X_59902_ }
C {devices/lab_pin.sym} 43060 -33930 0 0 {name=p42287 lab=_54973_/A }
C {devices/lab_pin.sym} 43140 -33930 0 1 {name=p42288 lab=_55026_/C }
C {sky130_stdcells/buf_2.sym} 43100 -33930 0 0 {name=X_55025_ }
C {devices/lab_pin.sym} 43040 -33830 0 0 {name=p42289 lab=_48667_/A }
C {devices/lab_pin.sym} 43040 -33790 0 0 {name=p42290 lab=_52248_/B }
C {devices/lab_pin.sym} 43040 -33750 0 0 {name=p42291 lab=_52223_/C }
C {devices/lab_pin.sym} 43160 -33790 0 1 {name=p42292 lab=_52237_/X }
C {sky130_stdcells/and3_4.sym} 43100 -33790 0 0 {name=X_52237_ }
C {devices/lab_pin.sym} 43060 -33650 0 0 {name=p42293 lab=_71071_/A }
C {devices/lab_pin.sym} 43140 -33650 0 1 {name=p42294 lab=_71078_/A }
C {sky130_stdcells/buf_2.sym} 43100 -33650 0 0 {name=X_71071_ }
C {devices/lab_pin.sym} 43010 -33530 0 0 {name=p42295 lab=_85566_/CLK }
C {devices/lab_pin.sym} 43010 -33510 0 0 {name=p42296 lab=_83057_/D }
C {devices/lab_pin.sym} 43190 -33530 0 1 {name=p42297 lab=_83057_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -33520 0 0 {name=X_83057_ }
C {devices/lab_pin.sym} 43010 -33390 0 0 {name=p42298 lab=_82886_/CLK }
C {devices/lab_pin.sym} 43010 -33370 0 0 {name=p42299 lab=_87934_/D }
C {devices/lab_pin.sym} 43190 -33390 0 1 {name=p42300 lab=_87934_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -33380 0 0 {name=X_87934_ }
C {devices/lab_pin.sym} 43040 -33260 0 0 {name=p42301 lab=_80266_/Y }
C {devices/lab_pin.sym} 43040 -33220 0 0 {name=p42302 lab=_80268_/Y }
C {devices/lab_pin.sym} 43160 -33240 0 1 {name=p42303 lab=_80636_/A }
C {sky130_stdcells/nand2_4.sym} 43100 -33240 0 0 {name=X_80269_ }
C {devices/lab_pin.sym} 43060 -33110 0 0 {name=p42304 lab=clkbuf_9_246_0_CLK/X }
C {devices/lab_pin.sym} 43140 -33110 0 1 {name=p42305 lab=_86398_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 43100 -33110 0 0 {name=Xclkbuf_10_493_0_CLK }
C {devices/lab_pin.sym} 43020 -33010 0 0 {name=p42306 lab=_83871_/Q }
C {devices/lab_pin.sym} 43020 -32970 0 0 {name=p42307 lab=_70010_/X }
C {devices/lab_pin.sym} 43020 -32930 0 0 {name=p42308 lab=_70021_/Y }
C {devices/lab_pin.sym} 43180 -32970 0 1 {name=p42309 lab=_70022_/X }
C {sky130_stdcells/a21bo_4.sym} 43100 -32970 0 0 {name=X_70022_ }
C {devices/lab_pin.sym} 43010 -32830 0 0 {name=p42310 lab=_82008_/CLK }
C {devices/lab_pin.sym} 43010 -32810 0 0 {name=p42311 lab=_82040_/Q }
C {devices/lab_pin.sym} 43190 -32830 0 1 {name=p42312 lab=_77174_/B }
C {sky130_stdcells/dfxtp_4.sym} 43100 -32820 0 0 {name=X_82008_ }
C {devices/lab_pin.sym} 43060 -32690 0 0 {name=p42313 lab=_65044_/A }
C {devices/lab_pin.sym} 43140 -32690 0 1 {name=p42314 lab=_59833_/X }
C {sky130_stdcells/buf_2.sym} 43100 -32690 0 0 {name=X_59833_ }
C {devices/lab_pin.sym} 43040 -32580 0 0 {name=p42315 lab=_52168_/A }
C {devices/lab_pin.sym} 43040 -32540 0 0 {name=p42316 lab=_50466_/B }
C {devices/lab_pin.sym} 43160 -32560 0 1 {name=p42317 lab=_52168_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -32560 0 0 {name=X_52168_ }
C {devices/lab_pin.sym} 43010 -32430 0 0 {name=p42318 lab=_87865_/CLK }
C {devices/lab_pin.sym} 43010 -32410 0 0 {name=p42319 lab=_87865_/D }
C {devices/lab_pin.sym} 43190 -32430 0 1 {name=p42320 lab=_87865_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -32420 0 0 {name=X_87865_ }
C {devices/lab_pin.sym} 43060 -32290 0 0 {name=p42321 lab=_51039_/A }
C {devices/lab_pin.sym} 43140 -32290 0 1 {name=p42322 lab=_51119_/X }
C {sky130_stdcells/buf_2.sym} 43100 -32290 0 0 {name=X_51119_ }
C {devices/lab_pin.sym} 43060 -32170 0 0 {name=p42323 lab=_74829_/Y }
C {devices/lab_pin.sym} 43140 -32170 0 1 {name=p42324 lab=_80658_/D }
C {sky130_stdcells/inv_2.sym} 43100 -32170 0 0 {name=X_74830_ }
C {devices/lab_pin.sym} 43010 -32050 0 0 {name=p42325 lab=_86784_/CLK }
C {devices/lab_pin.sym} 43010 -32030 0 0 {name=p42326 lab=_46011_/Y }
C {devices/lab_pin.sym} 43190 -32050 0 1 {name=p42327 lab=_67107_/B }
C {sky130_stdcells/dfxtp_4.sym} 43100 -32040 0 0 {name=X_86816_ }
C {devices/lab_pin.sym} 43060 -31910 0 0 {name=p42328 lab=_59722_/A }
C {devices/lab_pin.sym} 43140 -31910 0 1 {name=p42329 lab=_59765_/A }
C {sky130_stdcells/buf_2.sym} 43100 -31910 0 0 {name=X_59764_ }
C {devices/lab_pin.sym} 43040 -31800 0 0 {name=p42330 lab=_44990_/A }
C {devices/lab_pin.sym} 43040 -31760 0 0 {name=p42331 lab=_45033_/B }
C {devices/lab_pin.sym} 43160 -31780 0 1 {name=p42332 lab=_44990_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -31780 0 0 {name=X_44990_ }
C {devices/lab_pin.sym} 43020 -31670 0 0 {name=p42333 lab=_52096_/Y }
C {devices/lab_pin.sym} 43020 -31630 0 0 {name=p42334 lab=_52049_/X }
C {devices/lab_pin.sym} 43020 -31590 0 0 {name=p42335 lab=_52098_/X }
C {devices/lab_pin.sym} 43180 -31630 0 1 {name=p42336 lab=_85889_/D }
C {sky130_stdcells/a21oi_4.sym} 43100 -31630 0 0 {name=X_52099_ }
C {devices/lab_pin.sym} 43060 -31490 0 0 {name=p42337 lab=_56985_/D }
C {devices/lab_pin.sym} 43140 -31490 0 1 {name=p42338 lab=_56976_/X }
C {sky130_stdcells/buf_2.sym} 43100 -31490 0 0 {name=X_56976_ }
C {devices/lab_pin.sym} 43010 -31370 0 0 {name=p42339 lab=_88085_/CLK }
C {devices/lab_pin.sym} 43010 -31350 0 0 {name=p42340 lab=_42625_/Y }
C {devices/lab_pin.sym} 43190 -31370 0 1 {name=p42341 lab=_73527_/A }
C {sky130_stdcells/dfxtp_4.sym} 43100 -31360 0 0 {name=X_87796_ }
C {devices/lab_pin.sym} 43060 -31230 0 0 {name=p42342 lab=_64679_/A }
C {devices/lab_pin.sym} 43140 -31230 0 1 {name=p42343 lab=_58847_/A }
C {sky130_stdcells/buf_2.sym} 43100 -31230 0 0 {name=X_58715_ }
C {devices/lab_pin.sym} 43060 -31110 0 0 {name=p42344 lab=_45964_/A }
C {devices/lab_pin.sym} 43140 -31110 0 1 {name=p42345 lab=_43941_/X }
C {sky130_stdcells/buf_2.sym} 43100 -31110 0 0 {name=X_43941_ }
C {devices/lab_pin.sym} 43060 -30990 0 0 {name=p42346 lab=_55926_/X }
C {devices/lab_pin.sym} 43140 -30990 0 1 {name=p42347 lab=_55927_/X }
C {sky130_stdcells/buf_2.sym} 43100 -30990 0 0 {name=X_55927_ }
C {devices/lab_pin.sym} 43020 -30890 0 0 {name=p42348 lab=_70325_/Y }
C {devices/lab_pin.sym} 43020 -30850 0 0 {name=p42349 lab=_71012_/B }
C {devices/lab_pin.sym} 43020 -30810 0 0 {name=p42350 lab=_74760_/Y }
C {devices/lab_pin.sym} 43180 -30850 0 1 {name=p42351 lab=_74761_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -30850 0 0 {name=X_74761_ }
C {devices/lab_pin.sym} 43010 -30710 0 0 {name=p42352 lab=_85822_/CLK }
C {devices/lab_pin.sym} 43010 -30690 0 0 {name=p42353 lab=_46332_/Y }
C {devices/lab_pin.sym} 43190 -30710 0 1 {name=p42354 lab=_86747_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -30700 0 0 {name=X_86747_ }
C {devices/lab_pin.sym} 43020 -30590 0 0 {name=p42355 lab=_83310_/Q }
C {devices/lab_pin.sym} 43020 -30550 0 0 {name=p42356 lab=_57635_/X }
C {devices/lab_pin.sym} 43020 -30510 0 0 {name=p42357 lab=_71972_/Y }
C {devices/lab_pin.sym} 43180 -30550 0 1 {name=p42358 lab=_71973_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -30550 0 0 {name=X_71973_ }
C {devices/lab_pin.sym} 43020 -30430 0 0 {name=p42359 lab=_59691_/X }
C {devices/lab_pin.sym} 43020 -30390 0 0 {name=p42360 lab=_62183_/A }
C {devices/lab_pin.sym} 43020 -30350 0 0 {name=p42361 lab=_59631_/Y }
C {devices/lab_pin.sym} 43180 -30390 0 1 {name=p42362 lab=_59695_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -30390 0 0 {name=X_59695_ }
C {devices/lab_pin.sym} 43010 -30250 0 0 {name=p42363 lab=_80991_/CLK }
C {devices/lab_pin.sym} 43010 -30230 0 0 {name=p42364 lab=_68837_/X }
C {devices/lab_pin.sym} 43190 -30250 0 1 {name=p42365 lab=_83959_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -30240 0 0 {name=X_83959_ }
C {devices/lab_pin.sym} 43040 -30120 0 0 {name=p42366 lab=_76500_/A }
C {devices/lab_pin.sym} 43040 -30080 0 0 {name=p42367 lab=_76499_/X }
C {devices/lab_pin.sym} 43160 -30100 0 1 {name=p42368 lab=_76500_/X }
C {sky130_stdcells/xor2_4.sym} 43100 -30100 0 0 {name=X_76500_ }
C {devices/lab_pin.sym} 43020 -30000 0 0 {name=p42369 lab=_73609_/X }
C {devices/lab_pin.sym} 43020 -29960 0 0 {name=p42370 lab=_85627_/Q }
C {devices/lab_pin.sym} 43020 -29920 0 0 {name=p42371 lab=_73661_/X }
C {devices/lab_pin.sym} 43020 -29880 0 0 {name=p42372 lab=_73711_/X }
C {devices/lab_pin.sym} 43180 -29940 0 1 {name=p42373 lab=_73712_/X }
C {sky130_stdcells/a211o_4.sym} 43100 -29940 0 0 {name=X_73712_ }
C {devices/lab_pin.sym} 43020 -29810 0 0 {name=p42374 lab=_46652_/Y }
C {devices/lab_pin.sym} 43020 -29770 0 0 {name=p42375 lab=_46654_/X }
C {devices/lab_pin.sym} 43020 -29730 0 0 {name=p42376 lab=_46659_/X }
C {devices/lab_pin.sym} 43180 -29770 0 1 {name=p42377 lab=_86717_/D }
C {sky130_stdcells/a21oi_4.sym} 43100 -29770 0 0 {name=X_46660_ }
C {devices/lab_pin.sym} 43060 -29630 0 0 {name=p42378 lab=_58939_/A }
C {devices/lab_pin.sym} 43140 -29630 0 1 {name=p42379 lab=_58646_/X }
C {sky130_stdcells/buf_2.sym} 43100 -29630 0 0 {name=X_58646_ }
C {devices/lab_pin.sym} 43020 -29530 0 0 {name=p42380 lab=_51037_/B }
C {devices/lab_pin.sym} 43020 -29490 0 0 {name=p42381 lab=_70909_/X }
C {devices/lab_pin.sym} 43020 -29450 0 0 {name=p42382 lab=_70923_/Y }
C {devices/lab_pin.sym} 43180 -29490 0 1 {name=p42383 lab=_83661_/D }
C {sky130_stdcells/o21ai_4.sym} 43100 -29490 0 0 {name=X_70924_ }
C {devices/lab_pin.sym} 43060 -29350 0 0 {name=p42384 lab=_77479_/X }
C {devices/lab_pin.sym} 43140 -29350 0 1 {name=p42385 lab=_77480_/Y }
C {sky130_stdcells/inv_2.sym} 43100 -29350 0 0 {name=X_77480_ }
C {devices/lab_pin.sym} 43020 -29260 0 0 {name=p42386 lab=_41259_/X }
C {devices/lab_pin.sym} 43020 -29220 0 0 {name=p42387 lab=_43868_/X }
C {devices/lab_pin.sym} 43020 -29180 0 0 {name=p42388 lab=_69011_/B }
C {devices/lab_pin.sym} 43020 -29140 0 0 {name=p42389 lab=_43870_/X }
C {devices/lab_pin.sym} 43180 -29200 0 1 {name=p42390 lab=_87225_/D }
C {sky130_stdcells/a2bb2o_4.sym} 43100 -29200 0 0 {name=X_43872_ }
C {devices/lab_pin.sym} 43020 -29080 0 0 {name=p42391 lab=_56414_/C }
C {devices/lab_pin.sym} 43020 -29040 0 0 {name=p42392 lab=_55489_/A }
C {devices/lab_pin.sym} 43020 -29000 0 0 {name=p42393 lab=_55512_/X }
C {devices/lab_pin.sym} 43020 -28960 0 0 {name=p42394 lab=_55857_/X }
C {devices/lab_pin.sym} 43180 -29020 0 1 {name=p42395 lab=_55858_/X }
C {sky130_stdcells/a211o_4.sym} 43100 -29020 0 0 {name=X_55858_ }
C {devices/lab_pin.sym} 43020 -28890 0 0 {name=p42396 lab=_74675_/X }
C {devices/lab_pin.sym} 43020 -28850 0 0 {name=p42397 lab=_56873_/X }
C {devices/lab_pin.sym} 43020 -28810 0 0 {name=p42398 lab=_74691_/Y }
C {devices/lab_pin.sym} 43180 -28850 0 1 {name=p42399 lab=_74693_/A }
C {sky130_stdcells/o21ai_4.sym} 43100 -28850 0 0 {name=X_74692_ }
C {devices/lab_pin.sym} 43010 -28710 0 0 {name=p42400 lab=_86359_/CLK }
C {devices/lab_pin.sym} 43010 -28690 0 0 {name=p42401 lab=_86678_/D }
C {devices/lab_pin.sym} 43190 -28710 0 1 {name=p42402 lab=_59131_/A }
C {sky130_stdcells/dfxtp_4.sym} 43100 -28700 0 0 {name=X_86678_ }
C {devices/lab_pin.sym} 43060 -28570 0 0 {name=p42403 lab=_45611_/A }
C {devices/lab_pin.sym} 43140 -28570 0 1 {name=p42404 lab=_55470_/B }
C {sky130_stdcells/inv_2.sym} 43100 -28570 0 0 {name=X_45611_ }
C {devices/lab_pin.sym} 43020 -28470 0 0 {name=p42405 lab=_76430_/B }
C {devices/lab_pin.sym} 43020 -28430 0 0 {name=p42406 lab=_76430_/C }
C {devices/lab_pin.sym} 43020 -28390 0 0 {name=p42407 lab=_76430_/A }
C {devices/lab_pin.sym} 43180 -28430 0 1 {name=p42408 lab=_76431_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -28430 0 0 {name=X_76431_ }
C {devices/lab_pin.sym} 43060 -28290 0 0 {name=p42409 lab=_54889_/A }
C {devices/lab_pin.sym} 43140 -28290 0 1 {name=p42410 lab=_54831_/C }
C {sky130_stdcells/buf_2.sym} 43100 -28290 0 0 {name=X_54809_ }
C {devices/lab_pin.sym} 43020 -28200 0 0 {name=p42411 lab=_41447_/X }
C {devices/lab_pin.sym} 43020 -28160 0 0 {name=p42412 lab=_42821_/X }
C {devices/lab_pin.sym} 43020 -28120 0 0 {name=p42413 lab=_87701_/Q }
C {devices/lab_pin.sym} 43020 -28080 0 0 {name=p42414 lab=_42822_/X }
C {devices/lab_pin.sym} 43180 -28140 0 1 {name=p42415 lab=_42823_/X }
C {sky130_stdcells/a2bb2o_4.sym} 43100 -28140 0 0 {name=X_42823_ }
C {devices/lab_pin.sym} 43040 -28000 0 0 {name=p42416 lab=_73643_/A }
C {devices/lab_pin.sym} 43040 -27960 0 0 {name=p42417 lab=_73642_/X }
C {devices/lab_pin.sym} 43160 -27980 0 1 {name=p42418 lab=_73644_/B }
C {sky130_stdcells/nand2_4.sym} 43100 -27980 0 0 {name=X_73643_ }
C {devices/lab_pin.sym} 43010 -27850 0 0 {name=p42419 lab=_86237_/CLK }
C {devices/lab_pin.sym} 43010 -27830 0 0 {name=p42420 lab=_85629_/D }
C {devices/lab_pin.sym} 43190 -27850 0 1 {name=p42421 lab=_85629_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -27840 0 0 {name=X_85629_ }
C {devices/lab_pin.sym} 43060 -27710 0 0 {name=p42422 lab=_70855_/A }
C {devices/lab_pin.sym} 43140 -27710 0 1 {name=p42423 lab=_70855_/X }
C {sky130_stdcells/buf_2.sym} 43100 -27710 0 0 {name=X_70855_ }
C {devices/lab_pin.sym} 43060 -27590 0 0 {name=p42424 lab=_46591_/A }
C {devices/lab_pin.sym} 43140 -27590 0 1 {name=p42425 lab=_54087_/B }
C {sky130_stdcells/buf_2.sym} 43100 -27590 0 0 {name=X_46591_ }
C {devices/lab_pin.sym} 43040 -27480 0 0 {name=p42426 lab=_58577_/A }
C {devices/lab_pin.sym} 43040 -27440 0 0 {name=p42427 lab=_58614_/B }
C {devices/lab_pin.sym} 43160 -27460 0 1 {name=p42428 lab=_58577_/Y }
C {sky130_stdcells/nor2_4.sym} 43100 -27460 0 0 {name=X_58577_ }
C {devices/lab_pin.sym} 43020 -27360 0 0 {name=p42429 lab=_45244_/A }
C {devices/lab_pin.sym} 43020 -27320 0 0 {name=p42430 lab=_55306_/X }
C {devices/lab_pin.sym} 43020 -27280 0 0 {name=p42431 lab=_55172_/X }
C {devices/lab_pin.sym} 43020 -27240 0 0 {name=p42432 lab=_55788_/X }
C {devices/lab_pin.sym} 43180 -27300 0 1 {name=p42433 lab=_55790_/B }
C {sky130_stdcells/a211o_4.sym} 43100 -27300 0 0 {name=X_55789_ }
C {devices/lab_pin.sym} 43040 -27160 0 0 {name=p42434 lab=_48348_/A }
C {devices/lab_pin.sym} 43040 -27120 0 0 {name=p42435 lab=_50372_/B }
C {devices/lab_pin.sym} 43160 -27140 0 1 {name=p42436 lab=_48330_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -27140 0 0 {name=X_48330_ }
C {devices/lab_pin.sym} 43060 -27010 0 0 {name=p42437 lab=clkbuf_9_215_0_CLK/X }
C {devices/lab_pin.sym} 43140 -27010 0 1 {name=p42438 lab=_84177_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 43100 -27010 0 0 {name=Xclkbuf_10_431_0_CLK }
C {devices/lab_pin.sym} 43040 -26900 0 0 {name=p42439 lab=_79150_/A }
C {devices/lab_pin.sym} 43040 -26860 0 0 {name=p42440 lab=_79150_/B }
C {devices/lab_pin.sym} 43160 -26880 0 1 {name=p42441 lab=_82458_/D }
C {sky130_stdcells/xor2_4.sym} 43100 -26880 0 0 {name=X_79150_ }
C {devices/lab_pin.sym} 43020 -26770 0 0 {name=p42442 lab=_85144_/Q }
C {devices/lab_pin.sym} 43020 -26730 0 0 {name=p42443 lab=_45464_/X }
C {devices/lab_pin.sym} 43020 -26690 0 0 {name=p42444 lab=_44964_/X }
C {devices/lab_pin.sym} 43180 -26730 0 1 {name=p42445 lab=_45542_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -26730 0 0 {name=X_45542_ }
C {devices/lab_pin.sym} 43060 -26590 0 0 {name=p42446 lab=_46366_/A }
C {devices/lab_pin.sym} 43140 -26590 0 1 {name=p42447 lab=_57528_/X }
C {sky130_stdcells/buf_2.sym} 43100 -26590 0 0 {name=X_57528_ }
C {devices/lab_pin.sym} 43040 -26480 0 0 {name=p42448 lab=_76355_/Y }
C {devices/lab_pin.sym} 43040 -26440 0 0 {name=p42449 lab=_76361_/Y }
C {devices/lab_pin.sym} 43160 -26460 0 1 {name=p42450 lab=_76363_/B }
C {sky130_stdcells/xor2_4.sym} 43100 -26460 0 0 {name=X_76362_ }
C {devices/lab_pin.sym} 43020 -26360 0 0 {name=p42451 lab=_41259_/X }
C {devices/lab_pin.sym} 43020 -26320 0 0 {name=p42452 lab=_42745_/X }
C {devices/lab_pin.sym} 43020 -26280 0 0 {name=p42453 lab=_69008_/B }
C {devices/lab_pin.sym} 43020 -26240 0 0 {name=p42454 lab=_42746_/X }
C {devices/lab_pin.sym} 43180 -26300 0 1 {name=p42455 lab=_42754_/X }
C {sky130_stdcells/a2bb2o_4.sym} 43100 -26300 0 0 {name=X_42754_ }
C {devices/lab_pin.sym} 43010 -26150 0 0 {name=p42456 lab=_87851_/CLK }
C {devices/lab_pin.sym} 43010 -26130 0 0 {name=p42457 lab=_40721_/X }
C {devices/lab_pin.sym} 43190 -26150 0 1 {name=p42458 lab=_88348_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -26140 0 0 {name=X_88348_ }
C {devices/lab_pin.sym} 43020 -26030 0 0 {name=p42459 lab=_83145_/Q }
C {devices/lab_pin.sym} 43020 -25990 0 0 {name=p42460 lab=_73549_/X }
C {devices/lab_pin.sym} 43020 -25950 0 0 {name=p42461 lab=_73573_/Y }
C {devices/lab_pin.sym} 43180 -25990 0 1 {name=p42462 lab=_83145_/D }
C {sky130_stdcells/a21o_4.sym} 43100 -25990 0 0 {name=X_73574_ }
C {devices/lab_pin.sym} 43060 -25850 0 0 {name=p42463 lab=_70786_/A }
C {devices/lab_pin.sym} 43140 -25850 0 1 {name=p42464 lab=_70873_/A }
C {sky130_stdcells/buf_2.sym} 43100 -25850 0 0 {name=X_70786_ }
C {devices/lab_pin.sym} 43040 -25740 0 0 {name=p42465 lab=_82661_/Q }
C {devices/lab_pin.sym} 43040 -25700 0 0 {name=p42466 lab=_78101_/B }
C {devices/lab_pin.sym} 43160 -25720 0 1 {name=p42467 lab=_78101_/X }
C {sky130_stdcells/xor2_4.sym} 43100 -25720 0 0 {name=X_78101_ }
C {devices/lab_pin.sym} 43020 -25610 0 0 {name=p42468 lab=_75299_/Y }
C {devices/lab_pin.sym} 43020 -25570 0 0 {name=p42469 lab=_75311_/Y }
C {devices/lab_pin.sym} 43020 -25530 0 0 {name=p42470 lab=_75312_/Y }
C {devices/lab_pin.sym} 43180 -25570 0 1 {name=p42471 lab=_75322_/A }
C {sky130_stdcells/o21a_4.sym} 43100 -25570 0 0 {name=X_75313_ }
C {devices/lab_pin.sym} 43060 -25430 0 0 {name=p42472 lab=_41704_/X }
C {devices/lab_pin.sym} 43140 -25430 0 1 {name=p42473 lab=_41705_/X }
C {sky130_stdcells/buf_2.sym} 43100 -25430 0 0 {name=X_41705_ }
C {devices/lab_pin.sym} 43040 -25330 0 0 {name=p42474 lab=_50308_/A }
C {devices/lab_pin.sym} 43040 -25290 0 0 {name=p42475 lab=_48201_/B }
C {devices/lab_pin.sym} 43040 -25250 0 0 {name=p42476 lab=_48195_/X }
C {devices/lab_pin.sym} 43160 -25290 0 1 {name=p42477 lab=_48261_/X }
C {sky130_stdcells/and3_4.sym} 43100 -25290 0 0 {name=X_48261_ }
C {devices/lab_pin.sym} 43060 -25150 0 0 {name=p42478 lab=_72525_/A }
C {devices/lab_pin.sym} 43140 -25150 0 1 {name=p42479 lab=_72525_/Y }
C {sky130_stdcells/inv_2.sym} 43100 -25150 0 0 {name=X_72525_ }
C {devices/lab_pin.sym} 43060 -25030 0 0 {name=p42480 lab=_82751_/Q }
C {devices/lab_pin.sym} 43140 -25030 0 1 {name=p42481 lab=_79082_/B }
C {sky130_stdcells/inv_2.sym} 43100 -25030 0 0 {name=X_79081_ }
C {devices/lab_pin.sym} 43020 -24940 0 0 {name=p42482 lab=_45470_/Y }
C {devices/lab_pin.sym} 43020 -24900 0 0 {name=p42483 lab=_45439_/X }
C {devices/lab_pin.sym} 43020 -24860 0 0 {name=p42484 lab=_45471_/X }
C {devices/lab_pin.sym} 43020 -24820 0 0 {name=p42485 lab=_45472_/Y }
C {devices/lab_pin.sym} 43180 -24880 0 1 {name=p42486 lab=_45473_/X }
C {sky130_stdcells/a211o_4.sym} 43100 -24880 0 0 {name=X_45473_ }
C {devices/lab_pin.sym} 43020 -24750 0 0 {name=p42487 lab=_57441_/X }
C {devices/lab_pin.sym} 43020 -24710 0 0 {name=p42488 lab=_56761_/X }
C {devices/lab_pin.sym} 43020 -24670 0 0 {name=p42489 lab=_57458_/X }
C {devices/lab_pin.sym} 43180 -24710 0 1 {name=p42490 lab=_57459_/X }
C {sky130_stdcells/o21a_4.sym} 43100 -24710 0 0 {name=X_57459_ }
C {devices/lab_pin.sym} 43040 -24590 0 0 {name=p42491 lab=_76293_/A }
C {devices/lab_pin.sym} 43040 -24550 0 0 {name=p42492 lab=_76283_/Y }
C {devices/lab_pin.sym} 43040 -24510 0 0 {name=p42493 lab=_76273_/A }
C {devices/lab_pin.sym} 43160 -24550 0 1 {name=p42494 lab=_76293_/Y }
C {sky130_stdcells/nor3_4.sym} 43100 -24550 0 0 {name=X_76293_ }
C {devices/lab_pin.sym} 43010 -24410 0 0 {name=p42495 lab=_87011_/CLK }
C {devices/lab_pin.sym} 43010 -24390 0 0 {name=p42496 lab=_41094_/X }
C {devices/lab_pin.sym} 43190 -24410 0 1 {name=p42497 lab=_69526_/B }
C {sky130_stdcells/dfxtp_4.sym} 43100 -24400 0 0 {name=X_88279_ }
C {devices/lab_pin.sym} 43020 -24310 0 0 {name=p42498 lab=_42665_/X }
C {devices/lab_pin.sym} 43020 -24270 0 0 {name=p42499 lab=_42666_/X }
C {devices/lab_pin.sym} 43020 -24230 0 0 {name=p42500 lab=_41076_/X }
C {devices/lab_pin.sym} 43020 -24190 0 0 {name=p42501 lab=_69480_/B }
C {devices/lab_pin.sym} 43020 -24150 0 0 {name=p42502 lab=_42673_/X }
C {devices/lab_pin.sym} 43180 -24230 0 1 {name=p42503 lab=_42685_/Y }
C {sky130_stdcells/o32ai_4.sym} 43100 -24230 0 0 {name=X_42685_ }
C {devices/lab_pin.sym} 43060 -24070 0 0 {name=p42504 lab=_47212_/A }
C {devices/lab_pin.sym} 43140 -24070 0 1 {name=p42505 lab=_47212_/Y }
C {sky130_stdcells/inv_2.sym} 43100 -24070 0 0 {name=X_47212_ }
C {devices/lab_pin.sym} 43040 -23970 0 0 {name=p42506 lab=_78021_/C }
C {devices/lab_pin.sym} 43040 -23930 0 0 {name=p42507 lab=_78027_/B }
C {devices/lab_pin.sym} 43040 -23890 0 0 {name=p42508 lab=_78030_/A }
C {devices/lab_pin.sym} 43160 -23930 0 1 {name=p42509 lab=_78033_/B }
C {sky130_stdcells/nand3_4.sym} 43100 -23930 0 0 {name=X_78032_ }
C {devices/lab_pin.sym} 43020 -23820 0 0 {name=p42510 lab=_41570_/X }
C {devices/lab_pin.sym} 43020 -23780 0 0 {name=p42511 lab=_44412_/X }
C {devices/lab_pin.sym} 43020 -23740 0 0 {name=p42512 lab=_87114_/Q }
C {devices/lab_pin.sym} 43020 -23700 0 0 {name=p42513 lab=_44413_/X }
C {devices/lab_pin.sym} 43180 -23760 0 1 {name=p42514 lab=_87114_/D }
C {sky130_stdcells/a2bb2o_4.sym} 43100 -23760 0 0 {name=X_44424_ }
C {devices/lab_pin.sym} 43060 -23610 0 0 {name=p42515 lab=_75223_/Y }
C {devices/lab_pin.sym} 43140 -23610 0 1 {name=p42516 lab=_75244_/Y }
C {sky130_stdcells/inv_2.sym} 43100 -23610 0 0 {name=X_75244_ }
C {devices/lab_pin.sym} 43060 -23490 0 0 {name=p42517 lab=_41635_/Y }
C {devices/lab_pin.sym} 43140 -23490 0 1 {name=p42518 lab=_41636_/X }
C {sky130_stdcells/buf_2.sym} 43100 -23490 0 0 {name=X_41636_ }
C {devices/lab_pin.sym} 43060 -23370 0 0 {name=p42519 lab=_48192_/A }
C {devices/lab_pin.sym} 43140 -23370 0 1 {name=p42520 lab=_48934_/A }
C {sky130_stdcells/buf_2.sym} 43100 -23370 0 0 {name=X_48192_ }
C {devices/lab_pin.sym} 43060 -23250 0 0 {name=p42521 lab=_60469_/X }
C {devices/lab_pin.sym} 43140 -23250 0 1 {name=p42522 lab=_60476_/A }
C {sky130_stdcells/buf_2.sym} 43100 -23250 0 0 {name=X_60470_ }
C {devices/lab_pin.sym} 43020 -23150 0 0 {name=p42523 lab=_57712_/X }
C {devices/lab_pin.sym} 43020 -23110 0 0 {name=p42524 lab=_85316_/Q }
C {devices/lab_pin.sym} 43020 -23070 0 0 {name=p42525 lab=_72324_/X }
C {devices/lab_pin.sym} 43180 -23110 0 1 {name=p42526 lab=_72456_/X }
C {sky130_stdcells/o21a_4.sym} 43100 -23110 0 0 {name=X_72456_ }
C {devices/lab_pin.sym} 43060 -22970 0 0 {name=p42527 lab=clkbuf_9_223_0_CLK/X }
C {devices/lab_pin.sym} 43140 -22970 0 1 {name=p42528 lab=_84192_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 43100 -22970 0 0 {name=Xclkbuf_10_446_0_CLK }
C {devices/lab_pin.sym} 43040 -22880 0 0 {name=p42529 lab=_47113_/A }
C {devices/lab_pin.sym} 43040 -22840 0 0 {name=p42530 lab=_47133_/B }
C {devices/lab_pin.sym} 43040 -22800 0 0 {name=p42531 lab=_47143_/C }
C {devices/lab_pin.sym} 43040 -22760 0 0 {name=p42532 lab=_52879_/D }
C {devices/lab_pin.sym} 43160 -22820 0 1 {name=p42533 lab=_47143_/X }
C {sky130_stdcells/and4_4.sym} 43100 -22820 0 0 {name=X_47143_ }
C {devices/lab_pin.sym} 43060 -22670 0 0 {name=p42534 lab=_59043_/A }
C {devices/lab_pin.sym} 43140 -22670 0 1 {name=p42535 lab=_59129_/X }
C {sky130_stdcells/buf_2.sym} 43100 -22670 0 0 {name=X_59129_ }
C {devices/lab_pin.sym} 43020 -22570 0 0 {name=p42536 lab=_71397_/X }
C {devices/lab_pin.sym} 43020 -22530 0 0 {name=p42537 lab=_83510_/Q }
C {devices/lab_pin.sym} 43020 -22490 0 0 {name=p42538 lab=_71406_/Y }
C {devices/lab_pin.sym} 43180 -22530 0 1 {name=p42539 lab=_71407_/X }
C {sky130_stdcells/a21o_4.sym} 43100 -22530 0 0 {name=X_71407_ }
C {devices/lab_pin.sym} 43060 -22390 0 0 {name=p42540 lab=_44355_/A }
C {devices/lab_pin.sym} 43140 -22390 0 1 {name=p42541 lab=_87152_/D }
C {sky130_stdcells/inv_2.sym} 43100 -22390 0 0 {name=X_44355_ }
C {devices/lab_pin.sym} 43040 -22290 0 0 {name=p42542 lab=_75175_/A }
C {devices/lab_pin.sym} 43040 -22250 0 0 {name=p42543 lab=_75175_/B }
C {devices/lab_pin.sym} 43040 -22210 0 0 {name=p42544 lab=_75175_/C }
C {devices/lab_pin.sym} 43160 -22250 0 1 {name=p42545 lab=_75178_/B }
C {sky130_stdcells/nand3_4.sym} 43100 -22250 0 0 {name=X_75175_ }
C {devices/lab_pin.sym} 43060 -22110 0 0 {name=p42546 lab=_41567_/A }
C {devices/lab_pin.sym} 43140 -22110 0 1 {name=p42547 lab=_41567_/Y }
C {sky130_stdcells/inv_2.sym} 43100 -22110 0 0 {name=X_41567_ }
C {devices/lab_pin.sym} 43020 -22010 0 0 {name=p42548 lab=_72339_/X }
C {devices/lab_pin.sym} 43020 -21970 0 0 {name=p42549 lab=_85323_/Q }
C {devices/lab_pin.sym} 43020 -21930 0 0 {name=p42550 lab=_72386_/X }
C {devices/lab_pin.sym} 43180 -21970 0 1 {name=p42551 lab=_72387_/X }
C {sky130_stdcells/o21a_4.sym} 43100 -21970 0 0 {name=X_72387_ }
C {devices/lab_pin.sym} 43020 -21870 0 0 {name=p42552 lab=_43296_/X }
C {devices/lab_pin.sym} 43020 -21830 0 0 {name=p42553 lab=_43305_/X }
C {devices/lab_pin.sym} 43020 -21790 0 0 {name=p42554 lab=_41209_/X }
C {devices/lab_pin.sym} 43020 -21750 0 0 {name=p42555 lab=_87489_/Q }
C {devices/lab_pin.sym} 43020 -21710 0 0 {name=p42556 lab=_43273_/X }
C {devices/lab_pin.sym} 43180 -21790 0 1 {name=p42557 lab=_43306_/Y }
C {sky130_stdcells/o32ai_4.sym} 43100 -21790 0 0 {name=X_43306_ }
C {devices/lab_pin.sym} 43060 -21630 0 0 {name=p42558 lab=_84782_/Q }
C {devices/lab_pin.sym} 43140 -21630 0 1 {name=p42559 lab=_62140_/X }
C {sky130_stdcells/buf_2.sym} 43100 -21630 0 0 {name=X_62140_ }
C {devices/lab_pin.sym} 43020 -21530 0 0 {name=p42560 lab=_74119_/Y }
C {devices/lab_pin.sym} 43020 -21490 0 0 {name=p42561 lab=_74120_/Y }
C {devices/lab_pin.sym} 43020 -21450 0 0 {name=p42562 lab=_74125_/X }
C {devices/lab_pin.sym} 43180 -21490 0 1 {name=p42563 lab=_74126_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -21490 0 0 {name=X_74126_ }
C {devices/lab_pin.sym} 43040 -21360 0 0 {name=p42564 lab=_40416_/A }
C {devices/lab_pin.sym} 43040 -21320 0 0 {name=p42565 lab=_40518_/B }
C {devices/lab_pin.sym} 43160 -21340 0 1 {name=p42566 lab=_40518_/X }
C {sky130_stdcells/or2_4.sym} 43100 -21340 0 0 {name=X_40518_ }
C {devices/lab_pin.sym} 43060 -21210 0 0 {name=p42567 lab=_47074_/A }
C {devices/lab_pin.sym} 43140 -21210 0 1 {name=p42568 lab=_52841_/D }
C {sky130_stdcells/buf_2.sym} 43100 -21210 0 0 {name=X_47074_ }
C {devices/lab_pin.sym} 43040 -21110 0 0 {name=p42569 lab=_71338_/A }
C {devices/lab_pin.sym} 43040 -21070 0 0 {name=p42570 lab=_70431_/C }
C {devices/lab_pin.sym} 43040 -21030 0 0 {name=p42571 lab=_71779_/B }
C {devices/lab_pin.sym} 43160 -21070 0 1 {name=p42572 lab=_71338_/Y }
C {sky130_stdcells/nand3_4.sym} 43100 -21070 0 0 {name=X_71338_ }
C {devices/lab_pin.sym} 43060 -20930 0 0 {name=p42573 lab=_44274_/X }
C {devices/lab_pin.sym} 43140 -20930 0 1 {name=p42574 lab=_44286_/Y }
C {sky130_stdcells/inv_2.sym} 43100 -20930 0 0 {name=X_44286_ }
C {devices/lab_pin.sym} 43040 -20820 0 0 {name=p42575 lab=_84928_/Q }
C {devices/lab_pin.sym} 43040 -20780 0 0 {name=p42576 lab=_65817_/C }
C {devices/lab_pin.sym} 43160 -20800 0 1 {name=p42577 lab=_79985_/A }
C {sky130_stdcells/xor2_4.sym} 43100 -20800 0 0 {name=X_79983_ }
C {devices/lab_pin.sym} 43060 -20670 0 0 {name=p42578 lab=_41497_/X }
C {devices/lab_pin.sym} 43140 -20670 0 1 {name=p42579 lab=_41498_/X }
C {sky130_stdcells/buf_2.sym} 43100 -20670 0 0 {name=X_41498_ }
C {devices/lab_pin.sym} 43020 -20580 0 0 {name=p42580 lab=_40541_/Y }
C {devices/lab_pin.sym} 43020 -20540 0 0 {name=p42581 lab=_46022_/X }
C {devices/lab_pin.sym} 43020 -20500 0 0 {name=p42582 lab=_67287_/B }
C {devices/lab_pin.sym} 43020 -20460 0 0 {name=p42583 lab=_46023_/X }
C {devices/lab_pin.sym} 43180 -20520 0 1 {name=p42584 lab=_86808_/D }
C {sky130_stdcells/a2bb2o_4.sym} 43100 -20520 0 0 {name=X_46025_ }
C {devices/lab_pin.sym} 43020 -20410 0 0 {name=p42585 lab=_43226_/X }
C {devices/lab_pin.sym} 43020 -20370 0 0 {name=p42586 lab=_43229_/X }
C {devices/lab_pin.sym} 43020 -20330 0 0 {name=p42587 lab=_41021_/X }
C {devices/lab_pin.sym} 43020 -20290 0 0 {name=p42588 lab=_87524_/Q }
C {devices/lab_pin.sym} 43020 -20250 0 0 {name=p42589 lab=_43232_/X }
C {devices/lab_pin.sym} 43180 -20330 0 1 {name=p42590 lab=_43237_/Y }
C {sky130_stdcells/o32ai_4.sym} 43100 -20330 0 0 {name=X_43237_ }
C {devices/lab_pin.sym} 43060 -20170 0 0 {name=p42591 lab=_83243_/Q }
C {devices/lab_pin.sym} 43140 -20170 0 1 {name=p42592 lab=_63630_/A }
C {sky130_stdcells/inv_2.sym} 43100 -20170 0 0 {name=X_62071_ }
C {devices/lab_pin.sym} 43020 -20070 0 0 {name=p42593 lab=_86986_/Q }
C {devices/lab_pin.sym} 43020 -20030 0 0 {name=p42594 lab=_73916_/B }
C {devices/lab_pin.sym} 43020 -19990 0 0 {name=p42595 lab=_74056_/X }
C {devices/lab_pin.sym} 43180 -20030 0 1 {name=p42596 lab=_74057_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -20030 0 0 {name=X_74057_ }
C {devices/lab_pin.sym} 43060 -19890 0 0 {name=p42597 lab=_78912_/B }
C {devices/lab_pin.sym} 43140 -19890 0 1 {name=p42598 lab=_82510_/D }
C {sky130_stdcells/inv_2.sym} 43100 -19890 0 0 {name=X_78934_ }
C {devices/lab_pin.sym} 43060 -19770 0 0 {name=p42599 lab=_40448_/Y }
C {devices/lab_pin.sym} 43140 -19770 0 1 {name=p42600 lab=_88390_/D }
C {sky130_stdcells/inv_2.sym} 43100 -19770 0 0 {name=X_40449_ }
C {devices/lab_pin.sym} 43040 -19680 0 0 {name=p42601 lab=_71168_/A }
C {devices/lab_pin.sym} 43040 -19640 0 0 {name=p42602 lab=_71276_/B }
C {devices/lab_pin.sym} 43040 -19600 0 0 {name=p42603 lab=_71276_/C }
C {devices/lab_pin.sym} 43040 -19560 0 0 {name=p42604 lab=_70656_/D }
C {devices/lab_pin.sym} 43160 -19620 0 1 {name=p42605 lab=_71269_/Y }
C {sky130_stdcells/nand4_4.sym} 43100 -19620 0 0 {name=X_71269_ }
C {devices/lab_pin.sym} 43020 -19490 0 0 {name=p42606 lab=_60998_/X }
C {devices/lab_pin.sym} 43020 -19450 0 0 {name=p42607 lab=_60992_/X }
C {devices/lab_pin.sym} 43020 -19410 0 0 {name=p42608 lab=_65296_/A }
C {devices/lab_pin.sym} 43180 -19450 0 1 {name=p42609 lab=_61022_/Y }
C {sky130_stdcells/a21oi_4.sym} 43100 -19450 0 0 {name=X_61022_ }
C {devices/lab_pin.sym} 43020 -19330 0 0 {name=p42610 lab=_88330_/Q }
C {devices/lab_pin.sym} 43020 -19290 0 0 {name=p42611 lab=_72803_/X }
C {devices/lab_pin.sym} 43020 -19250 0 0 {name=p42612 lab=_73007_/X }
C {devices/lab_pin.sym} 43180 -19290 0 1 {name=p42613 lab=_73008_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -19290 0 0 {name=X_73008_ }
C {devices/lab_pin.sym} 43020 -19190 0 0 {name=p42614 lab=_43162_/X }
C {devices/lab_pin.sym} 43020 -19150 0 0 {name=p42615 lab=_43167_/X }
C {devices/lab_pin.sym} 43020 -19110 0 0 {name=p42616 lab=_40874_/X }
C {devices/lab_pin.sym} 43020 -19070 0 0 {name=p42617 lab=_73275_/A }
C {devices/lab_pin.sym} 43020 -19030 0 0 {name=p42618 lab=_43154_/X }
C {devices/lab_pin.sym} 43180 -19110 0 1 {name=p42619 lab=_43169_/A }
C {sky130_stdcells/o32ai_4.sym} 43100 -19110 0 0 {name=X_43168_ }
C {devices/lab_pin.sym} 43040 -18960 0 0 {name=p42620 lab=_78852_/X }
C {devices/lab_pin.sym} 43040 -18920 0 0 {name=p42621 lab=_78865_/B }
C {devices/lab_pin.sym} 43160 -18940 0 1 {name=p42622 lab=_78865_/X }
C {sky130_stdcells/and2_4.sym} 43100 -18940 0 0 {name=X_78865_ }
C {devices/lab_pin.sym} 43060 -18810 0 0 {name=p42623 lab=_65757_/A }
C {devices/lab_pin.sym} 43140 -18810 0 1 {name=p42624 lab=_65830_/X }
C {sky130_stdcells/buf_2.sym} 43100 -18810 0 0 {name=X_65830_ }
C {devices/lab_pin.sym} 43060 -18690 0 0 {name=p42625 lab=_42118_/Y }
C {devices/lab_pin.sym} 43140 -18690 0 1 {name=p42626 lab=_42119_/Y }
C {sky130_stdcells/inv_2.sym} 43100 -18690 0 0 {name=X_42119_ }
C {devices/lab_pin.sym} 43040 -18580 0 0 {name=p42627 lab=_77795_/X }
C {devices/lab_pin.sym} 43040 -18540 0 0 {name=p42628 lab=_77808_/X }
C {devices/lab_pin.sym} 43160 -18560 0 1 {name=p42629 lab=_77816_/X }
C {sky130_stdcells/and2_4.sym} 43100 -18560 0 0 {name=X_77816_ }
C {devices/lab_pin.sym} 43020 -18450 0 0 {name=p42630 lab=_47970_/Y }
C {devices/lab_pin.sym} 43020 -18410 0 0 {name=p42631 lab=_47954_/X }
C {devices/lab_pin.sym} 43020 -18370 0 0 {name=p42632 lab=_47975_/X }
C {devices/lab_pin.sym} 43180 -18410 0 1 {name=p42633 lab=_47976_/Y }
C {sky130_stdcells/a21oi_4.sym} 43100 -18410 0 0 {name=X_47976_ }
C {devices/lab_pin.sym} 43020 -18310 0 0 {name=p42634 lab=_43085_/X }
C {devices/lab_pin.sym} 43020 -18270 0 0 {name=p42635 lab=_43086_/X }
C {devices/lab_pin.sym} 43020 -18230 0 0 {name=p42636 lab=_40739_/X }
C {devices/lab_pin.sym} 43020 -18190 0 0 {name=p42637 lab=_43098_/Y }
C {devices/lab_pin.sym} 43020 -18150 0 0 {name=p42638 lab=_43090_/X }
C {devices/lab_pin.sym} 43180 -18230 0 1 {name=p42639 lab=_87576_/D }
C {sky130_stdcells/o32ai_4.sym} 43100 -18230 0 0 {name=X_43099_ }
C {devices/lab_pin.sym} 43040 -18090 0 0 {name=p42640 lab=_78782_/Y }
C {devices/lab_pin.sym} 43040 -18050 0 0 {name=p42641 lab=_78786_/X }
C {devices/lab_pin.sym} 43040 -18010 0 0 {name=p42642 lab=_78794_/A }
C {devices/lab_pin.sym} 43160 -18050 0 1 {name=p42643 lab=_78797_/B }
C {sky130_stdcells/nand3_4.sym} 43100 -18050 0 0 {name=X_78796_ }
C {devices/lab_pin.sym} 43060 -17910 0 0 {name=p42644 lab=_49632_/A }
C {devices/lab_pin.sym} 43140 -17910 0 1 {name=p42645 lab=_49715_/X }
C {sky130_stdcells/buf_2.sym} 43100 -17910 0 0 {name=X_49715_ }
C {devices/lab_pin.sym} 43020 -17810 0 0 {name=p42646 lab=_46923_/Y }
C {devices/lab_pin.sym} 43020 -17770 0 0 {name=p42647 lab=_46891_/X }
C {devices/lab_pin.sym} 43020 -17730 0 0 {name=p42648 lab=_46926_/X }
C {devices/lab_pin.sym} 43180 -17770 0 1 {name=p42649 lab=_46927_/Y }
C {sky130_stdcells/a21oi_4.sym} 43100 -17770 0 0 {name=X_46927_ }
C {devices/lab_pin.sym} 43060 -17630 0 0 {name=p42650 lab=_64902_/A }
C {devices/lab_pin.sym} 43140 -17630 0 1 {name=p42651 lab=_65761_/X }
C {sky130_stdcells/buf_2.sym} 43100 -17630 0 0 {name=X_65761_ }
C {devices/lab_pin.sym} 43040 -17520 0 0 {name=p42652 lab=_82260_/Q }
C {devices/lab_pin.sym} 43040 -17480 0 0 {name=p42653 lab=_77747_/B }
C {devices/lab_pin.sym} 43160 -17500 0 1 {name=p42654 lab=_77747_/X }
C {sky130_stdcells/or2_4.sym} 43100 -17500 0 0 {name=X_77747_ }
C {devices/lab_pin.sym} 43040 -17390 0 0 {name=p42655 lab=_62927_/A }
C {devices/lab_pin.sym} 43040 -17350 0 0 {name=p42656 lab=_62664_/B }
C {devices/lab_pin.sym} 43040 -17310 0 0 {name=p42657 lab=_62162_/X }
C {devices/lab_pin.sym} 43160 -17350 0 1 {name=p42658 lab=_62973_/Y }
C {sky130_stdcells/nand3_4.sym} 43100 -17350 0 0 {name=X_62973_ }
C {devices/lab_pin.sym} 43040 -17220 0 0 {name=p42659 lab=_74959_/A }
C {devices/lab_pin.sym} 43040 -17180 0 0 {name=p42660 lab=_74959_/B }
C {devices/lab_pin.sym} 43160 -17200 0 1 {name=p42661 lab=_74959_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -17200 0 0 {name=X_74959_ }
C {devices/lab_pin.sym} 43040 -17080 0 0 {name=p42662 lab=_67572_/A }
C {devices/lab_pin.sym} 43040 -17040 0 0 {name=p42663 lab=_86936_/Q }
C {devices/lab_pin.sym} 43160 -17060 0 1 {name=p42664 lab=_67500_/X }
C {sky130_stdcells/and2_4.sym} 43100 -17060 0 0 {name=X_67500_ }
C {devices/lab_pin.sym} 43040 -16950 0 0 {name=p42665 lab=_64702_/X }
C {devices/lab_pin.sym} 43040 -16910 0 0 {name=p42666 lab=_64712_/B }
C {devices/lab_pin.sym} 43040 -16870 0 0 {name=p42667 lab=_64711_/X }
C {devices/lab_pin.sym} 43160 -16910 0 1 {name=p42668 lab=_64737_/A }
C {sky130_stdcells/nand3_4.sym} 43100 -16910 0 0 {name=X_64712_ }
C {devices/lab_pin.sym} 43040 -16800 0 0 {name=p42669 lab=_49625_/A }
C {devices/lab_pin.sym} 43040 -16760 0 0 {name=p42670 lab=_49642_/B }
C {devices/lab_pin.sym} 43040 -16720 0 0 {name=p42671 lab=_49629_/X }
C {devices/lab_pin.sym} 43040 -16680 0 0 {name=p42672 lab=_52861_/D }
C {devices/lab_pin.sym} 43160 -16740 0 1 {name=p42673 lab=_49646_/X }
C {sky130_stdcells/and4_4.sym} 43100 -16740 0 0 {name=X_49646_ }
C {devices/lab_pin.sym} 43040 -16620 0 0 {name=p42674 lab=_61922_/X }
C {devices/lab_pin.sym} 43040 -16580 0 0 {name=p42675 lab=_61924_/B }
C {devices/lab_pin.sym} 43040 -16540 0 0 {name=p42676 lab=_61878_/C }
C {devices/lab_pin.sym} 43040 -16500 0 0 {name=p42677 lab=_61910_/D }
C {devices/lab_pin.sym} 43160 -16560 0 1 {name=p42678 lab=_61924_/Y }
C {sky130_stdcells/nand4_4.sym} 43100 -16560 0 0 {name=X_61924_ }
C {devices/lab_pin.sym} 43040 -16420 0 0 {name=p42679 lab=_68553_/A }
C {devices/lab_pin.sym} 43040 -16380 0 0 {name=p42680 lab=_68480_/B }
C {devices/lab_pin.sym} 43160 -16400 0 1 {name=p42681 lab=_68480_/X }
C {sky130_stdcells/and2_4.sym} 43100 -16400 0 0 {name=X_68480_ }
C {devices/lab_pin.sym} 43020 -16290 0 0 {name=p42682 lab=_46853_/Y }
C {devices/lab_pin.sym} 43020 -16250 0 0 {name=p42683 lab=_46844_/X }
C {devices/lab_pin.sym} 43020 -16210 0 0 {name=p42684 lab=_46857_/X }
C {devices/lab_pin.sym} 43180 -16250 0 1 {name=p42685 lab=_86696_/D }
C {sky130_stdcells/a21oi_4.sym} 43100 -16250 0 0 {name=X_46858_ }
C {devices/lab_pin.sym} 43040 -16120 0 0 {name=p42686 lab=_65825_/A }
C {devices/lab_pin.sym} 43040 -16080 0 0 {name=p42687 lab=_86512_/Q }
C {devices/lab_pin.sym} 43160 -16100 0 1 {name=p42688 lab=_65692_/X }
C {sky130_stdcells/and2_4.sym} 43100 -16100 0 0 {name=X_65692_ }
C {devices/lab_pin.sym} 43020 -15990 0 0 {name=p42689 lab=_77655_/A }
C {devices/lab_pin.sym} 43020 -15950 0 0 {name=p42690 lab=_77652_/Y }
C {devices/lab_pin.sym} 43020 -15910 0 0 {name=p42691 lab=_77653_/Y }
C {devices/lab_pin.sym} 43180 -15950 0 1 {name=p42692 lab=_77678_/X }
C {sky130_stdcells/o21a_4.sym} 43100 -15950 0 0 {name=X_77678_ }
C {devices/lab_pin.sym} 43060 -15810 0 0 {name=p42693 lab=clkbuf_9_505_0_CLK/A }
C {devices/lab_pin.sym} 43140 -15810 0 1 {name=p42694 lab=clkbuf_9_505_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 43100 -15810 0 0 {name=Xclkbuf_9_505_0_CLK }
C {devices/lab_pin.sym} 43020 -15710 0 0 {name=p42695 lab=_67428_/X }
C {devices/lab_pin.sym} 43020 -15670 0 0 {name=p42696 lab=_67430_/X }
C {devices/lab_pin.sym} 43020 -15630 0 0 {name=p42697 lab=_67383_/X }
C {devices/lab_pin.sym} 43180 -15670 0 1 {name=p42698 lab=_67436_/A }
C {sky130_stdcells/a21o_4.sym} 43100 -15670 0 0 {name=X_67431_ }
C {devices/lab_pin.sym} 43060 -15530 0 0 {name=p42699 lab=_79439_/A }
C {devices/lab_pin.sym} 43140 -15530 0 1 {name=p42700 lab=_79417_/Y }
C {sky130_stdcells/inv_2.sym} 43100 -15530 0 0 {name=X_79417_ }
C {devices/lab_pin.sym} 43040 -15420 0 0 {name=p42701 lab=_57210_/B }
C {devices/lab_pin.sym} 43040 -15380 0 0 {name=p42702 lab=_45736_/B }
C {devices/lab_pin.sym} 43160 -15400 0 1 {name=p42703 lab=_45809_/Y }
C {sky130_stdcells/nor2_4.sym} 43100 -15400 0 0 {name=X_45809_ }
C {devices/lab_pin.sym} 43040 -15280 0 0 {name=p42704 lab=_64769_/A }
C {devices/lab_pin.sym} 43040 -15240 0 0 {name=p42705 lab=_64643_/B }
C {devices/lab_pin.sym} 43160 -15260 0 1 {name=p42706 lab=_64643_/X }
C {sky130_stdcells/and2_4.sym} 43100 -15260 0 0 {name=X_64643_ }
C {devices/lab_pin.sym} 43040 -15140 0 0 {name=p42707 lab=_81376_/Q }
C {devices/lab_pin.sym} 43040 -15100 0 0 {name=p42708 lab=_76628_/A }
C {devices/lab_pin.sym} 43160 -15120 0 1 {name=p42709 lab=_76629_/Y }
C {sky130_stdcells/xnor2_4.sym} 43100 -15120 0 0 {name=X_76629_ }
C {devices/lab_pin.sym} 43040 -15020 0 0 {name=p42710 lab=_49571_/X }
C {devices/lab_pin.sym} 43040 -14980 0 0 {name=p42711 lab=_49561_/B }
C {devices/lab_pin.sym} 43040 -14940 0 0 {name=p42712 lab=_49577_/C }
C {devices/lab_pin.sym} 43040 -14900 0 0 {name=p42713 lab=_52790_/D }
C {devices/lab_pin.sym} 43160 -14960 0 1 {name=p42714 lab=_49577_/X }
C {sky130_stdcells/and4_4.sym} 43100 -14960 0 0 {name=X_49577_ }
C {devices/lab_pin.sym} 43060 -14810 0 0 {name=p42715 lab=_62185_/B }
C {devices/lab_pin.sym} 43140 -14810 0 1 {name=p42716 lab=_61874_/B }
C {sky130_stdcells/buf_2.sym} 43100 -14810 0 0 {name=X_61855_ }
C {devices/lab_pin.sym} 43020 -14710 0 0 {name=p42717 lab=_86703_/Q }
C {devices/lab_pin.sym} 43020 -14670 0 0 {name=p42718 lab=_46767_/X }
C {devices/lab_pin.sym} 43020 -14630 0 0 {name=p42719 lab=_46788_/Y }
C {devices/lab_pin.sym} 43180 -14670 0 1 {name=p42720 lab=_46789_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -14670 0 0 {name=X_46789_ }
C {devices/lab_pin.sym} 43020 -14550 0 0 {name=p42721 lab=_86514_/Q }
C {devices/lab_pin.sym} 43020 -14510 0 0 {name=p42722 lab=_48478_/X }
C {devices/lab_pin.sym} 43020 -14470 0 0 {name=p42723 lab=_48527_/Y }
C {devices/lab_pin.sym} 43180 -14510 0 1 {name=p42724 lab=_48528_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -14510 0 0 {name=X_48528_ }
C {devices/lab_pin.sym} 43060 -14370 0 0 {name=p42725 lab=_60715_/X }
C {devices/lab_pin.sym} 43140 -14370 0 1 {name=p42726 lab=_60810_/B }
C {sky130_stdcells/buf_2.sym} 43100 -14370 0 0 {name=X_60806_ }
C {devices/lab_pin.sym} 43020 -14280 0 0 {name=p42727 lab=_87410_/Q }
C {devices/lab_pin.sym} 43020 -14240 0 0 {name=p42728 lab=_67358_/X }
C {devices/lab_pin.sym} 43020 -14200 0 0 {name=p42729 lab=_67360_/X }
C {devices/lab_pin.sym} 43020 -14160 0 0 {name=p42730 lab=_67361_/X }
C {devices/lab_pin.sym} 43180 -14220 0 1 {name=p42731 lab=_67362_/X }
C {sky130_stdcells/a211o_4.sym} 43100 -14220 0 0 {name=X_67362_ }
C {devices/lab_pin.sym} 43040 -14080 0 0 {name=p42732 lab=_79355_/B }
C {devices/lab_pin.sym} 43040 -14040 0 0 {name=p42733 lab=_79347_/Y }
C {devices/lab_pin.sym} 43160 -14060 0 1 {name=p42734 lab=_79348_/X }
C {sky130_stdcells/xor2_4.sym} 43100 -14060 0 0 {name=X_79348_ }
C {devices/lab_pin.sym} 43060 -13930 0 0 {name=p42735 lab=_64619_/A }
C {devices/lab_pin.sym} 43140 -13930 0 1 {name=p42736 lab=_64574_/X }
C {sky130_stdcells/buf_2.sym} 43100 -13930 0 0 {name=X_64574_ }
C {devices/lab_pin.sym} 43060 -13810 0 0 {name=p42737 lab=_59765_/A }
C {devices/lab_pin.sym} 43140 -13810 0 1 {name=p42738 lab=_61823_/B }
C {sky130_stdcells/buf_2.sym} 43100 -13810 0 0 {name=X_61786_ }
C {devices/lab_pin.sym} 43020 -13720 0 0 {name=p42739 lab=_87477_/Q }
C {devices/lab_pin.sym} 43020 -13680 0 0 {name=p42740 lab=_69098_/X }
C {devices/lab_pin.sym} 43020 -13640 0 0 {name=p42741 lab=_69010_/X }
C {devices/lab_pin.sym} 43020 -13600 0 0 {name=p42742 lab=_69100_/X }
C {devices/lab_pin.sym} 43180 -13660 0 1 {name=p42743 lab=_69101_/X }
C {sky130_stdcells/a211o_4.sym} 43100 -13660 0 0 {name=X_69101_ }
C {devices/lab_pin.sym} 43040 -13520 0 0 {name=p42744 lab=_66326_/A }
C {devices/lab_pin.sym} 43040 -13480 0 0 {name=p42745 lab=_86533_/Q }
C {devices/lab_pin.sym} 43160 -13500 0 1 {name=p42746 lab=_66313_/X }
C {sky130_stdcells/and2_4.sym} 43100 -13500 0 0 {name=X_66313_ }
C {devices/lab_pin.sym} 43020 -13400 0 0 {name=p42747 lab=_61489_/B }
C {devices/lab_pin.sym} 43020 -13360 0 0 {name=p42748 lab=_63487_/X }
C {devices/lab_pin.sym} 43020 -13320 0 0 {name=p42749 lab=_63523_/X }
C {devices/lab_pin.sym} 43020 -13280 0 0 {name=p42750 lab=_63524_/X }
C {devices/lab_pin.sym} 43180 -13340 0 1 {name=p42751 lab=_63525_/X }
C {sky130_stdcells/a211o_4.sym} 43100 -13340 0 0 {name=X_63525_ }
C {devices/lab_pin.sym} 43020 -13230 0 0 {name=p42752 lab=_60736_/X }
C {devices/lab_pin.sym} 43020 -13190 0 0 {name=p42753 lab=_60804_/C }
C {devices/lab_pin.sym} 43020 -13150 0 0 {name=p42754 lab=_60694_/C }
C {devices/lab_pin.sym} 43020 -13110 0 0 {name=p42755 lab=_60804_/B }
C {devices/lab_pin.sym} 43020 -13080 0 0 {name=p42756 lab=_59846_/X }
C {devices/lab_pin.sym} 43180 -13150 0 1 {name=p42757 lab=_60737_/Y }
C {sky130_stdcells/a41oi_4.sym} 43100 -13150 0 0 {name=X_60737_ }
C {devices/lab_pin.sym} 43060 -12990 0 0 {name=p42758 lab=_48651_/A }
C {devices/lab_pin.sym} 43140 -12990 0 1 {name=p42759 lab=_48459_/X }
C {sky130_stdcells/buf_2.sym} 43100 -12990 0 0 {name=X_48459_ }
C {devices/lab_pin.sym} 43040 -12880 0 0 {name=p42760 lab=_84339_/Q }
C {devices/lab_pin.sym} 43040 -12840 0 0 {name=p42761 lab=_79279_/B }
C {devices/lab_pin.sym} 43160 -12860 0 1 {name=p42762 lab=_79285_/B }
C {sky130_stdcells/xor2_4.sym} 43100 -12860 0 0 {name=X_79279_ }
C {devices/lab_pin.sym} 43060 -12730 0 0 {name=p42763 lab=_67055_/X }
C {devices/lab_pin.sym} 43140 -12730 0 1 {name=p42764 lab=_67293_/X }
C {sky130_stdcells/buf_2.sym} 43100 -12730 0 0 {name=X_67293_ }
C {devices/lab_pin.sym} 43010 -12610 0 0 {name=p42765 lab=_81632_/CLK }
C {devices/lab_pin.sym} 43010 -12590 0 0 {name=p42766 lab=_76998_/X }
C {devices/lab_pin.sym} 43190 -12610 0 1 {name=p42767 lab=_81310_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -12600 0 0 {name=X_81310_ }
C {devices/lab_pin.sym} 43020 -12500 0 0 {name=p42768 lab=_87992_/Q }
C {devices/lab_pin.sym} 43020 -12460 0 0 {name=p42769 lab=_69007_/X }
C {devices/lab_pin.sym} 43020 -12420 0 0 {name=p42770 lab=_68916_/X }
C {devices/lab_pin.sym} 43020 -12380 0 0 {name=p42771 lab=_69031_/X }
C {devices/lab_pin.sym} 43180 -12440 0 1 {name=p42772 lab=_69032_/X }
C {sky130_stdcells/a211o_4.sym} 43100 -12440 0 0 {name=X_69032_ }
C {devices/lab_pin.sym} 43040 -12300 0 0 {name=p42773 lab=_66244_/A }
C {devices/lab_pin.sym} 43040 -12260 0 0 {name=p42774 lab=_66244_/B }
C {devices/lab_pin.sym} 43160 -12280 0 1 {name=p42775 lab=_66244_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -12280 0 0 {name=X_66244_ }
C {devices/lab_pin.sym} 43020 -12170 0 0 {name=p42776 lab=_86004_/Q }
C {devices/lab_pin.sym} 43020 -12130 0 0 {name=p42777 lab=_51458_/X }
C {devices/lab_pin.sym} 43020 -12090 0 0 {name=p42778 lab=_51469_/Y }
C {devices/lab_pin.sym} 43180 -12130 0 1 {name=p42779 lab=_51470_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -12130 0 0 {name=X_51470_ }
C {devices/lab_pin.sym} 43040 -12010 0 0 {name=p42780 lab=_63456_/A }
C {devices/lab_pin.sym} 43040 -11970 0 0 {name=p42781 lab=_63456_/B }
C {devices/lab_pin.sym} 43040 -11930 0 0 {name=p42782 lab=_84322_/Q }
C {devices/lab_pin.sym} 43160 -11970 0 1 {name=p42783 lab=_63456_/Y }
C {sky130_stdcells/nor3_4.sym} 43100 -11970 0 0 {name=X_63456_ }
C {devices/lab_pin.sym} 43010 -11830 0 0 {name=p42784 lab=_82103_/CLK }
C {devices/lab_pin.sym} 43010 -11810 0 0 {name=p42785 lab=_82290_/D }
C {devices/lab_pin.sym} 43190 -11830 0 1 {name=p42786 lab=_82290_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -11820 0 0 {name=X_82290_ }
C {devices/lab_pin.sym} 43040 -11720 0 0 {name=p42787 lab=_60642_/C }
C {devices/lab_pin.sym} 43040 -11680 0 0 {name=p42788 lab=_60616_/Y }
C {devices/lab_pin.sym} 43040 -11640 0 0 {name=p42789 lab=_60644_/C }
C {devices/lab_pin.sym} 43040 -11600 0 0 {name=p42790 lab=_60667_/Y }
C {devices/lab_pin.sym} 43160 -11660 0 1 {name=p42791 lab=_60770_/A }
C {sky130_stdcells/and4_4.sym} 43100 -11660 0 0 {name=X_60668_ }
C {devices/lab_pin.sym} 43060 -11510 0 0 {name=p42792 lab=clkbuf_8_73_0_CLK/A }
C {devices/lab_pin.sym} 43140 -11510 0 1 {name=p42793 lab=clkbuf_8_73_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 43100 -11510 0 0 {name=Xclkbuf_8_73_0_CLK }
C {devices/lab_pin.sym} 43040 -11400 0 0 {name=p42794 lab=_50556_/A }
C {devices/lab_pin.sym} 43040 -11360 0 0 {name=p42795 lab=_52123_/B }
C {devices/lab_pin.sym} 43160 -11380 0 1 {name=p42796 lab=_50421_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -11380 0 0 {name=X_50421_ }
C {devices/lab_pin.sym} 43060 -11250 0 0 {name=p42797 lab=_62478_/A }
C {devices/lab_pin.sym} 43140 -11250 0 1 {name=p42798 lab=_62407_/X }
C {sky130_stdcells/buf_2.sym} 43100 -11250 0 0 {name=X_62407_ }
C {devices/lab_pin.sym} 43010 -11130 0 0 {name=p42799 lab=_85338_/CLK }
C {devices/lab_pin.sym} 43010 -11110 0 0 {name=p42800 lab=_81049_/Q }
C {devices/lab_pin.sym} 43190 -11130 0 1 {name=p42801 lab=_81241_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -11120 0 0 {name=X_81241_ }
C {devices/lab_pin.sym} 43060 -10990 0 0 {name=p42802 lab=_66046_/A }
C {devices/lab_pin.sym} 43140 -10990 0 1 {name=p42803 lab=_66177_/A }
C {sky130_stdcells/buf_2.sym} 43100 -10990 0 0 {name=X_66175_ }
C {devices/lab_pin.sym} 43060 -10870 0 0 {name=p42804 lab=clkbuf_6_2_0_CLK/X }
C {devices/lab_pin.sym} 43140 -10870 0 1 {name=p42805 lab=clkbuf_7_5_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 43100 -10870 0 0 {name=Xclkbuf_7_5_0_CLK }
C {devices/lab_pin.sym} 43040 -10770 0 0 {name=p42806 lab=_63400_/A }
C {devices/lab_pin.sym} 43040 -10730 0 0 {name=p42807 lab=_58225_/A }
C {devices/lab_pin.sym} 43040 -10690 0 0 {name=p42808 lab=_63400_/C }
C {devices/lab_pin.sym} 43160 -10730 0 1 {name=p42809 lab=_63387_/X }
C {sky130_stdcells/and3_4.sym} 43100 -10730 0 0 {name=X_63387_ }
C {devices/lab_pin.sym} 43040 -10620 0 0 {name=p42810 lab=_60599_/A }
C {devices/lab_pin.sym} 43040 -10580 0 0 {name=p42811 lab=_60403_/A }
C {devices/lab_pin.sym} 43040 -10540 0 0 {name=p42812 lab=_60403_/B }
C {devices/lab_pin.sym} 43040 -10500 0 0 {name=p42813 lab=_59508_/X }
C {devices/lab_pin.sym} 43160 -10560 0 1 {name=p42814 lab=_60599_/X }
C {sky130_stdcells/and4_4.sym} 43100 -10560 0 0 {name=X_60599_ }
C {devices/lab_pin.sym} 43040 -10420 0 0 {name=p42815 lab=_65126_/A }
C {devices/lab_pin.sym} 43040 -10380 0 0 {name=p42816 lab=_65125_/X }
C {devices/lab_pin.sym} 43160 -10400 0 1 {name=p42817 lab=_65126_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -10400 0 0 {name=X_65126_ }
C {devices/lab_pin.sym} 43020 -10290 0 0 {name=p42818 lab=_53136_/Y }
C {devices/lab_pin.sym} 43020 -10250 0 0 {name=p42819 lab=_53137_/X }
C {devices/lab_pin.sym} 43020 -10210 0 0 {name=p42820 lab=_53139_/X }
C {devices/lab_pin.sym} 43180 -10250 0 1 {name=p42821 lab=_85690_/D }
C {sky130_stdcells/a21oi_4.sym} 43100 -10250 0 0 {name=X_53140_ }
C {devices/lab_pin.sym} 43040 -10120 0 0 {name=p42822 lab=_50356_/A }
C {devices/lab_pin.sym} 43040 -10080 0 0 {name=p42823 lab=_57609_/B }
C {devices/lab_pin.sym} 43160 -10100 0 1 {name=p42824 lab=_50352_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -10100 0 0 {name=X_50352_ }
C {devices/lab_pin.sym} 43020 -10010 0 0 {name=p42825 lab=_61427_/B }
C {devices/lab_pin.sym} 43020 -9970 0 0 {name=p42826 lab=_62278_/X }
C {devices/lab_pin.sym} 43020 -9930 0 0 {name=p42827 lab=_60027_/A }
C {devices/lab_pin.sym} 43020 -9890 0 0 {name=p42828 lab=_62323_/X }
C {devices/lab_pin.sym} 43020 -9860 0 0 {name=p42829 lab=_62337_/X }
C {devices/lab_pin.sym} 43180 -9930 0 1 {name=p42830 lab=_62338_/X }
C {sky130_stdcells/a41o_4.sym} 43100 -9930 0 0 {name=X_62338_ }
C {devices/lab_pin.sym} 43010 -9770 0 0 {name=p42831 lab=_82335_/CLK }
C {devices/lab_pin.sym} 43010 -9750 0 0 {name=p42832 lab=_74978_/B }
C {devices/lab_pin.sym} 43190 -9770 0 1 {name=p42833 lab=_41523_/A }
C {sky130_stdcells/dfxtp_4.sym} 43100 -9760 0 0 {name=X_81172_ }
C {devices/lab_pin.sym} 43060 -9630 0 0 {name=p42834 lab=_44133_/Y }
C {devices/lab_pin.sym} 43140 -9630 0 1 {name=p42835 lab=_44134_/D }
C {sky130_stdcells/buf_8.sym} 43100 -9630 0 0 {name=Xpsn_inst_psn_buff_11 }
C {devices/lab_pin.sym} 43060 -9510 0 0 {name=p42836 lab=_53441_/A }
C {devices/lab_pin.sym} 43140 -9510 0 1 {name=p42837 lab=_43182_/B1 }
C {sky130_stdcells/buf_2.sym} 43100 -9510 0 0 {name=Xpsn_inst_psn_buff_22 }
C {devices/lab_pin.sym} 43040 -9400 0 0 {name=p42838 lab=_84941_/Q }
C {devices/lab_pin.sym} 43040 -9360 0 0 {name=p42839 lab=_84189_/Q }
C {devices/lab_pin.sym} 43160 -9380 0 1 {name=p42840 lab=_80125_/A }
C {sky130_stdcells/xor2_4.sym} 43100 -9380 0 0 {name=X_80123_ }
C {devices/lab_pin.sym} 43020 -9270 0 0 {name=p42841 lab=_53068_/Y }
C {devices/lab_pin.sym} 43020 -9230 0 0 {name=p42842 lab=_53056_/X }
C {devices/lab_pin.sym} 43020 -9190 0 0 {name=p42843 lab=_53070_/X }
C {devices/lab_pin.sym} 43180 -9230 0 1 {name=p42844 lab=_85703_/D }
C {sky130_stdcells/a21oi_4.sym} 43100 -9230 0 0 {name=X_53071_ }
C {devices/lab_pin.sym} 43040 -9100 0 0 {name=p42845 lab=_64904_/A }
C {devices/lab_pin.sym} 43040 -9060 0 0 {name=p42846 lab=_85840_/Q }
C {devices/lab_pin.sym} 43160 -9080 0 1 {name=p42847 lab=_65057_/X }
C {sky130_stdcells/and2_4.sym} 43100 -9080 0 0 {name=X_65057_ }
C {devices/lab_pin.sym} 43020 -8970 0 0 {name=p42848 lab=_69931_/X }
C {devices/lab_pin.sym} 43020 -8930 0 0 {name=p42849 lab=_69933_/X }
C {devices/lab_pin.sym} 43020 -8890 0 0 {name=p42850 lab=_69624_/X }
C {devices/lab_pin.sym} 43180 -8930 0 1 {name=p42851 lab=_69937_/A }
C {sky130_stdcells/a21o_4.sym} 43100 -8930 0 0 {name=X_69934_ }
C {devices/lab_pin.sym} 43060 -8790 0 0 {name=p42852 lab=_50595_/A }
C {devices/lab_pin.sym} 43140 -8790 0 1 {name=p42853 lab=_50500_/A }
C {sky130_stdcells/buf_2.sym} 43100 -8790 0 0 {name=X_50283_ }
C {devices/lab_pin.sym} 43060 -8670 0 0 {name=p42854 lab=_62269_/A }
C {devices/lab_pin.sym} 43140 -8670 0 1 {name=p42855 lab=_62269_/X }
C {sky130_stdcells/buf_2.sym} 43100 -8670 0 0 {name=X_62269_ }
C {devices/lab_pin.sym} 43010 -8550 0 0 {name=p42856 lab=_85692_/CLK }
C {devices/lab_pin.sym} 43010 -8530 0 0 {name=p42857 lab=_85980_/D }
C {devices/lab_pin.sym} 43190 -8550 0 1 {name=p42858 lab=_85980_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -8540 0 0 {name=X_85980_ }
C {devices/lab_pin.sym} 43060 -8410 0 0 {name=p42859 lab=clkbuf_8_89_0_CLK/A }
C {devices/lab_pin.sym} 43140 -8410 0 1 {name=p42860 lab=clkbuf_8_88_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 43100 -8410 0 0 {name=Xclkbuf_8_88_0_CLK }
C {devices/lab_pin.sym} 43060 -8290 0 0 {name=p42861 lab=_52462_/A }
C {devices/lab_pin.sym} 43140 -8290 0 1 {name=p42862 lab=_52022_/X }
C {sky130_stdcells/buf_2.sym} 43100 -8290 0 0 {name=X_52022_ }
C {devices/lab_pin.sym} 43060 -8170 0 0 {name=p42863 lab=_63849_/A }
C {devices/lab_pin.sym} 43140 -8170 0 1 {name=p42864 lab=_64074_/B }
C {sky130_stdcells/buf_2.sym} 43100 -8170 0 0 {name=X_64008_ }
C {devices/lab_pin.sym} 43010 -8050 0 0 {name=p42865 lab=_86312_/CLK }
C {devices/lab_pin.sym} 43010 -8030 0 0 {name=p42866 lab=_84931_/D }
C {devices/lab_pin.sym} 43190 -8050 0 1 {name=p42867 lab=_84931_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -8040 0 0 {name=X_84931_ }
C {devices/lab_pin.sym} 43020 -7930 0 0 {name=p42868 lab=_80042_/A }
C {devices/lab_pin.sym} 43020 -7890 0 0 {name=p42869 lab=_80041_/Y }
C {devices/lab_pin.sym} 43020 -7850 0 0 {name=p42870 lab=_80053_/X }
C {devices/lab_pin.sym} 43180 -7890 0 1 {name=p42871 lab=_80054_/X }
C {sky130_stdcells/a21o_4.sym} 43100 -7890 0 0 {name=X_80054_ }
C {devices/lab_pin.sym} 43040 -7760 0 0 {name=p42872 lab=_69865_/A }
C {devices/lab_pin.sym} 43040 -7720 0 0 {name=p42873 lab=_69865_/B }
C {devices/lab_pin.sym} 43160 -7740 0 1 {name=p42874 lab=_69865_/X }
C {sky130_stdcells/and2_4.sym} 43100 -7740 0 0 {name=X_69865_ }
C {devices/lab_pin.sym} 43040 -7630 0 0 {name=p42875 lab=_56774_/A }
C {devices/lab_pin.sym} 43040 -7590 0 0 {name=p42876 lab=_85129_/Q }
C {devices/lab_pin.sym} 43040 -7550 0 0 {name=p42877 lab=_44135_/X }
C {devices/lab_pin.sym} 43160 -7590 0 1 {name=p42878 lab=_56830_/Y }
C {sky130_stdcells/nor3_4.sym} 43100 -7590 0 0 {name=X_56830_ }
C {devices/lab_pin.sym} 43020 -7480 0 0 {name=p42879 lab=_87489_/Q }
C {devices/lab_pin.sym} 43020 -7440 0 0 {name=p42880 lab=_68792_/X }
C {devices/lab_pin.sym} 43020 -7400 0 0 {name=p42881 lab=_68545_/X }
C {devices/lab_pin.sym} 43020 -7360 0 0 {name=p42882 lab=_68815_/X }
C {devices/lab_pin.sym} 43180 -7420 0 1 {name=p42883 lab=_68816_/X }
C {sky130_stdcells/a211o_4.sym} 43100 -7420 0 0 {name=X_68816_ }
C {devices/lab_pin.sym} 43010 -7270 0 0 {name=p42884 lab=_87394_/CLK }
C {devices/lab_pin.sym} 43010 -7250 0 0 {name=p42885 lab=_87650_/D }
C {devices/lab_pin.sym} 43190 -7270 0 1 {name=p42886 lab=_87650_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -7260 0 0 {name=X_87650_ }
C {devices/lab_pin.sym} 43010 -7130 0 0 {name=p42887 lab=_84344_/CLK }
C {devices/lab_pin.sym} 43010 -7110 0 0 {name=p42888 lab=_84862_/D }
C {devices/lab_pin.sym} 43190 -7130 0 1 {name=p42889 lab=_84862_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -7120 0 0 {name=X_84862_ }
C {devices/lab_pin.sym} 43060 -6990 0 0 {name=p42890 lab=_69796_/A }
C {devices/lab_pin.sym} 43140 -6990 0 1 {name=p42891 lab=_69796_/X }
C {sky130_stdcells/buf_2.sym} 43100 -6990 0 0 {name=X_69796_ }
C {devices/lab_pin.sym} 43010 -6870 0 0 {name=p42892 lab=_85961_/CLK }
C {devices/lab_pin.sym} 43010 -6850 0 0 {name=p42893 lab=_86601_/D }
C {devices/lab_pin.sym} 43190 -6870 0 1 {name=p42894 lab=_72405_/A }
C {sky130_stdcells/dfxtp_4.sym} 43100 -6860 0 0 {name=X_86601_ }
C {devices/lab_pin.sym} 43060 -6730 0 0 {name=p42895 lab=clkbuf_7_5_0_CLK/X }
C {devices/lab_pin.sym} 43140 -6730 0 1 {name=p42896 lab=clkbuf_9_23_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 43100 -6730 0 0 {name=Xclkbuf_8_11_0_CLK }
C {devices/lab_pin.sym} 43010 -6610 0 0 {name=p42897 lab=_83813_/CLK }
C {devices/lab_pin.sym} 43010 -6590 0 0 {name=p42898 lab=_70278_/X }
C {devices/lab_pin.sym} 43190 -6610 0 1 {name=p42899 lab=_74775_/B }
C {sky130_stdcells/dfxtp_4.sym} 43100 -6600 0 0 {name=X_83813_ }
C {devices/lab_pin.sym} 43060 -6470 0 0 {name=p42900 lab=_56788_/A }
C {devices/lab_pin.sym} 43140 -6470 0 1 {name=p42901 lab=_56761_/X }
C {sky130_stdcells/buf_2.sym} 43100 -6470 0 0 {name=X_56761_ }
C {devices/lab_pin.sym} 43020 -6380 0 0 {name=p42902 lab=_41938_/A }
C {devices/lab_pin.sym} 43020 -6340 0 0 {name=p42903 lab=_68493_/X }
C {devices/lab_pin.sym} 43020 -6300 0 0 {name=p42904 lab=_68745_/X }
C {devices/lab_pin.sym} 43020 -6260 0 0 {name=p42905 lab=_68746_/Y }
C {devices/lab_pin.sym} 43180 -6320 0 1 {name=p42906 lab=_68747_/X }
C {sky130_stdcells/a211o_4.sym} 43100 -6320 0 0 {name=X_68747_ }
C {devices/lab_pin.sym} 43010 -6170 0 0 {name=p42907 lab=_87542_/CLK }
C {devices/lab_pin.sym} 43010 -6150 0 0 {name=p42908 lab=_43088_/Y }
C {devices/lab_pin.sym} 43190 -6170 0 1 {name=p42909 lab=_87581_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -6160 0 0 {name=X_87581_ }
C {devices/lab_pin.sym} 43060 -6030 0 0 {name=p42910 lab=_53929_/A }
C {devices/lab_pin.sym} 43140 -6030 0 1 {name=p42911 lab=_53978_/A }
C {sky130_stdcells/buf_2.sym} 43100 -6030 0 0 {name=X_53973_ }
C {devices/lab_pin.sym} 43040 -5920 0 0 {name=p42912 lab=_64694_/A }
C {devices/lab_pin.sym} 43040 -5880 0 0 {name=p42913 lab=_86589_/Q }
C {devices/lab_pin.sym} 43160 -5900 0 1 {name=p42914 lab=_65959_/X }
C {sky130_stdcells/and2_4.sym} 43100 -5900 0 0 {name=X_65959_ }
C {devices/lab_pin.sym} 43010 -5770 0 0 {name=p42915 lab=_86701_/CLK }
C {devices/lab_pin.sym} 43010 -5750 0 0 {name=p42916 lab=_58885_/Y }
C {devices/lab_pin.sym} 43190 -5770 0 1 {name=p42917 lab=_84793_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -5760 0 0 {name=X_84793_ }
C {devices/lab_pin.sym} 43060 -5630 0 0 {name=p42918 lab=_83425_/Q }
C {devices/lab_pin.sym} 43140 -5630 0 1 {name=p42919 lab=_58500_/Y }
C {sky130_stdcells/inv_2.sym} 43100 -5630 0 0 {name=X_58500_ }
C {devices/lab_pin.sym} 43020 -5530 0 0 {name=p42920 lab=_55711_/X }
C {devices/lab_pin.sym} 43020 -5490 0 0 {name=p42921 lab=_85283_/Q }
C {devices/lab_pin.sym} 43020 -5450 0 0 {name=p42922 lab=_55172_/A }
C {devices/lab_pin.sym} 43180 -5490 0 1 {name=p42923 lab=_55712_/Y }
C {sky130_stdcells/a21oi_4.sym} 43100 -5490 0 0 {name=X_55712_ }
C {devices/lab_pin.sym} 43010 -5350 0 0 {name=p42924 lab=_86490_/CLK }
C {devices/lab_pin.sym} 43010 -5330 0 0 {name=p42925 lab=_86532_/D }
C {devices/lab_pin.sym} 43190 -5350 0 1 {name=p42926 lab=_66326_/B }
C {sky130_stdcells/dfxtp_4.sym} 43100 -5340 0 0 {name=X_86532_ }
C {devices/lab_pin.sym} 43040 -5220 0 0 {name=p42927 lab=_52910_/A }
C {devices/lab_pin.sym} 43040 -5180 0 0 {name=p42928 lab=_52924_/B }
C {devices/lab_pin.sym} 43160 -5200 0 1 {name=p42929 lab=_52924_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -5200 0 0 {name=X_52924_ }
C {devices/lab_pin.sym} 43010 -5070 0 0 {name=p42930 lab=_86647_/CLK }
C {devices/lab_pin.sym} 43010 -5050 0 0 {name=p42931 lab=_83744_/D }
C {devices/lab_pin.sym} 43190 -5070 0 1 {name=p42932 lab=_47305_/A }
C {sky130_stdcells/dfxtp_4.sym} 43100 -5060 0 0 {name=X_83744_ }
C {devices/lab_pin.sym} 43060 -4930 0 0 {name=p42933 lab=_83432_/Q }
C {devices/lab_pin.sym} 43140 -4930 0 1 {name=p42934 lab=_59480_/Y }
C {sky130_stdcells/inv_2.sym} 43100 -4930 0 0 {name=X_59480_ }
C {devices/lab_pin.sym} 43060 -4810 0 0 {name=p42935 lab=_56663_/X }
C {devices/lab_pin.sym} 43140 -4810 0 1 {name=p42936 lab=_56693_/C }
C {sky130_stdcells/inv_2.sym} 43100 -4810 0 0 {name=X_56692_ }
C {devices/lab_pin.sym} 43010 -4690 0 0 {name=p42937 lab=_80991_/CLK }
C {devices/lab_pin.sym} 43010 -4670 0 0 {name=p42938 lab=_80956_/D }
C {devices/lab_pin.sym} 43190 -4690 0 1 {name=p42939 lab=_80956_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -4680 0 0 {name=X_80956_ }
C {devices/lab_pin.sym} 43020 -4570 0 0 {name=p42940 lab=_68674_/X }
C {devices/lab_pin.sym} 43020 -4530 0 0 {name=p42941 lab=_68677_/X }
C {devices/lab_pin.sym} 43020 -4490 0 0 {name=p42942 lab=_68477_/X }
C {devices/lab_pin.sym} 43180 -4530 0 1 {name=p42943 lab=_68678_/Y }
C {sky130_stdcells/a21oi_4.sym} 43100 -4530 0 0 {name=X_68678_ }
C {devices/lab_pin.sym} 43020 -4410 0 0 {name=p42944 lab=_58334_/X }
C {devices/lab_pin.sym} 43020 -4370 0 0 {name=p42945 lab=_58429_/Y }
C {devices/lab_pin.sym} 43020 -4330 0 0 {name=p42946 lab=_58430_/Y }
C {devices/lab_pin.sym} 43180 -4370 0 1 {name=p42947 lab=_84850_/D }
C {sky130_stdcells/a21oi_4.sym} 43100 -4370 0 0 {name=X_58431_ }
C {devices/lab_pin.sym} 43040 -4240 0 0 {name=p42948 lab=_55643_/A }
C {devices/lab_pin.sym} 43040 -4200 0 0 {name=p42949 lab=_55642_/X }
C {devices/lab_pin.sym} 43160 -4220 0 1 {name=p42950 lab=_55644_/A }
C {sky130_stdcells/and2_4.sym} 43100 -4220 0 0 {name=X_55643_ }
C {devices/lab_pin.sym} 43040 -4100 0 0 {name=p42951 lab=_67582_/A }
C {devices/lab_pin.sym} 43040 -4060 0 0 {name=p42952 lab=_67629_/B }
C {devices/lab_pin.sym} 43160 -4080 0 1 {name=p42953 lab=_67629_/X }
C {sky130_stdcells/and2_4.sym} 43100 -4080 0 0 {name=X_67629_ }
C {devices/lab_pin.sym} 43010 -3950 0 0 {name=p42954 lab=_83623_/CLK }
C {devices/lab_pin.sym} 43010 -3930 0 0 {name=p42955 lab=_86463_/D }
C {devices/lab_pin.sym} 43190 -3950 0 1 {name=p42956 lab=_64658_/B }
C {sky130_stdcells/dfxtp_4.sym} 43100 -3940 0 0 {name=X_86463_ }
C {devices/lab_pin.sym} 43040 -3820 0 0 {name=p42957 lab=_52850_/A }
C {devices/lab_pin.sym} 43040 -3780 0 0 {name=p42958 lab=_52855_/B }
C {devices/lab_pin.sym} 43160 -3800 0 1 {name=p42959 lab=_52855_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -3800 0 0 {name=X_52855_ }
C {devices/lab_pin.sym} 43010 -3670 0 0 {name=p42960 lab=_83676_/CLK }
C {devices/lab_pin.sym} 43010 -3650 0 0 {name=p42961 lab=_70877_/Y }
C {devices/lab_pin.sym} 43190 -3670 0 1 {name=p42962 lab=_83675_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -3660 0 0 {name=X_83675_ }
C {devices/lab_pin.sym} 43010 -3530 0 0 {name=p42963 lab=_80854_/CLK }
C {devices/lab_pin.sym} 43010 -3510 0 0 {name=p42964 lab=_80887_/D }
C {devices/lab_pin.sym} 43190 -3530 0 1 {name=p42965 lab=_80887_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -3520 0 0 {name=X_80887_ }
C {devices/lab_pin.sym} 43060 -3390 0 0 {name=p42966 lab=clkbuf_8_27_0_CLK/A }
C {devices/lab_pin.sym} 43140 -3390 0 1 {name=p42967 lab=clkbuf_9_53_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 43100 -3390 0 0 {name=Xclkbuf_8_26_0_CLK }
C {devices/lab_pin.sym} 43010 -3270 0 0 {name=p42968 lab=_87126_/CLK }
C {devices/lab_pin.sym} 43010 -3250 0 0 {name=p42969 lab=_41508_/X }
C {devices/lab_pin.sym} 43190 -3270 0 1 {name=p42970 lab=_88202_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -3260 0 0 {name=X_88202_ }
C {devices/lab_pin.sym} 43010 -3130 0 0 {name=p42971 lab=_86054_/CLK }
C {devices/lab_pin.sym} 43010 -3110 0 0 {name=p42972 lab=_85414_/D }
C {devices/lab_pin.sym} 43190 -3130 0 1 {name=p42973 lab=_85414_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -3120 0 0 {name=X_85414_ }
C {devices/lab_pin.sym} 43020 -3010 0 0 {name=p42974 lab=_51801_/Y }
C {devices/lab_pin.sym} 43020 -2970 0 0 {name=p42975 lab=_51793_/X }
C {devices/lab_pin.sym} 43020 -2930 0 0 {name=p42976 lab=_51805_/X }
C {devices/lab_pin.sym} 43180 -2970 0 1 {name=p42977 lab=_51806_/Y }
C {sky130_stdcells/a21oi_4.sym} 43100 -2970 0 0 {name=X_51806_ }
C {devices/lab_pin.sym} 43020 -2850 0 0 {name=p42978 lab=_53012_/B }
C {devices/lab_pin.sym} 43020 -2810 0 0 {name=p42979 lab=_70632_/X }
C {devices/lab_pin.sym} 43020 -2770 0 0 {name=p42980 lab=_70639_/Y }
C {devices/lab_pin.sym} 43180 -2810 0 1 {name=p42981 lab=_83737_/D }
C {sky130_stdcells/o21ai_4.sym} 43100 -2810 0 0 {name=X_70640_ }
C {devices/lab_pin.sym} 43060 -2670 0 0 {name=p42982 lab=_84868_/Q }
C {devices/lab_pin.sym} 43140 -2670 0 1 {name=p42983 lab=_63335_/A }
C {sky130_stdcells/inv_2.sym} 43100 -2670 0 0 {name=X_58362_ }
C {devices/lab_pin.sym} 43010 -2550 0 0 {name=p42984 lab=_81179_/CLK }
C {devices/lab_pin.sym} 43010 -2530 0 0 {name=p42985 lab=_82626_/D }
C {devices/lab_pin.sym} 43190 -2550 0 1 {name=p42986 lab=_82626_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -2540 0 0 {name=X_82626_ }
C {devices/lab_pin.sym} 43020 -2440 0 0 {name=p42987 lab=_85116_/Q }
C {devices/lab_pin.sym} 43020 -2400 0 0 {name=p42988 lab=_55571_/X }
C {devices/lab_pin.sym} 43020 -2360 0 0 {name=p42989 lab=_44049_/X }
C {devices/lab_pin.sym} 43020 -2320 0 0 {name=p42990 lab=_55573_/Y }
C {devices/lab_pin.sym} 43180 -2380 0 1 {name=p42991 lab=_55574_/X }
C {sky130_stdcells/a211o_4.sym} 43100 -2380 0 0 {name=X_55574_ }
C {devices/lab_pin.sym} 43010 -2230 0 0 {name=p42992 lab=_86393_/CLK }
C {devices/lab_pin.sym} 43010 -2210 0 0 {name=p42993 lab=_86394_/D }
C {devices/lab_pin.sym} 43190 -2230 0 1 {name=p42994 lab=_86394_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -2220 0 0 {name=X_86394_ }
C {devices/lab_pin.sym} 43020 -2110 0 0 {name=p42995 lab=_52782_/Y }
C {devices/lab_pin.sym} 43020 -2070 0 0 {name=p42996 lab=_52783_/X }
C {devices/lab_pin.sym} 43020 -2030 0 0 {name=p42997 lab=_52785_/X }
C {devices/lab_pin.sym} 43180 -2070 0 1 {name=p42998 lab=_52786_/Y }
C {sky130_stdcells/a21oi_4.sym} 43100 -2070 0 0 {name=X_52786_ }
C {devices/lab_pin.sym} 43040 -1950 0 0 {name=p42999 lab=_57049_/A }
C {devices/lab_pin.sym} 43040 -1910 0 0 {name=p43000 lab=_85036_/Q }
C {devices/lab_pin.sym} 43040 -1870 0 0 {name=p43001 lab=_57326_/C }
C {devices/lab_pin.sym} 43160 -1910 0 1 {name=p43002 lab=_57313_/Y }
C {sky130_stdcells/nor3_4.sym} 43100 -1910 0 0 {name=X_57313_ }
C {devices/lab_pin.sym} 43010 -1770 0 0 {name=p43003 lab=_88133_/CLK }
C {devices/lab_pin.sym} 43010 -1750 0 0 {name=p43004 lab=_41829_/Y }
C {devices/lab_pin.sym} 43190 -1770 0 1 {name=p43005 lab=_66920_/B }
C {sky130_stdcells/dfxtp_4.sym} 43100 -1760 0 0 {name=X_88133_ }
C {devices/lab_pin.sym} 43020 -1650 0 0 {name=p43006 lab=_85426_/Q }
C {devices/lab_pin.sym} 43020 -1610 0 0 {name=p43007 lab=_54512_/X }
C {devices/lab_pin.sym} 43020 -1570 0 0 {name=p43008 lab=_54524_/Y }
C {devices/lab_pin.sym} 43180 -1610 0 1 {name=p43009 lab=_54525_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -1610 0 0 {name=X_54525_ }
C {devices/lab_pin.sym} 43010 -1470 0 0 {name=p43010 lab=_83711_/CLK }
C {devices/lab_pin.sym} 43010 -1450 0 0 {name=p43011 lab=_85345_/D }
C {devices/lab_pin.sym} 43190 -1470 0 1 {name=p43012 lab=_85345_/Q }
C {sky130_stdcells/dfxtp_4.sym} 43100 -1460 0 0 {name=X_85345_ }
C {devices/lab_pin.sym} 43040 -1340 0 0 {name=p43013 lab=_51737_/A }
C {devices/lab_pin.sym} 43040 -1300 0 0 {name=p43014 lab=_53259_/B }
C {devices/lab_pin.sym} 43160 -1320 0 1 {name=p43015 lab=_51737_/Y }
C {sky130_stdcells/nand2_4.sym} 43100 -1320 0 0 {name=X_51737_ }
C {devices/lab_pin.sym} 43060 -1190 0 0 {name=p43016 lab=_70570_/Y }
C {devices/lab_pin.sym} 43140 -1190 0 1 {name=p43017 lab=_71867_/A }
C {sky130_stdcells/buf_2.sym} 43100 -1190 0 0 {name=X_70571_ }
C {devices/lab_pin.sym} 43010 -1070 0 0 {name=p43018 lab=_82557_/CLK }
C {devices/lab_pin.sym} 43010 -1050 0 0 {name=p43019 lab=_82557_/D }
C {devices/lab_pin.sym} 43190 -1070 0 1 {name=p43020 lab=_78903_/B }
C {sky130_stdcells/dfxtp_4.sym} 43100 -1060 0 0 {name=X_82557_ }
C {devices/lab_pin.sym} 43020 -950 0 0 {name=p43021 lab=_58282_/X }
C {devices/lab_pin.sym} 43020 -910 0 0 {name=p43022 lab=_58290_/Y }
C {devices/lab_pin.sym} 43020 -870 0 0 {name=p43023 lab=_58292_/Y }
C {devices/lab_pin.sym} 43180 -910 0 1 {name=p43024 lab=_84886_/D }
C {sky130_stdcells/a21oi_4.sym} 43100 -910 0 0 {name=X_58293_ }
C {devices/lab_pin.sym} 43020 -790 0 0 {name=p43025 lab=_72209_/X }
C {devices/lab_pin.sym} 43020 -750 0 0 {name=p43026 lab=_85970_/Q }
C {devices/lab_pin.sym} 43020 -710 0 0 {name=p43027 lab=_72309_/X }
C {devices/lab_pin.sym} 43180 -750 0 1 {name=p43028 lab=_72310_/Y }
C {sky130_stdcells/o21ai_4.sym} 43100 -750 0 0 {name=X_72310_ }
C {devices/lab_pin.sym} 43980 -42150 0 0 {name=p43029 lab=_57235_/Y }
C {devices/lab_pin.sym} 44060 -42150 0 1 {name=p43030 lab=_57244_/X }
C {sky130_stdcells/buf_2.sym} 44020 -42150 0 0 {name=X_57244_ }
C {devices/lab_pin.sym} 43930 -42030 0 0 {name=p43031 lab=_83918_/CLK }
C {devices/lab_pin.sym} 43930 -42010 0 0 {name=p43032 lab=_76171_/B }
C {devices/lab_pin.sym} 44110 -42030 0 1 {name=p43033 lab=_81508_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -42020 0 0 {name=X_81508_ }
C {devices/lab_pin.sym} 43930 -41890 0 0 {name=p43034 lab=_87813_/CLK }
C {devices/lab_pin.sym} 43930 -41870 0 0 {name=p43035 lab=_88064_/D }
C {devices/lab_pin.sym} 44110 -41890 0 1 {name=p43036 lab=_73247_/A }
C {sky130_stdcells/dfxtp_4.sym} 44020 -41880 0 0 {name=X_88064_ }
C {devices/lab_pin.sym} 43940 -41790 0 0 {name=p43037 lab=_42466_/X }
C {devices/lab_pin.sym} 43940 -41750 0 0 {name=p43038 lab=_42467_/X }
C {devices/lab_pin.sym} 43940 -41710 0 0 {name=p43039 lab=_40610_/X }
C {devices/lab_pin.sym} 43940 -41670 0 0 {name=p43040 lab=_68490_/A }
C {devices/lab_pin.sym} 43940 -41630 0 0 {name=p43041 lab=_42453_/X }
C {devices/lab_pin.sym} 44100 -41710 0 1 {name=p43042 lab=_42470_/Y }
C {sky130_stdcells/o32ai_4.sym} 44020 -41710 0 0 {name=X_42470_ }
C {devices/lab_pin.sym} 43940 -41570 0 0 {name=p43043 lab=_54452_/Y }
C {devices/lab_pin.sym} 43940 -41530 0 0 {name=p43044 lab=_54448_/X }
C {devices/lab_pin.sym} 43940 -41490 0 0 {name=p43045 lab=_54455_/X }
C {devices/lab_pin.sym} 44100 -41530 0 1 {name=p43046 lab=_85439_/D }
C {sky130_stdcells/a21oi_4.sym} 44020 -41530 0 0 {name=X_54456_ }
C {devices/lab_pin.sym} 43960 -41400 0 0 {name=p43047 lab=_73290_/A }
C {devices/lab_pin.sym} 43960 -41360 0 0 {name=p43048 lab=_73290_/B }
C {devices/lab_pin.sym} 44080 -41380 0 1 {name=p43049 lab=_73290_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -41380 0 0 {name=X_73290_ }
C {devices/lab_pin.sym} 43930 -41250 0 0 {name=p43050 lab=_85277_/CLK }
C {devices/lab_pin.sym} 43930 -41230 0 0 {name=p43051 lab=_56207_/Y }
C {devices/lab_pin.sym} 44110 -41250 0 1 {name=p43052 lab=_56206_/C }
C {sky130_stdcells/dfxtp_4.sym} 44020 -41240 0 0 {name=X_85276_ }
C {devices/lab_pin.sym} 43980 -41110 0 0 {name=p43053 lab=_51694_/A }
C {devices/lab_pin.sym} 44060 -41110 0 1 {name=p43054 lab=_51684_/B }
C {sky130_stdcells/buf_2.sym} 44020 -41110 0 0 {name=X_51668_ }
C {devices/lab_pin.sym} 43930 -40990 0 0 {name=p43055 lab=_82518_/CLK }
C {devices/lab_pin.sym} 43930 -40970 0 0 {name=p43056 lab=_82488_/D }
C {devices/lab_pin.sym} 44110 -40990 0 1 {name=p43057 lab=_78174_/B }
C {sky130_stdcells/dfxtp_4.sym} 44020 -40980 0 0 {name=X_82488_ }
C {devices/lab_pin.sym} 43980 -40850 0 0 {name=p43058 lab=_41072_/X }
C {devices/lab_pin.sym} 44060 -40850 0 1 {name=p43059 lab=_41421_/X }
C {sky130_stdcells/buf_2.sym} 44020 -40850 0 0 {name=X_41421_ }
C {devices/lab_pin.sym} 43930 -40730 0 0 {name=p43060 lab=_88283_/CLK }
C {devices/lab_pin.sym} 43930 -40710 0 0 {name=p43061 lab=_44653_/X }
C {devices/lab_pin.sym} 44110 -40730 0 1 {name=p43062 lab=_87015_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -40720 0 0 {name=X_87015_ }
C {devices/lab_pin.sym} 43940 -40610 0 0 {name=p43063 lab=_85639_/Q }
C {devices/lab_pin.sym} 43940 -40570 0 0 {name=p43064 lab=_53404_/X }
C {devices/lab_pin.sym} 43940 -40530 0 0 {name=p43065 lab=_53406_/Y }
C {devices/lab_pin.sym} 44100 -40570 0 1 {name=p43066 lab=_53407_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -40570 0 0 {name=X_53407_ }
C {devices/lab_pin.sym} 43980 -40430 0 0 {name=p43067 lab=_64591_/X }
C {devices/lab_pin.sym} 44060 -40430 0 1 {name=p43068 lab=_72241_/X }
C {sky130_stdcells/buf_2.sym} 44020 -40430 0 0 {name=X_72241_ }
C {devices/lab_pin.sym} 43930 -40310 0 0 {name=p43069 lab=_84231_/CLK }
C {devices/lab_pin.sym} 43930 -40290 0 0 {name=p43070 lab=_84227_/D }
C {devices/lab_pin.sym} 44110 -40310 0 1 {name=p43071 lab=_84227_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -40300 0 0 {name=X_84227_ }
C {devices/lab_pin.sym} 43980 -40170 0 0 {name=p43072 lab=_50577_/A }
C {devices/lab_pin.sym} 44060 -40170 0 1 {name=p43073 lab=_50619_/X }
C {sky130_stdcells/buf_2.sym} 44020 -40170 0 0 {name=X_50619_ }
C {devices/lab_pin.sym} 43960 -40060 0 0 {name=p43074 lab=_57175_/A }
C {devices/lab_pin.sym} 43960 -40020 0 0 {name=p43075 lab=_57175_/B }
C {devices/lab_pin.sym} 44080 -40040 0 1 {name=p43076 lab=_57175_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -40040 0 0 {name=X_57175_ }
C {devices/lab_pin.sym} 43930 -39910 0 0 {name=p43077 lab=_81532_/CLK }
C {devices/lab_pin.sym} 43930 -39890 0 0 {name=p43078 lab=_81471_/Q }
C {devices/lab_pin.sym} 44110 -39910 0 1 {name=p43079 lab=_76139_/B }
C {sky130_stdcells/dfxtp_4.sym} 44020 -39900 0 0 {name=X_81439_ }
C {devices/lab_pin.sym} 43940 -39790 0 0 {name=p43080 lab=_54383_/Y }
C {devices/lab_pin.sym} 43940 -39750 0 0 {name=p43081 lab=_54366_/X }
C {devices/lab_pin.sym} 43940 -39710 0 0 {name=p43082 lab=_54386_/X }
C {devices/lab_pin.sym} 44100 -39750 0 1 {name=p43083 lab=_85452_/D }
C {sky130_stdcells/a21oi_4.sym} 44020 -39750 0 0 {name=X_54387_ }
C {devices/lab_pin.sym} 43940 -39630 0 0 {name=p43084 lab=_51597_/Y }
C {devices/lab_pin.sym} 43940 -39590 0 0 {name=p43085 lab=_51585_/X }
C {devices/lab_pin.sym} 43940 -39550 0 0 {name=p43086 lab=_51598_/X }
C {devices/lab_pin.sym} 44100 -39590 0 1 {name=p43087 lab=_85981_/D }
C {sky130_stdcells/a21oi_4.sym} 44020 -39590 0 0 {name=X_51599_ }
C {devices/lab_pin.sym} 43940 -39470 0 0 {name=p43088 lab=_60665_/C }
C {devices/lab_pin.sym} 43940 -39430 0 0 {name=p43089 lab=_44003_/X }
C {devices/lab_pin.sym} 43940 -39390 0 0 {name=p43090 lab=_62975_/D }
C {devices/lab_pin.sym} 44100 -39430 0 1 {name=p43091 lab=_44140_/X }
C {sky130_stdcells/a21o_4.sym} 44020 -39430 0 0 {name=X_44140_ }
C {devices/lab_pin.sym} 43980 -39290 0 0 {name=p43092 lab=_56117_/C }
C {devices/lab_pin.sym} 44060 -39290 0 1 {name=p43093 lab=_56147_/A }
C {sky130_stdcells/inv_2.sym} 44020 -39290 0 0 {name=X_56126_ }
C {devices/lab_pin.sym} 43980 -39170 0 0 {name=p43094 lab=_41351_/Y }
C {devices/lab_pin.sym} 44060 -39170 0 1 {name=p43095 lab=_41352_/X }
C {sky130_stdcells/buf_2.sym} 44020 -39170 0 0 {name=X_41352_ }
C {devices/lab_pin.sym} 43980 -39050 0 0 {name=p43096 lab=_53311_/A }
C {devices/lab_pin.sym} 44060 -39050 0 1 {name=p43097 lab=_53339_/A }
C {sky130_stdcells/buf_2.sym} 44020 -39050 0 0 {name=X_53338_ }
C {devices/lab_pin.sym} 43980 -38930 0 0 {name=p43098 lab=_58864_/A }
C {devices/lab_pin.sym} 44060 -38930 0 1 {name=p43099 lab=_72172_/X }
C {sky130_stdcells/buf_2.sym} 44020 -38930 0 0 {name=X_72172_ }
C {devices/lab_pin.sym} 43930 -38810 0 0 {name=p43100 lab=_84166_/CLK }
C {devices/lab_pin.sym} 43930 -38790 0 0 {name=p43101 lab=_84158_/D }
C {devices/lab_pin.sym} 44110 -38810 0 1 {name=p43102 lab=_84158_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -38800 0 0 {name=X_84158_ }
C {devices/lab_pin.sym} 43960 -38690 0 0 {name=p43103 lab=_71112_/X }
C {devices/lab_pin.sym} 43960 -38650 0 0 {name=p43104 lab=_71055_/B }
C {devices/lab_pin.sym} 43960 -38610 0 0 {name=p43105 lab=_71119_/C }
C {devices/lab_pin.sym} 44080 -38650 0 1 {name=p43106 lab=_71123_/Y }
C {sky130_stdcells/nand3_4.sym} 44020 -38650 0 0 {name=X_71123_ }
C {devices/lab_pin.sym} 43930 -38510 0 0 {name=p43107 lab=_82998_/CLK }
C {devices/lab_pin.sym} 43930 -38490 0 0 {name=p43108 lab=_74296_/X }
C {devices/lab_pin.sym} 44110 -38510 0 1 {name=p43109 lab=_70277_/C }
C {sky130_stdcells/dfxtp_4.sym} 44020 -38500 0 0 {name=X_83109_ }
C {devices/lab_pin.sym} 43960 -38390 0 0 {name=p43110 lab=_44071_/A }
C {devices/lab_pin.sym} 43960 -38350 0 0 {name=p43111 lab=_44232_/B }
C {devices/lab_pin.sym} 43960 -38310 0 0 {name=p43112 lab=_87178_/Q }
C {devices/lab_pin.sym} 44080 -38350 0 1 {name=p43113 lab=_44071_/X }
C {sky130_stdcells/and3_4.sym} 44020 -38350 0 0 {name=X_44071_ }
C {devices/lab_pin.sym} 43940 -38230 0 0 {name=p43114 lab=_56029_/X }
C {devices/lab_pin.sym} 43940 -38190 0 0 {name=p43115 lab=_56055_/X }
C {devices/lab_pin.sym} 43940 -38150 0 0 {name=p43116 lab=_56056_/Y }
C {devices/lab_pin.sym} 44100 -38190 0 1 {name=p43117 lab=_56057_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -38190 0 0 {name=X_56057_ }
C {devices/lab_pin.sym} 43980 -38050 0 0 {name=p43118 lab=_41181_/A }
C {devices/lab_pin.sym} 44060 -38050 0 1 {name=p43119 lab=_41283_/X }
C {sky130_stdcells/buf_2.sym} 44020 -38050 0 0 {name=X_41283_ }
C {devices/lab_pin.sym} 43980 -37930 0 0 {name=p43120 lab=_53269_/A }
C {devices/lab_pin.sym} 44060 -37930 0 1 {name=p43121 lab=_53276_/A }
C {sky130_stdcells/buf_2.sym} 44020 -37930 0 0 {name=X_53269_ }
C {devices/lab_pin.sym} 43960 -37820 0 0 {name=p43122 lab=_76980_/A }
C {devices/lab_pin.sym} 43960 -37780 0 0 {name=p43123 lab=_62527_/C }
C {devices/lab_pin.sym} 44080 -37800 0 1 {name=p43124 lab=_76980_/X }
C {sky130_stdcells/xor2_4.sym} 44020 -37800 0 0 {name=X_76980_ }
C {devices/lab_pin.sym} 43930 -37670 0 0 {name=p43125 lab=_81507_/CLK }
C {devices/lab_pin.sym} 43930 -37650 0 0 {name=p43126 lab=_84089_/D }
C {devices/lab_pin.sym} 44110 -37670 0 1 {name=p43127 lab=_80913_/D }
C {sky130_stdcells/dfxtp_4.sym} 44020 -37660 0 0 {name=X_84089_ }
C {devices/lab_pin.sym} 43940 -37570 0 0 {name=p43128 lab=_42439_/X }
C {devices/lab_pin.sym} 43940 -37530 0 0 {name=p43129 lab=_43017_/X }
C {devices/lab_pin.sym} 43940 -37490 0 0 {name=p43130 lab=_40560_/X }
C {devices/lab_pin.sym} 43940 -37450 0 0 {name=p43131 lab=_73554_/A }
C {devices/lab_pin.sym} 43940 -37410 0 0 {name=p43132 lab=_43021_/X }
C {devices/lab_pin.sym} 44100 -37490 0 1 {name=p43133 lab=_43023_/A }
C {sky130_stdcells/o32ai_4.sym} 44020 -37490 0 0 {name=X_43022_ }
C {devices/lab_pin.sym} 43940 -37350 0 0 {name=p43134 lab=_85336_/Q }
C {devices/lab_pin.sym} 43940 -37310 0 0 {name=p43135 lab=_54994_/X }
C {devices/lab_pin.sym} 43940 -37270 0 0 {name=p43136 lab=_55007_/Y }
C {devices/lab_pin.sym} 44100 -37310 0 1 {name=p43137 lab=_55008_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -37310 0 0 {name=X_55008_ }
C {devices/lab_pin.sym} 43980 -37170 0 0 {name=p43138 lab=_71054_/A }
C {devices/lab_pin.sym} 44060 -37170 0 1 {name=p43139 lab=_71055_/B }
C {sky130_stdcells/buf_2.sym} 44020 -37170 0 0 {name=X_71054_ }
C {devices/lab_pin.sym} 43960 -37060 0 0 {name=p43140 lab=_81700_/D }
C {devices/lab_pin.sym} 43960 -37020 0 0 {name=p43141 lab=_75930_/B }
C {devices/lab_pin.sym} 44080 -37040 0 1 {name=p43142 lab=_75932_/A }
C {sky130_stdcells/nand2_4.sym} 44020 -37040 0 0 {name=X_75931_ }
C {devices/lab_pin.sym} 43930 -36910 0 0 {name=p43143 lab=_86934_/CLK }
C {devices/lab_pin.sym} 43930 -36890 0 0 {name=p43144 lab=_87917_/D }
C {devices/lab_pin.sym} 44110 -36910 0 1 {name=p43145 lab=_87917_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -36900 0 0 {name=X_87917_ }
C {devices/lab_pin.sym} 43980 -36770 0 0 {name=p43146 lab=_69655_/A }
C {devices/lab_pin.sym} 44060 -36770 0 1 {name=p43147 lab=_70005_/X }
C {sky130_stdcells/buf_2.sym} 44020 -36770 0 0 {name=X_70005_ }
C {devices/lab_pin.sym} 43980 -36650 0 0 {name=p43148 lab=_83561_/Q }
C {devices/lab_pin.sym} 44060 -36650 0 1 {name=p43149 lab=_47830_/Y }
C {sky130_stdcells/inv_2.sym} 44020 -36650 0 0 {name=X_47830_ }
C {devices/lab_pin.sym} 43980 -36530 0 0 {name=p43150 lab=_59816_/A }
C {devices/lab_pin.sym} 44060 -36530 0 1 {name=p43151 lab=_61202_/A }
C {sky130_stdcells/buf_2.sym} 44020 -36530 0 0 {name=X_59816_ }
C {devices/lab_pin.sym} 43940 -36430 0 0 {name=p43152 lab=_78649_/B }
C {devices/lab_pin.sym} 43940 -36390 0 0 {name=p43153 lab=_78648_/Y }
C {devices/lab_pin.sym} 43940 -36350 0 0 {name=p43154 lab=_78645_/Y }
C {devices/lab_pin.sym} 44100 -36390 0 1 {name=p43155 lab=_78654_/C }
C {sky130_stdcells/o21ai_4.sym} 44020 -36390 0 0 {name=X_78650_ }
C {devices/lab_pin.sym} 43960 -36260 0 0 {name=p43156 lab=_75860_/B }
C {devices/lab_pin.sym} 43960 -36220 0 0 {name=p43157 lab=_75860_/A }
C {devices/lab_pin.sym} 44080 -36240 0 1 {name=p43158 lab=_75862_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -36240 0 0 {name=X_75862_ }
C {devices/lab_pin.sym} 43930 -36110 0 0 {name=p43159 lab=_87595_/CLK }
C {devices/lab_pin.sym} 43930 -36090 0 0 {name=p43160 lab=_42490_/Y }
C {devices/lab_pin.sym} 44110 -36110 0 1 {name=p43161 lab=_73820_/A }
C {sky130_stdcells/dfxtp_4.sym} 44020 -36100 0 0 {name=X_87848_ }
C {devices/lab_pin.sym} 43960 -35980 0 0 {name=p43162 lab=_77601_/A }
C {devices/lab_pin.sym} 43960 -35940 0 0 {name=p43163 lab=_82107_/D }
C {devices/lab_pin.sym} 44080 -35960 0 1 {name=p43164 lab=_77601_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -35960 0 0 {name=X_77601_ }
C {devices/lab_pin.sym} 43980 -35830 0 0 {name=p43165 lab=_46216_/A }
C {devices/lab_pin.sym} 44060 -35830 0 1 {name=p43166 lab=_74813_/Y }
C {sky130_stdcells/inv_2.sym} 44020 -35830 0 0 {name=X_74813_ }
C {devices/lab_pin.sym} 43980 -35710 0 0 {name=p43167 lab=_47620_/X }
C {devices/lab_pin.sym} 44060 -35710 0 1 {name=p43168 lab=_47799_/A }
C {sky130_stdcells/buf_2.sym} 44020 -35710 0 0 {name=X_47761_ }
C {devices/lab_pin.sym} 43960 -35610 0 0 {name=p43169 lab=_59737_/A }
C {devices/lab_pin.sym} 43960 -35570 0 0 {name=p43170 lab=_59711_/B }
C {devices/lab_pin.sym} 43960 -35530 0 0 {name=p43171 lab=_80539_/A }
C {devices/lab_pin.sym} 44080 -35570 0 1 {name=p43172 lab=_59747_/Y }
C {sky130_stdcells/nor3_4.sym} 44020 -35570 0 0 {name=X_59747_ }
C {devices/lab_pin.sym} 43960 -35440 0 0 {name=p43173 lab=_78600_/A }
C {devices/lab_pin.sym} 43960 -35400 0 0 {name=p43174 lab=_78581_/B }
C {devices/lab_pin.sym} 44080 -35420 0 1 {name=p43175 lab=_82772_/D }
C {sky130_stdcells/xor2_4.sym} 44020 -35420 0 0 {name=X_78581_ }
C {devices/lab_pin.sym} 43940 -35320 0 0 {name=p43176 lab=_56949_/X }
C {devices/lab_pin.sym} 43940 -35280 0 0 {name=p43177 lab=_56619_/X }
C {devices/lab_pin.sym} 43940 -35240 0 0 {name=p43178 lab=_45535_/A }
C {devices/lab_pin.sym} 43940 -35200 0 0 {name=p43179 lab=_56947_/X }
C {devices/lab_pin.sym} 44100 -35260 0 1 {name=p43180 lab=_85112_/D }
C {sky130_stdcells/a2bb2o_4.sym} 44020 -35260 0 0 {name=X_56959_ }
C {devices/lab_pin.sym} 43980 -35110 0 0 {name=p43181 lab=_44972_/X }
C {devices/lab_pin.sym} 44060 -35110 0 1 {name=p43182 lab=_44973_/X }
C {sky130_stdcells/buf_2.sym} 44020 -35110 0 0 {name=X_44973_ }
C {devices/lab_pin.sym} 43960 -35000 0 0 {name=p43183 lab=_75793_/A }
C {devices/lab_pin.sym} 43960 -34960 0 0 {name=p43184 lab=_75793_/B }
C {devices/lab_pin.sym} 44080 -34980 0 1 {name=p43185 lab=_80890_/D }
C {sky130_stdcells/xor2_4.sym} 44020 -34980 0 0 {name=X_75793_ }
C {devices/lab_pin.sym} 43930 -34850 0 0 {name=p43186 lab=_87533_/CLK }
C {devices/lab_pin.sym} 43930 -34830 0 0 {name=p43187 lab=_87779_/D }
C {devices/lab_pin.sym} 44110 -34850 0 1 {name=p43188 lab=_69354_/B }
C {sky130_stdcells/dfxtp_4.sym} 44020 -34840 0 0 {name=X_87779_ }
C {devices/lab_pin.sym} 43960 -34740 0 0 {name=p43189 lab=_49500_/A }
C {devices/lab_pin.sym} 43960 -34700 0 0 {name=p43190 lab=_49500_/B }
C {devices/lab_pin.sym} 43960 -34660 0 0 {name=p43191 lab=_49493_/X }
C {devices/lab_pin.sym} 43960 -34620 0 0 {name=p43192 lab=_52716_/D }
C {devices/lab_pin.sym} 44080 -34680 0 1 {name=p43193 lab=_49500_/X }
C {sky130_stdcells/and4_4.sym} 44020 -34680 0 0 {name=X_49500_ }
C {devices/lab_pin.sym} 43960 -34540 0 0 {name=p43194 lab=_46712_/A }
C {devices/lab_pin.sym} 43960 -34500 0 0 {name=p43195 lab=_51800_/B }
C {devices/lab_pin.sym} 44080 -34520 0 1 {name=p43196 lab=_46712_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -34520 0 0 {name=X_46712_ }
C {devices/lab_pin.sym} 43960 -34400 0 0 {name=p43197 lab=_77532_/A }
C {devices/lab_pin.sym} 43960 -34360 0 0 {name=p43198 lab=_82103_/D }
C {devices/lab_pin.sym} 44080 -34380 0 1 {name=p43199 lab=_77537_/A }
C {sky130_stdcells/nor2_4.sym} 44020 -34380 0 0 {name=X_77532_ }
C {devices/lab_pin.sym} 43980 -34250 0 0 {name=p43200 lab=_43854_/A }
C {devices/lab_pin.sym} 44060 -34250 0 1 {name=p43201 lab=_43924_/X }
C {sky130_stdcells/buf_2.sym} 44020 -34250 0 0 {name=X_43924_ }
C {devices/lab_pin.sym} 43980 -34130 0 0 {name=p43202 lab=_70732_/X }
C {devices/lab_pin.sym} 44060 -34130 0 1 {name=p43203 lab=_74744_/X }
C {sky130_stdcells/buf_2.sym} 44020 -34130 0 0 {name=X_74744_ }
C {devices/lab_pin.sym} 43960 -34040 0 0 {name=p43204 lab=_47692_/A }
C {devices/lab_pin.sym} 43960 -34000 0 0 {name=p43205 lab=_47692_/B }
C {devices/lab_pin.sym} 43960 -33960 0 0 {name=p43206 lab=_47692_/C }
C {devices/lab_pin.sym} 43960 -33920 0 0 {name=p43207 lab=_53191_/D }
C {devices/lab_pin.sym} 44080 -33980 0 1 {name=p43208 lab=_47692_/X }
C {sky130_stdcells/and4_4.sym} 44020 -33980 0 0 {name=X_47692_ }
C {devices/lab_pin.sym} 43940 -33850 0 0 {name=p43209 lab=_71942_/Y }
C {devices/lab_pin.sym} 43940 -33810 0 0 {name=p43210 lab=_83314_/Q }
C {devices/lab_pin.sym} 43940 -33770 0 0 {name=p43211 lab=_71955_/Y }
C {devices/lab_pin.sym} 44100 -33810 0 1 {name=p43212 lab=_71956_/X }
C {sky130_stdcells/a21o_4.sym} 44020 -33810 0 0 {name=X_71956_ }
C {devices/lab_pin.sym} 43940 -33710 0 0 {name=p43213 lab=_59621_/X }
C {devices/lab_pin.sym} 43940 -33670 0 0 {name=p43214 lab=_59619_/X }
C {devices/lab_pin.sym} 43940 -33630 0 0 {name=p43215 lab=_59753_/B }
C {devices/lab_pin.sym} 43940 -33590 0 0 {name=p43216 lab=_72569_/C }
C {devices/lab_pin.sym} 43940 -33550 0 0 {name=p43217 lab=_59600_/X }
C {devices/lab_pin.sym} 44100 -33630 0 1 {name=p43218 lab=_59680_/A }
C {sky130_stdcells/a32oi_4.sym} 44020 -33630 0 0 {name=X_59678_ }
C {devices/lab_pin.sym} 43960 -33480 0 0 {name=p43219 lab=_49418_/A }
C {devices/lab_pin.sym} 43960 -33440 0 0 {name=p43220 lab=_46740_/X }
C {devices/lab_pin.sym} 44080 -33460 0 1 {name=p43221 lab=_49431_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -33460 0 0 {name=X_49431_ }
C {devices/lab_pin.sym} 43980 -33330 0 0 {name=p43222 lab=clkbuf_9_185_0_CLK/X }
C {devices/lab_pin.sym} 44060 -33330 0 1 {name=p43223 lab=_86361_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44020 -33330 0 0 {name=Xclkbuf_10_370_0_CLK }
C {devices/lab_pin.sym} 43960 -33220 0 0 {name=p43224 lab=_46651_/A }
C {devices/lab_pin.sym} 43960 -33180 0 0 {name=p43225 lab=_51765_/B }
C {devices/lab_pin.sym} 44080 -33200 0 1 {name=p43226 lab=_46643_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -33200 0 0 {name=X_46643_ }
C {devices/lab_pin.sym} 43940 -33090 0 0 {name=p43227 lab=_58112_/X }
C {devices/lab_pin.sym} 43940 -33050 0 0 {name=p43228 lab=_86108_/Q }
C {devices/lab_pin.sym} 43940 -33010 0 0 {name=p43229 lab=_58628_/X }
C {devices/lab_pin.sym} 44100 -33050 0 1 {name=p43230 lab=_58629_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -33050 0 0 {name=X_58629_ }
C {devices/lab_pin.sym} 43960 -32930 0 0 {name=p43231 lab=_70358_/X }
C {devices/lab_pin.sym} 43960 -32890 0 0 {name=p43232 lab=_70907_/B }
C {devices/lab_pin.sym} 43960 -32850 0 0 {name=p43233 lab=_70495_/A }
C {devices/lab_pin.sym} 44080 -32890 0 1 {name=p43234 lab=_70908_/A }
C {sky130_stdcells/nand3_4.sym} 44020 -32890 0 0 {name=X_70907_ }
C {devices/lab_pin.sym} 43940 -32770 0 0 {name=p43235 lab=_77461_/X }
C {devices/lab_pin.sym} 43940 -32730 0 0 {name=p43236 lab=_77431_/Y }
C {devices/lab_pin.sym} 43940 -32690 0 0 {name=p43237 lab=_77462_/Y }
C {devices/lab_pin.sym} 44100 -32730 0 1 {name=p43238 lab=_77463_/X }
C {sky130_stdcells/a21o_4.sym} 44020 -32730 0 0 {name=X_77463_ }
C {devices/lab_pin.sym} 43940 -32630 0 0 {name=p43239 lab=_43846_/X }
C {devices/lab_pin.sym} 43940 -32590 0 0 {name=p43240 lab=_43854_/X }
C {devices/lab_pin.sym} 43940 -32550 0 0 {name=p43241 lab=_41214_/X }
C {devices/lab_pin.sym} 43940 -32510 0 0 {name=p43242 lab=_87232_/Q }
C {devices/lab_pin.sym} 43940 -32470 0 0 {name=p43243 lab=_43847_/X }
C {devices/lab_pin.sym} 44100 -32550 0 1 {name=p43244 lab=_43855_/Y }
C {sky130_stdcells/o32ai_4.sym} 44020 -32550 0 0 {name=X_43855_ }
C {devices/lab_pin.sym} 43980 -32390 0 0 {name=p43245 lab=_74675_/A }
C {devices/lab_pin.sym} 44060 -32390 0 1 {name=p43246 lab=_74675_/X }
C {sky130_stdcells/buf_2.sym} 44020 -32390 0 0 {name=X_74675_ }
C {devices/lab_pin.sym} 43960 -32300 0 0 {name=p43247 lab=_71887_/A }
C {devices/lab_pin.sym} 43960 -32260 0 0 {name=p43248 lab=_71783_/A }
C {devices/lab_pin.sym} 43960 -32220 0 0 {name=p43249 lab=_71783_/C }
C {devices/lab_pin.sym} 43960 -32180 0 0 {name=p43250 lab=_71883_/D }
C {devices/lab_pin.sym} 44080 -32240 0 1 {name=p43251 lab=_71887_/Y }
C {sky130_stdcells/nor4_4.sym} 44020 -32240 0 0 {name=X_71887_ }
C {devices/lab_pin.sym} 43960 -32100 0 0 {name=p43252 lab=_84789_/Q }
C {devices/lab_pin.sym} 43960 -32060 0 0 {name=p43253 lab=_66509_/C }
C {devices/lab_pin.sym} 44080 -32080 0 1 {name=p43254 lab=_79202_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -32080 0 0 {name=X_79202_ }
C {devices/lab_pin.sym} 43940 -31970 0 0 {name=p43255 lab=_76395_/Y }
C {devices/lab_pin.sym} 43940 -31930 0 0 {name=p43256 lab=_76392_/Y }
C {devices/lab_pin.sym} 43940 -31890 0 0 {name=p43257 lab=_76394_/A }
C {devices/lab_pin.sym} 44100 -31930 0 1 {name=p43258 lab=_76415_/A }
C {sky130_stdcells/o21a_4.sym} 44020 -31930 0 0 {name=X_76414_ }
C {devices/lab_pin.sym} 43940 -31830 0 0 {name=p43259 lab=_42795_/X }
C {devices/lab_pin.sym} 43940 -31790 0 0 {name=p43260 lab=_42796_/X }
C {devices/lab_pin.sym} 43940 -31750 0 0 {name=p43261 lab=_41403_/X }
C {devices/lab_pin.sym} 43940 -31710 0 0 {name=p43262 lab=_87709_/Q }
C {devices/lab_pin.sym} 43940 -31670 0 0 {name=p43263 lab=_42805_/X }
C {devices/lab_pin.sym} 44100 -31750 0 1 {name=p43264 lab=_42806_/Y }
C {sky130_stdcells/o32ai_4.sym} 44020 -31750 0 0 {name=X_42806_ }
C {devices/lab_pin.sym} 43960 -31600 0 0 {name=p43265 lab=_49382_/A }
C {devices/lab_pin.sym} 43960 -31560 0 0 {name=p43266 lab=_51744_/B }
C {devices/lab_pin.sym} 44080 -31580 0 1 {name=p43267 lab=_49362_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -31580 0 0 {name=X_49362_ }
C {devices/lab_pin.sym} 43960 -31480 0 0 {name=p43268 lab=_61640_/A }
C {devices/lab_pin.sym} 43960 -31440 0 0 {name=p43269 lab=_61611_/B }
C {devices/lab_pin.sym} 43960 -31400 0 0 {name=p43270 lab=_61611_/C }
C {devices/lab_pin.sym} 43960 -31360 0 0 {name=p43271 lab=_61639_/X }
C {devices/lab_pin.sym} 44080 -31420 0 1 {name=p43272 lab=_61640_/Y }
C {sky130_stdcells/nand4_4.sym} 44020 -31420 0 0 {name=X_61640_ }
C {devices/lab_pin.sym} 43940 -31300 0 0 {name=p43273 lab=_41889_/Y }
C {devices/lab_pin.sym} 43940 -31260 0 0 {name=p43274 lab=_73529_/X }
C {devices/lab_pin.sym} 43940 -31220 0 0 {name=p43275 lab=_73344_/X }
C {devices/lab_pin.sym} 43940 -31180 0 0 {name=p43276 lab=_73625_/Y }
C {devices/lab_pin.sym} 44100 -31240 0 1 {name=p43277 lab=_73626_/X }
C {sky130_stdcells/a211o_4.sym} 44020 -31240 0 0 {name=X_73626_ }
C {devices/lab_pin.sym} 43980 -31090 0 0 {name=p43278 lab=_70832_/A }
C {devices/lab_pin.sym} 44060 -31090 0 1 {name=p43279 lab=_70849_/C }
C {sky130_stdcells/buf_2.sym} 44020 -31090 0 0 {name=X_70838_ }
C {devices/lab_pin.sym} 43960 -30980 0 0 {name=p43280 lab=_46547_/A }
C {devices/lab_pin.sym} 43960 -30940 0 0 {name=p43281 lab=_50870_/B }
C {devices/lab_pin.sym} 44080 -30960 0 1 {name=p43282 lab=_46574_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -30960 0 0 {name=X_46574_ }
C {devices/lab_pin.sym} 43960 -30840 0 0 {name=p43283 lab=_77394_/A }
C {devices/lab_pin.sym} 43960 -30800 0 0 {name=p43284 lab=_77394_/B }
C {devices/lab_pin.sym} 44080 -30820 0 1 {name=p43285 lab=_77417_/B }
C {sky130_stdcells/xor2_4.sym} 44020 -30820 0 0 {name=X_77394_ }
C {devices/lab_pin.sym} 43940 -30730 0 0 {name=p43286 lab=_43774_/X }
C {devices/lab_pin.sym} 43940 -30690 0 0 {name=p43287 lab=_43781_/X }
C {devices/lab_pin.sym} 43940 -30650 0 0 {name=p43288 lab=_41021_/X }
C {devices/lab_pin.sym} 43940 -30610 0 0 {name=p43289 lab=_87268_/Q }
C {devices/lab_pin.sym} 43940 -30570 0 0 {name=p43290 lab=_43776_/X }
C {devices/lab_pin.sym} 44100 -30650 0 1 {name=p43291 lab=_43787_/A }
C {sky130_stdcells/o32ai_4.sym} 44020 -30650 0 0 {name=X_43786_ }
C {devices/lab_pin.sym} 43980 -30490 0 0 {name=p43292 lab=_40686_/A }
C {devices/lab_pin.sym} 44060 -30490 0 1 {name=p43293 lab=_40999_/A }
C {sky130_stdcells/buf_2.sym} 44020 -30490 0 0 {name=X_40998_ }
C {devices/lab_pin.sym} 43960 -30380 0 0 {name=p43294 lab=_48275_/X }
C {devices/lab_pin.sym} 43960 -30340 0 0 {name=p43295 lab=_50356_/B }
C {devices/lab_pin.sym} 44080 -30360 0 1 {name=p43296 lab=_48313_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -30360 0 0 {name=X_48313_ }
C {devices/lab_pin.sym} 43980 -30230 0 0 {name=p43297 lab=clkbuf_9_491_0_CLK/A }
C {devices/lab_pin.sym} 44060 -30230 0 1 {name=p43298 lab=clkbuf_9_491_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 44020 -30230 0 0 {name=Xclkbuf_9_491_0_CLK }
C {devices/lab_pin.sym} 43960 -30120 0 0 {name=p43299 lab=_79133_/A }
C {devices/lab_pin.sym} 43960 -30080 0 0 {name=p43300 lab=_79133_/B }
C {devices/lab_pin.sym} 44080 -30100 0 1 {name=p43301 lab=_79133_/X }
C {sky130_stdcells/xor2_4.sym} 44020 -30100 0 0 {name=X_79133_ }
C {devices/lab_pin.sym} 43940 -29990 0 0 {name=p43302 lab=_56614_/B }
C {devices/lab_pin.sym} 43940 -29950 0 0 {name=p43303 lab=_45343_/X }
C {devices/lab_pin.sym} 43940 -29910 0 0 {name=p43304 lab=_45378_/X }
C {devices/lab_pin.sym} 44100 -29950 0 1 {name=p43305 lab=_45525_/X }
C {sky130_stdcells/o21a_4.sym} 44020 -29950 0 0 {name=X_45525_ }
C {devices/lab_pin.sym} 43960 -29820 0 0 {name=p43306 lab=_76345_/A }
C {devices/lab_pin.sym} 43960 -29780 0 0 {name=p43307 lab=_81564_/Q }
C {devices/lab_pin.sym} 44080 -29800 0 1 {name=p43308 lab=_76348_/B }
C {sky130_stdcells/nor2_4.sym} 44020 -29800 0 0 {name=X_76345_ }
C {devices/lab_pin.sym} 43940 -29710 0 0 {name=p43309 lab=_42721_/X }
C {devices/lab_pin.sym} 43940 -29670 0 0 {name=p43310 lab=_42723_/X }
C {devices/lab_pin.sym} 43940 -29630 0 0 {name=p43311 lab=_41220_/X }
C {devices/lab_pin.sym} 43940 -29590 0 0 {name=p43312 lab=_68868_/B }
C {devices/lab_pin.sym} 43940 -29550 0 0 {name=p43313 lab=_42732_/X }
C {devices/lab_pin.sym} 44100 -29630 0 1 {name=p43314 lab=_42737_/Y }
C {sky130_stdcells/o32ai_4.sym} 44020 -29630 0 0 {name=X_42737_ }
C {devices/lab_pin.sym} 43960 -29490 0 0 {name=p43315 lab=_50812_/A }
C {devices/lab_pin.sym} 43960 -29450 0 0 {name=p43316 lab=_49283_/B }
C {devices/lab_pin.sym} 43960 -29410 0 0 {name=p43317 lab=_49234_/X }
C {devices/lab_pin.sym} 44080 -29450 0 1 {name=p43318 lab=_49293_/X }
C {sky130_stdcells/and3_4.sym} 44020 -29450 0 0 {name=X_49293_ }
C {devices/lab_pin.sym} 43980 -29310 0 0 {name=p43319 lab=_61342_/X }
C {devices/lab_pin.sym} 44060 -29310 0 1 {name=p43320 lab=_61572_/D }
C {sky130_stdcells/buf_2.sym} 44020 -29310 0 0 {name=X_61571_ }
C {devices/lab_pin.sym} 43940 -29210 0 0 {name=p43321 lab=_88371_/Q }
C {devices/lab_pin.sym} 43940 -29170 0 0 {name=p43322 lab=_72769_/B }
C {devices/lab_pin.sym} 43940 -29130 0 0 {name=p43323 lab=_72866_/X }
C {devices/lab_pin.sym} 44100 -29170 0 1 {name=p43324 lab=_73557_/X }
C {sky130_stdcells/o21a_4.sym} 44020 -29170 0 0 {name=X_73557_ }
C {devices/lab_pin.sym} 43960 -29060 0 0 {name=p43325 lab=_70863_/A }
C {devices/lab_pin.sym} 43960 -29020 0 0 {name=p43326 lab=_70779_/B }
C {devices/lab_pin.sym} 43960 -28980 0 0 {name=p43327 lab=_70766_/C }
C {devices/lab_pin.sym} 43960 -28940 0 0 {name=p43328 lab=_70769_/D }
C {devices/lab_pin.sym} 44080 -29000 0 1 {name=p43329 lab=_70769_/Y }
C {sky130_stdcells/nand4_4.sym} 44020 -29000 0 0 {name=X_70769_ }
C {devices/lab_pin.sym} 43980 -28850 0 0 {name=p43330 lab=clkbuf_9_192_0_CLK/X }
C {devices/lab_pin.sym} 44060 -28850 0 1 {name=p43331 lab=_83216_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44020 -28850 0 0 {name=Xclkbuf_10_385_0_CLK }
C {devices/lab_pin.sym} 43980 -28730 0 0 {name=p43332 lab=_72381_/A }
C {devices/lab_pin.sym} 44060 -28730 0 1 {name=p43333 lab=_63310_/X }
C {sky130_stdcells/buf_2.sym} 44020 -28730 0 0 {name=X_63310_ }
C {devices/lab_pin.sym} 43960 -28620 0 0 {name=p43334 lab=_48244_/A }
C {devices/lab_pin.sym} 43960 -28580 0 0 {name=p43335 lab=_50293_/B }
C {devices/lab_pin.sym} 44080 -28600 0 1 {name=p43336 lab=_48244_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -28600 0 0 {name=X_48244_ }
C {devices/lab_pin.sym} 43980 -28470 0 0 {name=p43337 lab=_60522_/A }
C {devices/lab_pin.sym} 44060 -28470 0 1 {name=p43338 lab=_60523_/A }
C {sky130_stdcells/buf_2.sym} 44020 -28470 0 0 {name=X_60522_ }
C {devices/lab_pin.sym} 43980 -28350 0 0 {name=p43339 lab=_72508_/A }
C {devices/lab_pin.sym} 44060 -28350 0 1 {name=p43340 lab=_72516_/A }
C {sky130_stdcells/buf_2.sym} 44020 -28350 0 0 {name=X_72508_ }
C {devices/lab_pin.sym} 43960 -28240 0 0 {name=p43341 lab=_79064_/A }
C {devices/lab_pin.sym} 43960 -28200 0 0 {name=p43342 lab=_79064_/B }
C {devices/lab_pin.sym} 44080 -28220 0 1 {name=p43343 lab=_79065_/A }
C {sky130_stdcells/xor2_4.sym} 44020 -28220 0 0 {name=X_79064_ }
C {devices/lab_pin.sym} 43980 -28090 0 0 {name=p43344 lab=_45612_/A }
C {devices/lab_pin.sym} 44060 -28090 0 1 {name=p43345 lab=_45456_/X }
C {sky130_stdcells/buf_2.sym} 44020 -28090 0 0 {name=X_45456_ }
C {devices/lab_pin.sym} 43940 -27990 0 0 {name=p43346 lab=_64282_/Y }
C {devices/lab_pin.sym} 43940 -27950 0 0 {name=p43347 lab=_64289_/X }
C {devices/lab_pin.sym} 43940 -27910 0 0 {name=p43348 lab=_64269_/X }
C {devices/lab_pin.sym} 44100 -27950 0 1 {name=p43349 lab=_64290_/X }
C {sky130_stdcells/o21a_4.sym} 44020 -27950 0 0 {name=X_64290_ }
C {devices/lab_pin.sym} 43960 -27820 0 0 {name=p43350 lab=_81643_/Q }
C {devices/lab_pin.sym} 43960 -27780 0 0 {name=p43351 lab=_76276_/B }
C {devices/lab_pin.sym} 44080 -27800 0 1 {name=p43352 lab=_76276_/X }
C {sky130_stdcells/or2_4.sym} 44020 -27800 0 0 {name=X_76276_ }
C {devices/lab_pin.sym} 43980 -27670 0 0 {name=p43353 lab=_42667_/Y }
C {devices/lab_pin.sym} 44060 -27670 0 1 {name=p43354 lab=_42668_/Y }
C {sky130_stdcells/inv_2.sym} 44020 -27670 0 0 {name=X_42668_ }
C {devices/lab_pin.sym} 43940 -27580 0 0 {name=p43355 lab=_43199_/Y }
C {devices/lab_pin.sym} 43940 -27540 0 0 {name=p43356 lab=_72895_/X }
C {devices/lab_pin.sym} 43940 -27500 0 0 {name=p43357 lab=_73486_/X }
C {devices/lab_pin.sym} 43940 -27460 0 0 {name=p43358 lab=_73487_/Y }
C {devices/lab_pin.sym} 44100 -27520 0 1 {name=p43359 lab=_73488_/X }
C {sky130_stdcells/a211o_4.sym} 44020 -27520 0 0 {name=X_73488_ }
C {devices/lab_pin.sym} 43940 -27390 0 0 {name=p43360 lab=_82079_/Q }
C {devices/lab_pin.sym} 43940 -27350 0 0 {name=p43361 lab=_78012_/Y }
C {devices/lab_pin.sym} 43940 -27310 0 0 {name=p43362 lab=_78014_/X }
C {devices/lab_pin.sym} 44100 -27350 0 1 {name=p43363 lab=_78015_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -27350 0 0 {name=X_78015_ }
C {devices/lab_pin.sym} 43940 -27250 0 0 {name=p43364 lab=_44404_/X }
C {devices/lab_pin.sym} 43940 -27210 0 0 {name=p43365 lab=_44405_/X }
C {devices/lab_pin.sym} 43940 -27170 0 0 {name=p43366 lab=_41515_/X }
C {devices/lab_pin.sym} 43940 -27130 0 0 {name=p43367 lab=_87124_/Q }
C {devices/lab_pin.sym} 43940 -27090 0 0 {name=p43368 lab=_44406_/X }
C {devices/lab_pin.sym} 44100 -27170 0 1 {name=p43369 lab=_44407_/Y }
C {sky130_stdcells/o32ai_4.sym} 44020 -27170 0 0 {name=X_44407_ }
C {devices/lab_pin.sym} 43960 -27040 0 0 {name=p43370 lab=_63216_/X }
C {devices/lab_pin.sym} 43960 -27000 0 0 {name=p43371 lab=_63241_/B }
C {devices/lab_pin.sym} 43960 -26960 0 0 {name=p43372 lab=_63241_/C }
C {devices/lab_pin.sym} 43960 -26920 0 0 {name=p43373 lab=_63240_/X }
C {devices/lab_pin.sym} 44080 -26980 0 1 {name=p43374 lab=_63241_/X }
C {sky130_stdcells/and4_4.sym} 44020 -26980 0 0 {name=X_63241_ }
C {devices/lab_pin.sym} 43980 -26830 0 0 {name=p43375 lab=_75226_/Y }
C {devices/lab_pin.sym} 44060 -26830 0 1 {name=p43376 lab=_75227_/Y }
C {sky130_stdcells/inv_2.sym} 44020 -26830 0 0 {name=X_75227_ }
C {devices/lab_pin.sym} 43960 -26720 0 0 {name=p43377 lab=_81155_/Q }
C {devices/lab_pin.sym} 43960 -26680 0 0 {name=p43378 lab=_41563_/B }
C {devices/lab_pin.sym} 44080 -26700 0 1 {name=p43379 lab=_41619_/X }
C {sky130_stdcells/or2_4.sym} 44020 -26700 0 0 {name=X_41619_ }
C {devices/lab_pin.sym} 43980 -26570 0 0 {name=p43380 lab=_60452_/X }
C {devices/lab_pin.sym} 44060 -26570 0 1 {name=p43381 lab=_60454_/A }
C {sky130_stdcells/buf_2.sym} 44020 -26570 0 0 {name=X_60453_ }
C {devices/lab_pin.sym} 43940 -26470 0 0 {name=p43382 lab=_64758_/X }
C {devices/lab_pin.sym} 43940 -26430 0 0 {name=p43383 lab=_85318_/Q }
C {devices/lab_pin.sym} 43940 -26390 0 0 {name=p43384 lab=_72386_/X }
C {devices/lab_pin.sym} 44100 -26430 0 1 {name=p43385 lab=_72439_/X }
C {sky130_stdcells/o21a_4.sym} 44020 -26430 0 0 {name=X_72439_ }
C {devices/lab_pin.sym} 43980 -26290 0 0 {name=p43386 lab=_48226_/A }
C {devices/lab_pin.sym} 44060 -26290 0 1 {name=p43387 lab=_48175_/X }
C {sky130_stdcells/buf_2.sym} 44020 -26290 0 0 {name=X_48175_ }
C {devices/lab_pin.sym} 43980 -26170 0 0 {name=p43388 lab=_45387_/A }
C {devices/lab_pin.sym} 44060 -26170 0 1 {name=p43389 lab=_45596_/A }
C {sky130_stdcells/buf_2.sym} 44020 -26170 0 0 {name=X_45387_ }
C {devices/lab_pin.sym} 43980 -26050 0 0 {name=p43390 lab=_42599_/A }
C {devices/lab_pin.sym} 44060 -26050 0 1 {name=p43391 lab=_42599_/Y }
C {sky130_stdcells/inv_2.sym} 44020 -26050 0 0 {name=X_42599_ }
C {devices/lab_pin.sym} 43940 -25950 0 0 {name=p43392 lab=_59270_/A }
C {devices/lab_pin.sym} 43940 -25910 0 0 {name=p43393 lab=_47096_/X }
C {devices/lab_pin.sym} 43940 -25870 0 0 {name=p43394 lab=_47125_/Y }
C {devices/lab_pin.sym} 44100 -25910 0 1 {name=p43395 lab=_47126_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -25910 0 0 {name=X_47126_ }
C {devices/lab_pin.sym} 43940 -25810 0 0 {name=p43396 lab=_44330_/X }
C {devices/lab_pin.sym} 43940 -25770 0 0 {name=p43397 lab=_44331_/X }
C {devices/lab_pin.sym} 43940 -25730 0 0 {name=p43398 lab=_41676_/X }
C {devices/lab_pin.sym} 43940 -25690 0 0 {name=p43399 lab=_87159_/Q }
C {devices/lab_pin.sym} 43940 -25650 0 0 {name=p43400 lab=_44332_/X }
C {devices/lab_pin.sym} 44100 -25730 0 1 {name=p43401 lab=_44339_/A }
C {sky130_stdcells/o32ai_4.sym} 44020 -25730 0 0 {name=X_44338_ }
C {devices/lab_pin.sym} 43980 -25570 0 0 {name=p43402 lab=_63231_/A }
C {devices/lab_pin.sym} 44060 -25570 0 1 {name=p43403 lab=_63172_/X }
C {sky130_stdcells/buf_2.sym} 44020 -25570 0 0 {name=X_63172_ }
C {devices/lab_pin.sym} 43980 -25450 0 0 {name=p43404 lab=_81063_/Q }
C {devices/lab_pin.sym} 44060 -25450 0 1 {name=p43405 lab=_75158_/Y }
C {sky130_stdcells/inv_2.sym} 44020 -25450 0 0 {name=X_75158_ }
C {devices/lab_pin.sym} 43960 -25340 0 0 {name=p43406 lab=_60392_/A }
C {devices/lab_pin.sym} 43960 -25300 0 0 {name=p43407 lab=_60392_/C }
C {devices/lab_pin.sym} 44080 -25320 0 1 {name=p43408 lab=_60404_/C }
C {sky130_stdcells/and2_4.sym} 44020 -25320 0 0 {name=X_60384_ }
C {devices/lab_pin.sym} 43940 -25210 0 0 {name=p43409 lab=_62118_/Y }
C {devices/lab_pin.sym} 43940 -25170 0 0 {name=p43410 lab=_62101_/X }
C {devices/lab_pin.sym} 43940 -25130 0 0 {name=p43411 lab=_62122_/Y }
C {devices/lab_pin.sym} 44100 -25170 0 1 {name=p43412 lab=_84432_/D }
C {sky130_stdcells/a21oi_4.sym} 44020 -25170 0 0 {name=X_62123_ }
C {devices/lab_pin.sym} 43960 -25040 0 0 {name=p43413 lab=_74152_/A }
C {devices/lab_pin.sym} 43960 -25000 0 0 {name=p43414 lab=_66238_/B }
C {devices/lab_pin.sym} 44080 -25020 0 1 {name=p43415 lab=_74109_/X }
C {sky130_stdcells/and2_4.sym} 44020 -25020 0 0 {name=X_74109_ }
C {devices/lab_pin.sym} 43980 -24890 0 0 {name=p43416 lab=_82387_/Q }
C {devices/lab_pin.sym} 44060 -24890 0 1 {name=p43417 lab=_54522_/D }
C {sky130_stdcells/inv_2.sym} 44020 -24890 0 0 {name=X_47057_ }
C {devices/lab_pin.sym} 43980 -24770 0 0 {name=p43418 lab=_44187_/A }
C {devices/lab_pin.sym} 44060 -24770 0 1 {name=p43419 lab=_72908_/A }
C {sky130_stdcells/buf_2.sym} 44020 -24770 0 0 {name=X_44269_ }
C {devices/lab_pin.sym} 43940 -24680 0 0 {name=p43420 lab=_86948_/Q }
C {devices/lab_pin.sym} 43940 -24640 0 0 {name=p43421 lab=_67906_/X }
C {devices/lab_pin.sym} 43940 -24600 0 0 {name=p43422 lab=_67908_/X }
C {devices/lab_pin.sym} 43940 -24560 0 0 {name=p43423 lab=_67979_/X }
C {devices/lab_pin.sym} 44100 -24620 0 1 {name=p43424 lab=_67981_/B }
C {sky130_stdcells/a211o_4.sym} 44020 -24620 0 0 {name=X_67980_ }
C {devices/lab_pin.sym} 43960 -24480 0 0 {name=p43425 lab=_79964_/Y }
C {devices/lab_pin.sym} 43960 -24440 0 0 {name=p43426 lab=_79965_/Y }
C {devices/lab_pin.sym} 44080 -24460 0 1 {name=p43427 lab=_79966_/X }
C {sky130_stdcells/xor2_4.sym} 44020 -24460 0 0 {name=X_79966_ }
C {devices/lab_pin.sym} 43940 -24350 0 0 {name=p43428 lab=_75087_/Y }
C {devices/lab_pin.sym} 43940 -24310 0 0 {name=p43429 lab=_81058_/Q }
C {devices/lab_pin.sym} 43940 -24270 0 0 {name=p43430 lab=_75088_/Y }
C {devices/lab_pin.sym} 44100 -24310 0 1 {name=p43431 lab=_75091_/B }
C {sky130_stdcells/a21bo_4.sym} 44020 -24310 0 0 {name=X_75089_ }
C {devices/lab_pin.sym} 43980 -24170 0 0 {name=p43432 lab=_45975_/X }
C {devices/lab_pin.sym} 44060 -24170 0 1 {name=p43433 lab=_46008_/X }
C {sky130_stdcells/buf_2.sym} 44020 -24170 0 0 {name=X_46008_ }
C {devices/lab_pin.sym} 43940 -24070 0 0 {name=p43434 lab=_66928_/X }
C {devices/lab_pin.sym} 43940 -24030 0 0 {name=p43435 lab=_66930_/X }
C {devices/lab_pin.sym} 43940 -23990 0 0 {name=p43436 lab=_66905_/X }
C {devices/lab_pin.sym} 44100 -24030 0 1 {name=p43437 lab=_66931_/X }
C {sky130_stdcells/a21o_4.sym} 44020 -24030 0 0 {name=X_66931_ }
C {devices/lab_pin.sym} 43980 -23890 0 0 {name=p43438 lab=_59588_/Y }
C {devices/lab_pin.sym} 44060 -23890 0 1 {name=p43439 lab=_62055_/A }
C {sky130_stdcells/buf_2.sym} 44020 -23890 0 0 {name=X_62054_ }
C {devices/lab_pin.sym} 43940 -23790 0 0 {name=p43440 lab=_82637_/Q }
C {devices/lab_pin.sym} 43940 -23750 0 0 {name=p43441 lab=_82509_/D }
C {devices/lab_pin.sym} 43940 -23710 0 0 {name=p43442 lab=_78916_/X }
C {devices/lab_pin.sym} 44100 -23750 0 1 {name=p43443 lab=_78918_/B }
C {sky130_stdcells/o21ai_4.sym} 44020 -23750 0 0 {name=X_78917_ }
C {devices/lab_pin.sym} 43960 -23620 0 0 {name=p43444 lab=_79896_/Y }
C {devices/lab_pin.sym} 43960 -23580 0 0 {name=p43445 lab=_60152_/A }
C {devices/lab_pin.sym} 44080 -23600 0 1 {name=p43446 lab=_79899_/A }
C {sky130_stdcells/nand2_4.sym} 44020 -23600 0 0 {name=X_79897_ }
C {devices/lab_pin.sym} 43940 -23490 0 0 {name=p43447 lab=_60854_/Y }
C {devices/lab_pin.sym} 43940 -23450 0 0 {name=p43448 lab=_60915_/A }
C {devices/lab_pin.sym} 43940 -23410 0 0 {name=p43449 lab=_60928_/X }
C {devices/lab_pin.sym} 44100 -23450 0 1 {name=p43450 lab=_63734_/A }
C {sky130_stdcells/a21boi_4.sym} 44020 -23450 0 0 {name=X_61005_ }
C {devices/lab_pin.sym} 43980 -23310 0 0 {name=p43451 lab=clkbuf_9_161_0_CLK/X }
C {devices/lab_pin.sym} 44060 -23310 0 1 {name=p43452 lab=_85725_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44020 -23310 0 0 {name=Xclkbuf_10_323_0_CLK }
C {devices/lab_pin.sym} 43940 -23210 0 0 {name=p43453 lab=_69647_/X }
C {devices/lab_pin.sym} 43940 -23170 0 0 {name=p43454 lab=_69649_/X }
C {devices/lab_pin.sym} 43940 -23130 0 0 {name=p43455 lab=_69385_/X }
C {devices/lab_pin.sym} 44100 -23170 0 1 {name=p43456 lab=_69650_/X }
C {sky130_stdcells/a21o_4.sym} 44020 -23170 0 0 {name=X_69650_ }
C {devices/lab_pin.sym} 43940 -23060 0 0 {name=p43457 lab=_87879_/Q }
C {devices/lab_pin.sym} 43940 -23020 0 0 {name=p43458 lab=_66816_/X }
C {devices/lab_pin.sym} 43940 -22980 0 0 {name=p43459 lab=_66794_/X }
C {devices/lab_pin.sym} 43940 -22940 0 0 {name=p43460 lab=_66861_/X }
C {devices/lab_pin.sym} 44100 -23000 0 1 {name=p43461 lab=_66862_/X }
C {sky130_stdcells/a211o_4.sym} 44020 -23000 0 0 {name=X_66862_ }
C {devices/lab_pin.sym} 43960 -22860 0 0 {name=p43462 lab=_78839_/X }
C {devices/lab_pin.sym} 43960 -22820 0 0 {name=p43463 lab=_78840_/A }
C {devices/lab_pin.sym} 44080 -22840 0 1 {name=p43464 lab=_78856_/A }
C {sky130_stdcells/nand2_4.sym} 44020 -22840 0 0 {name=X_78848_ }
C {devices/lab_pin.sym} 43980 -22710 0 0 {name=p43465 lab=clkbuf_9_476_0_CLK/X }
C {devices/lab_pin.sym} 44060 -22710 0 1 {name=p43466 lab=_88081_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44020 -22710 0 0 {name=Xclkbuf_10_953_0_CLK }
C {devices/lab_pin.sym} 43980 -22590 0 0 {name=p43467 lab=_68450_/A }
C {devices/lab_pin.sym} 44060 -22590 0 1 {name=p43468 lab=_68601_/X }
C {sky130_stdcells/buf_2.sym} 44020 -22590 0 0 {name=X_68601_ }
C {devices/lab_pin.sym} 43940 -22500 0 0 {name=p43469 lab=_65811_/X }
C {devices/lab_pin.sym} 43940 -22460 0 0 {name=p43470 lab=_83056_/Q }
C {devices/lab_pin.sym} 43940 -22420 0 0 {name=p43471 lab=_65768_/X }
C {devices/lab_pin.sym} 43940 -22380 0 0 {name=p43472 lab=_65812_/X }
C {devices/lab_pin.sym} 44100 -22440 0 1 {name=p43473 lab=_65813_/X }
C {sky130_stdcells/a211o_4.sym} 44020 -22440 0 0 {name=X_65813_ }
C {devices/lab_pin.sym} 43940 -22320 0 0 {name=p43474 lab=_43115_/A }
C {devices/lab_pin.sym} 43940 -22280 0 0 {name=p43475 lab=_69506_/X }
C {devices/lab_pin.sym} 43940 -22240 0 0 {name=p43476 lab=_66349_/X }
C {devices/lab_pin.sym} 43940 -22200 0 0 {name=p43477 lab=_69580_/X }
C {devices/lab_pin.sym} 44100 -22260 0 1 {name=p43478 lab=_69581_/X }
C {sky130_stdcells/a211o_4.sym} 44020 -22260 0 0 {name=X_69581_ }
C {devices/lab_pin.sym} 43980 -22110 0 0 {name=p43479 lab=_47959_/A }
C {devices/lab_pin.sym} 44060 -22110 0 1 {name=p43480 lab=_73864_/A }
C {sky130_stdcells/inv_2.sym} 44020 -22110 0 0 {name=X_47959_ }
C {devices/lab_pin.sym} 43980 -21990 0 0 {name=p43481 lab=_78778_/X }
C {devices/lab_pin.sym} 44060 -21990 0 1 {name=p43482 lab=_78779_/Y }
C {sky130_stdcells/inv_2.sym} 44020 -21990 0 0 {name=X_78779_ }
C {devices/lab_pin.sym} 43980 -21870 0 0 {name=p43483 lab=_66910_/A }
C {devices/lab_pin.sym} 44060 -21870 0 1 {name=p43484 lab=_66793_/X }
C {sky130_stdcells/buf_2.sym} 44020 -21870 0 0 {name=X_66793_ }
C {devices/lab_pin.sym} 43980 -21750 0 0 {name=p43485 lab=clkbuf_9_444_0_CLK/A }
C {devices/lab_pin.sym} 44060 -21750 0 1 {name=p43486 lab=clkbuf_9_444_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 44020 -21750 0 0 {name=Xclkbuf_9_444_0_CLK }
C {devices/lab_pin.sym} 43930 -21630 0 0 {name=p43487 lab=_80821_/CLK }
C {devices/lab_pin.sym} 43930 -21610 0 0 {name=p43488 lab=_83954_/Q }
C {devices/lab_pin.sym} 44110 -21630 0 1 {name=p43489 lab=_75786_/B }
C {sky130_stdcells/dfxtp_4.sym} 44020 -21620 0 0 {name=X_80810_ }
C {devices/lab_pin.sym} 43940 -21510 0 0 {name=p43490 lab=_68529_/X }
C {devices/lab_pin.sym} 43940 -21470 0 0 {name=p43491 lab=_68531_/X }
C {devices/lab_pin.sym} 43940 -21430 0 0 {name=p43492 lab=_68429_/X }
C {devices/lab_pin.sym} 44100 -21470 0 1 {name=p43493 lab=_68532_/X }
C {sky130_stdcells/a21o_4.sym} 44020 -21470 0 0 {name=X_68532_ }
C {devices/lab_pin.sym} 43980 -21330 0 0 {name=p43494 lab=_84181_/Q }
C {devices/lab_pin.sym} 44060 -21330 0 1 {name=p43495 lab=_65745_/C }
C {sky130_stdcells/inv_2.sym} 44020 -21330 0 0 {name=X_65744_ }
C {devices/lab_pin.sym} 43940 -21230 0 0 {name=p43496 lab=_50968_/Y }
C {devices/lab_pin.sym} 43940 -21190 0 0 {name=p43497 lab=_50957_/X }
C {devices/lab_pin.sym} 43940 -21150 0 0 {name=p43498 lab=_50969_/X }
C {devices/lab_pin.sym} 44100 -21190 0 1 {name=p43499 lab=_50970_/Y }
C {sky130_stdcells/a21oi_4.sym} 44020 -21190 0 0 {name=X_50970_ }
C {devices/lab_pin.sym} 43940 -21090 0 0 {name=p43500 lab=_58198_/A }
C {devices/lab_pin.sym} 43940 -21050 0 0 {name=p43501 lab=_62808_/X }
C {devices/lab_pin.sym} 43940 -21010 0 0 {name=p43502 lab=_62827_/X }
C {devices/lab_pin.sym} 43940 -20970 0 0 {name=p43503 lab=_62818_/X }
C {devices/lab_pin.sym} 43940 -20940 0 0 {name=p43504 lab=_62955_/X }
C {devices/lab_pin.sym} 44100 -21010 0 1 {name=p43505 lab=_62956_/Y }
C {sky130_stdcells/a41oi_4.sym} 44020 -21010 0 0 {name=X_62956_ }
C {devices/lab_pin.sym} 43930 -20850 0 0 {name=p43506 lab=_83133_/CLK }
C {devices/lab_pin.sym} 43930 -20830 0 0 {name=p43507 lab=_81790_/D }
C {devices/lab_pin.sym} 44110 -20850 0 1 {name=p43508 lab=_48914_/B }
C {sky130_stdcells/dfxtp_4.sym} 44020 -20840 0 0 {name=X_81790_ }
C {devices/lab_pin.sym} 43980 -20710 0 0 {name=p43509 lab=clkbuf_9_169_0_CLK/X }
C {devices/lab_pin.sym} 44060 -20710 0 1 {name=p43510 lab=_82381_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44020 -20710 0 0 {name=Xclkbuf_10_338_0_CLK }
C {devices/lab_pin.sym} 43980 -20590 0 0 {name=p43511 lab=_49548_/A }
C {devices/lab_pin.sym} 44060 -20590 0 1 {name=p43512 lab=_49629_/X }
C {sky130_stdcells/buf_2.sym} 44020 -20590 0 0 {name=X_49629_ }
C {devices/lab_pin.sym} 43960 -20500 0 0 {name=p43513 lab=_61461_/X }
C {devices/lab_pin.sym} 43960 -20460 0 0 {name=p43514 lab=_61874_/B }
C {devices/lab_pin.sym} 43960 -20420 0 0 {name=p43515 lab=_61907_/C }
C {devices/lab_pin.sym} 43960 -20380 0 0 {name=p43516 lab=_61874_/D }
C {devices/lab_pin.sym} 44080 -20440 0 1 {name=p43517 lab=_61907_/Y }
C {sky130_stdcells/nand4_4.sym} 44020 -20440 0 0 {name=X_61907_ }
C {devices/lab_pin.sym} 43930 -20290 0 0 {name=p43518 lab=_81994_/CLK }
C {devices/lab_pin.sym} 43930 -20270 0 0 {name=p43519 lab=_80741_/D }
C {devices/lab_pin.sym} 44110 -20290 0 1 {name=p43520 lab=_81149_/D }
C {sky130_stdcells/dfxtp_4.sym} 44020 -20280 0 0 {name=X_80741_ }
C {devices/lab_pin.sym} 43980 -20150 0 0 {name=p43521 lab=_69645_/A }
C {devices/lab_pin.sym} 44060 -20150 0 1 {name=p43522 lab=_68463_/X }
C {sky130_stdcells/buf_2.sym} 44020 -20150 0 0 {name=X_68463_ }
C {devices/lab_pin.sym} 43940 -20060 0 0 {name=p43523 lab=_65596_/X }
C {devices/lab_pin.sym} 43940 -20020 0 0 {name=p43524 lab=_83065_/Q }
C {devices/lab_pin.sym} 43940 -19980 0 0 {name=p43525 lab=_65540_/X }
C {devices/lab_pin.sym} 43940 -19940 0 0 {name=p43526 lab=_65674_/X }
C {devices/lab_pin.sym} 44100 -20000 0 1 {name=p43527 lab=_65675_/X }
C {sky130_stdcells/a211o_4.sym} 44020 -20000 0 0 {name=X_65675_ }
C {devices/lab_pin.sym} 43980 -19850 0 0 {name=p43528 lab=_60362_/A }
C {devices/lab_pin.sym} 44060 -19850 0 1 {name=p43529 lab=_62965_/A }
C {sky130_stdcells/buf_2.sym} 44020 -19850 0 0 {name=X_62887_ }
C {devices/lab_pin.sym} 43980 -19730 0 0 {name=p43530 lab=clkbuf_9_484_0_CLK/X }
C {devices/lab_pin.sym} 44060 -19730 0 1 {name=p43531 lab=_86541_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44020 -19730 0 0 {name=Xclkbuf_10_968_0_CLK }
C {devices/lab_pin.sym} 43980 -19610 0 0 {name=p43532 lab=_67055_/X }
C {devices/lab_pin.sym} 44060 -19610 0 1 {name=p43533 lab=_67414_/X }
C {sky130_stdcells/buf_2.sym} 44020 -19610 0 0 {name=X_67414_ }
C {devices/lab_pin.sym} 43940 -19510 0 0 {name=p43534 lab=_52638_/Y }
C {devices/lab_pin.sym} 43940 -19470 0 0 {name=p43535 lab=_52619_/X }
C {devices/lab_pin.sym} 43940 -19430 0 0 {name=p43536 lab=_52639_/X }
C {devices/lab_pin.sym} 44100 -19470 0 1 {name=p43537 lab=_52640_/Y }
C {sky130_stdcells/a21oi_4.sym} 44020 -19470 0 0 {name=X_52640_ }
C {devices/lab_pin.sym} 43980 -19330 0 0 {name=p43538 lab=_64803_/A }
C {devices/lab_pin.sym} 44060 -19330 0 1 {name=p43539 lab=_64680_/A }
C {sky130_stdcells/buf_2.sym} 44020 -19330 0 0 {name=X_64626_ }
C {devices/lab_pin.sym} 43930 -19210 0 0 {name=p43540 lab=_83495_/CLK }
C {devices/lab_pin.sym} 43930 -19190 0 0 {name=p43541 lab=_71549_/X }
C {devices/lab_pin.sym} 44110 -19210 0 1 {name=p43542 lab=_83460_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -19200 0 0 {name=X_83460_ }
C {devices/lab_pin.sym} 43980 -19070 0 0 {name=p43543 lab=_61755_/X }
C {devices/lab_pin.sym} 44060 -19070 0 1 {name=p43544 lab=_61838_/X }
C {sky130_stdcells/buf_2.sym} 44020 -19070 0 0 {name=X_61838_ }
C {devices/lab_pin.sym} 43930 -18950 0 0 {name=p43545 lab=_80672_/CLK }
C {devices/lab_pin.sym} 43930 -18930 0 0 {name=p43546 lab=_80672_/D }
C {devices/lab_pin.sym} 44110 -18950 0 1 {name=p43547 lab=_80672_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -18940 0 0 {name=X_80672_ }
C {devices/lab_pin.sym} 43980 -18810 0 0 {name=p43548 lab=_68394_/A }
C {devices/lab_pin.sym} 44060 -18810 0 1 {name=p43549 lab=_68394_/X }
C {sky130_stdcells/buf_2.sym} 44020 -18810 0 0 {name=X_68394_ }
C {devices/lab_pin.sym} 43980 -18690 0 0 {name=p43550 lab=clkbuf_9_459_0_CLK/A }
C {devices/lab_pin.sym} 44060 -18690 0 1 {name=p43551 lab=clkbuf_9_459_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 44020 -18690 0 0 {name=Xclkbuf_9_459_0_CLK }
C {devices/lab_pin.sym} 43930 -18570 0 0 {name=p43552 lab=_82443_/CLK }
C {devices/lab_pin.sym} 43930 -18550 0 0 {name=p43553 lab=_82411_/D }
C {devices/lab_pin.sym} 44110 -18570 0 1 {name=p43554 lab=_78432_/A }
C {sky130_stdcells/dfxtp_4.sym} 44020 -18560 0 0 {name=X_82411_ }
C {devices/lab_pin.sym} 43960 -18440 0 0 {name=p43555 lab=_67320_/A }
C {devices/lab_pin.sym} 43960 -18400 0 0 {name=p43556 lab=_86943_/Q }
C {devices/lab_pin.sym} 44080 -18420 0 1 {name=p43557 lab=_67345_/X }
C {sky130_stdcells/and2_4.sym} 44020 -18420 0 0 {name=X_67345_ }
C {devices/lab_pin.sym} 43960 -18300 0 0 {name=p43558 lab=_52518_/A }
C {devices/lab_pin.sym} 43960 -18260 0 0 {name=p43559 lab=_52571_/B }
C {devices/lab_pin.sym} 44080 -18280 0 1 {name=p43560 lab=_52571_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -18280 0 0 {name=X_52571_ }
C {devices/lab_pin.sym} 43940 -18170 0 0 {name=p43561 lab=_58993_/Y }
C {devices/lab_pin.sym} 43940 -18130 0 0 {name=p43562 lab=_61085_/X }
C {devices/lab_pin.sym} 43940 -18090 0 0 {name=p43563 lab=_64556_/Y }
C {devices/lab_pin.sym} 44100 -18130 0 1 {name=p43564 lab=_64557_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -18130 0 0 {name=X_64557_ }
C {devices/lab_pin.sym} 43930 -17990 0 0 {name=p43565 lab=_85407_/CLK }
C {devices/lab_pin.sym} 43930 -17970 0 0 {name=p43566 lab=_83391_/D }
C {devices/lab_pin.sym} 44110 -17990 0 1 {name=p43567 lab=_47242_/A }
C {sky130_stdcells/dfxtp_4.sym} 44020 -17980 0 0 {name=X_83391_ }
C {devices/lab_pin.sym} 43940 -17870 0 0 {name=p43568 lab=_61767_/Y }
C {devices/lab_pin.sym} 43940 -17830 0 0 {name=p43569 lab=_61699_/X }
C {devices/lab_pin.sym} 43940 -17790 0 0 {name=p43570 lab=_61768_/Y }
C {devices/lab_pin.sym} 44100 -17830 0 1 {name=p43571 lab=_61769_/Y }
C {sky130_stdcells/a21oi_4.sym} 44020 -17830 0 0 {name=X_61769_ }
C {sky130_stdcells/decap_3.sym} 44020 -17660 0 0 {name=XPHY_508 }
C {devices/lab_pin.sym} 43940 -17530 0 0 {name=p43572 lab=_85465_/Q }
C {devices/lab_pin.sym} 43940 -17490 0 0 {name=p43573 lab=_54294_/X }
C {devices/lab_pin.sym} 43940 -17450 0 0 {name=p43574 lab=_54309_/Y }
C {devices/lab_pin.sym} 44100 -17490 0 1 {name=p43575 lab=_54310_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -17490 0 0 {name=X_54310_ }
C {sky130_stdcells/decap_3.sym} 44020 -17320 0 0 {name=XPHY_519 }
C {devices/lab_pin.sym} 43930 -17170 0 0 {name=p43576 lab=_85067_/CLK }
C {devices/lab_pin.sym} 43930 -17150 0 0 {name=p43577 lab=_56827_/Y }
C {devices/lab_pin.sym} 44110 -17170 0 1 {name=p43578 lab=_85130_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -17160 0 0 {name=X_85130_ }
C {devices/lab_pin.sym} 43960 -17060 0 0 {name=p43579 lab=_51521_/X }
C {devices/lab_pin.sym} 43960 -17020 0 0 {name=p43580 lab=_51527_/B }
C {devices/lab_pin.sym} 43960 -16980 0 0 {name=p43581 lab=_51522_/C }
C {devices/lab_pin.sym} 43960 -16940 0 0 {name=p43582 lab=_53048_/D }
C {devices/lab_pin.sym} 44080 -17000 0 1 {name=p43583 lab=_51522_/X }
C {sky130_stdcells/and4_4.sym} 44020 -17000 0 0 {name=X_51522_ }
C {devices/lab_pin.sym} 43940 -16870 0 0 {name=p43584 lab=_63506_/Y }
C {devices/lab_pin.sym} 43940 -16830 0 0 {name=p43585 lab=_63455_/X }
C {devices/lab_pin.sym} 43940 -16790 0 0 {name=p43586 lab=_63507_/Y }
C {devices/lab_pin.sym} 44100 -16830 0 1 {name=p43587 lab=_84318_/D }
C {sky130_stdcells/a21oi_4.sym} 44020 -16830 0 0 {name=X_63508_ }
C {devices/lab_pin.sym} 43930 -16690 0 0 {name=p43588 lab=_82369_/CLK }
C {devices/lab_pin.sym} 43930 -16670 0 0 {name=p43589 lab=_77081_/X }
C {devices/lab_pin.sym} 44110 -16690 0 1 {name=p43590 lab=_82342_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -16680 0 0 {name=X_82342_ }
C {devices/lab_pin.sym} 43980 -16550 0 0 {name=p43591 lab=_55290_/A }
C {devices/lab_pin.sym} 44060 -16550 0 1 {name=p43592 lab=_55290_/Y }
C {sky130_stdcells/inv_2.sym} 44020 -16550 0 0 {name=X_55290_ }
C {devices/lab_pin.sym} 43940 -16460 0 0 {name=p43593 lab=_87414_/Q }
C {devices/lab_pin.sym} 43940 -16420 0 0 {name=p43594 lab=_67274_/X }
C {devices/lab_pin.sym} 43940 -16380 0 0 {name=p43595 lab=_67226_/X }
C {devices/lab_pin.sym} 43940 -16340 0 0 {name=p43596 lab=_67275_/X }
C {devices/lab_pin.sym} 44100 -16400 0 1 {name=p43597 lab=_67276_/X }
C {sky130_stdcells/a211o_4.sym} 44020 -16400 0 0 {name=X_67276_ }
C {devices/lab_pin.sym} 43940 -16270 0 0 {name=p43598 lab=_58970_/A }
C {devices/lab_pin.sym} 43940 -16230 0 0 {name=p43599 lab=_61085_/X }
C {devices/lab_pin.sym} 43940 -16190 0 0 {name=p43600 lab=_64487_/Y }
C {devices/lab_pin.sym} 44100 -16230 0 1 {name=p43601 lab=_64488_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -16230 0 0 {name=X_64488_ }
C {devices/lab_pin.sym} 43960 -16100 0 0 {name=p43602 lab=_69059_/A }
C {devices/lab_pin.sym} 43960 -16060 0 0 {name=p43603 lab=_88249_/Q }
C {devices/lab_pin.sym} 44080 -16080 0 1 {name=p43604 lab=_69015_/X }
C {sky130_stdcells/and2_4.sym} 44020 -16080 0 0 {name=X_69015_ }
C {devices/lab_pin.sym} 43960 -15980 0 0 {name=p43605 lab=_54255_/A }
C {devices/lab_pin.sym} 43960 -15940 0 0 {name=p43606 lab=_54237_/B }
C {devices/lab_pin.sym} 43960 -15900 0 0 {name=p43607 lab=_54237_/C }
C {devices/lab_pin.sym} 43960 -15860 0 0 {name=p43608 lab=_53074_/D }
C {devices/lab_pin.sym} 44080 -15920 0 1 {name=p43609 lab=_54241_/X }
C {sky130_stdcells/and4_4.sym} 44020 -15920 0 0 {name=X_54241_ }
C {devices/lab_pin.sym} 43940 -15800 0 0 {name=p43610 lab=_66225_/X }
C {devices/lab_pin.sym} 43940 -15760 0 0 {name=p43611 lab=_84971_/Q }
C {devices/lab_pin.sym} 43940 -15720 0 0 {name=p43612 lab=_66186_/X }
C {devices/lab_pin.sym} 43940 -15680 0 0 {name=p43613 lab=_66226_/X }
C {devices/lab_pin.sym} 44100 -15740 0 1 {name=p43614 lab=_66227_/X }
C {sky130_stdcells/a211o_4.sym} 44020 -15740 0 0 {name=X_66227_ }
C {devices/lab_pin.sym} 43930 -15590 0 0 {name=p43615 lab=_85128_/CLK }
C {devices/lab_pin.sym} 43930 -15570 0 0 {name=p43616 lab=_85061_/D }
C {devices/lab_pin.sym} 44110 -15590 0 1 {name=p43617 lab=_57217_/B }
C {sky130_stdcells/dfxtp_4.sym} 44020 -15580 0 0 {name=X_85061_ }
C {devices/lab_pin.sym} 43940 -15470 0 0 {name=p43618 lab=_51446_/Y }
C {devices/lab_pin.sym} 43940 -15430 0 0 {name=p43619 lab=_51448_/X }
C {devices/lab_pin.sym} 43940 -15390 0 0 {name=p43620 lab=_51452_/X }
C {devices/lab_pin.sym} 44100 -15430 0 1 {name=p43621 lab=_86008_/D }
C {sky130_stdcells/a21oi_4.sym} 44020 -15430 0 0 {name=X_51453_ }
C {devices/lab_pin.sym} 43960 -15300 0 0 {name=p43622 lab=_63427_/A }
C {devices/lab_pin.sym} 43960 -15260 0 0 {name=p43623 lab=_61831_/X }
C {devices/lab_pin.sym} 44080 -15280 0 1 {name=p43624 lab=_63439_/X }
C {sky130_stdcells/and2_4.sym} 44020 -15280 0 0 {name=X_63439_ }
C {devices/lab_pin.sym} 43930 -15150 0 0 {name=p43625 lab=_83508_/CLK }
C {devices/lab_pin.sym} 43930 -15130 0 0 {name=p43626 lab=_80634_/Y }
C {devices/lab_pin.sym} 44110 -15150 0 1 {name=p43627 lab=_82273_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -15140 0 0 {name=X_82273_ }
C {devices/lab_pin.sym} 43930 -15010 0 0 {name=p43628 lab=_84074_/CLK }
C {devices/lab_pin.sym} 43930 -14990 0 0 {name=p43629 lab=_68206_/X }
C {devices/lab_pin.sym} 44110 -15010 0 1 {name=p43630 lab=_82052_/D }
C {sky130_stdcells/dfxtp_4.sym} 44020 -15000 0 0 {name=X_84012_ }
C {devices/lab_pin.sym} 43980 -14870 0 0 {name=p43631 lab=_50213_/X }
C {devices/lab_pin.sym} 44060 -14870 0 1 {name=p43632 lab=_50432_/A }
C {sky130_stdcells/buf_2.sym} 44020 -14870 0 0 {name=X_50404_ }
C {devices/lab_pin.sym} 43930 -14750 0 0 {name=p43633 lab=_81224_/CLK }
C {devices/lab_pin.sym} 43930 -14730 0 0 {name=p43634 lab=_81032_/Q }
C {devices/lab_pin.sym} 44110 -14750 0 1 {name=p43635 lab=_81224_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -14740 0 0 {name=X_81224_ }
C {devices/lab_pin.sym} 43980 -14610 0 0 {name=p43636 lab=_54254_/A }
C {devices/lab_pin.sym} 44060 -14610 0 1 {name=p43637 lab=_54191_/C }
C {sky130_stdcells/buf_2.sym} 44020 -14610 0 0 {name=X_54172_ }
C {devices/lab_pin.sym} 43980 -14490 0 0 {name=p43638 lab=_66391_/A }
C {devices/lab_pin.sym} 44060 -14490 0 1 {name=p43639 lab=_66385_/B }
C {sky130_stdcells/buf_2.sym} 44020 -14490 0 0 {name=X_66158_ }
C {devices/lab_pin.sym} 43960 -14380 0 0 {name=p43640 lab=_51367_/X }
C {devices/lab_pin.sym} 43960 -14340 0 0 {name=p43641 lab=_51384_/B }
C {devices/lab_pin.sym} 44080 -14360 0 1 {name=p43642 lab=_51384_/X }
C {sky130_stdcells/and2_4.sym} 44020 -14360 0 0 {name=X_51384_ }
C {devices/lab_pin.sym} 43980 -14230 0 0 {name=p43643 lab=clkbuf_9_453_0_CLK/X }
C {devices/lab_pin.sym} 44060 -14230 0 1 {name=p43644 lab=_87850_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44020 -14230 0 0 {name=Xclkbuf_10_906_0_CLK }
C {devices/lab_pin.sym} 43940 -14130 0 0 {name=p43645 lab=_85693_/Q }
C {devices/lab_pin.sym} 43940 -14090 0 0 {name=p43646 lab=_53120_/X }
C {devices/lab_pin.sym} 43940 -14050 0 0 {name=p43647 lab=_53122_/Y }
C {devices/lab_pin.sym} 44100 -14090 0 1 {name=p43648 lab=_53123_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -14090 0 0 {name=X_53123_ }
C {devices/lab_pin.sym} 43960 -13960 0 0 {name=p43649 lab=_65005_/X }
C {devices/lab_pin.sym} 43960 -13920 0 0 {name=p43650 lab=_65109_/B }
C {devices/lab_pin.sym} 44080 -13940 0 1 {name=p43651 lab=_65109_/X }
C {sky130_stdcells/and2_4.sym} 44020 -13940 0 0 {name=X_65109_ }
C {devices/lab_pin.sym} 43960 -13820 0 0 {name=p43652 lab=_50398_/A }
C {devices/lab_pin.sym} 43960 -13780 0 0 {name=p43653 lab=_52036_/B }
C {devices/lab_pin.sym} 44080 -13800 0 1 {name=p43654 lab=_50335_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -13800 0 0 {name=X_50335_ }
C {devices/lab_pin.sym} 43930 -13670 0 0 {name=p43655 lab=_81179_/CLK }
C {devices/lab_pin.sym} 43930 -13650 0 0 {name=p43656 lab=_74853_/B }
C {devices/lab_pin.sym} 44110 -13670 0 1 {name=p43657 lab=_81155_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -13660 0 0 {name=X_81155_ }
C {devices/lab_pin.sym} 43960 -13550 0 0 {name=p43658 lab=_66426_/A }
C {devices/lab_pin.sym} 43960 -13510 0 0 {name=p43659 lab=_65741_/B }
C {devices/lab_pin.sym} 43960 -13470 0 0 {name=p43660 lab=_66426_/C }
C {devices/lab_pin.sym} 44080 -13510 0 1 {name=p43661 lab=_66089_/Y }
C {sky130_stdcells/nand3_4.sym} 44020 -13510 0 0 {name=X_66089_ }
C {devices/lab_pin.sym} 43940 -13390 0 0 {name=p43662 lab=_58559_/X }
C {devices/lab_pin.sym} 43940 -13350 0 0 {name=p43663 lab=_83438_/Q }
C {devices/lab_pin.sym} 43940 -13310 0 0 {name=p43664 lab=_58979_/Y }
C {devices/lab_pin.sym} 44100 -13350 0 1 {name=p43665 lab=_84782_/D }
C {sky130_stdcells/o21a_4.sym} 44020 -13350 0 0 {name=X_58980_ }
C {devices/lab_pin.sym} 43980 -13210 0 0 {name=p43666 lab=clkbuf_5_23_0_CLK/A }
C {devices/lab_pin.sym} 44060 -13210 0 1 {name=p43667 lab=clkbuf_6_47_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 44020 -13210 0 0 {name=Xclkbuf_5_23_0_CLK }
C {devices/lab_pin.sym} 43940 -13110 0 0 {name=p43668 lab=_80098_/B }
C {devices/lab_pin.sym} 43940 -13070 0 0 {name=p43669 lab=_80098_/A }
C {devices/lab_pin.sym} 43940 -13030 0 0 {name=p43670 lab=_80105_/X }
C {devices/lab_pin.sym} 44100 -13070 0 1 {name=p43671 lab=_80106_/Y }
C {sky130_stdcells/a21boi_4.sym} 44020 -13070 0 0 {name=X_80106_ }
C {devices/lab_pin.sym} 43960 -12940 0 0 {name=p43672 lab=_53040_/X }
C {devices/lab_pin.sym} 43960 -12900 0 0 {name=p43673 lab=_53054_/B }
C {devices/lab_pin.sym} 44080 -12920 0 1 {name=p43674 lab=_53054_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -12920 0 0 {name=X_53054_ }
C {devices/lab_pin.sym} 43960 -12800 0 0 {name=p43675 lab=_86643_/Q }
C {devices/lab_pin.sym} 43960 -12760 0 0 {name=p43676 lab=_57791_/X }
C {devices/lab_pin.sym} 44080 -12780 0 1 {name=p43677 lab=_57931_/Y }
C {sky130_stdcells/nor2_4.sym} 44020 -12780 0 0 {name=X_57931_ }
C {devices/lab_pin.sym} 43980 -12650 0 0 {name=p43678 lab=_69917_/A }
C {devices/lab_pin.sym} 44060 -12650 0 1 {name=p43679 lab=_69918_/B }
C {sky130_stdcells/inv_2.sym} 44020 -12650 0 0 {name=X_69917_ }
C {devices/lab_pin.sym} 43960 -12540 0 0 {name=p43680 lab=_50230_/A }
C {devices/lab_pin.sym} 43960 -12500 0 0 {name=p43681 lab=_53488_/B }
C {devices/lab_pin.sym} 44080 -12520 0 1 {name=p43682 lab=_50266_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -12520 0 0 {name=X_50266_ }
C {devices/lab_pin.sym} 43930 -12390 0 0 {name=p43683 lab=_85962_/CLK }
C {devices/lab_pin.sym} 43930 -12370 0 0 {name=p43684 lab=_85963_/D }
C {devices/lab_pin.sym} 44110 -12390 0 1 {name=p43685 lab=_85963_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -12380 0 0 {name=X_85963_ }
C {devices/lab_pin.sym} 43930 -12250 0 0 {name=p43686 lab=_81087_/CLK }
C {devices/lab_pin.sym} 43930 -12230 0 0 {name=p43687 lab=_81118_/Q }
C {devices/lab_pin.sym} 44110 -12250 0 1 {name=p43688 lab=_81086_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -12240 0 0 {name=X_81086_ }
C {devices/lab_pin.sym} 43960 -12120 0 0 {name=p43689 lab=_52027_/A }
C {devices/lab_pin.sym} 43960 -12080 0 0 {name=p43690 lab=_50302_/B }
C {devices/lab_pin.sym} 44080 -12100 0 1 {name=p43691 lab=_52005_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -12100 0 0 {name=X_52005_ }
C {devices/lab_pin.sym} 43930 -11970 0 0 {name=p43692 lab=_87221_/CLK }
C {devices/lab_pin.sym} 43930 -11950 0 0 {name=p43693 lab=_87702_/D }
C {devices/lab_pin.sym} 44110 -11970 0 1 {name=p43694 lab=_87702_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -11960 0 0 {name=X_87702_ }
C {devices/lab_pin.sym} 43960 -11840 0 0 {name=p43695 lab=_84932_/Q }
C {devices/lab_pin.sym} 43960 -11800 0 0 {name=p43696 lab=_84180_/Q }
C {devices/lab_pin.sym} 44080 -11820 0 1 {name=p43697 lab=_80037_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -11820 0 0 {name=X_80037_ }
C {devices/lab_pin.sym} 43930 -11690 0 0 {name=p43698 lab=_84914_/CLK }
C {devices/lab_pin.sym} 43930 -11670 0 0 {name=p43699 lab=_84914_/D }
C {devices/lab_pin.sym} 44110 -11690 0 1 {name=p43700 lab=_58177_/A }
C {sky130_stdcells/dfxtp_4.sym} 44020 -11680 0 0 {name=X_84914_ }
C {devices/lab_pin.sym} 43940 -11570 0 0 {name=p43701 lab=_57852_/X }
C {devices/lab_pin.sym} 43940 -11530 0 0 {name=p43702 lab=_85720_/Q }
C {devices/lab_pin.sym} 43940 -11490 0 0 {name=p43703 lab=_57814_/X }
C {devices/lab_pin.sym} 44100 -11530 0 1 {name=p43704 lab=_57862_/X }
C {sky130_stdcells/o21a_4.sym} 44020 -11530 0 0 {name=X_57862_ }
C {devices/lab_pin.sym} 43960 -11400 0 0 {name=p43705 lab=_69633_/A }
C {devices/lab_pin.sym} 43960 -11360 0 0 {name=p43706 lab=_73299_/A }
C {devices/lab_pin.sym} 44080 -11380 0 1 {name=p43707 lab=_69848_/X }
C {sky130_stdcells/and2_4.sym} 44020 -11380 0 0 {name=X_69848_ }
C {devices/lab_pin.sym} 43960 -11260 0 0 {name=p43708 lab=_51242_/A }
C {devices/lab_pin.sym} 43960 -11220 0 0 {name=p43709 lab=_50710_/B }
C {devices/lab_pin.sym} 44080 -11240 0 1 {name=p43710 lab=_50197_/X }
C {sky130_stdcells/and2_4.sym} 44020 -11240 0 0 {name=X_50197_ }
C {devices/lab_pin.sym} 43930 -11110 0 0 {name=p43711 lab=_86213_/CLK }
C {devices/lab_pin.sym} 43930 -11090 0 0 {name=p43712 lab=_85894_/D }
C {devices/lab_pin.sym} 44110 -11110 0 1 {name=p43713 lab=_66296_/B }
C {sky130_stdcells/dfxtp_4.sym} 44020 -11100 0 0 {name=X_85894_ }
C {devices/lab_pin.sym} 43960 -10980 0 0 {name=p43714 lab=_59751_/A }
C {devices/lab_pin.sym} 43960 -10940 0 0 {name=p43715 lab=_59752_/A }
C {devices/lab_pin.sym} 44080 -10960 0 1 {name=p43716 lab=_59639_/A }
C {sky130_stdcells/and2_4.sym} 44020 -10960 0 0 {name=X_59601_ }
C {devices/lab_pin.sym} 43960 -10840 0 0 {name=p43717 lab=_57029_/A }
C {devices/lab_pin.sym} 43960 -10800 0 0 {name=p43718 lab=_56812_/X }
C {devices/lab_pin.sym} 44080 -10820 0 1 {name=p43719 lab=_56814_/A }
C {sky130_stdcells/nand2_4.sym} 44020 -10820 0 0 {name=X_56813_ }
C {devices/lab_pin.sym} 43930 -10690 0 0 {name=p43720 lab=_88201_/CLK }
C {devices/lab_pin.sym} 43930 -10670 0 0 {name=p43721 lab=_87633_/D }
C {devices/lab_pin.sym} 44110 -10690 0 1 {name=p43722 lab=_66616_/B }
C {sky130_stdcells/dfxtp_4.sym} 44020 -10680 0 0 {name=X_87633_ }
C {devices/lab_pin.sym} 43930 -10550 0 0 {name=p43723 lab=_84877_/CLK }
C {devices/lab_pin.sym} 43930 -10530 0 0 {name=p43724 lab=_84845_/D }
C {devices/lab_pin.sym} 44110 -10550 0 1 {name=p43725 lab=_84845_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -10540 0 0 {name=X_84845_ }
C {devices/lab_pin.sym} 43980 -10410 0 0 {name=p43726 lab=_58007_/A }
C {devices/lab_pin.sym} 44060 -10410 0 1 {name=p43727 lab=_57793_/X }
C {sky130_stdcells/buf_2.sym} 44020 -10410 0 0 {name=X_57793_ }
C {devices/lab_pin.sym} 43980 -10290 0 0 {name=p43728 lab=_69779_/A }
C {devices/lab_pin.sym} 44060 -10290 0 1 {name=p43729 lab=_69779_/X }
C {sky130_stdcells/buf_2.sym} 44020 -10290 0 0 {name=X_69779_ }
C {devices/lab_pin.sym} 43980 -10170 0 0 {name=p43730 lab=_70502_/Y }
C {devices/lab_pin.sym} 44060 -10170 0 1 {name=p43731 lab=_71813_/A }
C {sky130_stdcells/buf_2.sym} 44020 -10170 0 0 {name=X_71810_ }
C {devices/lab_pin.sym} 43980 -10050 0 0 {name=p43732 lab=_59532_/A }
C {devices/lab_pin.sym} 44060 -10050 0 1 {name=p43733 lab=_59716_/B }
C {sky130_stdcells/buf_2.sym} 44020 -10050 0 0 {name=X_59532_ }
C {devices/lab_pin.sym} 43960 -9940 0 0 {name=p43734 lab=_57179_/A }
C {devices/lab_pin.sym} 43960 -9900 0 0 {name=p43735 lab=_85135_/Q }
C {devices/lab_pin.sym} 44080 -9920 0 1 {name=p43736 lab=_56744_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -9920 0 0 {name=X_56744_ }
C {devices/lab_pin.sym} 43940 -9830 0 0 {name=p43737 lab=_41965_/X }
C {devices/lab_pin.sym} 43940 -9790 0 0 {name=p43738 lab=_41956_/X }
C {devices/lab_pin.sym} 43940 -9750 0 0 {name=p43739 lab=_40739_/X }
C {devices/lab_pin.sym} 43940 -9710 0 0 {name=p43740 lab=_41969_/Y }
C {devices/lab_pin.sym} 43940 -9670 0 0 {name=p43741 lab=_41967_/X }
C {devices/lab_pin.sym} 44100 -9750 0 1 {name=p43742 lab=_41970_/Y }
C {sky130_stdcells/o32ai_4.sym} 44020 -9750 0 0 {name=X_41970_ }
C {devices/lab_pin.sym} 43930 -9590 0 0 {name=p43743 lab=_87821_/CLK }
C {devices/lab_pin.sym} 43930 -9570 0 0 {name=p43744 lab=_87564_/D }
C {devices/lab_pin.sym} 44110 -9590 0 1 {name=p43745 lab=_43133_/A }
C {sky130_stdcells/dfxtp_4.sym} 44020 -9580 0 0 {name=X_87564_ }
C {devices/lab_pin.sym} 43980 -9450 0 0 {name=p43746 lab=_53956_/A }
C {devices/lab_pin.sym} 44060 -9450 0 1 {name=p43747 lab=_53956_/X }
C {sky130_stdcells/buf_2.sym} 44020 -9450 0 0 {name=X_53956_ }
C {devices/lab_pin.sym} 43940 -9350 0 0 {name=p43748 lab=_72774_/X }
C {devices/lab_pin.sym} 43940 -9310 0 0 {name=p43749 lab=_72791_/C }
C {devices/lab_pin.sym} 43940 -9270 0 0 {name=p43750 lab=_72789_/X }
C {devices/lab_pin.sym} 44100 -9310 0 1 {name=p43751 lab=_72790_/X }
C {sky130_stdcells/a21o_4.sym} 44020 -9310 0 0 {name=X_72790_ }
C {devices/lab_pin.sym} 43930 -9170 0 0 {name=p43752 lab=_86688_/CLK }
C {devices/lab_pin.sym} 43930 -9150 0 0 {name=p43753 lab=_84776_/D }
C {devices/lab_pin.sym} 44110 -9170 0 1 {name=p43754 lab=_84776_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -9160 0 0 {name=X_84776_ }
C {devices/lab_pin.sym} 43930 -9030 0 0 {name=p43755 lab=_82104_/CLK }
C {devices/lab_pin.sym} 43930 -9010 0 0 {name=p43756 lab=_81988_/D }
C {devices/lab_pin.sym} 44110 -9030 0 1 {name=p43757 lab=_77009_/A }
C {sky130_stdcells/dfxtp_4.sym} 44020 -9020 0 0 {name=X_81988_ }
C {devices/lab_pin.sym} 43930 -8890 0 0 {name=p43758 lab=_85581_/CLK }
C {devices/lab_pin.sym} 43930 -8870 0 0 {name=p43759 lab=_86515_/D }
C {devices/lab_pin.sym} 44110 -8890 0 1 {name=p43760 lab=_86515_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -8880 0 0 {name=X_86515_ }
C {devices/lab_pin.sym} 43980 -8750 0 0 {name=p43761 lab=_40921_/A }
C {devices/lab_pin.sym} 44060 -8750 0 1 {name=p43762 lab=_40921_/X }
C {sky130_stdcells/buf_2.sym} 44020 -8750 0 0 {name=X_40921_ }
C {devices/lab_pin.sym} 43980 -8630 0 0 {name=p43763 lab=_52852_/A }
C {devices/lab_pin.sym} 44060 -8630 0 1 {name=p43764 lab=_52916_/B }
C {sky130_stdcells/buf_2.sym} 44020 -8630 0 0 {name=X_52907_ }
C {devices/lab_pin.sym} 43960 -8540 0 0 {name=p43765 lab=_71168_/A }
C {devices/lab_pin.sym} 43960 -8500 0 0 {name=p43766 lab=_70656_/B }
C {devices/lab_pin.sym} 43960 -8460 0 0 {name=p43767 lab=_71279_/C }
C {devices/lab_pin.sym} 43960 -8420 0 0 {name=p43768 lab=_71744_/D }
C {devices/lab_pin.sym} 44080 -8480 0 1 {name=p43769 lab=_71741_/Y }
C {sky130_stdcells/nand4_4.sym} 44020 -8480 0 0 {name=X_71741_ }
C {devices/lab_pin.sym} 43980 -8330 0 0 {name=p43770 lab=_59463_/A }
C {devices/lab_pin.sym} 44060 -8330 0 1 {name=p43771 lab=_59463_/Y }
C {sky130_stdcells/inv_2.sym} 44020 -8330 0 0 {name=X_59463_ }
C {devices/lab_pin.sym} 43930 -8210 0 0 {name=p43772 lab=_85381_/CLK }
C {devices/lab_pin.sym} 43930 -8190 0 0 {name=p43773 lab=_83727_/D }
C {devices/lab_pin.sym} 44110 -8210 0 1 {name=p43774 lab=_47468_/A }
C {sky130_stdcells/dfxtp_4.sym} 44020 -8200 0 0 {name=X_83727_ }
C {devices/lab_pin.sym} 43980 -8070 0 0 {name=p43775 lab=_83332_/Q }
C {devices/lab_pin.sym} 44060 -8070 0 1 {name=p43776 lab=_56675_/X }
C {sky130_stdcells/buf_2.sym} 44020 -8070 0 0 {name=X_56675_ }
C {devices/lab_pin.sym} 43930 -7950 0 0 {name=p43777 lab=_80804_/CLK }
C {devices/lab_pin.sym} 43930 -7930 0 0 {name=p43778 lab=_80983_/Q }
C {devices/lab_pin.sym} 44110 -7950 0 1 {name=p43779 lab=_80939_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -7940 0 0 {name=X_80939_ }
C {devices/lab_pin.sym} 43930 -7810 0 0 {name=p43780 lab=_87758_/CLK }
C {devices/lab_pin.sym} 43930 -7790 0 0 {name=p43781 lab=_87495_/D }
C {devices/lab_pin.sym} 44110 -7810 0 1 {name=p43782 lab=_87495_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -7800 0 0 {name=X_87495_ }
C {devices/lab_pin.sym} 43940 -7690 0 0 {name=p43783 lab=_85548_/Q }
C {devices/lab_pin.sym} 43940 -7650 0 0 {name=p43784 lab=_53869_/X }
C {devices/lab_pin.sym} 43940 -7610 0 0 {name=p43785 lab=_53886_/Y }
C {devices/lab_pin.sym} 44100 -7650 0 1 {name=p43786 lab=_53887_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -7650 0 0 {name=X_53887_ }
C {devices/lab_pin.sym} 43980 -7510 0 0 {name=p43787 lab=_84854_/Q }
C {devices/lab_pin.sym} 44060 -7510 0 1 {name=p43788 lab=_58415_/A }
C {sky130_stdcells/inv_2.sym} 44020 -7510 0 0 {name=X_58414_ }
C {devices/lab_pin.sym} 43940 -7420 0 0 {name=p43789 lab=_40678_/X }
C {devices/lab_pin.sym} 43940 -7380 0 0 {name=p43790 lab=_43624_/X }
C {devices/lab_pin.sym} 43940 -7340 0 0 {name=p43791 lab=_87331_/Q }
C {devices/lab_pin.sym} 43940 -7300 0 0 {name=p43792 lab=_43625_/X }
C {devices/lab_pin.sym} 44100 -7360 0 1 {name=p43793 lab=_43640_/X }
C {sky130_stdcells/a2bb2o_4.sym} 44020 -7360 0 0 {name=X_43640_ }
C {devices/lab_pin.sym} 43940 -7230 0 0 {name=p43794 lab=_74457_/Y }
C {devices/lab_pin.sym} 43940 -7190 0 0 {name=p43795 lab=_74430_/X }
C {devices/lab_pin.sym} 43940 -7150 0 0 {name=p43796 lab=_74459_/X }
C {devices/lab_pin.sym} 44100 -7190 0 1 {name=p43797 lab=_74460_/Y }
C {sky130_stdcells/a21oi_4.sym} 44020 -7190 0 0 {name=X_74460_ }
C {devices/lab_pin.sym} 43940 -7080 0 0 {name=p43798 lab=_45409_/A }
C {devices/lab_pin.sym} 43940 -7040 0 0 {name=p43799 lab=_55617_/X }
C {devices/lab_pin.sym} 43940 -7000 0 0 {name=p43800 lab=_44052_/A }
C {devices/lab_pin.sym} 43940 -6960 0 0 {name=p43801 lab=_55625_/Y }
C {devices/lab_pin.sym} 44100 -7020 0 1 {name=p43802 lab=_55626_/X }
C {sky130_stdcells/a211o_4.sym} 44020 -7020 0 0 {name=X_55626_ }
C {devices/lab_pin.sym} 43930 -6870 0 0 {name=p43803 lab=_85557_/CLK }
C {devices/lab_pin.sym} 43930 -6850 0 0 {name=p43804 lab=_86446_/D }
C {devices/lab_pin.sym} 44110 -6870 0 1 {name=p43805 lab=_65100_/B }
C {sky130_stdcells/dfxtp_4.sym} 44020 -6860 0 0 {name=X_86446_ }
C {devices/lab_pin.sym} 43960 -6740 0 0 {name=p43806 lab=_40829_/A }
C {devices/lab_pin.sym} 43960 -6700 0 0 {name=p43807 lab=_40852_/B }
C {devices/lab_pin.sym} 44080 -6720 0 1 {name=p43808 lab=_40852_/X }
C {sky130_stdcells/or2_4.sym} 44020 -6720 0 0 {name=X_40852_ }
C {devices/lab_pin.sym} 43940 -6610 0 0 {name=p43809 lab=_85745_/Q }
C {devices/lab_pin.sym} 43940 -6570 0 0 {name=p43810 lab=_52821_/X }
C {devices/lab_pin.sym} 43940 -6530 0 0 {name=p43811 lab=_52837_/Y }
C {devices/lab_pin.sym} 44100 -6570 0 1 {name=p43812 lab=_52838_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -6570 0 0 {name=X_52838_ }
C {devices/lab_pin.sym} 43930 -6430 0 0 {name=p43813 lab=_83660_/CLK }
C {devices/lab_pin.sym} 43930 -6410 0 0 {name=p43814 lab=_70931_/Y }
C {devices/lab_pin.sym} 44110 -6430 0 1 {name=p43815 lab=_46911_/A }
C {sky130_stdcells/dfxtp_4.sym} 44020 -6420 0 0 {name=X_83658_ }
C {devices/lab_pin.sym} 43960 -6310 0 0 {name=p43816 lab=_71680_/A }
C {devices/lab_pin.sym} 43960 -6270 0 0 {name=p43817 lab=_71671_/X }
C {devices/lab_pin.sym} 43960 -6230 0 0 {name=p43818 lab=_71672_/C }
C {devices/lab_pin.sym} 44080 -6270 0 1 {name=p43819 lab=_71672_/Y }
C {sky130_stdcells/nand3_4.sym} 44020 -6270 0 0 {name=X_71672_ }
C {devices/lab_pin.sym} 43980 -6130 0 0 {name=p43820 lab=_58982_/A }
C {devices/lab_pin.sym} 44060 -6130 0 1 {name=p43821 lab=_59394_/X }
C {sky130_stdcells/buf_2.sym} 44020 -6130 0 0 {name=X_59394_ }
C {devices/lab_pin.sym} 43940 -6030 0 0 {name=p43822 lab=_73412_/B }
C {devices/lab_pin.sym} 43940 -5990 0 0 {name=p43823 lab=_73412_/C }
C {devices/lab_pin.sym} 43940 -5950 0 0 {name=p43824 lab=_73410_/X }
C {devices/lab_pin.sym} 44100 -5990 0 1 {name=p43825 lab=_73411_/X }
C {sky130_stdcells/a21o_4.sym} 44020 -5990 0 0 {name=X_73411_ }
C {devices/lab_pin.sym} 43960 -5880 0 0 {name=p43826 lab=_70727_/A }
C {devices/lab_pin.sym} 43960 -5840 0 0 {name=p43827 lab=_70620_/B }
C {devices/lab_pin.sym} 43960 -5800 0 0 {name=p43828 lab=_70620_/C }
C {devices/lab_pin.sym} 43960 -5760 0 0 {name=p43829 lab=_70620_/D }
C {devices/lab_pin.sym} 44080 -5820 0 1 {name=p43830 lab=_70623_/Y }
C {sky130_stdcells/nand4_4.sym} 44020 -5820 0 0 {name=X_70623_ }
C {devices/lab_pin.sym} 43940 -5690 0 0 {name=p43831 lab=_58341_/X }
C {devices/lab_pin.sym} 43940 -5650 0 0 {name=p43832 lab=_58342_/Y }
C {devices/lab_pin.sym} 43940 -5610 0 0 {name=p43833 lab=_58344_/Y }
C {devices/lab_pin.sym} 44100 -5650 0 1 {name=p43834 lab=_84873_/D }
C {sky130_stdcells/a21oi_4.sym} 44020 -5650 0 0 {name=X_58345_ }
C {devices/lab_pin.sym} 43930 -5510 0 0 {name=p43835 lab=_82702_/CLK }
C {devices/lab_pin.sym} 43930 -5490 0 0 {name=p43836 lab=_78947_/B }
C {devices/lab_pin.sym} 44110 -5510 0 1 {name=p43837 lab=_82609_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -5500 0 0 {name=X_82609_ }
C {devices/lab_pin.sym} 43980 -5370 0 0 {name=p43838 lab=_43570_/Y }
C {devices/lab_pin.sym} 44060 -5370 0 1 {name=p43839 lab=_87355_/D }
C {sky130_stdcells/inv_2.sym} 44020 -5370 0 0 {name=X_43571_ }
C {devices/lab_pin.sym} 43940 -5270 0 0 {name=p43840 lab=_55554_/X }
C {devices/lab_pin.sym} 43940 -5230 0 0 {name=p43841 lab=_55556_/X }
C {devices/lab_pin.sym} 43940 -5190 0 0 {name=p43842 lab=_44113_/X }
C {devices/lab_pin.sym} 44100 -5230 0 1 {name=p43843 lab=_56595_/A }
C {sky130_stdcells/a21o_4.sym} 44020 -5230 0 0 {name=X_55557_ }
C {devices/lab_pin.sym} 43960 -5100 0 0 {name=p43844 lab=_74391_/A }
C {devices/lab_pin.sym} 43960 -5060 0 0 {name=p43845 lab=_52123_/B }
C {devices/lab_pin.sym} 44080 -5080 0 1 {name=p43846 lab=_74391_/Y }
C {sky130_stdcells/nand2_4.sym} 44020 -5080 0 0 {name=X_74391_ }
C {devices/lab_pin.sym} 43930 -4950 0 0 {name=p43847 lab=_83666_/CLK }
C {devices/lab_pin.sym} 43930 -4930 0 0 {name=p43848 lab=_86377_/D }
C {devices/lab_pin.sym} 44110 -4950 0 1 {name=p43849 lab=_86377_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -4940 0 0 {name=X_86377_ }
C {devices/lab_pin.sym} 43980 -4810 0 0 {name=p43850 lab=_40783_/A }
C {devices/lab_pin.sym} 44060 -4810 0 1 {name=p43851 lab=_40783_/X }
C {sky130_stdcells/buf_2.sym} 44020 -4810 0 0 {name=X_40783_ }
C {devices/lab_pin.sym} 43940 -4710 0 0 {name=p43852 lab=_85758_/Q }
C {devices/lab_pin.sym} 43940 -4670 0 0 {name=p43853 lab=_52765_/X }
C {devices/lab_pin.sym} 43940 -4630 0 0 {name=p43854 lab=_52768_/Y }
C {devices/lab_pin.sym} 44100 -4670 0 1 {name=p43855 lab=_52769_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -4670 0 0 {name=X_52769_ }
C {devices/lab_pin.sym} 43930 -4530 0 0 {name=p43856 lab=_83589_/CLK }
C {devices/lab_pin.sym} 43930 -4510 0 0 {name=p43857 lab=_71153_/Y }
C {devices/lab_pin.sym} 44110 -4530 0 1 {name=p43858 lab=_83589_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -4520 0 0 {name=X_83589_ }
C {devices/lab_pin.sym} 43940 -4410 0 0 {name=p43859 lab=_45302_/X }
C {devices/lab_pin.sym} 43940 -4370 0 0 {name=p43860 lab=_45307_/Y }
C {devices/lab_pin.sym} 43940 -4330 0 0 {name=p43861 lab=_45309_/Y }
C {devices/lab_pin.sym} 44100 -4370 0 1 {name=p43862 lab=_45310_/Y }
C {sky130_stdcells/a21oi_4.sym} 44020 -4370 0 0 {name=X_45310_ }
C {devices/lab_pin.sym} 43960 -4240 0 0 {name=p43863 lab=_76130_/A }
C {devices/lab_pin.sym} 43960 -4200 0 0 {name=p43864 lab=_76130_/B }
C {devices/lab_pin.sym} 44080 -4220 0 1 {name=p43865 lab=_76130_/X }
C {sky130_stdcells/xor2_4.sym} 44020 -4220 0 0 {name=X_76130_ }
C {devices/lab_pin.sym} 43930 -4090 0 0 {name=p43866 lab=_88116_/CLK }
C {devices/lab_pin.sym} 43930 -4070 0 0 {name=p43867 lab=_88116_/D }
C {devices/lab_pin.sym} 44110 -4090 0 1 {name=p43868 lab=_88116_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -4080 0 0 {name=X_88116_ }
C {devices/lab_pin.sym} 43980 -3950 0 0 {name=p43869 lab=_42574_/A }
C {devices/lab_pin.sym} 44060 -3950 0 1 {name=p43870 lab=_42522_/X }
C {sky130_stdcells/buf_2.sym} 44020 -3950 0 0 {name=X_42522_ }
C {devices/lab_pin.sym} 43980 -3830 0 0 {name=p43871 lab=_54401_/A }
C {devices/lab_pin.sym} 44060 -3830 0 1 {name=p43872 lab=_54509_/C }
C {sky130_stdcells/buf_2.sym} 44020 -3830 0 0 {name=X_54508_ }
C {devices/lab_pin.sym} 43940 -3740 0 0 {name=p43873 lab=_69873_/Y }
C {devices/lab_pin.sym} 43940 -3700 0 0 {name=p43874 lab=_73224_/X }
C {devices/lab_pin.sym} 43940 -3660 0 0 {name=p43875 lab=_56935_/X }
C {devices/lab_pin.sym} 43940 -3620 0 0 {name=p43876 lab=_73341_/Y }
C {devices/lab_pin.sym} 44100 -3680 0 1 {name=p43877 lab=_73342_/X }
C {sky130_stdcells/a211o_4.sym} 44020 -3680 0 0 {name=X_73342_ }
C {devices/lab_pin.sym} 43930 -3530 0 0 {name=p43878 lab=_83550_/CLK }
C {devices/lab_pin.sym} 43930 -3510 0 0 {name=p43879 lab=_85328_/D }
C {devices/lab_pin.sym} 44110 -3530 0 1 {name=p43880 lab=_85328_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -3520 0 0 {name=X_85328_ }
C {devices/lab_pin.sym} 43980 -3390 0 0 {name=p43881 lab=_46290_/A }
C {devices/lab_pin.sym} 44060 -3390 0 1 {name=p43882 lab=_72052_/A }
C {sky130_stdcells/buf_2.sym} 44020 -3390 0 0 {name=X_46290_ }
C {devices/lab_pin.sym} 43980 -3270 0 0 {name=p43883 lab=_70554_/A }
C {devices/lab_pin.sym} 44060 -3270 0 1 {name=p43884 lab=_70568_/C }
C {sky130_stdcells/buf_2.sym} 44020 -3270 0 0 {name=X_70554_ }
C {devices/lab_pin.sym} 43980 -3150 0 0 {name=p43885 lab=_84890_/Q }
C {devices/lab_pin.sym} 44060 -3150 0 1 {name=p43886 lab=_58277_/A }
C {sky130_stdcells/inv_2.sym} 44020 -3150 0 0 {name=X_58276_ }
C {devices/lab_pin.sym} 43980 -3030 0 0 {name=p43887 lab=_85138_/Q }
C {devices/lab_pin.sym} 44060 -3030 0 1 {name=p43888 lab=_55489_/B }
C {sky130_stdcells/inv_2.sym} 44020 -3030 0 0 {name=X_55488_ }
C {devices/lab_pin.sym} 43940 -2930 0 0 {name=p43889 lab=_85195_/Q }
C {devices/lab_pin.sym} 43940 -2890 0 0 {name=p43890 lab=_45176_/X }
C {devices/lab_pin.sym} 43940 -2850 0 0 {name=p43891 lab=_45240_/X }
C {devices/lab_pin.sym} 44100 -2890 0 1 {name=p43892 lab=_45241_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -2890 0 0 {name=X_45241_ }
C {devices/lab_pin.sym} 43940 -2770 0 0 {name=p43893 lab=_57121_/X }
C {devices/lab_pin.sym} 43940 -2730 0 0 {name=p43894 lab=_56917_/A }
C {devices/lab_pin.sym} 43940 -2690 0 0 {name=p43895 lab=_57226_/X }
C {devices/lab_pin.sym} 44100 -2730 0 1 {name=p43896 lab=_57227_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -2730 0 0 {name=X_57227_ }
C {devices/lab_pin.sym} 43960 -2600 0 0 {name=p43897 lab=_81525_/Q }
C {devices/lab_pin.sym} 43960 -2560 0 0 {name=p43898 lab=_76061_/B }
C {devices/lab_pin.sym} 44080 -2580 0 1 {name=p43899 lab=_76061_/X }
C {sky130_stdcells/xor2_4.sym} 44020 -2580 0 0 {name=X_76061_ }
C {devices/lab_pin.sym} 43930 -2450 0 0 {name=p43900 lab=_87544_/CLK }
C {devices/lab_pin.sym} 43930 -2430 0 0 {name=p43901 lab=_42071_/Y }
C {devices/lab_pin.sym} 44110 -2450 0 1 {name=p43902 lab=_88047_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44020 -2440 0 0 {name=X_88047_ }
C {devices/lab_pin.sym} 43980 -2310 0 0 {name=p43903 lab=_42612_/A }
C {devices/lab_pin.sym} 44060 -2310 0 1 {name=p43904 lab=_42453_/X }
C {sky130_stdcells/buf_2.sym} 44020 -2310 0 0 {name=X_42453_ }
C {devices/lab_pin.sym} 43980 -2190 0 0 {name=p43905 lab=_54385_/A }
C {devices/lab_pin.sym} 44060 -2190 0 1 {name=p43906 lab=_54440_/B }
C {sky130_stdcells/buf_2.sym} 44020 -2190 0 0 {name=X_54439_ }
C {devices/lab_pin.sym} 43930 -2070 0 0 {name=p43907 lab=_85192_/CLK }
C {devices/lab_pin.sym} 43930 -2050 0 0 {name=p43908 lab=_85259_/D }
C {devices/lab_pin.sym} 44110 -2070 0 1 {name=p43909 lab=_56250_/C }
C {sky130_stdcells/dfxtp_4.sym} 44020 -2060 0 0 {name=X_85259_ }
C {devices/lab_pin.sym} 43960 -1940 0 0 {name=p43910 lab=_73273_/A }
C {devices/lab_pin.sym} 43960 -1900 0 0 {name=p43911 lab=_73196_/B }
C {devices/lab_pin.sym} 44080 -1920 0 1 {name=p43912 lab=_73273_/Y }
C {sky130_stdcells/nor2_4.sym} 44020 -1920 0 0 {name=X_73273_ }
C {devices/lab_pin.sym} 43980 -1790 0 0 {name=p43913 lab=_70400_/A }
C {devices/lab_pin.sym} 44060 -1790 0 1 {name=p43914 lab=_71777_/B }
C {sky130_stdcells/buf_2.sym} 44020 -1790 0 0 {name=X_70485_ }
C {devices/lab_pin.sym} 43940 -1690 0 0 {name=p43915 lab=_80768_/Q }
C {devices/lab_pin.sym} 43940 -1650 0 0 {name=p43916 lab=_75020_/C }
C {devices/lab_pin.sym} 43940 -1610 0 0 {name=p43917 lab=_75011_/Y }
C {devices/lab_pin.sym} 44100 -1650 0 1 {name=p43918 lab=_75013_/B }
C {sky130_stdcells/a21oi_4.sym} 44020 -1650 0 0 {name=X_75012_ }
C {devices/lab_pin.sym} 43940 -1550 0 0 {name=p43919 lab=_41399_/X }
C {devices/lab_pin.sym} 43940 -1510 0 0 {name=p43920 lab=_41400_/X }
C {devices/lab_pin.sym} 43940 -1470 0 0 {name=p43921 lab=_41403_/X }
C {devices/lab_pin.sym} 43940 -1430 0 0 {name=p43922 lab=_67860_/B }
C {devices/lab_pin.sym} 43940 -1390 0 0 {name=p43923 lab=_41388_/X }
C {devices/lab_pin.sym} 44100 -1470 0 1 {name=p43924 lab=_41405_/A }
C {sky130_stdcells/o32ai_4.sym} 44020 -1470 0 0 {name=X_41404_ }
C {devices/lab_pin.sym} 43980 -1310 0 0 {name=p43925 lab=_72224_/A }
C {devices/lab_pin.sym} 44060 -1310 0 1 {name=p43926 lab=_72224_/Y }
C {sky130_stdcells/inv_2.sym} 44020 -1310 0 0 {name=X_72224_ }
C {devices/lab_pin.sym} 43940 -1210 0 0 {name=p43927 lab=_45127_/X }
C {devices/lab_pin.sym} 43940 -1170 0 0 {name=p43928 lab=_61538_/B }
C {devices/lab_pin.sym} 43940 -1130 0 0 {name=p43929 lab=_45144_/X }
C {devices/lab_pin.sym} 44100 -1170 0 1 {name=p43930 lab=_45172_/Y }
C {sky130_stdcells/o21ai_4.sym} 44020 -1170 0 0 {name=X_45172_ }
C {devices/lab_pin.sym} 43960 -1050 0 0 {name=p43931 lab=_57158_/A }
C {devices/lab_pin.sym} 43960 -1010 0 0 {name=p43932 lab=_57158_/B }
C {devices/lab_pin.sym} 43960 -970 0 0 {name=p43933 lab=_57158_/C }
C {devices/lab_pin.sym} 44080 -1010 0 1 {name=p43934 lab=_57158_/Y }
C {sky130_stdcells/nor3_4.sym} 44020 -1010 0 0 {name=X_57158_ }
C {devices/lab_pin.sym} 43940 -900 0 0 {name=p43935 lab=_40331_/X }
C {devices/lab_pin.sym} 43940 -860 0 0 {name=p43936 lab=_42374_/X }
C {devices/lab_pin.sym} 43940 -820 0 0 {name=p43937 lab=_87890_/Q }
C {devices/lab_pin.sym} 43940 -780 0 0 {name=p43938 lab=_42375_/X }
C {devices/lab_pin.sym} 44100 -840 0 1 {name=p43939 lab=_42384_/X }
C {sky130_stdcells/a2bb2o_4.sym} 44020 -840 0 0 {name=X_42384_ }
C {devices/lab_pin.sym} 43980 -690 0 0 {name=p43940 lab=_44187_/A }
C {devices/lab_pin.sym} 44060 -690 0 1 {name=p43941 lab=_44124_/A }
C {sky130_stdcells/inv_2.sym} 44020 -690 0 0 {name=X_44123_ }
C {devices/lab_pin.sym} 44900 -42150 0 0 {name=p43942 lab=_56109_/A }
C {devices/lab_pin.sym} 44980 -42150 0 1 {name=p43943 lab=_56109_/X }
C {sky130_stdcells/buf_2.sym} 44940 -42150 0 0 {name=X_56109_ }
C {devices/lab_pin.sym} 44880 -42040 0 0 {name=p43944 lab=_79804_/X }
C {devices/lab_pin.sym} 44880 -42000 0 0 {name=p43945 lab=_79820_/B }
C {devices/lab_pin.sym} 45000 -42020 0 1 {name=p43946 lab=_79820_/Y }
C {sky130_stdcells/nor2_4.sym} 44940 -42020 0 0 {name=X_79820_ }
C {devices/lab_pin.sym} 44900 -41890 0 0 {name=p43947 lab=_41334_/Y }
C {devices/lab_pin.sym} 44980 -41890 0 1 {name=p43948 lab=_88234_/D }
C {sky130_stdcells/inv_2.sym} 44940 -41890 0 0 {name=X_41335_ }
C {devices/lab_pin.sym} 44900 -41770 0 0 {name=p43949 lab=_72155_/A }
C {devices/lab_pin.sym} 44980 -41770 0 1 {name=p43950 lab=_72155_/X }
C {sky130_stdcells/buf_2.sym} 44940 -41770 0 0 {name=X_72155_ }
C {devices/lab_pin.sym} 44860 -41670 0 0 {name=p43951 lab=_49976_/Y }
C {devices/lab_pin.sym} 44860 -41630 0 0 {name=p43952 lab=_49977_/X }
C {devices/lab_pin.sym} 44860 -41590 0 0 {name=p43953 lab=_49979_/X }
C {devices/lab_pin.sym} 45020 -41630 0 1 {name=p43954 lab=_86288_/D }
C {sky130_stdcells/a21oi_4.sym} 44940 -41630 0 0 {name=X_49980_ }
C {devices/lab_pin.sym} 44900 -41490 0 0 {name=p43955 lab=_73183_/A }
C {devices/lab_pin.sym} 44980 -41490 0 1 {name=p43956 lab=_73186_/A }
C {sky130_stdcells/buf_2.sym} 44940 -41490 0 0 {name=X_57089_ }
C {devices/lab_pin.sym} 44880 -41390 0 0 {name=p43957 lab=_71101_/X }
C {devices/lab_pin.sym} 44880 -41350 0 0 {name=p43958 lab=_71082_/B }
C {devices/lab_pin.sym} 44880 -41310 0 0 {name=p43959 lab=_71099_/C }
C {devices/lab_pin.sym} 45000 -41350 0 1 {name=p43960 lab=_71106_/Y }
C {sky130_stdcells/nand3_4.sym} 44940 -41350 0 0 {name=X_71106_ }
C {devices/lab_pin.sym} 44900 -41210 0 0 {name=p43961 lab=_48931_/A }
C {devices/lab_pin.sym} 44980 -41210 0 1 {name=p43962 lab=_52287_/B }
C {sky130_stdcells/buf_2.sym} 44940 -41210 0 0 {name=X_48931_ }
C {devices/lab_pin.sym} 44900 -41090 0 0 {name=p43963 lab=_87180_/Q }
C {devices/lab_pin.sym} 44980 -41090 0 1 {name=p43964 lab=_44054_/Y }
C {sky130_stdcells/inv_2.sym} 44940 -41090 0 0 {name=X_44054_ }
C {devices/lab_pin.sym} 44880 -40980 0 0 {name=p43965 lab=_79745_/Y }
C {devices/lab_pin.sym} 44880 -40940 0 0 {name=p43966 lab=_79750_/Y }
C {devices/lab_pin.sym} 45000 -40960 0 1 {name=p43967 lab=_79751_/X }
C {sky130_stdcells/xor2_4.sym} 44940 -40960 0 0 {name=X_79751_ }
C {devices/lab_pin.sym} 44880 -40840 0 0 {name=p43968 lab=_41266_/A }
C {devices/lab_pin.sym} 44880 -40800 0 0 {name=p43969 lab=_41280_/B }
C {devices/lab_pin.sym} 45000 -40820 0 1 {name=p43970 lab=_41266_/X }
C {sky130_stdcells/or2_4.sym} 44940 -40820 0 0 {name=X_41266_ }
C {devices/lab_pin.sym} 44880 -40700 0 0 {name=p43971 lab=_72053_/A }
C {devices/lab_pin.sym} 44880 -40660 0 0 {name=p43972 lab=_49144_/A }
C {devices/lab_pin.sym} 45000 -40680 0 1 {name=p43973 lab=_72086_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -40680 0 0 {name=X_72086_ }
C {devices/lab_pin.sym} 44900 -40550 0 0 {name=p43974 lab=_76874_/Y }
C {devices/lab_pin.sym} 44980 -40550 0 1 {name=p43975 lab=_76963_/Y }
C {sky130_stdcells/inv_2.sym} 44940 -40550 0 0 {name=X_76963_ }
C {devices/lab_pin.sym} 44900 -40430 0 0 {name=p43976 lab=_43774_/A }
C {devices/lab_pin.sym} 44980 -40430 0 1 {name=p43977 lab=_43005_/X }
C {sky130_stdcells/buf_2.sym} 44940 -40430 0 0 {name=X_43005_ }
C {devices/lab_pin.sym} 44900 -40310 0 0 {name=p43978 lab=_78684_/X }
C {devices/lab_pin.sym} 44980 -40310 0 1 {name=p43979 lab=_78702_/Y }
C {sky130_stdcells/inv_2.sym} 44940 -40310 0 0 {name=X_78702_ }
C {devices/lab_pin.sym} 44860 -40210 0 0 {name=p43980 lab=_53167_/B }
C {devices/lab_pin.sym} 44860 -40170 0 0 {name=p43981 lab=_71013_/A }
C {devices/lab_pin.sym} 44860 -40130 0 0 {name=p43982 lab=_71036_/Y }
C {devices/lab_pin.sym} 45020 -40170 0 1 {name=p43983 lab=_83628_/D }
C {sky130_stdcells/o21ai_4.sym} 44940 -40170 0 0 {name=X_71037_ }
C {devices/lab_pin.sym} 44880 -40040 0 0 {name=p43984 lab=_61185_/C }
C {devices/lab_pin.sym} 44880 -40000 0 0 {name=p43985 lab=_62766_/C }
C {devices/lab_pin.sym} 45000 -40020 0 1 {name=p43986 lab=_75914_/X }
C {sky130_stdcells/xor2_4.sym} 44940 -40020 0 0 {name=X_75914_ }
C {devices/lab_pin.sym} 44900 -39890 0 0 {name=p43987 lab=_48837_/A }
C {devices/lab_pin.sym} 44980 -39890 0 1 {name=p43988 lab=_50056_/A }
C {sky130_stdcells/buf_2.sym} 44940 -39890 0 0 {name=X_48862_ }
C {devices/lab_pin.sym} 44880 -39780 0 0 {name=p43989 lab=_79678_/X }
C {devices/lab_pin.sym} 44880 -39740 0 0 {name=p43990 lab=_79682_/B }
C {devices/lab_pin.sym} 45000 -39760 0 1 {name=p43991 lab=_79704_/B }
C {sky130_stdcells/xor2_4.sym} 44940 -39760 0 0 {name=X_79682_ }
C {devices/lab_pin.sym} 44880 -39640 0 0 {name=p43992 lab=_81713_/Q }
C {devices/lab_pin.sym} 44880 -39600 0 0 {name=p43993 lab=_41197_/B }
C {devices/lab_pin.sym} 45000 -39620 0 1 {name=p43994 lab=_41197_/X }
C {sky130_stdcells/or2_4.sym} 44940 -39620 0 0 {name=X_41197_ }
C {devices/lab_pin.sym} 44900 -39490 0 0 {name=p43995 lab=_76894_/A }
C {devices/lab_pin.sym} 44980 -39490 0 1 {name=p43996 lab=_76894_/Y }
C {sky130_stdcells/inv_2.sym} 44940 -39490 0 0 {name=X_76894_ }
C {devices/lab_pin.sym} 44900 -39370 0 0 {name=p43997 lab=_81219_/Q }
C {devices/lab_pin.sym} 44980 -39370 0 1 {name=p43998 lab=_47814_/A }
C {sky130_stdcells/inv_2.sym} 44940 -39370 0 0 {name=X_47813_ }
C {devices/lab_pin.sym} 44860 -39270 0 0 {name=p43999 lab=_78632_/B }
C {devices/lab_pin.sym} 44860 -39230 0 0 {name=p44000 lab=_78632_/C }
C {devices/lab_pin.sym} 44860 -39190 0 0 {name=p44001 lab=_78628_/Y }
C {devices/lab_pin.sym} 45020 -39230 0 1 {name=p44002 lab=_78637_/C }
C {sky130_stdcells/o21ai_4.sym} 44940 -39230 0 0 {name=X_78633_ }
C {devices/lab_pin.sym} 44880 -39100 0 0 {name=p44003 lab=_75841_/Y }
C {devices/lab_pin.sym} 44880 -39060 0 0 {name=p44004 lab=_75844_/Y }
C {devices/lab_pin.sym} 45000 -39080 0 1 {name=p44005 lab=_75846_/A }
C {sky130_stdcells/xor2_4.sym} 44940 -39080 0 0 {name=X_75845_ }
C {devices/lab_pin.sym} 44880 -38960 0 0 {name=p44006 lab=_48793_/A }
C {devices/lab_pin.sym} 44880 -38920 0 0 {name=p44007 lab=_48540_/B }
C {devices/lab_pin.sym} 45000 -38940 0 1 {name=p44008 lab=_48793_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -38940 0 0 {name=X_48793_ }
C {devices/lab_pin.sym} 44860 -38850 0 0 {name=p44009 lab=_57672_/X }
C {devices/lab_pin.sym} 44860 -38810 0 0 {name=p44010 lab=_62808_/X }
C {devices/lab_pin.sym} 44860 -38770 0 0 {name=p44011 lab=_62768_/X }
C {devices/lab_pin.sym} 44860 -38730 0 0 {name=p44012 lab=_62759_/X }
C {devices/lab_pin.sym} 44860 -38700 0 0 {name=p44013 lab=_62809_/X }
C {devices/lab_pin.sym} 45020 -38770 0 1 {name=p44014 lab=_62810_/Y }
C {sky130_stdcells/a41oi_4.sym} 44940 -38770 0 0 {name=X_62810_ }
C {devices/lab_pin.sym} 44860 -38630 0 0 {name=p44015 lab=_86602_/Q }
C {devices/lab_pin.sym} 44860 -38590 0 0 {name=p44016 lab=_47714_/X }
C {devices/lab_pin.sym} 44860 -38550 0 0 {name=p44017 lab=_47743_/Y }
C {devices/lab_pin.sym} 45020 -38590 0 1 {name=p44018 lab=_47744_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -38590 0 0 {name=X_47744_ }
C {devices/lab_pin.sym} 44880 -38460 0 0 {name=p44019 lab=_82515_/Q }
C {devices/lab_pin.sym} 44880 -38420 0 0 {name=p44020 lab=_82771_/D }
C {devices/lab_pin.sym} 45000 -38440 0 1 {name=p44021 lab=_78564_/X }
C {sky130_stdcells/xor2_4.sym} 44940 -38440 0 0 {name=X_78564_ }
C {devices/lab_pin.sym} 44900 -38310 0 0 {name=p44022 lab=clkbuf_6_60_0_CLK/X }
C {devices/lab_pin.sym} 44980 -38310 0 1 {name=p44023 lab=clkbuf_8_243_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 44940 -38310 0 0 {name=Xclkbuf_7_121_0_CLK }
C {devices/lab_pin.sym} 44860 -38210 0 0 {name=p44024 lab=_85245_/Q }
C {devices/lab_pin.sym} 44860 -38170 0 0 {name=p44025 lab=_44874_/X }
C {devices/lab_pin.sym} 44860 -38130 0 0 {name=p44026 lab=_44926_/X }
C {devices/lab_pin.sym} 45020 -38170 0 1 {name=p44027 lab=_44956_/X }
C {sky130_stdcells/o21a_4.sym} 44940 -38170 0 0 {name=X_44956_ }
C {devices/lab_pin.sym} 44900 -38030 0 0 {name=p44028 lab=_61003_/A }
C {devices/lab_pin.sym} 44980 -38030 0 1 {name=p44029 lab=_63790_/X }
C {sky130_stdcells/buf_2.sym} 44940 -38030 0 0 {name=X_63790_ }
C {devices/lab_pin.sym} 44880 -37920 0 0 {name=p44030 lab=_75771_/Y }
C {devices/lab_pin.sym} 44880 -37880 0 0 {name=p44031 lab=_75775_/Y }
C {devices/lab_pin.sym} 45000 -37900 0 1 {name=p44032 lab=_80888_/D }
C {sky130_stdcells/xor2_4.sym} 44940 -37900 0 0 {name=X_75776_ }
C {devices/lab_pin.sym} 44900 -37770 0 0 {name=p44033 lab=_72720_/A }
C {devices/lab_pin.sym} 44980 -37770 0 1 {name=p44034 lab=_72988_/X }
C {sky130_stdcells/buf_2.sym} 44940 -37770 0 0 {name=X_72988_ }
C {devices/lab_pin.sym} 44880 -37660 0 0 {name=p44035 lab=_81941_/Q }
C {devices/lab_pin.sym} 44880 -37620 0 0 {name=p44036 lab=_82197_/D }
C {devices/lab_pin.sym} 45000 -37640 0 1 {name=p44037 lab=_81909_/D }
C {sky130_stdcells/xor2_4.sym} 44940 -37640 0 0 {name=X_77515_ }
C {devices/lab_pin.sym} 44900 -37510 0 0 {name=p44038 lab=_43842_/A }
C {devices/lab_pin.sym} 44980 -37510 0 1 {name=p44039 lab=_43907_/X }
C {sky130_stdcells/buf_2.sym} 44940 -37510 0 0 {name=X_43907_ }
C {devices/lab_pin.sym} 44900 -37390 0 0 {name=p44040 lab=_62679_/X }
C {devices/lab_pin.sym} 44980 -37390 0 1 {name=p44041 lab=_62743_/B }
C {sky130_stdcells/buf_2.sym} 44940 -37390 0 0 {name=X_62741_ }
C {devices/lab_pin.sym} 44880 -37300 0 0 {name=p44042 lab=_74727_/A }
C {devices/lab_pin.sym} 44880 -37260 0 0 {name=p44043 lab=_74796_/C }
C {devices/lab_pin.sym} 44880 -37220 0 0 {name=p44044 lab=_71738_/X }
C {devices/lab_pin.sym} 44880 -37180 0 0 {name=p44045 lab=_71016_/A }
C {devices/lab_pin.sym} 45000 -37240 0 1 {name=p44046 lab=_74730_/C }
C {sky130_stdcells/nand4_4.sym} 44940 -37240 0 0 {name=X_74727_ }
C {devices/lab_pin.sym} 44900 -37090 0 0 {name=p44047 lab=_47675_/A }
C {devices/lab_pin.sym} 44980 -37090 0 1 {name=p44048 lab=_53181_/D }
C {sky130_stdcells/buf_2.sym} 44940 -37090 0 0 {name=X_47675_ }
C {devices/lab_pin.sym} 44900 -36970 0 0 {name=p44049 lab=_71938_/Y }
C {devices/lab_pin.sym} 44980 -36970 0 1 {name=p44050 lab=_71939_/X }
C {sky130_stdcells/buf_2.sym} 44940 -36970 0 0 {name=X_71939_ }
C {devices/lab_pin.sym} 44880 -36860 0 0 {name=p44051 lab=_78486_/Y }
C {devices/lab_pin.sym} 44880 -36820 0 0 {name=p44052 lab=_78515_/A }
C {devices/lab_pin.sym} 45000 -36840 0 1 {name=p44053 lab=_78499_/A }
C {sky130_stdcells/xor2_4.sym} 44940 -36840 0 0 {name=X_78495_ }
C {devices/lab_pin.sym} 44900 -36710 0 0 {name=p44054 lab=_80672_/Q }
C {devices/lab_pin.sym} 44980 -36710 0 1 {name=p44055 lab=_44887_/X }
C {sky130_stdcells/buf_2.sym} 44940 -36710 0 0 {name=X_44887_ }
C {devices/lab_pin.sym} 44900 -36590 0 0 {name=p44056 lab=clkbuf_9_45_0_CLK/X }
C {devices/lab_pin.sym} 44980 -36590 0 1 {name=p44057 lab=_84421_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44940 -36590 0 0 {name=Xclkbuf_10_91_0_CLK }
C {devices/lab_pin.sym} 44860 -36490 0 0 {name=p44058 lab=_49411_/Y }
C {devices/lab_pin.sym} 44860 -36450 0 0 {name=p44059 lab=_49405_/X }
C {devices/lab_pin.sym} 44860 -36410 0 0 {name=p44060 lab=_49413_/X }
C {devices/lab_pin.sym} 45020 -36450 0 1 {name=p44061 lab=_49414_/Y }
C {sky130_stdcells/a21oi_4.sym} 44940 -36450 0 0 {name=X_49414_ }
C {devices/lab_pin.sym} 44880 -36320 0 0 {name=p44062 lab=_46651_/A }
C {devices/lab_pin.sym} 44880 -36280 0 0 {name=p44063 lab=_46625_/X }
C {devices/lab_pin.sym} 45000 -36300 0 1 {name=p44064 lab=_46626_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -36300 0 0 {name=X_46626_ }
C {devices/lab_pin.sym} 44860 -36200 0 0 {name=p44065 lab=_65428_/X }
C {devices/lab_pin.sym} 44860 -36160 0 0 {name=p44066 lab=_83079_/Q }
C {devices/lab_pin.sym} 44860 -36120 0 0 {name=p44067 lab=_65407_/X }
C {devices/lab_pin.sym} 44860 -36080 0 0 {name=p44068 lab=_65459_/X }
C {devices/lab_pin.sym} 45020 -36140 0 1 {name=p44069 lab=_65461_/B }
C {sky130_stdcells/a211o_4.sym} 44940 -36140 0 0 {name=X_65460_ }
C {devices/lab_pin.sym} 44900 -35990 0 0 {name=p44070 lab=_77446_/A }
C {devices/lab_pin.sym} 44980 -35990 0 1 {name=p44071 lab=_77446_/Y }
C {sky130_stdcells/inv_2.sym} 44940 -35990 0 0 {name=X_77446_ }
C {devices/lab_pin.sym} 44860 -35900 0 0 {name=p44072 lab=_41169_/X }
C {devices/lab_pin.sym} 44860 -35860 0 0 {name=p44073 lab=_43832_/X }
C {devices/lab_pin.sym} 44860 -35820 0 0 {name=p44074 lab=_87240_/Q }
C {devices/lab_pin.sym} 44860 -35780 0 0 {name=p44075 lab=_43833_/X }
C {devices/lab_pin.sym} 45020 -35840 0 1 {name=p44076 lab=_43838_/X }
C {sky130_stdcells/a2bb2o_4.sym} 44940 -35840 0 0 {name=X_43838_ }
C {devices/lab_pin.sym} 44900 -35690 0 0 {name=p44077 lab=_62672_/A }
C {devices/lab_pin.sym} 44980 -35690 0 1 {name=p44078 lab=_62673_/B }
C {sky130_stdcells/buf_2.sym} 44940 -35690 0 0 {name=X_62672_ }
C {devices/lab_pin.sym} 44860 -35590 0 0 {name=p44079 lab=_56666_/Y }
C {devices/lab_pin.sym} 44860 -35550 0 0 {name=p44080 lab=_74656_/X }
C {devices/lab_pin.sym} 44860 -35510 0 0 {name=p44081 lab=_74657_/Y }
C {devices/lab_pin.sym} 45020 -35550 0 1 {name=p44082 lab=_74659_/A }
C {sky130_stdcells/a21bo_4.sym} 44940 -35550 0 0 {name=X_74658_ }
C {devices/lab_pin.sym} 44880 -35430 0 0 {name=p44083 lab=_64377_/X }
C {devices/lab_pin.sym} 44880 -35390 0 0 {name=p44084 lab=_64411_/B }
C {devices/lab_pin.sym} 44880 -35350 0 0 {name=p44085 lab=_64391_/X }
C {devices/lab_pin.sym} 45000 -35390 0 1 {name=p44086 lab=_64411_/X }
C {sky130_stdcells/and3_4.sym} 44940 -35390 0 0 {name=X_64411_ }
C {devices/lab_pin.sym} 44860 -35270 0 0 {name=p44087 lab=_65343_/B }
C {devices/lab_pin.sym} 44860 -35230 0 0 {name=p44088 lab=_49334_/X }
C {devices/lab_pin.sym} 44860 -35190 0 0 {name=p44089 lab=_49344_/Y }
C {devices/lab_pin.sym} 45020 -35230 0 1 {name=p44090 lab=_49345_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -35230 0 0 {name=X_49345_ }
C {devices/lab_pin.sym} 44860 -35130 0 0 {name=p44091 lab=_61617_/Y }
C {devices/lab_pin.sym} 44860 -35090 0 0 {name=p44092 lab=_61619_/Y }
C {devices/lab_pin.sym} 44860 -35050 0 0 {name=p44093 lab=_61583_/Y }
C {devices/lab_pin.sym} 44860 -35010 0 0 {name=p44094 lab=_61620_/Y }
C {devices/lab_pin.sym} 44860 -34980 0 0 {name=p44095 lab=_61622_/Y }
C {devices/lab_pin.sym} 45020 -35050 0 1 {name=p44096 lab=_61623_/X }
C {sky130_stdcells/a41o_4.sym} 44940 -35050 0 0 {name=X_61623_ }
C {devices/lab_pin.sym} 44900 -34890 0 0 {name=p44097 lab=_74012_/A }
C {devices/lab_pin.sym} 44980 -34890 0 1 {name=p44098 lab=_73609_/X }
C {sky130_stdcells/buf_2.sym} 44940 -34890 0 0 {name=X_73609_ }
C {devices/lab_pin.sym} 44860 -34790 0 0 {name=p44099 lab=_86726_/Q }
C {devices/lab_pin.sym} 44860 -34750 0 0 {name=p44100 lab=_46543_/X }
C {devices/lab_pin.sym} 44860 -34710 0 0 {name=p44101 lab=_46556_/Y }
C {devices/lab_pin.sym} 45020 -34750 0 1 {name=p44102 lab=_46557_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -34750 0 0 {name=X_46557_ }
C {devices/lab_pin.sym} 44900 -34610 0 0 {name=p44103 lab=_64991_/A }
C {devices/lab_pin.sym} 44980 -34610 0 1 {name=p44104 lab=_65391_/X }
C {sky130_stdcells/buf_2.sym} 44940 -34610 0 0 {name=X_65391_ }
C {devices/lab_pin.sym} 44860 -34510 0 0 {name=p44105 lab=_77367_/X }
C {devices/lab_pin.sym} 44860 -34470 0 0 {name=p44106 lab=_82220_/Q }
C {devices/lab_pin.sym} 44860 -34430 0 0 {name=p44107 lab=_77376_/Y }
C {devices/lab_pin.sym} 45020 -34470 0 1 {name=p44108 lab=_77386_/A }
C {sky130_stdcells/a21boi_4.sym} 44940 -34470 0 0 {name=X_77377_ }
C {devices/lab_pin.sym} 44860 -34360 0 0 {name=p44109 lab=_40982_/X }
C {devices/lab_pin.sym} 44860 -34320 0 0 {name=p44110 lab=_43752_/X }
C {devices/lab_pin.sym} 44860 -34280 0 0 {name=p44111 lab=_69262_/B }
C {devices/lab_pin.sym} 44860 -34240 0 0 {name=p44112 lab=_43753_/X }
C {devices/lab_pin.sym} 45020 -34300 0 1 {name=p44113 lab=_43769_/X }
C {sky130_stdcells/a2bb2o_4.sym} 44940 -34300 0 0 {name=X_43769_ }
C {devices/lab_pin.sym} 44860 -34180 0 0 {name=p44114 lab=_74575_/X }
C {devices/lab_pin.sym} 44860 -34140 0 0 {name=p44115 lab=_74583_/X }
C {devices/lab_pin.sym} 44860 -34100 0 0 {name=p44116 lab=_56099_/A }
C {devices/lab_pin.sym} 44860 -34060 0 0 {name=p44117 lab=_74584_/X }
C {devices/lab_pin.sym} 45020 -34120 0 1 {name=p44118 lab=_74589_/X }
C {sky130_stdcells/a211o_4.sym} 44940 -34120 0 0 {name=X_74589_ }
C {devices/lab_pin.sym} 44900 -33970 0 0 {name=p44119 lab=clkbuf_opt_9_CLK/A }
C {devices/lab_pin.sym} 44980 -33970 0 1 {name=p44120 lab=_84888_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 44940 -33970 0 0 {name=Xclkbuf_opt_8_CLK }
C {devices/lab_pin.sym} 44880 -33860 0 0 {name=p44121 lab=_67130_/A }
C {devices/lab_pin.sym} 44880 -33820 0 0 {name=p44122 lab=_67129_/X }
C {devices/lab_pin.sym} 45000 -33840 0 1 {name=p44123 lab=_67130_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -33840 0 0 {name=X_67130_ }
C {devices/lab_pin.sym} 44900 -33710 0 0 {name=p44124 lab=_78960_/Y }
C {devices/lab_pin.sym} 44980 -33710 0 1 {name=p44125 lab=_82515_/D }
C {sky130_stdcells/inv_2.sym} 44940 -33710 0 0 {name=X_79116_ }
C {devices/lab_pin.sym} 44860 -33610 0 0 {name=p44126 lab=_85146_/Q }
C {devices/lab_pin.sym} 44860 -33570 0 0 {name=p44127 lab=_45507_/X }
C {devices/lab_pin.sym} 44860 -33530 0 0 {name=p44128 lab=_45429_/X }
C {devices/lab_pin.sym} 45020 -33570 0 1 {name=p44129 lab=_45508_/X }
C {sky130_stdcells/o21a_4.sym} 44940 -33570 0 0 {name=X_45508_ }
C {devices/lab_pin.sym} 44880 -33460 0 0 {name=p44130 lab=_64304_/A }
C {devices/lab_pin.sym} 44880 -33420 0 0 {name=p44131 lab=_64303_/X }
C {devices/lab_pin.sym} 44880 -33380 0 0 {name=p44132 lab=_57664_/A }
C {devices/lab_pin.sym} 44880 -33340 0 0 {name=p44133 lab=_64318_/D }
C {devices/lab_pin.sym} 45000 -33400 0 1 {name=p44134 lab=_64342_/X }
C {sky130_stdcells/and4_4.sym} 44940 -33400 0 0 {name=X_64342_ }
C {devices/lab_pin.sym} 44880 -33260 0 0 {name=p44135 lab=_76328_/A }
C {devices/lab_pin.sym} 44880 -33220 0 0 {name=p44136 lab=_81518_/D }
C {devices/lab_pin.sym} 45000 -33240 0 1 {name=p44137 lab=_76328_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -33240 0 0 {name=X_76328_ }
C {devices/lab_pin.sym} 44860 -33130 0 0 {name=p44138 lab=_86419_/Q }
C {devices/lab_pin.sym} 44860 -33090 0 0 {name=p44139 lab=_49255_/X }
C {devices/lab_pin.sym} 44860 -33050 0 0 {name=p44140 lab=_49275_/Y }
C {devices/lab_pin.sym} 45020 -33090 0 1 {name=p44141 lab=_49276_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -33090 0 0 {name=X_49276_ }
C {devices/lab_pin.sym} 44860 -32990 0 0 {name=p44142 lab=_61548_/Y }
C {devices/lab_pin.sym} 44860 -32950 0 0 {name=p44143 lab=_61550_/Y }
C {devices/lab_pin.sym} 44860 -32910 0 0 {name=p44144 lab=_61525_/X }
C {devices/lab_pin.sym} 44860 -32870 0 0 {name=p44145 lab=_61551_/Y }
C {devices/lab_pin.sym} 44860 -32840 0 0 {name=p44146 lab=_61553_/Y }
C {devices/lab_pin.sym} 45020 -32910 0 1 {name=p44147 lab=_61554_/X }
C {sky130_stdcells/a41o_4.sym} 44940 -32910 0 0 {name=X_61554_ }
C {devices/lab_pin.sym} 44860 -32770 0 0 {name=p44148 lab=_46479_/Y }
C {devices/lab_pin.sym} 44860 -32730 0 0 {name=p44149 lab=_46445_/X }
C {devices/lab_pin.sym} 44860 -32690 0 0 {name=p44150 lab=_46487_/X }
C {devices/lab_pin.sym} 45020 -32730 0 1 {name=p44151 lab=_46488_/Y }
C {sky130_stdcells/a21oi_4.sym} 44940 -32730 0 0 {name=X_46488_ }
C {devices/lab_pin.sym} 44900 -32590 0 0 {name=p44152 lab=_49173_/A }
C {devices/lab_pin.sym} 44980 -32590 0 1 {name=p44153 lab=_48229_/A }
C {sky130_stdcells/buf_2.sym} 44940 -32590 0 0 {name=X_48227_ }
C {devices/lab_pin.sym} 44860 -32490 0 0 {name=p44154 lab=_60566_/A }
C {devices/lab_pin.sym} 44860 -32450 0 0 {name=p44155 lab=_60595_/C }
C {devices/lab_pin.sym} 44860 -32410 0 0 {name=p44156 lab=_59512_/A }
C {devices/lab_pin.sym} 45020 -32450 0 1 {name=p44157 lab=_60586_/D }
C {sky130_stdcells/a21oi_4.sym} 44940 -32450 0 0 {name=X_60505_ }
C {devices/lab_pin.sym} 44860 -32330 0 0 {name=p44158 lab=_67058_/X }
C {devices/lab_pin.sym} 44860 -32290 0 0 {name=p44159 lab=_67060_/X }
C {devices/lab_pin.sym} 44860 -32250 0 0 {name=p44160 lab=_66964_/X }
C {devices/lab_pin.sym} 45020 -32290 0 1 {name=p44161 lab=_67061_/X }
C {sky130_stdcells/a21o_4.sym} 44940 -32290 0 0 {name=X_67061_ }
C {devices/lab_pin.sym} 44900 -32150 0 0 {name=p44162 lab=clkbuf_8_253_0_CLK/A }
C {devices/lab_pin.sym} 44980 -32150 0 1 {name=p44163 lab=clkbuf_9_505_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 44940 -32150 0 0 {name=Xclkbuf_8_252_0_CLK }
C {devices/lab_pin.sym} 44880 -32040 0 0 {name=p44164 lab=_82748_/Q }
C {devices/lab_pin.sym} 44880 -32000 0 0 {name=p44165 lab=_79047_/B }
C {devices/lab_pin.sym} 45000 -32020 0 1 {name=p44166 lab=_82716_/D }
C {sky130_stdcells/xor2_4.sym} 44940 -32020 0 0 {name=X_79047_ }
C {devices/lab_pin.sym} 44900 -31890 0 0 {name=p44167 lab=_45596_/A }
C {devices/lab_pin.sym} 44980 -31890 0 1 {name=p44168 lab=_45439_/X }
C {sky130_stdcells/buf_2.sym} 44940 -31890 0 0 {name=X_45439_ }
C {devices/lab_pin.sym} 44880 -31800 0 0 {name=p44169 lab=_64273_/A }
C {devices/lab_pin.sym} 44880 -31760 0 0 {name=p44170 lab=_64273_/B }
C {devices/lab_pin.sym} 44880 -31720 0 0 {name=p44171 lab=_84900_/Q }
C {devices/lab_pin.sym} 44880 -31680 0 0 {name=p44172 lab=_64304_/D }
C {devices/lab_pin.sym} 45000 -31740 0 1 {name=p44173 lab=_64273_/X }
C {sky130_stdcells/and4_4.sym} 44940 -31740 0 0 {name=X_64273_ }
C {devices/lab_pin.sym} 44880 -31600 0 0 {name=p44174 lab=_81353_/Q }
C {devices/lab_pin.sym} 44880 -31560 0 0 {name=p44175 lab=_76258_/Y }
C {devices/lab_pin.sym} 45000 -31580 0 1 {name=p44176 lab=_81321_/D }
C {sky130_stdcells/xor2_4.sym} 44940 -31580 0 0 {name=X_76259_ }
C {devices/lab_pin.sym} 44900 -31450 0 0 {name=p44177 lab=_61485_/A }
C {devices/lab_pin.sym} 44980 -31450 0 1 {name=p44178 lab=_61485_/Y }
C {sky130_stdcells/inv_2.sym} 44940 -31450 0 0 {name=X_61485_ }
C {devices/lab_pin.sym} 44880 -31340 0 0 {name=p44179 lab=_66011_/X }
C {devices/lab_pin.sym} 44880 -31300 0 0 {name=p44180 lab=_86554_/Q }
C {devices/lab_pin.sym} 45000 -31320 0 1 {name=p44181 lab=_66012_/X }
C {sky130_stdcells/and2_4.sym} 44940 -31320 0 0 {name=X_66012_ }
C {devices/lab_pin.sym} 44900 -31190 0 0 {name=p44182 lab=_60466_/X }
C {devices/lab_pin.sym} 44980 -31190 0 1 {name=p44183 lab=_63312_/C }
C {sky130_stdcells/buf_2.sym} 44940 -31190 0 0 {name=X_63224_ }
C {devices/lab_pin.sym} 44860 -31090 0 0 {name=p44184 lab=_46301_/X }
C {devices/lab_pin.sym} 44860 -31050 0 0 {name=p44185 lab=_82338_/Q }
C {devices/lab_pin.sym} 44860 -31010 0 0 {name=p44186 lab=_48157_/X }
C {devices/lab_pin.sym} 45020 -31050 0 1 {name=p44187 lab=_52093_/A }
C {sky130_stdcells/o21ai_4.sym} 44940 -31050 0 0 {name=X_48158_ }
C {devices/lab_pin.sym} 44860 -30930 0 0 {name=p44188 lab=_79156_/A }
C {devices/lab_pin.sym} 44860 -30890 0 0 {name=p44189 lab=_60074_/X }
C {devices/lab_pin.sym} 44860 -30850 0 0 {name=p44190 lab=_60435_/Y }
C {devices/lab_pin.sym} 45020 -30890 0 1 {name=p44191 lab=_60436_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -30890 0 0 {name=X_60436_ }
C {devices/lab_pin.sym} 44880 -30760 0 0 {name=p44192 lab=_47109_/A }
C {devices/lab_pin.sym} 44880 -30720 0 0 {name=p44193 lab=_52859_/B }
C {devices/lab_pin.sym} 45000 -30740 0 1 {name=p44194 lab=_47109_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -30740 0 0 {name=X_47109_ }
C {devices/lab_pin.sym} 44880 -30640 0 0 {name=p44195 lab=_63154_/X }
C {devices/lab_pin.sym} 44880 -30600 0 0 {name=p44196 lab=_64364_/B }
C {devices/lab_pin.sym} 44880 -30560 0 0 {name=p44197 lab=_63108_/C }
C {devices/lab_pin.sym} 44880 -30520 0 0 {name=p44198 lab=_63121_/D }
C {devices/lab_pin.sym} 45000 -30580 0 1 {name=p44199 lab=_63155_/X }
C {sky130_stdcells/and4_4.sym} 44940 -30580 0 0 {name=X_63155_ }
C {devices/lab_pin.sym} 44860 -30450 0 0 {name=p44200 lab=_48084_/Y }
C {devices/lab_pin.sym} 44860 -30410 0 0 {name=p44201 lab=_48055_/X }
C {devices/lab_pin.sym} 44860 -30370 0 0 {name=p44202 lab=_48088_/X }
C {devices/lab_pin.sym} 45020 -30410 0 1 {name=p44203 lab=_48089_/Y }
C {sky130_stdcells/a21oi_4.sym} 44940 -30410 0 0 {name=X_48089_ }
C {devices/lab_pin.sym} 44880 -30300 0 0 {name=p44204 lab=_60267_/X }
C {devices/lab_pin.sym} 44880 -30260 0 0 {name=p44205 lab=_60367_/B }
C {devices/lab_pin.sym} 44880 -30220 0 0 {name=p44206 lab=_60367_/C }
C {devices/lab_pin.sym} 44880 -30180 0 0 {name=p44207 lab=_60367_/D }
C {devices/lab_pin.sym} 45000 -30240 0 1 {name=p44208 lab=_60367_/Y }
C {sky130_stdcells/nand4_4.sym} 44940 -30240 0 0 {name=X_60367_ }
C {devices/lab_pin.sym} 44880 -30100 0 0 {name=p44209 lab=_50120_/A }
C {devices/lab_pin.sym} 44880 -30060 0 0 {name=p44210 lab=_49015_/X }
C {devices/lab_pin.sym} 45000 -30080 0 1 {name=p44211 lab=_50120_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -30080 0 0 {name=X_50120_ }
C {devices/lab_pin.sym} 44900 -29950 0 0 {name=p44212 lab=_59684_/X }
C {devices/lab_pin.sym} 44980 -29950 0 1 {name=p44213 lab=_62170_/B }
C {sky130_stdcells/buf_2.sym} 44940 -29950 0 0 {name=X_62106_ }
C {devices/lab_pin.sym} 44900 -29830 0 0 {name=p44214 lab=clkbuf_9_131_0_CLK/X }
C {devices/lab_pin.sym} 44980 -29830 0 1 {name=p44215 lab=_83451_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44940 -29830 0 0 {name=Xclkbuf_10_262_0_CLK }
C {devices/lab_pin.sym} 44860 -29740 0 0 {name=p44216 lab=_87897_/Q }
C {devices/lab_pin.sym} 44860 -29700 0 0 {name=p44217 lab=_67888_/X }
C {devices/lab_pin.sym} 44860 -29660 0 0 {name=p44218 lab=_67865_/X }
C {devices/lab_pin.sym} 44860 -29620 0 0 {name=p44219 lab=_67962_/X }
C {devices/lab_pin.sym} 45020 -29680 0 1 {name=p44220 lab=_67963_/X }
C {sky130_stdcells/a211o_4.sym} 44940 -29680 0 0 {name=X_67963_ }
C {devices/lab_pin.sym} 44900 -29530 0 0 {name=p44221 lab=_60503_/X }
C {devices/lab_pin.sym} 44980 -29530 0 1 {name=p44222 lab=_63088_/A }
C {sky130_stdcells/buf_2.sym} 44940 -29530 0 0 {name=X_63086_ }
C {devices/lab_pin.sym} 44880 -29420 0 0 {name=p44223 lab=_79947_/Y }
C {devices/lab_pin.sym} 44880 -29380 0 0 {name=p44224 lab=_79948_/Y }
C {devices/lab_pin.sym} 45000 -29400 0 1 {name=p44225 lab=_79949_/X }
C {sky130_stdcells/xor2_4.sym} 44940 -29400 0 0 {name=X_79949_ }
C {devices/lab_pin.sym} 44880 -29290 0 0 {name=p44226 lab=_60402_/A }
C {devices/lab_pin.sym} 44880 -29250 0 0 {name=p44227 lab=_60406_/B }
C {devices/lab_pin.sym} 44880 -29210 0 0 {name=p44228 lab=_60298_/C }
C {devices/lab_pin.sym} 45000 -29250 0 1 {name=p44229 lab=_60299_/C }
C {sky130_stdcells/and3_4.sym} 44940 -29250 0 0 {name=X_60298_ }
C {devices/lab_pin.sym} 44900 -29110 0 0 {name=p44230 lab=clkbuf_9_446_0_CLK/X }
C {devices/lab_pin.sym} 44980 -29110 0 1 {name=p44231 lab=_86139_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44940 -29110 0 0 {name=Xclkbuf_10_892_0_CLK }
C {devices/lab_pin.sym} 44860 -29010 0 0 {name=p44232 lab=_69699_/X }
C {devices/lab_pin.sym} 44860 -28970 0 0 {name=p44233 lab=_69701_/X }
C {devices/lab_pin.sym} 44860 -28930 0 0 {name=p44234 lab=_66579_/X }
C {devices/lab_pin.sym} 45020 -28970 0 1 {name=p44235 lab=_69702_/X }
C {sky130_stdcells/a21o_4.sym} 44940 -28970 0 0 {name=X_69702_ }
C {devices/lab_pin.sym} 44860 -28850 0 0 {name=p44236 lab=_50049_/Y }
C {devices/lab_pin.sym} 44860 -28810 0 0 {name=p44237 lab=_50029_/X }
C {devices/lab_pin.sym} 44860 -28770 0 0 {name=p44238 lab=_50050_/X }
C {devices/lab_pin.sym} 45020 -28810 0 1 {name=p44239 lab=_86274_/D }
C {sky130_stdcells/a21oi_4.sym} 44940 -28810 0 0 {name=X_50051_ }
C {devices/lab_pin.sym} 44900 -28670 0 0 {name=p44240 lab=_68392_/A }
C {devices/lab_pin.sym} 44980 -28670 0 1 {name=p44241 lab=_66915_/A }
C {sky130_stdcells/buf_2.sym} 44940 -28670 0 0 {name=X_66914_ }
C {devices/lab_pin.sym} 44900 -28550 0 0 {name=p44242 lab=_62094_/B }
C {devices/lab_pin.sym} 44980 -28550 0 1 {name=p44243 lab=_62037_/X }
C {sky130_stdcells/buf_2.sym} 44940 -28550 0 0 {name=X_62037_ }
C {devices/lab_pin.sym} 44850 -28430 0 0 {name=p44244 lab=_82769_/CLK }
C {devices/lab_pin.sym} 44850 -28410 0 0 {name=p44245 lab=_82960_/D }
C {devices/lab_pin.sym} 45030 -28430 0 1 {name=p44246 lab=_82960_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -28420 0 0 {name=X_82960_ }
C {devices/lab_pin.sym} 44900 -28290 0 0 {name=p44247 lab=_67657_/X }
C {devices/lab_pin.sym} 44980 -28290 0 1 {name=p44248 lab=_67992_/A }
C {sky130_stdcells/buf_2.sym} 44940 -28290 0 0 {name=X_67894_ }
C {devices/lab_pin.sym} 44900 -28170 0 0 {name=p44249 lab=clkbuf_9_22_0_CLK/X }
C {devices/lab_pin.sym} 44980 -28170 0 1 {name=p44250 lab=_85049_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44940 -28170 0 0 {name=Xclkbuf_10_44_0_CLK }
C {devices/lab_pin.sym} 44900 -28050 0 0 {name=p44251 lab=clkbuf_9_382_0_CLK/A }
C {devices/lab_pin.sym} 44980 -28050 0 1 {name=p44252 lab=clkbuf_9_383_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 44940 -28050 0 0 {name=Xclkbuf_9_383_0_CLK }
C {devices/lab_pin.sym} 44850 -27930 0 0 {name=p44253 lab=_82005_/CLK }
C {devices/lab_pin.sym} 44850 -27910 0 0 {name=p44254 lab=_81911_/D }
C {devices/lab_pin.sym} 45030 -27930 0 1 {name=p44255 lab=_82287_/D }
C {sky130_stdcells/dfxtp_4.sym} 44940 -27920 0 0 {name=X_81911_ }
C {devices/lab_pin.sym} 44880 -27800 0 0 {name=p44256 lab=_69633_/A }
C {devices/lab_pin.sym} 44880 -27760 0 0 {name=p44257 lab=_87310_/Q }
C {devices/lab_pin.sym} 45000 -27780 0 1 {name=p44258 lab=_69633_/X }
C {sky130_stdcells/and2_4.sym} 44940 -27780 0 0 {name=X_69633_ }
C {devices/lab_pin.sym} 44880 -27660 0 0 {name=p44259 lab=_66823_/A }
C {devices/lab_pin.sym} 44880 -27620 0 0 {name=p44260 lab=_66845_/B }
C {devices/lab_pin.sym} 45000 -27640 0 1 {name=p44261 lab=_66845_/X }
C {sky130_stdcells/and2_4.sym} 44940 -27640 0 0 {name=X_66845_ }
C {devices/lab_pin.sym} 44850 -27510 0 0 {name=p44262 lab=_87926_/CLK }
C {devices/lab_pin.sym} 44850 -27490 0 0 {name=p44263 lab=_78144_/B }
C {devices/lab_pin.sym} 45030 -27510 0 1 {name=p44264 lab=_82891_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -27500 0 0 {name=X_82891_ }
C {devices/lab_pin.sym} 44900 -27370 0 0 {name=p44265 lab=clkbuf_9_138_0_CLK/X }
C {devices/lab_pin.sym} 44980 -27370 0 1 {name=p44266 lab=_85505_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44940 -27370 0 0 {name=Xclkbuf_10_277_0_CLK }
C {devices/lab_pin.sym} 44880 -27270 0 0 {name=p44267 lab=_52291_/A }
C {devices/lab_pin.sym} 44880 -27230 0 0 {name=p44268 lab=_53806_/B }
C {devices/lab_pin.sym} 44880 -27190 0 0 {name=p44269 lab=_53806_/C }
C {devices/lab_pin.sym} 45000 -27230 0 1 {name=p44270 lab=_53810_/X }
C {sky130_stdcells/and3_4.sym} 44940 -27230 0 0 {name=X_53810_ }
C {devices/lab_pin.sym} 44850 -27090 0 0 {name=p44271 lab=_84645_/CLK }
C {devices/lab_pin.sym} 44850 -27070 0 0 {name=p44272 lab=_60333_/Y }
C {devices/lab_pin.sym} 45030 -27090 0 1 {name=p44273 lab=_79680_/A }
C {sky130_stdcells/dfxtp_4.sym} 44940 -27080 0 0 {name=X_84630_ }
C {devices/lab_pin.sym} 44900 -26950 0 0 {name=p44274 lab=_69696_/A }
C {devices/lab_pin.sym} 44980 -26950 0 1 {name=p44275 lab=_69564_/X }
C {sky130_stdcells/buf_2.sym} 44940 -26950 0 0 {name=X_69564_ }
C {devices/lab_pin.sym} 44850 -26830 0 0 {name=p44276 lab=_81857_/CLK }
C {devices/lab_pin.sym} 44850 -26810 0 0 {name=p44277 lab=_81842_/D }
C {devices/lab_pin.sym} 45030 -26830 0 1 {name=p44278 lab=_77468_/A }
C {sky130_stdcells/dfxtp_4.sym} 44940 -26820 0 0 {name=X_81842_ }
C {devices/lab_pin.sym} 44880 -26700 0 0 {name=p44279 lab=_54790_/A }
C {devices/lab_pin.sym} 44880 -26660 0 0 {name=p44280 lab=_47526_/Y }
C {devices/lab_pin.sym} 45000 -26680 0 1 {name=p44281 lab=_54790_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -26680 0 0 {name=X_54790_ }
C {devices/lab_pin.sym} 44860 -26570 0 0 {name=p44282 lab=_66773_/X }
C {devices/lab_pin.sym} 44860 -26530 0 0 {name=p44283 lab=_66775_/X }
C {devices/lab_pin.sym} 44860 -26490 0 0 {name=p44284 lab=_66726_/X }
C {devices/lab_pin.sym} 45020 -26530 0 1 {name=p44285 lab=_66776_/X }
C {sky130_stdcells/a21o_4.sym} 44940 -26530 0 0 {name=X_66776_ }
C {devices/lab_pin.sym} 44900 -26390 0 0 {name=p44286 lab=_64067_/A }
C {devices/lab_pin.sym} 44980 -26390 0 1 {name=p44287 lab=_64052_/B }
C {sky130_stdcells/buf_2.sym} 44940 -26390 0 0 {name=X_63988_ }
C {devices/lab_pin.sym} 44860 -26290 0 0 {name=p44288 lab=_83972_/Q }
C {devices/lab_pin.sym} 44860 -26250 0 0 {name=p44289 lab=_68462_/X }
C {devices/lab_pin.sym} 44860 -26210 0 0 {name=p44290 lab=_68514_/X }
C {devices/lab_pin.sym} 45020 -26250 0 1 {name=p44291 lab=_68515_/X }
C {sky130_stdcells/a21bo_4.sym} 44940 -26250 0 0 {name=X_68515_ }
C {devices/lab_pin.sym} 44880 -26120 0 0 {name=p44292 lab=_53750_/A }
C {devices/lab_pin.sym} 44880 -26080 0 0 {name=p44293 lab=_48627_/A }
C {devices/lab_pin.sym} 45000 -26100 0 1 {name=p44294 lab=_53741_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -26100 0 0 {name=X_53741_ }
C {devices/lab_pin.sym} 44900 -25970 0 0 {name=p44295 lab=_84182_/Q }
C {devices/lab_pin.sym} 44980 -25970 0 1 {name=p44296 lab=_65728_/C }
C {sky130_stdcells/inv_2.sym} 44940 -25970 0 0 {name=X_65727_ }
C {devices/lab_pin.sym} 44850 -25850 0 0 {name=p44297 lab=_84562_/CLK }
C {devices/lab_pin.sym} 44850 -25830 0 0 {name=p44298 lab=_84561_/D }
C {devices/lab_pin.sym} 45030 -25850 0 1 {name=p44299 lab=_60810_/C }
C {sky130_stdcells/dfxtp_4.sym} 44940 -25840 0 0 {name=X_84561_ }
C {devices/lab_pin.sym} 44900 -25710 0 0 {name=p44300 lab=clkbuf_9_29_0_CLK/X }
C {devices/lab_pin.sym} 44980 -25710 0 1 {name=p44301 lab=_85037_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44940 -25710 0 0 {name=Xclkbuf_10_59_0_CLK }
C {devices/lab_pin.sym} 44880 -25620 0 0 {name=p44302 lab=_50963_/A }
C {devices/lab_pin.sym} 44880 -25580 0 0 {name=p44303 lab=_50941_/B }
C {devices/lab_pin.sym} 44880 -25540 0 0 {name=p44304 lab=_50963_/C }
C {devices/lab_pin.sym} 44880 -25500 0 0 {name=p44305 lab=_46736_/X }
C {devices/lab_pin.sym} 45000 -25560 0 1 {name=p44306 lab=_50953_/X }
C {sky130_stdcells/and4_4.sym} 44940 -25560 0 0 {name=X_50953_ }
C {devices/lab_pin.sym} 44900 -25410 0 0 {name=p44307 lab=_60360_/X }
C {devices/lab_pin.sym} 44980 -25410 0 1 {name=p44308 lab=_62939_/X }
C {sky130_stdcells/buf_2.sym} 44940 -25410 0 0 {name=X_62939_ }
C {devices/lab_pin.sym} 44850 -25290 0 0 {name=p44309 lab=_81575_/CLK }
C {devices/lab_pin.sym} 44850 -25270 0 0 {name=p44310 lab=_76054_/X }
C {devices/lab_pin.sym} 45030 -25290 0 1 {name=p44311 lab=_81773_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -25280 0 0 {name=X_81773_ }
C {devices/lab_pin.sym} 44860 -25180 0 0 {name=p44312 lab=_87513_/Q }
C {devices/lab_pin.sym} 44860 -25140 0 0 {name=p44313 lab=_69442_/X }
C {devices/lab_pin.sym} 44860 -25100 0 0 {name=p44314 lab=_69396_/X }
C {devices/lab_pin.sym} 44860 -25060 0 0 {name=p44315 lab=_69494_/X }
C {devices/lab_pin.sym} 45020 -25120 0 1 {name=p44316 lab=_69495_/X }
C {sky130_stdcells/a211o_4.sym} 44940 -25120 0 0 {name=X_69495_ }
C {devices/lab_pin.sym} 44850 -24970 0 0 {name=p44317 lab=_86301_/CLK }
C {devices/lab_pin.sym} 44850 -24950 0 0 {name=p44318 lab=_49917_/Y }
C {devices/lab_pin.sym} 45030 -24970 0 1 {name=p44319 lab=_72187_/B }
C {sky130_stdcells/dfxtp_4.sym} 44940 -24960 0 0 {name=X_86300_ }
C {devices/lab_pin.sym} 44900 -24830 0 0 {name=p44320 lab=clkbuf_9_398_0_CLK/A }
C {devices/lab_pin.sym} 44980 -24830 0 1 {name=p44321 lab=clkbuf_9_398_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 44940 -24830 0 0 {name=Xclkbuf_9_398_0_CLK }
C {devices/lab_pin.sym} 44850 -24710 0 0 {name=p44322 lab=_83507_/CLK }
C {devices/lab_pin.sym} 44850 -24690 0 0 {name=p44323 lab=_83512_/D }
C {devices/lab_pin.sym} 45030 -24710 0 1 {name=p44324 lab=_83512_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -24700 0 0 {name=X_83512_ }
C {devices/lab_pin.sym} 44900 -24570 0 0 {name=p44325 lab=clkbuf_8_205_0_CLK/A }
C {devices/lab_pin.sym} 44980 -24570 0 1 {name=p44326 lab=clkbuf_9_411_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 44940 -24570 0 0 {name=Xclkbuf_8_205_0_CLK }
C {devices/lab_pin.sym} 44880 -24480 0 0 {name=p44327 lab=_73024_/B }
C {devices/lab_pin.sym} 44880 -24440 0 0 {name=p44328 lab=_56460_/B }
C {devices/lab_pin.sym} 44880 -24400 0 0 {name=p44329 lab=_56370_/C }
C {devices/lab_pin.sym} 44880 -24360 0 0 {name=p44330 lab=_56460_/D }
C {devices/lab_pin.sym} 45000 -24420 0 1 {name=p44331 lab=_56463_/A }
C {sky130_stdcells/nand4_4.sym} 44940 -24420 0 0 {name=X_56460_ }
C {devices/lab_pin.sym} 44850 -24270 0 0 {name=p44332 lab=_80676_/CLK }
C {devices/lab_pin.sym} 44850 -24250 0 0 {name=p44333 lab=_75910_/X }
C {devices/lab_pin.sym} 45030 -24270 0 1 {name=p44334 lab=_80692_/D }
C {sky130_stdcells/dfxtp_4.sym} 44940 -24260 0 0 {name=X_80724_ }
C {devices/lab_pin.sym} 44880 -24140 0 0 {name=p44335 lab=_68446_/A }
C {devices/lab_pin.sym} 44880 -24100 0 0 {name=p44336 lab=_68445_/X }
C {devices/lab_pin.sym} 45000 -24120 0 1 {name=p44337 lab=_68446_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -24120 0 0 {name=X_68446_ }
C {devices/lab_pin.sym} 44900 -23990 0 0 {name=p44338 lab=clkbuf_9_100_0_CLK/X }
C {devices/lab_pin.sym} 44980 -23990 0 1 {name=p44339 lab=_81082_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44940 -23990 0 0 {name=Xclkbuf_10_200_0_CLK }
C {devices/lab_pin.sym} 44850 -23870 0 0 {name=p44340 lab=_88087_/CLK }
C {devices/lab_pin.sym} 44850 -23850 0 0 {name=p44341 lab=_87280_/D }
C {devices/lab_pin.sym} 45030 -23870 0 1 {name=p44342 lab=_69179_/B }
C {sky130_stdcells/dfxtp_4.sym} 44940 -23860 0 0 {name=X_87280_ }
C {devices/lab_pin.sym} 44880 -23750 0 0 {name=p44343 lab=_50447_/A }
C {devices/lab_pin.sym} 44880 -23710 0 0 {name=p44344 lab=_53666_/X }
C {devices/lab_pin.sym} 44880 -23670 0 0 {name=p44345 lab=_53692_/C }
C {devices/lab_pin.sym} 45000 -23710 0 1 {name=p44346 lab=_53672_/X }
C {sky130_stdcells/and3_4.sym} 44940 -23710 0 0 {name=X_53672_ }
C {devices/lab_pin.sym} 44860 -23600 0 0 {name=p44347 lab=_65503_/X }
C {devices/lab_pin.sym} 44860 -23560 0 0 {name=p44348 lab=_85586_/Q }
C {devices/lab_pin.sym} 44860 -23520 0 0 {name=p44349 lab=_65504_/X }
C {devices/lab_pin.sym} 44860 -23480 0 0 {name=p44350 lab=_65657_/X }
C {devices/lab_pin.sym} 45020 -23540 0 1 {name=p44351 lab=_65658_/X }
C {sky130_stdcells/a211o_4.sym} 44940 -23540 0 0 {name=X_65658_ }
C {devices/lab_pin.sym} 44850 -23390 0 0 {name=p44352 lab=_84520_/CLK }
C {devices/lab_pin.sym} 44850 -23370 0 0 {name=p44353 lab=_84492_/D }
C {devices/lab_pin.sym} 45030 -23390 0 1 {name=p44354 lab=_84492_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -23380 0 0 {name=X_84492_ }
C {devices/lab_pin.sym} 44880 -23260 0 0 {name=p44355 lab=_50906_/A }
C {devices/lab_pin.sym} 44880 -23220 0 0 {name=p44356 lab=_51744_/B }
C {devices/lab_pin.sym} 45000 -23240 0 1 {name=p44357 lab=_50884_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -23240 0 0 {name=X_50884_ }
C {devices/lab_pin.sym} 44880 -23120 0 0 {name=p44358 lab=_55410_/Y }
C {devices/lab_pin.sym} 44880 -23080 0 0 {name=p44359 lab=_55200_/C }
C {devices/lab_pin.sym} 45000 -23100 0 1 {name=p44360 lab=_55411_/Y }
C {sky130_stdcells/nand2_4.sym} 44940 -23100 0 0 {name=X_55411_ }
C {devices/lab_pin.sym} 44900 -22970 0 0 {name=p44361 lab=clkbuf_9_415_0_CLK/X }
C {devices/lab_pin.sym} 44980 -22970 0 1 {name=p44362 lab=_86753_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44940 -22970 0 0 {name=Xclkbuf_10_830_0_CLK }
C {devices/lab_pin.sym} 44850 -22850 0 0 {name=p44363 lab=_86235_/CLK }
C {devices/lab_pin.sym} 44850 -22830 0 0 {name=p44364 lab=_86231_/D }
C {devices/lab_pin.sym} 45030 -22850 0 1 {name=p44365 lab=_86231_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -22840 0 0 {name=X_86231_ }
C {devices/lab_pin.sym} 44860 -22730 0 0 {name=p44366 lab=_52617_/Y }
C {devices/lab_pin.sym} 44860 -22690 0 0 {name=p44367 lab=_52619_/X }
C {devices/lab_pin.sym} 44860 -22650 0 0 {name=p44368 lab=_52622_/X }
C {devices/lab_pin.sym} 45020 -22690 0 1 {name=p44369 lab=_85785_/D }
C {sky130_stdcells/a21oi_4.sym} 44940 -22690 0 0 {name=X_52623_ }
C {devices/lab_pin.sym} 44880 -22570 0 0 {name=p44370 lab=_66195_/B }
C {devices/lab_pin.sym} 44880 -22530 0 0 {name=p44371 lab=_64638_/B }
C {devices/lab_pin.sym} 44880 -22490 0 0 {name=p44372 lab=_84233_/Q }
C {devices/lab_pin.sym} 45000 -22530 0 1 {name=p44373 lab=_64609_/X }
C {sky130_stdcells/and3_4.sym} 44940 -22530 0 0 {name=X_64609_ }
C {devices/lab_pin.sym} 44850 -22390 0 0 {name=p44374 lab=_83763_/CLK }
C {devices/lab_pin.sym} 44850 -22370 0 0 {name=p44375 lab=_83443_/D }
C {devices/lab_pin.sym} 45030 -22390 0 1 {name=p44376 lab=_83443_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -22380 0 0 {name=X_83443_ }
C {devices/lab_pin.sym} 44860 -22270 0 0 {name=p44377 lab=_56031_/X }
C {devices/lab_pin.sym} 44860 -22230 0 0 {name=p44378 lab=_56378_/X }
C {devices/lab_pin.sym} 44860 -22190 0 0 {name=p44379 lab=_56390_/Y }
C {devices/lab_pin.sym} 45020 -22230 0 1 {name=p44380 lab=_85212_/D }
C {sky130_stdcells/o21ai_4.sym} 44940 -22230 0 0 {name=X_56391_ }
C {devices/lab_pin.sym} 44850 -22090 0 0 {name=p44381 lab=_86896_/CLK }
C {devices/lab_pin.sym} 44850 -22070 0 0 {name=p44382 lab=_80655_/D }
C {devices/lab_pin.sym} 45030 -22090 0 1 {name=p44383 lab=_80655_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -22080 0 0 {name=X_80655_ }
C {devices/lab_pin.sym} 44900 -21950 0 0 {name=p44384 lab=_68377_/A }
C {devices/lab_pin.sym} 44980 -21950 0 1 {name=p44385 lab=_68377_/X }
C {sky130_stdcells/buf_2.sym} 44940 -21950 0 0 {name=X_68377_ }
C {devices/lab_pin.sym} 44860 -21850 0 0 {name=p44386 lab=_65587_/Y }
C {devices/lab_pin.sym} 44860 -21810 0 0 {name=p44387 lab=_65529_/X }
C {devices/lab_pin.sym} 44860 -21770 0 0 {name=p44388 lab=_65588_/X }
C {devices/lab_pin.sym} 45020 -21810 0 1 {name=p44389 lab=_84191_/D }
C {sky130_stdcells/a21o_4.sym} 44940 -21810 0 0 {name=X_65589_ }
C {devices/lab_pin.sym} 44880 -21680 0 0 {name=p44390 lab=_57991_/A }
C {devices/lab_pin.sym} 44880 -21640 0 0 {name=p44391 lab=_58130_/B }
C {devices/lab_pin.sym} 45000 -21660 0 1 {name=p44392 lab=_58130_/Y }
C {sky130_stdcells/nor2_4.sym} 44940 -21660 0 0 {name=X_58130_ }
C {sky130_stdcells/decap_3.sym} 44940 -21500 0 0 {name=XPHY_305 }
C {devices/lab_pin.sym} 44900 -21350 0 0 {name=p44393 lab=_44059_/X }
C {devices/lab_pin.sym} 44980 -21350 0 1 {name=p44394 lab=_55342_/X }
C {sky130_stdcells/buf_2.sym} 44940 -21350 0 0 {name=X_55342_ }
C {devices/lab_pin.sym} 44860 -21250 0 0 {name=p44395 lab=_84074_/Q }
C {devices/lab_pin.sym} 44860 -21210 0 0 {name=p44396 lab=_67211_/X }
C {devices/lab_pin.sym} 44860 -21170 0 0 {name=p44397 lab=_67327_/X }
C {devices/lab_pin.sym} 45020 -21210 0 1 {name=p44398 lab=_84074_/D }
C {sky130_stdcells/a21bo_4.sym} 44940 -21210 0 0 {name=X_67328_ }
C {devices/lab_pin.sym} 44850 -21070 0 0 {name=p44399 lab=_83303_/CLK }
C {devices/lab_pin.sym} 44850 -21050 0 0 {name=p44400 lab=_50641_/Y }
C {devices/lab_pin.sym} 45030 -21070 0 1 {name=p44401 lab=_86162_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -21060 0 0 {name=X_86162_ }
C {devices/lab_pin.sym} 44900 -20930 0 0 {name=p44402 lab=clkbuf_8_160_0_CLK/X }
C {devices/lab_pin.sym} 44980 -20930 0 1 {name=p44403 lab=clkbuf_9_321_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 44940 -20930 0 0 {name=Xclkbuf_9_321_0_CLK }
C {sky130_stdcells/decap_3.sym} 44940 -20780 0 0 {name=XPHY_316 }
C {devices/lab_pin.sym} 44860 -20650 0 0 {name=p44404 lab=_52552_/Y }
C {devices/lab_pin.sym} 44860 -20610 0 0 {name=p44405 lab=_52541_/X }
C {devices/lab_pin.sym} 44860 -20570 0 0 {name=p44406 lab=_52553_/Y }
C {devices/lab_pin.sym} 45020 -20610 0 1 {name=p44407 lab=_52554_/Y }
C {sky130_stdcells/a21boi_4.sym} 44940 -20610 0 0 {name=X_52554_ }
C {devices/lab_pin.sym} 44850 -20470 0 0 {name=p44408 lab=_83372_/CLK }
C {devices/lab_pin.sym} 44850 -20450 0 0 {name=p44409 lab=_71793_/Y }
C {devices/lab_pin.sym} 45030 -20470 0 1 {name=p44410 lab=_58196_/A }
C {sky130_stdcells/dfxtp_4.sym} 44940 -20460 0 0 {name=X_83374_ }
C {sky130_stdcells/decap_3.sym} 44940 -20300 0 0 {name=XPHY_327 }
C {devices/lab_pin.sym} 44860 -20170 0 0 {name=p44411 lab=_80580_/A }
C {devices/lab_pin.sym} 44860 -20130 0 0 {name=p44412 lab=_80580_/B }
C {devices/lab_pin.sym} 44860 -20090 0 0 {name=p44413 lab=_80585_/Y }
C {devices/lab_pin.sym} 45020 -20130 0 1 {name=p44414 lab=_80608_/A }
C {sky130_stdcells/a21boi_4.sym} 44940 -20130 0 0 {name=X_80586_ }
C {sky130_stdcells/decap_3.sym} 44940 -19960 0 0 {name=XPHY_338 }
C {devices/lab_pin.sym} 44850 -19810 0 0 {name=p44415 lab=_85057_/CLK }
C {devices/lab_pin.sym} 44850 -19790 0 0 {name=p44416 lab=_85113_/D }
C {devices/lab_pin.sym} 45030 -19810 0 1 {name=p44417 lab=_85113_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -19800 0 0 {name=X_85113_ }
C {sky130_stdcells/decap_3.sym} 44940 -19640 0 0 {name=XPHY_349 }
C {devices/lab_pin.sym} 44880 -19520 0 0 {name=p44418 lab=_51509_/A }
C {devices/lab_pin.sym} 44880 -19480 0 0 {name=p44419 lab=_51527_/B }
C {devices/lab_pin.sym} 44880 -19440 0 0 {name=p44420 lab=_51522_/C }
C {devices/lab_pin.sym} 44880 -19400 0 0 {name=p44421 lab=_53031_/D }
C {devices/lab_pin.sym} 45000 -19460 0 1 {name=p44422 lab=_51505_/X }
C {sky130_stdcells/and4_4.sym} 44940 -19460 0 0 {name=X_51505_ }
C {devices/lab_pin.sym} 44860 -19350 0 0 {name=p44423 lab=_58010_/X }
C {devices/lab_pin.sym} 44860 -19310 0 0 {name=p44424 lab=_58058_/Y }
C {devices/lab_pin.sym} 44860 -19270 0 0 {name=p44425 lab=_58060_/Y }
C {devices/lab_pin.sym} 44860 -19230 0 0 {name=p44426 lab=_58028_/X }
C {devices/lab_pin.sym} 44860 -19190 0 0 {name=p44427 lab=_58015_/X }
C {devices/lab_pin.sym} 45020 -19270 0 1 {name=p44428 lab=_58061_/X }
C {sky130_stdcells/o32a_4.sym} 44940 -19270 0 0 {name=X_58061_ }
C {devices/lab_pin.sym} 44900 -19110 0 0 {name=p44429 lab=clkbuf_9_107_0_CLK/X }
C {devices/lab_pin.sym} 44980 -19110 0 1 {name=p44430 lab=_84620_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44940 -19110 0 0 {name=Xclkbuf_10_215_0_CLK }
C {devices/lab_pin.sym} 44850 -18990 0 0 {name=p44431 lab=_82327_/CLK }
C {devices/lab_pin.sym} 44850 -18970 0 0 {name=p44432 lab=_77139_/B }
C {devices/lab_pin.sym} 45030 -18990 0 1 {name=p44433 lab=_82325_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -18980 0 0 {name=X_82325_ }
C {devices/lab_pin.sym} 44880 -18860 0 0 {name=p44434 lab=_55252_/A }
C {devices/lab_pin.sym} 44880 -18820 0 0 {name=p44435 lab=_56887_/B }
C {devices/lab_pin.sym} 45000 -18840 0 1 {name=p44436 lab=_55273_/X }
C {sky130_stdcells/and2_4.sym} 44940 -18840 0 0 {name=X_55273_ }
C {devices/lab_pin.sym} 44880 -18720 0 0 {name=p44437 lab=_67259_/A }
C {devices/lab_pin.sym} 44880 -18680 0 0 {name=p44438 lab=_67259_/B }
C {devices/lab_pin.sym} 45000 -18700 0 1 {name=p44439 lab=_67259_/X }
C {sky130_stdcells/and2_4.sym} 44940 -18700 0 0 {name=X_67259_ }
C {devices/lab_pin.sym} 44850 -18570 0 0 {name=p44440 lab=_85773_/CLK }
C {devices/lab_pin.sym} 44850 -18550 0 0 {name=p44441 lab=_86093_/D }
C {devices/lab_pin.sym} 45030 -18570 0 1 {name=p44442 lab=_86093_/Q }
C {sky130_stdcells/dfxtp_4.sym} 44940 -18560 0 0 {name=X_86093_ }
C {devices/lab_pin.sym} 44860 -18450 0 0 {name=p44443 lab=_85812_/Q }
C {devices/lab_pin.sym} 44860 -18410 0 0 {name=p44444 lab=_52470_/X }
C {devices/lab_pin.sym} 44860 -18370 0 0 {name=p44445 lab=_52484_/Y }
C {devices/lab_pin.sym} 45020 -18410 0 1 {name=p44446 lab=_52485_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -18410 0 0 {name=X_52485_ }
C {devices/lab_pin.sym} 44900 -18270 0 0 {name=p44447 lab=clkbuf_9_422_0_CLK/X }
C {devices/lab_pin.sym} 44980 -18270 0 1 {name=p44448 lab=_82975_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 44940 -18270 0 0 {name=Xclkbuf_10_845_0_CLK }
C {devices/lab_pin.sym} 44880 -18160 0 0 {name=p44449 lab=_57010_/Y }
C {devices/lab_pin.sym} 44880 -18120 0 0 {name=p44450 lab=_57011_/Y }
C {devices/lab_pin.sym} 45000 -18140 0 1 {name=p44451 lab=_57012_/Y }
C {sky130_stdcells/nor2_4.sym} 44940 -18140 0 0 {name=X_57012_ }
C {devices/lab_pin.sym} 44860 -18030 0 0 {name=p44452 lab=_85481_/Q }
C {devices/lab_pin.sym} 44860 -17990 0 0 {name=p44453 lab=_54220_/X }
C {devices/lab_pin.sym} 44860 -17950 0 0 {name=p44454 lab=_54223_/Y }
C {devices/lab_pin.sym} 45020 -17990 0 1 {name=p44455 lab=_54224_/Y }
C {sky130_stdcells/o21ai_4.sym} 44940 -17990 0 0 {name=X_54224_ }
C {devices/lab_pin.sym} 44850 -17850 0 0 {name=p44456 lab=_85075_/CLK }
