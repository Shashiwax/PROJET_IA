C {devices/lab_pin.sym} 4380 -1090 0 0 {name=p4552 lab=_66423_/Y }
C {devices/lab_pin.sym} 4380 -1050 0 0 {name=p4553 lab=_65842_/X }
C {devices/lab_pin.sym} 4540 -1090 0 1 {name=p4554 lab=_66424_/Y }
C {sky130_stdcells/a21oi_4.sym} 4460 -1090 0 0 {name=X_66424_ }
C {devices/lab_pin.sym} 4380 -970 0 0 {name=p4555 lab=_85971_/Q }
C {devices/lab_pin.sym} 4380 -930 0 0 {name=p4556 lab=_51647_/X }
C {devices/lab_pin.sym} 4380 -890 0 0 {name=p4557 lab=_51649_/Y }
C {devices/lab_pin.sym} 4540 -930 0 1 {name=p4558 lab=_51650_/Y }
C {sky130_stdcells/o21ai_4.sym} 4460 -930 0 0 {name=X_51650_ }
C {devices/lab_pin.sym} 4400 -810 0 0 {name=p4559 lab=_63615_/A }
C {devices/lab_pin.sym} 4400 -770 0 0 {name=p4560 lab=_63615_/B }
C {devices/lab_pin.sym} 4400 -730 0 0 {name=p4561 lab=_63636_/C }
C {devices/lab_pin.sym} 4520 -770 0 1 {name=p4562 lab=_63636_/Y }
C {sky130_stdcells/nor3_4.sym} 4460 -770 0 0 {name=X_63636_ }
C {devices/lab_pin.sym} 5290 -42150 0 0 {name=p4563 lab=_82675_/CLK }
C {devices/lab_pin.sym} 5290 -42130 0 0 {name=p4564 lab=_82470_/D }
C {devices/lab_pin.sym} 5470 -42150 0 1 {name=p4565 lab=_78290_/B }
C {sky130_stdcells/dfxtp_4.sym} 5380 -42140 0 0 {name=X_82470_ }
C {devices/lab_pin.sym} 5340 -42010 0 0 {name=p4566 lab=_60848_/A }
C {devices/lab_pin.sym} 5420 -42010 0 1 {name=p4567 lab=_60857_/D }
C {sky130_stdcells/buf_2.sym} 5380 -42010 0 0 {name=X_60848_ }
C {devices/lab_pin.sym} 5320 -41900 0 0 {name=p4568 lab=_50580_/A }
C {devices/lab_pin.sym} 5320 -41860 0 0 {name=p4569 lab=_71994_/B }
C {devices/lab_pin.sym} 5440 -41880 0 1 {name=p4570 lab=_50601_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -41880 0 0 {name=X_50601_ }
C {devices/lab_pin.sym} 5290 -41750 0 0 {name=p4571 lab=_82648_/CLK }
C {devices/lab_pin.sym} 5290 -41730 0 0 {name=p4572 lab=_81453_/Q }
C {devices/lab_pin.sym} 5470 -41750 0 1 {name=p4573 lab=_81421_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -41740 0 0 {name=X_81421_ }
C {devices/lab_pin.sym} 5300 -41630 0 0 {name=p4574 lab=_69139_/X }
C {devices/lab_pin.sym} 5300 -41590 0 0 {name=p4575 lab=_69141_/X }
C {devices/lab_pin.sym} 5300 -41550 0 0 {name=p4576 lab=_69142_/X }
C {devices/lab_pin.sym} 5460 -41590 0 1 {name=p4577 lab=_69143_/Y }
C {sky130_stdcells/a21oi_4.sym} 5380 -41590 0 0 {name=X_69143_ }
C {devices/lab_pin.sym} 5320 -41460 0 0 {name=p4578 lab=_66352_/X }
C {devices/lab_pin.sym} 5320 -41420 0 0 {name=p4579 lab=_66354_/X }
C {devices/lab_pin.sym} 5440 -41440 0 1 {name=p4580 lab=_66355_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -41440 0 0 {name=X_66355_ }
C {devices/lab_pin.sym} 5300 -41330 0 0 {name=p4581 lab=_51578_/Y }
C {devices/lab_pin.sym} 5300 -41290 0 0 {name=p4582 lab=_51557_/X }
C {devices/lab_pin.sym} 5300 -41250 0 0 {name=p4583 lab=_51580_/X }
C {devices/lab_pin.sym} 5460 -41290 0 1 {name=p4584 lab=_51581_/Y }
C {sky130_stdcells/a21oi_4.sym} 5380 -41290 0 0 {name=X_51581_ }
C {devices/lab_pin.sym} 5320 -41170 0 0 {name=p4585 lab=_63554_/A }
C {devices/lab_pin.sym} 5320 -41130 0 0 {name=p4586 lab=_63554_/B }
C {devices/lab_pin.sym} 5320 -41090 0 0 {name=p4587 lab=_80455_/B }
C {devices/lab_pin.sym} 5440 -41130 0 1 {name=p4588 lab=_63567_/Y }
C {sky130_stdcells/nor3_4.sym} 5380 -41130 0 0 {name=X_63567_ }
C {devices/lab_pin.sym} 5300 -41030 0 0 {name=p4589 lab=_61075_/C }
C {devices/lab_pin.sym} 5300 -40990 0 0 {name=p4590 lab=_60629_/Y }
C {devices/lab_pin.sym} 5300 -40950 0 0 {name=p4591 lab=_60616_/Y }
C {devices/lab_pin.sym} 5300 -40910 0 0 {name=p4592 lab=_60644_/C }
C {devices/lab_pin.sym} 5300 -40880 0 0 {name=p4593 lab=_60667_/A }
C {devices/lab_pin.sym} 5460 -40950 0 1 {name=p4594 lab=_63371_/A }
C {sky130_stdcells/a41oi_4.sym} 5380 -40950 0 0 {name=X_60779_ }
C {devices/lab_pin.sym} 5340 -40790 0 0 {name=p4595 lab=clkbuf_4_5_0_CLK/A }
C {devices/lab_pin.sym} 5420 -40790 0 1 {name=p4596 lab=clkbuf_4_5_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 5380 -40790 0 0 {name=Xclkbuf_4_5_0_CLK }
C {devices/lab_pin.sym} 5340 -40670 0 0 {name=p4597 lab=_51842_/A }
C {devices/lab_pin.sym} 5420 -40670 0 1 {name=p4598 lab=_53347_/A }
C {sky130_stdcells/buf_2.sym} 5380 -40670 0 0 {name=X_53320_ }
C {devices/lab_pin.sym} 5340 -40550 0 0 {name=p4599 lab=_64961_/A }
C {devices/lab_pin.sym} 5420 -40550 0 1 {name=p4600 lab=_65307_/A }
C {sky130_stdcells/buf_2.sym} 5380 -40550 0 0 {name=X_65306_ }
C {devices/lab_pin.sym} 5290 -40430 0 0 {name=p4601 lab=_84220_/CLK }
C {devices/lab_pin.sym} 5290 -40410 0 0 {name=p4602 lab=_84140_/D }
C {devices/lab_pin.sym} 5470 -40430 0 1 {name=p4603 lab=_84140_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -40420 0 0 {name=X_84140_ }
C {devices/lab_pin.sym} 5300 -40310 0 0 {name=p4604 lab=_50529_/Y }
C {devices/lab_pin.sym} 5300 -40270 0 0 {name=p4605 lab=_50525_/X }
C {devices/lab_pin.sym} 5300 -40230 0 0 {name=p4606 lab=_50531_/X }
C {devices/lab_pin.sym} 5460 -40270 0 1 {name=p4607 lab=_86183_/D }
C {sky130_stdcells/a21oi_4.sym} 5380 -40270 0 0 {name=X_50532_ }
C {devices/lab_pin.sym} 5340 -40130 0 0 {name=p4608 lab=_62517_/Y }
C {devices/lab_pin.sym} 5420 -40130 0 1 {name=p4609 lab=_64454_/A }
C {sky130_stdcells/buf_2.sym} 5380 -40130 0 0 {name=X_62518_ }
C {devices/lab_pin.sym} 5290 -40010 0 0 {name=p4610 lab=_81352_/CLK }
C {devices/lab_pin.sym} 5290 -39990 0 0 {name=p4611 lab=_76696_/X }
C {devices/lab_pin.sym} 5470 -40010 0 1 {name=p4612 lab=_81352_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -40000 0 0 {name=X_81352_ }
C {devices/lab_pin.sym} 5300 -39900 0 0 {name=p4613 lab=_44745_/A }
C {devices/lab_pin.sym} 5300 -39860 0 0 {name=p4614 lab=_68864_/X }
C {devices/lab_pin.sym} 5300 -39820 0 0 {name=p4615 lab=_68891_/X }
C {devices/lab_pin.sym} 5300 -39780 0 0 {name=p4616 lab=_69073_/X }
C {devices/lab_pin.sym} 5460 -39840 0 1 {name=p4617 lab=_69074_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -39840 0 0 {name=X_69074_ }
C {devices/lab_pin.sym} 5300 -39720 0 0 {name=p4618 lab=_64722_/X }
C {devices/lab_pin.sym} 5300 -39680 0 0 {name=p4619 lab=_85607_/Q }
C {devices/lab_pin.sym} 5300 -39640 0 0 {name=p4620 lab=_64724_/X }
C {devices/lab_pin.sym} 5300 -39600 0 0 {name=p4621 lab=_66285_/X }
C {devices/lab_pin.sym} 5460 -39660 0 1 {name=p4622 lab=_66286_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -39660 0 0 {name=X_66286_ }
C {devices/lab_pin.sym} 5340 -39510 0 0 {name=p4623 lab=_63372_/A }
C {devices/lab_pin.sym} 5420 -39510 0 1 {name=p4624 lab=_63498_/X }
C {sky130_stdcells/buf_2.sym} 5380 -39510 0 0 {name=X_63498_ }
C {devices/lab_pin.sym} 5320 -39400 0 0 {name=p4625 lab=_80301_/Y }
C {devices/lab_pin.sym} 5320 -39360 0 0 {name=p4626 lab=_80303_/B }
C {devices/lab_pin.sym} 5440 -39380 0 1 {name=p4627 lab=_80304_/B }
C {sky130_stdcells/nand2_4.sym} 5380 -39380 0 0 {name=X_80303_ }
C {devices/lab_pin.sym} 5320 -39260 0 0 {name=p4628 lab=_68025_/A }
C {devices/lab_pin.sym} 5320 -39220 0 0 {name=p4629 lab=_88150_/Q }
C {devices/lab_pin.sym} 5440 -39240 0 1 {name=p4630 lab=_68025_/X }
C {sky130_stdcells/and2_4.sym} 5380 -39240 0 0 {name=X_68025_ }
C {devices/lab_pin.sym} 5320 -39120 0 0 {name=p4631 lab=_53259_/A }
C {devices/lab_pin.sym} 5320 -39080 0 0 {name=p4632 lab=_51728_/B }
C {devices/lab_pin.sym} 5440 -39100 0 1 {name=p4633 lab=_53251_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -39100 0 0 {name=X_53251_ }
C {devices/lab_pin.sym} 5300 -39000 0 0 {name=p4634 lab=_65211_/X }
C {devices/lab_pin.sym} 5300 -38960 0 0 {name=p4635 lab=_85513_/Q }
C {devices/lab_pin.sym} 5300 -38920 0 0 {name=p4636 lab=_65212_/X }
C {devices/lab_pin.sym} 5300 -38880 0 0 {name=p4637 lab=_65236_/X }
C {devices/lab_pin.sym} 5460 -38940 0 1 {name=p4638 lab=_65237_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -38940 0 0 {name=X_65237_ }
C {devices/lab_pin.sym} 5290 -38790 0 0 {name=p4639 lab=_81461_/CLK }
C {devices/lab_pin.sym} 5290 -38770 0 0 {name=p4640 lab=_67404_/X }
C {devices/lab_pin.sym} 5470 -38790 0 1 {name=p4641 lab=_84071_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -38780 0 0 {name=X_84071_ }
C {devices/lab_pin.sym} 5300 -38670 0 0 {name=p4642 lab=_50459_/Y }
C {devices/lab_pin.sym} 5300 -38630 0 0 {name=p4643 lab=_50455_/X }
C {devices/lab_pin.sym} 5300 -38590 0 0 {name=p4644 lab=_50462_/X }
C {devices/lab_pin.sym} 5460 -38630 0 1 {name=p4645 lab=_50463_/Y }
C {sky130_stdcells/a21oi_4.sym} 5380 -38630 0 0 {name=X_50463_ }
C {devices/lab_pin.sym} 5340 -38490 0 0 {name=p4646 lab=_62534_/A }
C {devices/lab_pin.sym} 5420 -38490 0 1 {name=p4647 lab=_62449_/X }
C {sky130_stdcells/buf_2.sym} 5380 -38490 0 0 {name=X_62449_ }
C {devices/lab_pin.sym} 5290 -38370 0 0 {name=p4648 lab=_81794_/CLK }
C {devices/lab_pin.sym} 5290 -38350 0 0 {name=p4649 lab=_76971_/X }
C {devices/lab_pin.sym} 5470 -38370 0 1 {name=p4650 lab=_81283_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -38360 0 0 {name=X_81283_ }
C {devices/lab_pin.sym} 5300 -38250 0 0 {name=p4651 lab=_85869_/Q }
C {devices/lab_pin.sym} 5300 -38210 0 0 {name=p4652 lab=_52178_/X }
C {devices/lab_pin.sym} 5300 -38170 0 0 {name=p4653 lab=_52201_/Y }
C {devices/lab_pin.sym} 5460 -38210 0 1 {name=p4654 lab=_52202_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -38210 0 0 {name=X_52202_ }
C {devices/lab_pin.sym} 5290 -38070 0 0 {name=p4655 lab=_83022_/CLK }
C {devices/lab_pin.sym} 5290 -38050 0 0 {name=p4656 lab=_83022_/D }
C {devices/lab_pin.sym} 5470 -38070 0 1 {name=p4657 lab=_45196_/A }
C {sky130_stdcells/dfxtp_4.sym} 5380 -38060 0 0 {name=X_83022_ }
C {devices/lab_pin.sym} 5320 -37940 0 0 {name=p4658 lab=_80230_/Y }
C {devices/lab_pin.sym} 5320 -37900 0 0 {name=p4659 lab=_80233_/Y }
C {devices/lab_pin.sym} 5440 -37920 0 1 {name=p4660 lab=_80244_/B }
C {sky130_stdcells/xor2_4.sym} 5380 -37920 0 0 {name=X_80234_ }
C {devices/lab_pin.sym} 5300 -37810 0 0 {name=p4661 lab=_53180_/Y }
C {devices/lab_pin.sym} 5300 -37770 0 0 {name=p4662 lab=_53163_/X }
C {devices/lab_pin.sym} 5300 -37730 0 0 {name=p4663 lab=_53181_/X }
C {devices/lab_pin.sym} 5460 -37770 0 1 {name=p4664 lab=_85682_/D }
C {sky130_stdcells/a21oi_4.sym} 5380 -37770 0 0 {name=X_53182_ }
C {devices/lab_pin.sym} 5340 -37630 0 0 {name=p4665 lab=_64739_/A }
C {devices/lab_pin.sym} 5420 -37630 0 1 {name=p4666 lab=_65397_/A }
C {sky130_stdcells/buf_2.sym} 5380 -37630 0 0 {name=X_65168_ }
C {devices/lab_pin.sym} 5300 -37530 0 0 {name=p4667 lab=_86209_/Q }
C {devices/lab_pin.sym} 5300 -37490 0 0 {name=p4668 lab=_50333_/X }
C {devices/lab_pin.sym} 5300 -37450 0 0 {name=p4669 lab=_50393_/Y }
C {devices/lab_pin.sym} 5460 -37490 0 1 {name=p4670 lab=_50394_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -37490 0 0 {name=X_50394_ }
C {devices/lab_pin.sym} 5300 -37370 0 0 {name=p4671 lab=_72957_/B }
C {devices/lab_pin.sym} 5300 -37330 0 0 {name=p4672 lab=_52125_/X }
C {devices/lab_pin.sym} 5300 -37290 0 0 {name=p4673 lab=_52132_/Y }
C {devices/lab_pin.sym} 5460 -37330 0 1 {name=p4674 lab=_52133_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -37330 0 0 {name=X_52133_ }
C {devices/lab_pin.sym} 5340 -37190 0 0 {name=p4675 lab=_64012_/A }
C {devices/lab_pin.sym} 5420 -37190 0 1 {name=p4676 lab=_64178_/C }
C {sky130_stdcells/buf_2.sym} 5380 -37190 0 0 {name=X_64119_ }
C {devices/lab_pin.sym} 5290 -37070 0 0 {name=p4677 lab=_87834_/CLK }
C {devices/lab_pin.sym} 5290 -37050 0 0 {name=p4678 lab=_87830_/D }
C {devices/lab_pin.sym} 5470 -37070 0 1 {name=p4679 lab=_74224_/A }
C {sky130_stdcells/dfxtp_4.sym} 5380 -37060 0 0 {name=X_87830_ }
C {devices/lab_pin.sym} 5320 -36940 0 0 {name=p4680 lab=_84945_/Q }
C {devices/lab_pin.sym} 5320 -36900 0 0 {name=p4681 lab=_65559_/C }
C {devices/lab_pin.sym} 5440 -36920 0 1 {name=p4682 lab=_80167_/A }
C {sky130_stdcells/xor2_4.sym} 5380 -36920 0 0 {name=X_80165_ }
C {devices/lab_pin.sym} 5340 -36790 0 0 {name=p4683 lab=_58749_/A }
C {devices/lab_pin.sym} 5420 -36790 0 1 {name=p4684 lab=_57991_/A }
C {sky130_stdcells/buf_2.sym} 5380 -36790 0 0 {name=X_57990_ }
C {devices/lab_pin.sym} 5340 -36670 0 0 {name=p4685 lab=_64797_/A }
C {devices/lab_pin.sym} 5420 -36670 0 1 {name=p4686 lab=_65099_/X }
C {sky130_stdcells/buf_2.sym} 5380 -36670 0 0 {name=X_65099_ }
C {devices/lab_pin.sym} 5300 -36580 0 0 {name=p4687 lab=_69943_/X }
C {devices/lab_pin.sym} 5300 -36540 0 0 {name=p4688 lab=_69974_/Y }
C {devices/lab_pin.sym} 5300 -36500 0 0 {name=p4689 lab=_69938_/X }
C {devices/lab_pin.sym} 5300 -36460 0 0 {name=p4690 lab=_69975_/Y }
C {devices/lab_pin.sym} 5460 -36520 0 1 {name=p4691 lab=_69976_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -36520 0 0 {name=X_69976_ }
C {devices/lab_pin.sym} 5320 -36380 0 0 {name=p4692 lab=_52070_/A }
C {devices/lab_pin.sym} 5320 -36340 0 0 {name=p4693 lab=_50365_/B }
C {devices/lab_pin.sym} 5440 -36360 0 1 {name=p4694 lab=_52064_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -36360 0 0 {name=X_52064_ }
C {devices/lab_pin.sym} 5340 -36230 0 0 {name=p4695 lab=_56940_/Y }
C {devices/lab_pin.sym} 5420 -36230 0 1 {name=p4696 lab=_57084_/A }
C {sky130_stdcells/buf_2.sym} 5380 -36230 0 0 {name=X_56941_ }
C {devices/lab_pin.sym} 5300 -36140 0 0 {name=p4697 lab=_68907_/X }
C {devices/lab_pin.sym} 5300 -36100 0 0 {name=p4698 lab=_68882_/X }
C {devices/lab_pin.sym} 5300 -36060 0 0 {name=p4699 lab=_68915_/Y }
C {devices/lab_pin.sym} 5300 -36020 0 0 {name=p4700 lab=_68926_/Y }
C {devices/lab_pin.sym} 5460 -36080 0 1 {name=p4701 lab=_68927_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -36080 0 0 {name=X_68927_ }
C {devices/lab_pin.sym} 5290 -35930 0 0 {name=p4702 lab=_87758_/CLK }
C {devices/lab_pin.sym} 5290 -35910 0 0 {name=p4703 lab=_87761_/D }
C {devices/lab_pin.sym} 5470 -35930 0 1 {name=p4704 lab=_68425_/B }
C {sky130_stdcells/dfxtp_4.sym} 5380 -35920 0 0 {name=X_87761_ }
C {devices/lab_pin.sym} 5290 -35790 0 0 {name=p4705 lab=_86541_/CLK }
C {devices/lab_pin.sym} 5290 -35770 0 0 {name=p4706 lab=_57594_/Y }
C {devices/lab_pin.sym} 5470 -35790 0 1 {name=p4707 lab=_84973_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -35780 0 0 {name=X_84973_ }
C {devices/lab_pin.sym} 5300 -35670 0 0 {name=p4708 lab=_80080_/Y }
C {devices/lab_pin.sym} 5300 -35630 0 0 {name=p4709 lab=_80083_/Y }
C {devices/lab_pin.sym} 5300 -35590 0 0 {name=p4710 lab=_80095_/X }
C {devices/lab_pin.sym} 5460 -35630 0 1 {name=p4711 lab=_80096_/X }
C {sky130_stdcells/a21o_4.sym} 5380 -35630 0 0 {name=X_80096_ }
C {devices/lab_pin.sym} 5300 -35510 0 0 {name=p4712 lab=_51009_/Y }
C {devices/lab_pin.sym} 5300 -35470 0 0 {name=p4713 lab=_51011_/X }
C {devices/lab_pin.sym} 5300 -35430 0 0 {name=p4714 lab=_51014_/X }
C {devices/lab_pin.sym} 5460 -35470 0 1 {name=p4715 lab=_86090_/D }
C {sky130_stdcells/a21oi_4.sym} 5380 -35470 0 0 {name=X_51015_ }
C {devices/lab_pin.sym} 5290 -35330 0 0 {name=p4716 lab=_86393_/CLK }
C {devices/lab_pin.sym} 5290 -35310 0 0 {name=p4717 lab=_46709_/Y }
C {devices/lab_pin.sym} 5470 -35330 0 1 {name=p4718 lab=_58677_/A }
C {sky130_stdcells/dfxtp_4.sym} 5380 -35320 0 0 {name=X_86712_ }
C {devices/lab_pin.sym} 5320 -35220 0 0 {name=p4719 lab=_60414_/B }
C {devices/lab_pin.sym} 5320 -35180 0 0 {name=p4720 lab=_60353_/B }
C {devices/lab_pin.sym} 5320 -35140 0 0 {name=p4721 lab=_59660_/C }
C {devices/lab_pin.sym} 5320 -35100 0 0 {name=p4722 lab=_59660_/D }
C {devices/lab_pin.sym} 5440 -35160 0 1 {name=p4723 lab=_59805_/A }
C {sky130_stdcells/and4_4.sym} 5380 -35160 0 0 {name=X_59660_ }
C {devices/lab_pin.sym} 5290 -35010 0 0 {name=p4724 lab=_81322_/CLK }
C {devices/lab_pin.sym} 5290 -34990 0 0 {name=p4725 lab=_83924_/D }
C {devices/lab_pin.sym} 5470 -35010 0 1 {name=p4726 lab=_81388_/D }
C {sky130_stdcells/dfxtp_4.sym} 5380 -35000 0 0 {name=X_83924_ }
C {devices/lab_pin.sym} 5300 -34890 0 0 {name=p4727 lab=_56688_/X }
C {devices/lab_pin.sym} 5300 -34850 0 0 {name=p4728 lab=_56867_/X }
C {devices/lab_pin.sym} 5300 -34810 0 0 {name=p4729 lab=_56871_/Y }
C {devices/lab_pin.sym} 5460 -34850 0 1 {name=p4730 lab=_56872_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -34850 0 0 {name=X_56872_ }
C {devices/lab_pin.sym} 5340 -34710 0 0 {name=p4731 lab=_87839_/Q }
C {devices/lab_pin.sym} 5420 -34710 0 1 {name=p4732 lab=_68859_/B }
C {sky130_stdcells/inv_2.sym} 5380 -34710 0 0 {name=X_68858_ }
C {devices/lab_pin.sym} 5290 -34590 0 0 {name=p4733 lab=_87126_/CLK }
C {devices/lab_pin.sym} 5290 -34570 0 0 {name=p4734 lab=_87692_/D }
C {devices/lab_pin.sym} 5470 -34590 0 1 {name=p4735 lab=_66745_/B }
C {sky130_stdcells/dfxtp_4.sym} 5380 -34580 0 0 {name=X_87692_ }
C {devices/lab_pin.sym} 5300 -34470 0 0 {name=p4736 lab=_58607_/Y }
C {devices/lab_pin.sym} 5300 -34430 0 0 {name=p4737 lab=_58609_/Y }
C {devices/lab_pin.sym} 5300 -34390 0 0 {name=p4738 lab=_58610_/X }
C {devices/lab_pin.sym} 5460 -34430 0 1 {name=p4739 lab=_58611_/X }
C {sky130_stdcells/a21o_4.sym} 5380 -34430 0 0 {name=X_58611_ }
C {devices/lab_pin.sym} 5320 -34300 0 0 {name=p4740 lab=_55817_/A }
C {devices/lab_pin.sym} 5320 -34260 0 0 {name=p4741 lab=_55823_/B }
C {devices/lab_pin.sym} 5440 -34280 0 1 {name=p4742 lab=_55823_/X }
C {sky130_stdcells/and2_4.sym} 5380 -34280 0 0 {name=X_55823_ }
C {devices/lab_pin.sym} 5300 -34180 0 0 {name=p4743 lab=_87967_/Q }
C {devices/lab_pin.sym} 5300 -34140 0 0 {name=p4744 lab=_67713_/X }
C {devices/lab_pin.sym} 5300 -34100 0 0 {name=p4745 lab=_67761_/X }
C {devices/lab_pin.sym} 5300 -34060 0 0 {name=p4746 lab=_67808_/X }
C {devices/lab_pin.sym} 5460 -34120 0 1 {name=p4747 lab=_67809_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -34120 0 0 {name=X_67809_ }
C {devices/lab_pin.sym} 5290 -33970 0 0 {name=p4748 lab=_86005_/CLK }
C {devices/lab_pin.sym} 5290 -33950 0 0 {name=p4749 lab=_86643_/D }
C {devices/lab_pin.sym} 5470 -33970 0 1 {name=p4750 lab=_86643_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -33960 0 0 {name=X_86643_ }
C {devices/lab_pin.sym} 5290 -33830 0 0 {name=p4751 lab=_82536_/CLK }
C {devices/lab_pin.sym} 5290 -33810 0 0 {name=p4752 lab=_83855_/D }
C {devices/lab_pin.sym} 5470 -33830 0 1 {name=p4753 lab=_82535_/D }
C {sky130_stdcells/dfxtp_4.sym} 5380 -33820 0 0 {name=X_83855_ }
C {devices/lab_pin.sym} 5340 -33690 0 0 {name=p4754 lab=_59591_/A }
C {devices/lab_pin.sym} 5420 -33690 0 1 {name=p4755 lab=_59689_/A }
C {sky130_stdcells/buf_2.sym} 5380 -33690 0 0 {name=X_59591_ }
C {devices/lab_pin.sym} 5300 -33590 0 0 {name=p4756 lab=_83961_/Q }
C {devices/lab_pin.sym} 5300 -33550 0 0 {name=p4757 lab=_68713_/X }
C {devices/lab_pin.sym} 5300 -33510 0 0 {name=p4758 lab=_68788_/X }
C {devices/lab_pin.sym} 5460 -33550 0 1 {name=p4759 lab=_83961_/D }
C {sky130_stdcells/a21bo_4.sym} 5380 -33550 0 0 {name=X_68789_ }
C {devices/lab_pin.sym} 5320 -33430 0 0 {name=p4760 lab=_71219_/A }
C {devices/lab_pin.sym} 5320 -33390 0 0 {name=p4761 lab=_70952_/B }
C {devices/lab_pin.sym} 5320 -33350 0 0 {name=p4762 lab=_70703_/X }
C {devices/lab_pin.sym} 5440 -33390 0 1 {name=p4763 lab=_70820_/Y }
C {sky130_stdcells/nand3_4.sym} 5380 -33390 0 0 {name=X_70820_ }
C {devices/lab_pin.sym} 5300 -33270 0 0 {name=p4764 lab=_58538_/X }
C {devices/lab_pin.sym} 5300 -33230 0 0 {name=p4765 lab=_83360_/Q }
C {devices/lab_pin.sym} 5300 -33190 0 0 {name=p4766 lab=_58541_/Y }
C {devices/lab_pin.sym} 5460 -33230 0 1 {name=p4767 lab=_84824_/D }
C {sky130_stdcells/o21a_4.sym} 5380 -33230 0 0 {name=X_58542_ }
C {devices/lab_pin.sym} 5290 -33090 0 0 {name=p4768 lab=_82529_/CLK }
C {devices/lab_pin.sym} 5290 -33070 0 0 {name=p4769 lab=_82838_/Q }
C {devices/lab_pin.sym} 5470 -33090 0 1 {name=p4770 lab=_82806_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -33080 0 0 {name=X_82806_ }
C {devices/lab_pin.sym} 5300 -32980 0 0 {name=p4771 lab=_45290_/A }
C {devices/lab_pin.sym} 5300 -32940 0 0 {name=p4772 lab=_55190_/X }
C {devices/lab_pin.sym} 5300 -32900 0 0 {name=p4773 lab=_44095_/A }
C {devices/lab_pin.sym} 5300 -32860 0 0 {name=p4774 lab=_55753_/X }
C {devices/lab_pin.sym} 5460 -32920 0 1 {name=p4775 lab=_55754_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -32920 0 0 {name=X_55754_ }
C {devices/lab_pin.sym} 5290 -32770 0 0 {name=p4776 lab=_86530_/CLK }
C {devices/lab_pin.sym} 5290 -32750 0 0 {name=p4777 lab=_86574_/D }
C {devices/lab_pin.sym} 5470 -32770 0 1 {name=p4778 lab=_66183_/B }
C {sky130_stdcells/dfxtp_4.sym} 5380 -32760 0 0 {name=X_86574_ }
C {devices/lab_pin.sym} 5320 -32640 0 0 {name=p4779 lab=_82296_/Q }
C {devices/lab_pin.sym} 5320 -32600 0 0 {name=p4780 lab=_40932_/X }
C {devices/lab_pin.sym} 5440 -32620 0 1 {name=p4781 lab=_40980_/X }
C {sky130_stdcells/or2_4.sym} 5380 -32620 0 0 {name=X_40980_ }
C {devices/lab_pin.sym} 5300 -32510 0 0 {name=p4782 lab=_85722_/Q }
C {devices/lab_pin.sym} 5300 -32470 0 0 {name=p4783 lab=_52957_/X }
C {devices/lab_pin.sym} 5300 -32430 0 0 {name=p4784 lab=_52965_/Y }
C {devices/lab_pin.sym} 5460 -32470 0 1 {name=p4785 lab=_52966_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -32470 0 0 {name=X_52966_ }
C {devices/lab_pin.sym} 5290 -32330 0 0 {name=p4786 lab=_83787_/CLK }
C {devices/lab_pin.sym} 5290 -32310 0 0 {name=p4787 lab=_70351_/X }
C {devices/lab_pin.sym} 5470 -32330 0 1 {name=p4788 lab=_74727_/A }
C {sky130_stdcells/dfxtp_4.sym} 5380 -32320 0 0 {name=X_83786_ }
C {devices/lab_pin.sym} 5290 -32190 0 0 {name=p4789 lab=_82532_/CLK }
C {devices/lab_pin.sym} 5290 -32170 0 0 {name=p4790 lab=_84206_/Q }
C {devices/lab_pin.sym} 5470 -32190 0 1 {name=p4791 lab=_80998_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -32180 0 0 {name=X_80998_ }
C {devices/lab_pin.sym} 5290 -32050 0 0 {name=p4792 lab=_88324_/CLK }
C {devices/lab_pin.sym} 5290 -32030 0 0 {name=p4793 lab=_88313_/D }
C {devices/lab_pin.sym} 5470 -32050 0 1 {name=p4794 lab=_88313_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -32040 0 0 {name=X_88313_ }
C {devices/lab_pin.sym} 5320 -31920 0 0 {name=p4795 lab=_54718_/A }
C {devices/lab_pin.sym} 5320 -31880 0 0 {name=p4796 lab=_47372_/Y }
C {devices/lab_pin.sym} 5440 -31900 0 1 {name=p4797 lab=_54705_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -31900 0 0 {name=X_54705_ }
C {devices/lab_pin.sym} 5290 -31770 0 0 {name=p4798 lab=_85815_/CLK }
C {devices/lab_pin.sym} 5290 -31750 0 0 {name=p4799 lab=_85525_/D }
C {devices/lab_pin.sym} 5470 -31770 0 1 {name=p4800 lab=_85525_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -31760 0 0 {name=X_85525_ }
C {devices/lab_pin.sym} 5300 -31650 0 0 {name=p4801 lab=_85922_/Q }
C {devices/lab_pin.sym} 5300 -31610 0 0 {name=p4802 lab=_51900_/X }
C {devices/lab_pin.sym} 5300 -31570 0 0 {name=p4803 lab=_51916_/Y }
C {devices/lab_pin.sym} 5460 -31610 0 1 {name=p4804 lab=_51917_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -31610 0 0 {name=X_51917_ }
C {devices/lab_pin.sym} 5320 -31480 0 0 {name=p4805 lab=_70753_/A }
C {devices/lab_pin.sym} 5320 -31440 0 0 {name=p4806 lab=_70722_/A }
C {devices/lab_pin.sym} 5440 -31460 0 1 {name=p4807 lab=_70751_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -31460 0 0 {name=X_70751_ }
C {devices/lab_pin.sym} 5340 -31330 0 0 {name=p4808 lab=_64412_/C }
C {devices/lab_pin.sym} 5420 -31330 0 1 {name=p4809 lab=_58474_/A }
C {sky130_stdcells/buf_2.sym} 5380 -31330 0 0 {name=X_58473_ }
C {devices/lab_pin.sym} 5290 -31210 0 0 {name=p4810 lab=_81019_/CLK }
C {devices/lab_pin.sym} 5290 -31190 0 0 {name=p4811 lab=_84121_/Q }
C {devices/lab_pin.sym} 5470 -31210 0 1 {name=p4812 lab=_82737_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -31200 0 0 {name=X_82737_ }
C {devices/lab_pin.sym} 5340 -31070 0 0 {name=p4813 lab=_55684_/X }
C {devices/lab_pin.sym} 5420 -31070 0 1 {name=p4814 lab=_56171_/C }
C {sky130_stdcells/buf_2.sym} 5380 -31070 0 0 {name=X_55685_ }
C {devices/lab_pin.sym} 5320 -30960 0 0 {name=p4815 lab=_52885_/A }
C {devices/lab_pin.sym} 5320 -30920 0 0 {name=p4816 lab=_47174_/X }
C {devices/lab_pin.sym} 5440 -30940 0 1 {name=p4817 lab=_52897_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -30940 0 0 {name=X_52897_ }
C {devices/lab_pin.sym} 5340 -30810 0 0 {name=p4818 lab=_57423_/Y }
C {devices/lab_pin.sym} 5420 -30810 0 1 {name=p4819 lab=_85007_/D }
C {sky130_stdcells/inv_2.sym} 5380 -30810 0 0 {name=X_57424_ }
C {devices/lab_pin.sym} 5290 -30690 0 0 {name=p4820 lab=_82629_/CLK }
C {devices/lab_pin.sym} 5290 -30670 0 0 {name=p4821 lab=_88244_/D }
C {devices/lab_pin.sym} 5470 -30690 0 1 {name=p4822 lab=_69129_/B }
C {sky130_stdcells/dfxtp_4.sym} 5380 -30680 0 0 {name=X_88244_ }
C {devices/lab_pin.sym} 5340 -30550 0 0 {name=p4823 lab=_42649_/Y }
C {devices/lab_pin.sym} 5420 -30550 0 1 {name=p4824 lab=_42650_/Y }
C {sky130_stdcells/inv_2.sym} 5380 -30550 0 0 {name=X_42650_ }
C {devices/lab_pin.sym} 5320 -30440 0 0 {name=p4825 lab=_54636_/A }
C {devices/lab_pin.sym} 5320 -30400 0 0 {name=p4826 lab=_47260_/A }
C {devices/lab_pin.sym} 5440 -30420 0 1 {name=p4827 lab=_54636_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -30420 0 0 {name=X_54636_ }
C {devices/lab_pin.sym} 5290 -30290 0 0 {name=p4828 lab=_85459_/CLK }
C {devices/lab_pin.sym} 5290 -30270 0 0 {name=p4829 lab=_85456_/D }
C {devices/lab_pin.sym} 5470 -30290 0 1 {name=p4830 lab=_85456_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -30280 0 0 {name=X_85456_ }
C {devices/lab_pin.sym} 5320 -30160 0 0 {name=p4831 lab=_73353_/A }
C {devices/lab_pin.sym} 5320 -30120 0 0 {name=p4832 lab=_85861_/Q }
C {devices/lab_pin.sym} 5440 -30140 0 1 {name=p4833 lab=_73470_/X }
C {sky130_stdcells/and2_4.sym} 5380 -30140 0 0 {name=X_73470_ }
C {devices/lab_pin.sym} 5320 -30020 0 0 {name=p4834 lab=_51853_/A }
C {devices/lab_pin.sym} 5320 -29980 0 0 {name=p4835 lab=_50981_/B }
C {devices/lab_pin.sym} 5440 -30000 0 1 {name=p4836 lab=_51848_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -30000 0 0 {name=X_51848_ }
C {devices/lab_pin.sym} 5320 -29890 0 0 {name=p4837 lab=_70682_/A }
C {devices/lab_pin.sym} 5320 -29850 0 0 {name=p4838 lab=_70676_/B }
C {devices/lab_pin.sym} 5320 -29810 0 0 {name=p4839 lab=_70676_/C }
C {devices/lab_pin.sym} 5440 -29850 0 1 {name=p4840 lab=_70682_/Y }
C {sky130_stdcells/nor3_4.sym} 5380 -29850 0 0 {name=X_70682_ }
C {devices/lab_pin.sym} 5290 -29710 0 0 {name=p4841 lab=_82803_/CLK }
C {devices/lab_pin.sym} 5290 -29690 0 0 {name=p4842 lab=_82668_/D }
C {devices/lab_pin.sym} 5470 -29710 0 1 {name=p4843 lab=_82668_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -29700 0 0 {name=X_82668_ }
C {devices/lab_pin.sym} 5340 -29570 0 0 {name=p4844 lab=_41600_/Y }
C {devices/lab_pin.sym} 5420 -29570 0 1 {name=p4845 lab=_41601_/X }
C {sky130_stdcells/buf_2.sym} 5380 -29570 0 0 {name=X_41601_ }
C {devices/lab_pin.sym} 5300 -29470 0 0 {name=p4846 lab=_72419_/X }
C {devices/lab_pin.sym} 5300 -29430 0 0 {name=p4847 lab=_85352_/Q }
C {devices/lab_pin.sym} 5300 -29390 0 0 {name=p4848 lab=_72420_/X }
C {devices/lab_pin.sym} 5460 -29430 0 1 {name=p4849 lab=_72421_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -29430 0 0 {name=X_72421_ }
C {devices/lab_pin.sym} 5290 -29290 0 0 {name=p4850 lab=_84407_/CLK }
C {devices/lab_pin.sym} 5290 -29270 0 0 {name=p4851 lab=_84407_/D }
C {devices/lab_pin.sym} 5470 -29290 0 1 {name=p4852 lab=_62485_/C }
C {sky130_stdcells/dfxtp_4.sym} 5380 -29280 0 0 {name=X_84407_ }
C {devices/lab_pin.sym} 5320 -29160 0 0 {name=p4853 lab=_57236_/X }
C {devices/lab_pin.sym} 5320 -29120 0 0 {name=p4854 lab=_45811_/A }
C {devices/lab_pin.sym} 5440 -29140 0 1 {name=p4855 lab=_57355_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -29140 0 0 {name=X_57355_ }
C {devices/lab_pin.sym} 5290 -29010 0 0 {name=p4856 lab=_81259_/CLK }
C {devices/lab_pin.sym} 5290 -28990 0 0 {name=p4857 lab=_76407_/B }
C {devices/lab_pin.sym} 5470 -29010 0 1 {name=p4858 lab=_81619_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -29000 0 0 {name=X_81619_ }
C {devices/lab_pin.sym} 5290 -28870 0 0 {name=p4859 lab=_88175_/CLK }
C {devices/lab_pin.sym} 5290 -28850 0 0 {name=p4860 lab=_88175_/D }
C {devices/lab_pin.sym} 5470 -28870 0 1 {name=p4861 lab=_67434_/B }
C {sky130_stdcells/dfxtp_4.sym} 5380 -28860 0 0 {name=X_88175_ }
C {devices/lab_pin.sym} 5300 -28770 0 0 {name=p4862 lab=_42573_/X }
C {devices/lab_pin.sym} 5300 -28730 0 0 {name=p4863 lab=_42574_/X }
C {devices/lab_pin.sym} 5300 -28690 0 0 {name=p4864 lab=_40839_/X }
C {devices/lab_pin.sym} 5300 -28650 0 0 {name=p4865 lab=_87813_/Q }
C {devices/lab_pin.sym} 5300 -28610 0 0 {name=p4866 lab=_42580_/X }
C {devices/lab_pin.sym} 5460 -28690 0 1 {name=p4867 lab=_42581_/Y }
C {sky130_stdcells/o32ai_4.sym} 5380 -28690 0 0 {name=X_42581_ }
C {devices/lab_pin.sym} 5340 -28530 0 0 {name=p4868 lab=_54540_/A }
C {devices/lab_pin.sym} 5420 -28530 0 1 {name=p4869 lab=_54567_/X }
C {sky130_stdcells/buf_2.sym} 5380 -28530 0 0 {name=X_54567_ }
C {devices/lab_pin.sym} 5290 -28410 0 0 {name=p4870 lab=_85484_/CLK }
C {devices/lab_pin.sym} 5290 -28390 0 0 {name=p4871 lab=_85387_/D }
C {devices/lab_pin.sym} 5470 -28410 0 1 {name=p4872 lab=_85387_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -28400 0 0 {name=X_85387_ }
C {devices/lab_pin.sym} 5320 -28280 0 0 {name=p4873 lab=_51779_/A }
C {devices/lab_pin.sym} 5320 -28240 0 0 {name=p4874 lab=_51779_/B }
C {devices/lab_pin.sym} 5440 -28260 0 1 {name=p4875 lab=_51779_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -28260 0 0 {name=X_51779_ }
C {devices/lab_pin.sym} 5290 -28130 0 0 {name=p4876 lab=_82879_/CLK }
C {devices/lab_pin.sym} 5290 -28110 0 0 {name=p4877 lab=_78851_/B }
C {devices/lab_pin.sym} 5470 -28130 0 1 {name=p4878 lab=_82567_/D }
C {sky130_stdcells/dfxtp_4.sym} 5380 -28120 0 0 {name=X_82599_ }
C {devices/lab_pin.sym} 5320 -28000 0 0 {name=p4879 lab=_44320_/A }
C {devices/lab_pin.sym} 5320 -27960 0 0 {name=p4880 lab=_44318_/A }
C {devices/lab_pin.sym} 5440 -27980 0 1 {name=p4881 lab=_44320_/Y }
C {sky130_stdcells/nor2_4.sym} 5380 -27980 0 0 {name=X_44320_ }
C {devices/lab_pin.sym} 5320 -27870 0 0 {name=p4882 lab=_56296_/A }
C {devices/lab_pin.sym} 5320 -27830 0 0 {name=p4883 lab=_56298_/X }
C {devices/lab_pin.sym} 5320 -27790 0 0 {name=p4884 lab=_56306_/C }
C {devices/lab_pin.sym} 5440 -27830 0 1 {name=p4885 lab=_56306_/Y }
C {sky130_stdcells/nand3_4.sym} 5380 -27830 0 0 {name=X_56306_ }
C {devices/lab_pin.sym} 5320 -27700 0 0 {name=p4886 lab=_75138_/A }
C {devices/lab_pin.sym} 5320 -27660 0 0 {name=p4887 lab=_75138_/B }
C {devices/lab_pin.sym} 5440 -27680 0 1 {name=p4888 lab=_75140_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -27680 0 0 {name=X_75140_ }
C {devices/lab_pin.sym} 5290 -27550 0 0 {name=p4889 lab=_87126_/CLK }
C {devices/lab_pin.sym} 5290 -27530 0 0 {name=p4890 lab=_44402_/X }
C {devices/lab_pin.sym} 5470 -27550 0 1 {name=p4891 lab=_87126_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -27540 0 0 {name=X_87126_ }
C {devices/lab_pin.sym} 5320 -27420 0 0 {name=p4892 lab=_53509_/A }
C {devices/lab_pin.sym} 5320 -27380 0 0 {name=p4893 lab=_73864_/A }
C {devices/lab_pin.sym} 5440 -27400 0 1 {name=p4894 lab=_53518_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -27400 0 0 {name=X_53518_ }
C {devices/lab_pin.sym} 5300 -27300 0 0 {name=p4895 lab=_41529_/X }
C {devices/lab_pin.sym} 5300 -27260 0 0 {name=p4896 lab=_41530_/X }
C {devices/lab_pin.sym} 5300 -27220 0 0 {name=p4897 lab=_88197_/Q }
C {devices/lab_pin.sym} 5300 -27180 0 0 {name=p4898 lab=_41531_/X }
C {devices/lab_pin.sym} 5460 -27240 0 1 {name=p4899 lab=_88197_/D }
C {sky130_stdcells/a2bb2o_4.sym} 5380 -27240 0 0 {name=X_41532_ }
C {devices/lab_pin.sym} 5340 -27090 0 0 {name=p4900 lab=_59286_/A }
C {devices/lab_pin.sym} 5420 -27090 0 1 {name=p4901 lab=_72352_/X }
C {sky130_stdcells/buf_2.sym} 5380 -27090 0 0 {name=X_72352_ }
C {devices/lab_pin.sym} 5290 -26970 0 0 {name=p4902 lab=_83218_/CLK }
C {devices/lab_pin.sym} 5290 -26950 0 0 {name=p4903 lab=_84338_/D }
C {devices/lab_pin.sym} 5470 -26970 0 1 {name=p4904 lab=_79267_/A }
C {sky130_stdcells/dfxtp_4.sym} 5380 -26960 0 0 {name=X_84338_ }
C {devices/lab_pin.sym} 5300 -26860 0 0 {name=p4905 lab=_57280_/X }
C {devices/lab_pin.sym} 5300 -26820 0 0 {name=p4906 lab=_57282_/Y }
C {devices/lab_pin.sym} 5300 -26780 0 0 {name=p4907 lab=_57283_/Y }
C {devices/lab_pin.sym} 5300 -26740 0 0 {name=p4908 lab=_57285_/Y }
C {devices/lab_pin.sym} 5460 -26800 0 1 {name=p4909 lab=_57286_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -26800 0 0 {name=X_57286_ }
C {devices/lab_pin.sym} 5320 -26680 0 0 {name=p4910 lab=_54483_/A }
C {devices/lab_pin.sym} 5320 -26640 0 0 {name=p4911 lab=_54503_/B }
C {devices/lab_pin.sym} 5320 -26600 0 0 {name=p4912 lab=_54483_/C }
C {devices/lab_pin.sym} 5320 -26560 0 0 {name=p4913 lab=_54498_/D }
C {devices/lab_pin.sym} 5440 -26620 0 1 {name=p4914 lab=_54498_/X }
C {sky130_stdcells/and4_4.sym} 5380 -26620 0 0 {name=X_54498_ }
C {devices/lab_pin.sym} 5320 -26490 0 0 {name=p4915 lab=_71303_/A }
C {devices/lab_pin.sym} 5320 -26450 0 0 {name=p4916 lab=_71303_/B }
C {devices/lab_pin.sym} 5320 -26410 0 0 {name=p4917 lab=_71302_/X }
C {devices/lab_pin.sym} 5440 -26450 0 1 {name=p4918 lab=_71303_/Y }
C {sky130_stdcells/nand3_4.sym} 5380 -26450 0 0 {name=X_71303_ }
C {devices/lab_pin.sym} 5300 -26330 0 0 {name=p4919 lab=_59022_/Y }
C {devices/lab_pin.sym} 5300 -26290 0 0 {name=p4920 lab=_59024_/Y }
C {devices/lab_pin.sym} 5300 -26250 0 0 {name=p4921 lab=_58966_/X }
C {devices/lab_pin.sym} 5460 -26290 0 1 {name=p4922 lab=_59025_/X }
C {sky130_stdcells/a21o_4.sym} 5380 -26290 0 0 {name=X_59025_ }
C {devices/lab_pin.sym} 5340 -26150 0 0 {name=p4923 lab=_59036_/A }
C {devices/lab_pin.sym} 5420 -26150 0 1 {name=p4924 lab=_58020_/A }
C {sky130_stdcells/buf_2.sym} 5380 -26150 0 0 {name=X_44251_ }
C {devices/lab_pin.sym} 5320 -26050 0 0 {name=p4925 lab=_56233_/A }
C {devices/lab_pin.sym} 5320 -26010 0 0 {name=p4926 lab=_56243_/B }
C {devices/lab_pin.sym} 5320 -25970 0 0 {name=p4927 lab=_85264_/Q }
C {devices/lab_pin.sym} 5440 -26010 0 1 {name=p4928 lab=_56237_/Y }
C {sky130_stdcells/nand3_4.sym} 5380 -26010 0 0 {name=X_56237_ }
C {devices/lab_pin.sym} 5340 -25870 0 0 {name=p4929 lab=_75070_/Y }
C {devices/lab_pin.sym} 5420 -25870 0 1 {name=p4930 lab=_75071_/Y }
C {sky130_stdcells/inv_2.sym} 5380 -25870 0 0 {name=X_75071_ }
C {devices/lab_pin.sym} 5320 -25760 0 0 {name=p4931 lab=_81184_/Q }
C {devices/lab_pin.sym} 5320 -25720 0 0 {name=p4932 lab=_41459_/B }
C {devices/lab_pin.sym} 5440 -25740 0 1 {name=p4933 lab=_41463_/X }
C {sky130_stdcells/or2_4.sym} 5380 -25740 0 0 {name=X_41463_ }
C {devices/lab_pin.sym} 5290 -25610 0 0 {name=p4934 lab=_88062_/CLK }
C {devices/lab_pin.sym} 5290 -25590 0 0 {name=p4935 lab=_44553_/Y }
C {devices/lab_pin.sym} 5470 -25610 0 1 {name=p4936 lab=_87057_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -25600 0 0 {name=X_87057_ }
C {devices/lab_pin.sym} 5340 -25470 0 0 {name=p4937 lab=_53448_/X }
C {devices/lab_pin.sym} 5420 -25470 0 1 {name=p4938 lab=_53449_/X }
C {sky130_stdcells/buf_2.sym} 5380 -25470 0 0 {name=X_53449_ }
C {devices/lab_pin.sym} 5300 -25370 0 0 {name=p4939 lab=_72209_/X }
C {devices/lab_pin.sym} 5300 -25330 0 0 {name=p4940 lab=_85972_/Q }
C {devices/lab_pin.sym} 5300 -25290 0 0 {name=p4941 lab=_72282_/X }
C {devices/lab_pin.sym} 5460 -25330 0 1 {name=p4942 lab=_72283_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -25330 0 0 {name=X_72283_ }
C {devices/lab_pin.sym} 5290 -25190 0 0 {name=p4943 lab=_84269_/CLK }
C {devices/lab_pin.sym} 5290 -25170 0 0 {name=p4944 lab=_64165_/Y }
C {devices/lab_pin.sym} 5470 -25190 0 1 {name=p4945 lab=_79937_/B }
C {sky130_stdcells/dfxtp_4.sym} 5380 -25180 0 0 {name=X_84269_ }
C {devices/lab_pin.sym} 5300 -25090 0 0 {name=p4946 lab=_43047_/X }
C {devices/lab_pin.sym} 5300 -25050 0 0 {name=p4947 lab=_53944_/A }
C {devices/lab_pin.sym} 5300 -25010 0 0 {name=p4948 lab=_40925_/X }
C {devices/lab_pin.sym} 5300 -24970 0 0 {name=p4949 lab=_43201_/Y }
C {devices/lab_pin.sym} 5300 -24930 0 0 {name=p4950 lab=_43021_/X }
C {devices/lab_pin.sym} 5460 -25010 0 1 {name=p4951 lab=_87541_/D }
C {sky130_stdcells/o32ai_4.sym} 5380 -25010 0 0 {name=X_43202_ }
C {devices/lab_pin.sym} 5340 -24850 0 0 {name=p4952 lab=_72874_/A }
C {devices/lab_pin.sym} 5420 -24850 0 1 {name=p4953 lab=_74022_/X }
C {sky130_stdcells/buf_2.sym} 5380 -24850 0 0 {name=X_74022_ }
C {devices/lab_pin.sym} 5290 -24730 0 0 {name=p4954 lab=_86008_/CLK }
C {devices/lab_pin.sym} 5290 -24710 0 0 {name=p4955 lab=_86008_/D }
C {devices/lab_pin.sym} 5470 -24730 0 1 {name=p4956 lab=_86008_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -24720 0 0 {name=X_86008_ }
C {devices/lab_pin.sym} 5340 -24590 0 0 {name=p4957 lab=_40413_/X }
C {devices/lab_pin.sym} 5420 -24590 0 1 {name=p4958 lab=_40414_/X }
C {sky130_stdcells/buf_2.sym} 5380 -24590 0 0 {name=X_40414_ }
C {devices/lab_pin.sym} 5340 -24470 0 0 {name=p4959 lab=_71221_/A }
C {devices/lab_pin.sym} 5420 -24470 0 1 {name=p4960 lab=_71235_/A }
C {sky130_stdcells/buf_2.sym} 5380 -24470 0 0 {name=X_71234_ }
C {devices/lab_pin.sym} 5340 -24350 0 0 {name=p4961 lab=_44181_/X }
C {devices/lab_pin.sym} 5420 -24350 0 1 {name=p4962 lab=_72461_/A }
C {sky130_stdcells/buf_2.sym} 5380 -24350 0 0 {name=X_44182_ }
C {devices/lab_pin.sym} 5340 -24230 0 0 {name=p4963 lab=_56168_/A }
C {devices/lab_pin.sym} 5420 -24230 0 1 {name=p4964 lab=_56168_/X }
C {sky130_stdcells/buf_2.sym} 5380 -24230 0 0 {name=X_56168_ }
C {devices/lab_pin.sym} 5300 -24140 0 0 {name=p4965 lab=_41393_/X }
C {devices/lab_pin.sym} 5300 -24100 0 0 {name=p4966 lab=_41362_/X }
C {devices/lab_pin.sym} 5300 -24060 0 0 {name=p4967 lab=_67813_/B }
C {devices/lab_pin.sym} 5300 -24020 0 0 {name=p4968 lab=_41363_/X }
C {devices/lab_pin.sym} 5460 -24080 0 1 {name=p4969 lab=_88223_/D }
C {sky130_stdcells/a2bb2o_4.sym} 5380 -24080 0 0 {name=X_41394_ }
C {devices/lab_pin.sym} 5300 -23950 0 0 {name=p4970 lab=_85314_/Q }
C {devices/lab_pin.sym} 5300 -23910 0 0 {name=p4971 lab=_55098_/X }
C {devices/lab_pin.sym} 5300 -23870 0 0 {name=p4972 lab=_55118_/Y }
C {devices/lab_pin.sym} 5460 -23910 0 1 {name=p4973 lab=_55119_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -23910 0 0 {name=X_55119_ }
C {devices/lab_pin.sym} 5340 -23770 0 0 {name=p4974 lab=_43133_/A }
C {devices/lab_pin.sym} 5420 -23770 0 1 {name=p4975 lab=_43133_/Y }
C {sky130_stdcells/inv_2.sym} 5380 -23770 0 0 {name=X_43133_ }
C {devices/lab_pin.sym} 5320 -23660 0 0 {name=p4976 lab=_78830_/A }
C {devices/lab_pin.sym} 5320 -23620 0 0 {name=p4977 lab=_78829_/Y }
C {devices/lab_pin.sym} 5440 -23640 0 1 {name=p4978 lab=_78831_/B }
C {sky130_stdcells/xor2_4.sym} 5380 -23640 0 0 {name=X_78830_ }
C {devices/lab_pin.sym} 5340 -23510 0 0 {name=p4979 lab=_46610_/A }
C {devices/lab_pin.sym} 5420 -23510 0 1 {name=p4980 lab=_46725_/A }
C {sky130_stdcells/buf_2.sym} 5380 -23510 0 0 {name=X_40345_ }
C {devices/lab_pin.sym} 5340 -23390 0 0 {name=p4981 lab=_71164_/Y }
C {devices/lab_pin.sym} 5420 -23390 0 1 {name=p4982 lab=_71165_/X }
C {sky130_stdcells/buf_2.sym} 5380 -23390 0 0 {name=X_71165_ }
C {devices/lab_pin.sym} 5300 -23290 0 0 {name=p4983 lab=_48984_/Y }
C {devices/lab_pin.sym} 5300 -23250 0 0 {name=p4984 lab=_48985_/X }
C {devices/lab_pin.sym} 5300 -23210 0 0 {name=p4985 lab=_48989_/X }
C {devices/lab_pin.sym} 5460 -23250 0 1 {name=p4986 lab=_48990_/Y }
C {sky130_stdcells/a21oi_4.sym} 5380 -23250 0 0 {name=X_48990_ }
C {devices/lab_pin.sym} 5340 -23110 0 0 {name=p4987 lab=_56099_/A }
C {devices/lab_pin.sym} 5420 -23110 0 1 {name=p4988 lab=_56099_/X }
C {sky130_stdcells/buf_2.sym} 5380 -23110 0 0 {name=X_56099_ }
C {devices/lab_pin.sym} 5340 -22990 0 0 {name=p4989 lab=_83128_/Q }
C {devices/lab_pin.sym} 5420 -22990 0 1 {name=p4990 lab=_70117_/D }
C {sky130_stdcells/inv_2.sym} 5380 -22990 0 0 {name=X_70116_ }
C {devices/lab_pin.sym} 5320 -22880 0 0 {name=p4991 lab=_47912_/A }
C {devices/lab_pin.sym} 5320 -22840 0 0 {name=p4992 lab=_48231_/B }
C {devices/lab_pin.sym} 5440 -22860 0 1 {name=p4993 lab=_47941_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -22860 0 0 {name=X_47941_ }
C {devices/lab_pin.sym} 5300 -22770 0 0 {name=p4994 lab=_43038_/X }
C {devices/lab_pin.sym} 5300 -22730 0 0 {name=p4995 lab=_43050_/X }
C {devices/lab_pin.sym} 5300 -22690 0 0 {name=p4996 lab=_40661_/X }
C {devices/lab_pin.sym} 5300 -22650 0 0 {name=p4997 lab=_73873_/A }
C {devices/lab_pin.sym} 5300 -22610 0 0 {name=p4998 lab=_43061_/X }
C {devices/lab_pin.sym} 5460 -22690 0 1 {name=p4999 lab=_43065_/A }
C {sky130_stdcells/o32ai_4.sym} 5380 -22690 0 0 {name=X_43064_ }
C {devices/lab_pin.sym} 5340 -22530 0 0 {name=p5000 lab=_59927_/A }
C {devices/lab_pin.sym} 5420 -22530 0 1 {name=p5001 lab=_59927_/Y }
C {sky130_stdcells/inv_2.sym} 5380 -22530 0 0 {name=X_59927_ }
C {devices/lab_pin.sym} 5300 -22430 0 0 {name=p5002 lab=_78747_/A }
C {devices/lab_pin.sym} 5300 -22390 0 0 {name=p5003 lab=_78746_/Y }
C {devices/lab_pin.sym} 5300 -22350 0 0 {name=p5004 lab=_78737_/Y }
C {devices/lab_pin.sym} 5460 -22390 0 1 {name=p5005 lab=_78761_/X }
C {sky130_stdcells/o21a_4.sym} 5380 -22390 0 0 {name=X_78761_ }
C {devices/lab_pin.sym} 5340 -22250 0 0 {name=p5006 lab=_70905_/D }
C {devices/lab_pin.sym} 5420 -22250 0 1 {name=p5007 lab=_71099_/C }
C {sky130_stdcells/buf_2.sym} 5380 -22250 0 0 {name=X_71096_ }
C {devices/lab_pin.sym} 5320 -22160 0 0 {name=p5008 lab=_75949_/A }
C {devices/lab_pin.sym} 5320 -22120 0 0 {name=p5009 lab=_75954_/A }
C {devices/lab_pin.sym} 5320 -22080 0 0 {name=p5010 lab=_75961_/A }
C {devices/lab_pin.sym} 5320 -22040 0 0 {name=p5011 lab=_75970_/A }
C {devices/lab_pin.sym} 5440 -22100 0 1 {name=p5012 lab=_75974_/B }
C {sky130_stdcells/and4_4.sym} 5380 -22100 0 0 {name=X_75973_ }
C {devices/lab_pin.sym} 5290 -21950 0 0 {name=p5013 lab=_87952_/CLK }
C {devices/lab_pin.sym} 5290 -21930 0 0 {name=p5014 lab=_87959_/D }
C {devices/lab_pin.sym} 5470 -21950 0 1 {name=p5015 lab=_87959_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -21940 0 0 {name=X_87959_ }
C {devices/lab_pin.sym} 5340 -21810 0 0 {name=p5016 lab=_42014_/Y }
C {devices/lab_pin.sym} 5420 -21810 0 1 {name=p5017 lab=_88071_/D }
C {sky130_stdcells/inv_2.sym} 5380 -21810 0 0 {name=X_42015_ }
C {devices/lab_pin.sym} 5320 -21700 0 0 {name=p5018 lab=_77712_/A }
C {devices/lab_pin.sym} 5320 -21660 0 0 {name=p5019 lab=_82124_/Q }
C {devices/lab_pin.sym} 5440 -21680 0 1 {name=p5020 lab=_77712_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -21680 0 0 {name=X_77712_ }
C {devices/lab_pin.sym} 5320 -21560 0 0 {name=p5021 lab=_81132_/D }
C {devices/lab_pin.sym} 5320 -21520 0 0 {name=p5022 lab=_74912_/B }
C {devices/lab_pin.sym} 5440 -21540 0 1 {name=p5023 lab=_74924_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -21540 0 0 {name=X_74924_ }
C {devices/lab_pin.sym} 5300 -21430 0 0 {name=p5024 lab=_82544_/D }
C {devices/lab_pin.sym} 5300 -21390 0 0 {name=p5025 lab=_70029_/X }
C {devices/lab_pin.sym} 5300 -21350 0 0 {name=p5026 lab=_70046_/X }
C {devices/lab_pin.sym} 5460 -21390 0 1 {name=p5027 lab=_70047_/X }
C {sky130_stdcells/a21bo_4.sym} 5380 -21390 0 0 {name=X_70047_ }
C {devices/lab_pin.sym} 5340 -21250 0 0 {name=p5028 lab=_47872_/A }
C {devices/lab_pin.sym} 5420 -21250 0 1 {name=p5029 lab=_52139_/A }
C {sky130_stdcells/buf_2.sym} 5380 -21250 0 0 {name=X_47872_ }
C {devices/lab_pin.sym} 5340 -21130 0 0 {name=p5030 lab=_59858_/A }
C {devices/lab_pin.sym} 5420 -21130 0 1 {name=p5031 lab=_59858_/Y }
C {sky130_stdcells/inv_2.sym} 5380 -21130 0 0 {name=X_59858_ }
C {devices/lab_pin.sym} 5340 -21010 0 0 {name=p5032 lab=_78691_/Y }
C {devices/lab_pin.sym} 5420 -21010 0 1 {name=p5033 lab=_78693_/C }
C {sky130_stdcells/inv_2.sym} 5380 -21010 0 0 {name=X_78692_ }
C {devices/lab_pin.sym} 5300 -20910 0 0 {name=p5034 lab=_49609_/Y }
C {devices/lab_pin.sym} 5300 -20870 0 0 {name=p5035 lab=_49596_/X }
C {devices/lab_pin.sym} 5300 -20830 0 0 {name=p5036 lab=_49610_/X }
C {devices/lab_pin.sym} 5460 -20870 0 1 {name=p5037 lab=_49611_/Y }
C {sky130_stdcells/a21oi_4.sym} 5380 -20870 0 0 {name=X_49611_ }
C {devices/lab_pin.sym} 5300 -20750 0 0 {name=p5038 lab=_46818_/Y }
C {devices/lab_pin.sym} 5300 -20710 0 0 {name=p5039 lab=_46798_/X }
C {devices/lab_pin.sym} 5300 -20670 0 0 {name=p5040 lab=_46822_/X }
C {devices/lab_pin.sym} 5460 -20710 0 1 {name=p5041 lab=_86700_/D }
C {sky130_stdcells/a21oi_4.sym} 5380 -20710 0 0 {name=X_46823_ }
C {devices/lab_pin.sym} 5340 -20570 0 0 {name=p5042 lab=_57848_/A }
C {devices/lab_pin.sym} 5420 -20570 0 1 {name=p5043 lab=_58810_/A }
C {sky130_stdcells/buf_2.sym} 5380 -20570 0 0 {name=X_58809_ }
C {devices/lab_pin.sym} 5320 -20460 0 0 {name=p5044 lab=_77643_/A }
C {devices/lab_pin.sym} 5320 -20420 0 0 {name=p5045 lab=_77643_/B }
C {devices/lab_pin.sym} 5440 -20440 0 1 {name=p5046 lab=_77643_/X }
C {sky130_stdcells/xor2_4.sym} 5380 -20440 0 0 {name=X_77643_ }
C {devices/lab_pin.sym} 5320 -20320 0 0 {name=p5047 lab=_81124_/D }
C {devices/lab_pin.sym} 5320 -20280 0 0 {name=p5048 lab=_74854_/B }
C {devices/lab_pin.sym} 5440 -20300 0 1 {name=p5049 lab=_74855_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -20300 0 0 {name=X_74855_ }
C {devices/lab_pin.sym} 5320 -20180 0 0 {name=p5050 lab=_59789_/A }
C {devices/lab_pin.sym} 5320 -20140 0 0 {name=p5051 lab=_59591_/A }
C {devices/lab_pin.sym} 5440 -20160 0 1 {name=p5052 lab=_59789_/Y }
C {sky130_stdcells/nor2_4.sym} 5380 -20160 0 0 {name=X_59789_ }
C {devices/lab_pin.sym} 5340 -20030 0 0 {name=p5053 lab=_49406_/A }
C {devices/lab_pin.sym} 5420 -20030 0 1 {name=p5054 lab=_49571_/A }
C {sky130_stdcells/buf_2.sym} 5380 -20030 0 0 {name=X_49542_ }
C {devices/lab_pin.sym} 5340 -19910 0 0 {name=p5055 lab=_61820_/A }
C {devices/lab_pin.sym} 5420 -19910 0 1 {name=p5056 lab=_61865_/B }
C {sky130_stdcells/buf_2.sym} 5380 -19910 0 0 {name=X_61820_ }
C {devices/lab_pin.sym} 5300 -19820 0 0 {name=p5057 lab=_73731_/X }
C {devices/lab_pin.sym} 5300 -19780 0 0 {name=p5058 lab=_86231_/Q }
C {devices/lab_pin.sym} 5300 -19740 0 0 {name=p5059 lab=_73804_/X }
C {devices/lab_pin.sym} 5300 -19700 0 0 {name=p5060 lab=_73805_/X }
C {devices/lab_pin.sym} 5460 -19760 0 1 {name=p5061 lab=_73806_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -19760 0 0 {name=X_73806_ }
C {devices/lab_pin.sym} 5340 -19610 0 0 {name=p5062 lab=_46753_/Y }
C {devices/lab_pin.sym} 5420 -19610 0 1 {name=p5063 lab=_52654_/D }
C {sky130_stdcells/buf_2.sym} 5380 -19610 0 0 {name=X_46754_ }
C {devices/lab_pin.sym} 5300 -19510 0 0 {name=p5064 lab=_77575_/A }
C {devices/lab_pin.sym} 5300 -19470 0 0 {name=p5065 lab=_77571_/Y }
C {devices/lab_pin.sym} 5300 -19430 0 0 {name=p5066 lab=_77575_/B }
C {devices/lab_pin.sym} 5460 -19470 0 1 {name=p5067 lab=_77576_/A }
C {sky130_stdcells/a21o_4.sym} 5380 -19470 0 0 {name=X_77574_ }
C {devices/lab_pin.sym} 5300 -19350 0 0 {name=p5068 lab=_43963_/X }
C {devices/lab_pin.sym} 5300 -19310 0 0 {name=p5069 lab=_43965_/X }
C {devices/lab_pin.sym} 5300 -19270 0 0 {name=p5070 lab=_80669_/Q }
C {devices/lab_pin.sym} 5460 -19310 0 1 {name=p5071 lab=_43969_/A }
C {sky130_stdcells/a21o_4.sym} 5380 -19310 0 0 {name=X_43966_ }
C {devices/lab_pin.sym} 5320 -19200 0 0 {name=p5072 lab=_74786_/A }
C {devices/lab_pin.sym} 5320 -19160 0 0 {name=p5073 lab=_74720_/C }
C {devices/lab_pin.sym} 5320 -19120 0 0 {name=p5074 lab=_74804_/D }
C {devices/lab_pin.sym} 5320 -19080 0 0 {name=p5075 lab=_74780_/D }
C {devices/lab_pin.sym} 5440 -19140 0 1 {name=p5076 lab=_74786_/Y }
C {sky130_stdcells/nand4_4.sym} 5380 -19140 0 0 {name=X_74786_ }
C {devices/lab_pin.sym} 5320 -19000 0 0 {name=p5077 lab=_71993_/X }
C {devices/lab_pin.sym} 5320 -18960 0 0 {name=p5078 lab=_71998_/B }
C {devices/lab_pin.sym} 5440 -18980 0 1 {name=p5079 lab=_71998_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -18980 0 0 {name=X_71998_ }
C {devices/lab_pin.sym} 5320 -18860 0 0 {name=p5080 lab=_79291_/A }
C {devices/lab_pin.sym} 5320 -18820 0 0 {name=p5081 lab=_79303_/X }
C {devices/lab_pin.sym} 5440 -18840 0 1 {name=p5082 lab=_79313_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -18840 0 0 {name=X_79313_ }
C {devices/lab_pin.sym} 5340 -18710 0 0 {name=p5083 lab=_45705_/A }
C {devices/lab_pin.sym} 5420 -18710 0 1 {name=p5084 lab=_45705_/X }
C {sky130_stdcells/buf_2.sym} 5380 -18710 0 0 {name=X_45705_ }
C {devices/lab_pin.sym} 5300 -18610 0 0 {name=p5085 lab=_76521_/Y }
C {devices/lab_pin.sym} 5300 -18570 0 0 {name=p5086 lab=_76524_/C }
C {devices/lab_pin.sym} 5300 -18530 0 0 {name=p5087 lab=_76520_/Y }
C {devices/lab_pin.sym} 5460 -18570 0 1 {name=p5088 lab=_76525_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -18570 0 0 {name=X_76525_ }
C {devices/lab_pin.sym} 5340 -18430 0 0 {name=p5089 lab=_42945_/A }
C {devices/lab_pin.sym} 5420 -18430 0 1 {name=p5090 lab=_42917_/X }
C {sky130_stdcells/buf_2.sym} 5380 -18430 0 0 {name=X_42917_ }
C {devices/lab_pin.sym} 5300 -18330 0 0 {name=p5091 lab=_86381_/Q }
C {devices/lab_pin.sym} 5300 -18290 0 0 {name=p5092 lab=_49470_/X }
C {devices/lab_pin.sym} 5300 -18250 0 0 {name=p5093 lab=_49472_/Y }
C {devices/lab_pin.sym} 5460 -18290 0 1 {name=p5094 lab=_49473_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -18290 0 0 {name=X_49473_ }
C {devices/lab_pin.sym} 5300 -18180 0 0 {name=p5095 lab=_73735_/X }
C {devices/lab_pin.sym} 5300 -18140 0 0 {name=p5096 lab=_85626_/Q }
C {devices/lab_pin.sym} 5300 -18100 0 0 {name=p5097 lab=_73661_/X }
C {devices/lab_pin.sym} 5300 -18060 0 0 {name=p5098 lab=_73736_/X }
C {devices/lab_pin.sym} 5460 -18120 0 1 {name=p5099 lab=_73737_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -18120 0 0 {name=X_73737_ }
C {devices/lab_pin.sym} 5300 -18010 0 0 {name=p5100 lab=_61726_/X }
C {devices/lab_pin.sym} 5300 -17970 0 0 {name=p5101 lab=_61734_/X }
C {devices/lab_pin.sym} 5300 -17930 0 0 {name=p5102 lab=_61750_/Y }
C {devices/lab_pin.sym} 5300 -17890 0 0 {name=p5103 lab=_58149_/A }
C {devices/lab_pin.sym} 5300 -17850 0 0 {name=p5104 lab=_61719_/X }
C {devices/lab_pin.sym} 5460 -17930 0 1 {name=p5105 lab=_61751_/Y }
C {sky130_stdcells/o32ai_4.sym} 5380 -17930 0 0 {name=X_61751_ }
C {devices/lab_pin.sym} 5340 -17770 0 0 {name=p5106 lab=clkbuf_8_95_0_CLK/X }
C {devices/lab_pin.sym} 5420 -17770 0 1 {name=p5107 lab=clkbuf_9_191_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 5380 -17770 0 0 {name=Xclkbuf_9_191_0_CLK }
C {devices/lab_pin.sym} 5340 -17650 0 0 {name=p5108 lab=_46685_/A }
C {devices/lab_pin.sym} 5420 -17650 0 1 {name=p5109 lab=_46685_/X }
C {sky130_stdcells/buf_2.sym} 5380 -17650 0 0 {name=X_46685_ }
C {devices/lab_pin.sym} 5320 -17550 0 0 {name=p5110 lab=_70947_/A }
C {devices/lab_pin.sym} 5320 -17510 0 0 {name=p5111 lab=_70949_/B }
C {devices/lab_pin.sym} 5320 -17470 0 0 {name=p5112 lab=_70947_/C }
C {devices/lab_pin.sym} 5440 -17510 0 1 {name=p5113 lab=_70949_/Y }
C {sky130_stdcells/nand3_4.sym} 5380 -17510 0 0 {name=X_70949_ }
C {devices/lab_pin.sym} 5340 -17370 0 0 {name=p5114 lab=_43896_/X }
C {devices/lab_pin.sym} 5420 -17370 0 1 {name=p5115 lab=_43897_/X }
C {sky130_stdcells/buf_2.sym} 5380 -17370 0 0 {name=X_43897_ }
C {devices/lab_pin.sym} 5320 -17260 0 0 {name=p5116 lab=_48469_/A }
C {devices/lab_pin.sym} 5320 -17220 0 0 {name=p5117 lab=_52128_/B }
C {devices/lab_pin.sym} 5440 -17240 0 1 {name=p5118 lab=_48424_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -17240 0 0 {name=X_48424_ }
C {devices/lab_pin.sym} 5320 -17130 0 0 {name=p5119 lab=_60652_/A }
C {devices/lab_pin.sym} 5320 -17090 0 0 {name=p5120 lab=_60677_/A }
C {devices/lab_pin.sym} 5320 -17050 0 0 {name=p5121 lab=_60702_/C }
C {devices/lab_pin.sym} 5440 -17090 0 1 {name=p5122 lab=_60702_/Y }
C {sky130_stdcells/nand3_4.sym} 5380 -17090 0 0 {name=X_60702_ }
C {devices/lab_pin.sym} 5320 -16960 0 0 {name=p5123 lab=_84792_/Q }
C {devices/lab_pin.sym} 5320 -16920 0 0 {name=p5124 lab=_66495_/C }
C {devices/lab_pin.sym} 5440 -16940 0 1 {name=p5125 lab=_79244_/X }
C {sky130_stdcells/xor2_4.sym} 5380 -16940 0 0 {name=X_79244_ }
C {devices/lab_pin.sym} 5300 -16830 0 0 {name=p5126 lab=_85138_/Q }
C {devices/lab_pin.sym} 5300 -16790 0 0 {name=p5127 lab=_45556_/X }
C {devices/lab_pin.sym} 5300 -16750 0 0 {name=p5128 lab=_45378_/X }
C {devices/lab_pin.sym} 5460 -16790 0 1 {name=p5129 lab=_45636_/X }
C {sky130_stdcells/o21a_4.sym} 5380 -16790 0 0 {name=X_45636_ }
C {devices/lab_pin.sym} 5300 -16690 0 0 {name=p5130 lab=_64465_/Y }
C {devices/lab_pin.sym} 5300 -16650 0 0 {name=p5131 lab=_64466_/X }
C {devices/lab_pin.sym} 5300 -16610 0 0 {name=p5132 lab=_64467_/X }
C {devices/lab_pin.sym} 5300 -16570 0 0 {name=p5133 lab=_64469_/Y }
C {devices/lab_pin.sym} 5300 -16530 0 0 {name=p5134 lab=_64440_/X }
C {devices/lab_pin.sym} 5460 -16610 0 1 {name=p5135 lab=_64470_/X }
C {sky130_stdcells/o41a_4.sym} 5380 -16610 0 0 {name=X_64470_ }
C {devices/lab_pin.sym} 5320 -16460 0 0 {name=p5136 lab=_76456_/A }
C {devices/lab_pin.sym} 5320 -16420 0 0 {name=p5137 lab=_76453_/A }
C {devices/lab_pin.sym} 5440 -16440 0 1 {name=p5138 lab=_76456_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -16440 0 0 {name=X_76456_ }
C {devices/lab_pin.sym} 5340 -16310 0 0 {name=p5139 lab=_42429_/A }
C {devices/lab_pin.sym} 5420 -16310 0 1 {name=p5140 lab=_42945_/A }
C {sky130_stdcells/buf_2.sym} 5380 -16310 0 0 {name=X_42848_ }
C {devices/lab_pin.sym} 5320 -16210 0 0 {name=p5141 lab=_61305_/A }
C {devices/lab_pin.sym} 5320 -16170 0 0 {name=p5142 lab=_61682_/B }
C {devices/lab_pin.sym} 5320 -16130 0 0 {name=p5143 lab=_61682_/C }
C {devices/lab_pin.sym} 5440 -16170 0 1 {name=p5144 lab=_61682_/Y }
C {sky130_stdcells/nand3_4.sym} 5380 -16170 0 0 {name=X_61682_ }
C {devices/lab_pin.sym} 5320 -16040 0 0 {name=p5145 lab=_73668_/A }
C {devices/lab_pin.sym} 5320 -16000 0 0 {name=p5146 lab=_73667_/X }
C {devices/lab_pin.sym} 5440 -16020 0 1 {name=p5147 lab=_73668_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -16020 0 0 {name=X_73668_ }
C {devices/lab_pin.sym} 5300 -15910 0 0 {name=p5148 lab=_63419_/Y }
C {devices/lab_pin.sym} 5300 -15870 0 0 {name=p5149 lab=_63391_/X }
C {devices/lab_pin.sym} 5300 -15830 0 0 {name=p5150 lab=_63420_/Y }
C {devices/lab_pin.sym} 5460 -15870 0 1 {name=p5151 lab=_63421_/Y }
C {sky130_stdcells/a21oi_4.sym} 5380 -15870 0 0 {name=X_63421_ }
C {devices/lab_pin.sym} 5320 -15740 0 0 {name=p5152 lab=_75403_/Y }
C {devices/lab_pin.sym} 5320 -15700 0 0 {name=p5153 lab=_75406_/Y }
C {devices/lab_pin.sym} 5440 -15720 0 1 {name=p5154 lab=_75407_/X }
C {sky130_stdcells/xor2_4.sym} 5380 -15720 0 0 {name=X_75407_ }
C {devices/lab_pin.sym} 5320 -15610 0 0 {name=p5155 lab=_50391_/A }
C {devices/lab_pin.sym} 5320 -15570 0 0 {name=p5156 lab=_48286_/X }
C {devices/lab_pin.sym} 5320 -15530 0 0 {name=p5157 lab=_48354_/X }
C {devices/lab_pin.sym} 5440 -15570 0 1 {name=p5158 lab=_48355_/X }
C {sky130_stdcells/and3_4.sym} 5380 -15570 0 0 {name=X_48355_ }
C {devices/lab_pin.sym} 5340 -15430 0 0 {name=p5159 lab=_60632_/X }
C {devices/lab_pin.sym} 5420 -15430 0 1 {name=p5160 lab=_60659_/A }
C {sky130_stdcells/buf_2.sym} 5380 -15430 0 0 {name=X_60633_ }
C {devices/lab_pin.sym} 5300 -15330 0 0 {name=p5161 lab=_72579_/A }
C {devices/lab_pin.sym} 5300 -15290 0 0 {name=p5162 lab=_72579_/B }
C {devices/lab_pin.sym} 5300 -15250 0 0 {name=p5163 lab=_65842_/X }
C {devices/lab_pin.sym} 5460 -15290 0 1 {name=p5164 lab=_72619_/Y }
C {sky130_stdcells/a21oi_4.sym} 5380 -15290 0 0 {name=X_72619_ }
C {devices/lab_pin.sym} 5320 -15160 0 0 {name=p5165 lab=_79171_/B }
C {devices/lab_pin.sym} 5320 -15120 0 0 {name=p5166 lab=_79171_/C }
C {devices/lab_pin.sym} 5440 -15140 0 1 {name=p5167 lab=_79175_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -15140 0 0 {name=X_79175_ }
C {devices/lab_pin.sym} 5320 -15020 0 0 {name=p5168 lab=_45567_/A }
C {devices/lab_pin.sym} 5320 -14980 0 0 {name=p5169 lab=_45597_/B }
C {devices/lab_pin.sym} 5440 -15000 0 1 {name=p5170 lab=_45567_/Y }
C {sky130_stdcells/nor2_4.sym} 5380 -15000 0 0 {name=X_45567_ }
C {devices/lab_pin.sym} 5320 -14880 0 0 {name=p5171 lab=_76387_/A }
C {devices/lab_pin.sym} 5320 -14840 0 0 {name=p5172 lab=_76387_/B }
C {devices/lab_pin.sym} 5440 -14860 0 1 {name=p5173 lab=_81618_/D }
C {sky130_stdcells/xor2_4.sym} 5380 -14860 0 0 {name=X_76387_ }
C {devices/lab_pin.sym} 5300 -14770 0 0 {name=p5174 lab=_42774_/X }
C {devices/lab_pin.sym} 5300 -14730 0 0 {name=p5175 lab=_42775_/X }
C {devices/lab_pin.sym} 5300 -14690 0 0 {name=p5176 lab=_41332_/X }
C {devices/lab_pin.sym} 5300 -14650 0 0 {name=p5177 lab=_87722_/Q }
C {devices/lab_pin.sym} 5300 -14610 0 0 {name=p5178 lab=_42750_/X }
C {devices/lab_pin.sym} 5460 -14690 0 1 {name=p5179 lab=_42779_/Y }
C {sky130_stdcells/o32ai_4.sym} 5380 -14690 0 0 {name=X_42779_ }
C {devices/lab_pin.sym} 5320 -14540 0 0 {name=p5180 lab=_73599_/A }
C {devices/lab_pin.sym} 5320 -14500 0 0 {name=p5181 lab=_73599_/B }
C {devices/lab_pin.sym} 5440 -14520 0 1 {name=p5182 lab=_73599_/Y }
C {sky130_stdcells/nor2_4.sym} 5380 -14520 0 0 {name=X_73599_ }
C {devices/lab_pin.sym} 5340 -14390 0 0 {name=p5183 lab=_47306_/A }
C {devices/lab_pin.sym} 5420 -14390 0 1 {name=p5184 lab=_52973_/B }
C {sky130_stdcells/buf_2.sym} 5380 -14390 0 0 {name=X_47306_ }
C {devices/lab_pin.sym} 5300 -14290 0 0 {name=p5185 lab=_66136_/Y }
C {devices/lab_pin.sym} 5300 -14250 0 0 {name=p5186 lab=_66137_/X }
C {devices/lab_pin.sym} 5300 -14210 0 0 {name=p5187 lab=_66139_/Y }
C {devices/lab_pin.sym} 5460 -14250 0 1 {name=p5188 lab=_84154_/D }
C {sky130_stdcells/a21o_4.sym} 5380 -14250 0 0 {name=X_66140_ }
C {devices/lab_pin.sym} 5320 -14120 0 0 {name=p5189 lab=_78119_/X }
C {devices/lab_pin.sym} 5320 -14080 0 0 {name=p5190 lab=_78125_/Y }
C {devices/lab_pin.sym} 5440 -14100 0 1 {name=p5191 lab=_78126_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -14100 0 0 {name=X_78126_ }
C {devices/lab_pin.sym} 5340 -13970 0 0 {name=p5192 lab=_44518_/A }
C {devices/lab_pin.sym} 5420 -13970 0 1 {name=p5193 lab=_44518_/Y }
C {sky130_stdcells/inv_2.sym} 5380 -13970 0 0 {name=X_44518_ }
C {devices/lab_pin.sym} 5300 -13870 0 0 {name=p5194 lab=_75334_/X }
C {devices/lab_pin.sym} 5300 -13830 0 0 {name=p5195 lab=_75339_/C }
C {devices/lab_pin.sym} 5300 -13790 0 0 {name=p5196 lab=_75337_/Y }
C {devices/lab_pin.sym} 5460 -13830 0 1 {name=p5197 lab=_75340_/A }
C {sky130_stdcells/a21o_4.sym} 5380 -13830 0 0 {name=X_75338_ }
C {devices/lab_pin.sym} 5320 -13710 0 0 {name=p5198 lab=_63305_/X }
C {devices/lab_pin.sym} 5320 -13670 0 0 {name=p5199 lab=_63392_/B }
C {devices/lab_pin.sym} 5320 -13630 0 0 {name=p5200 lab=_79158_/B }
C {devices/lab_pin.sym} 5440 -13670 0 1 {name=p5201 lab=_63352_/Y }
C {sky130_stdcells/nor3_4.sym} 5380 -13670 0 0 {name=X_63352_ }
C {devices/lab_pin.sym} 5340 -13530 0 0 {name=p5202 lab=_46485_/X }
C {devices/lab_pin.sym} 5420 -13530 0 1 {name=p5203 lab=_48286_/X }
C {sky130_stdcells/buf_2.sym} 5380 -13530 0 0 {name=X_48286_ }
C {devices/lab_pin.sym} 5300 -13440 0 0 {name=p5204 lab=_79139_/A }
C {devices/lab_pin.sym} 5300 -13400 0 0 {name=p5205 lab=_60132_/X }
C {devices/lab_pin.sym} 5300 -13360 0 0 {name=p5206 lab=_60562_/Y }
C {devices/lab_pin.sym} 5300 -13320 0 0 {name=p5207 lab=_60563_/X }
C {devices/lab_pin.sym} 5460 -13380 0 1 {name=p5208 lab=_60564_/X }
C {sky130_stdcells/a2bb2o_4.sym} 5380 -13380 0 0 {name=X_60564_ }
C {devices/lab_pin.sym} 5300 -13250 0 0 {name=p5209 lab=_45434_/X }
C {devices/lab_pin.sym} 5300 -13210 0 0 {name=p5210 lab=_61406_/A }
C {devices/lab_pin.sym} 5300 -13170 0 0 {name=p5211 lab=_45452_/X }
C {devices/lab_pin.sym} 5460 -13210 0 1 {name=p5212 lab=_45498_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -13210 0 0 {name=X_45498_ }
C {devices/lab_pin.sym} 5300 -13090 0 0 {name=p5213 lab=_62301_/Y }
C {devices/lab_pin.sym} 5300 -13050 0 0 {name=p5214 lab=_62253_/X }
C {devices/lab_pin.sym} 5300 -13010 0 0 {name=p5215 lab=_62302_/Y }
C {devices/lab_pin.sym} 5460 -13050 0 1 {name=p5216 lab=_62303_/Y }
C {sky130_stdcells/a21oi_4.sym} 5380 -13050 0 0 {name=X_62303_ }
C {devices/lab_pin.sym} 5320 -12940 0 0 {name=p5217 lab=_47210_/A }
C {devices/lab_pin.sym} 5320 -12900 0 0 {name=p5218 lab=_47228_/B }
C {devices/lab_pin.sym} 5320 -12860 0 0 {name=p5219 lab=_47234_/X }
C {devices/lab_pin.sym} 5320 -12820 0 0 {name=p5220 lab=_52934_/D }
C {devices/lab_pin.sym} 5440 -12880 0 1 {name=p5221 lab=_47237_/X }
C {sky130_stdcells/and4_4.sym} 5380 -12880 0 0 {name=X_47237_ }
C {devices/lab_pin.sym} 5320 -12740 0 0 {name=p5222 lab=_64694_/A }
C {devices/lab_pin.sym} 5320 -12700 0 0 {name=p5223 lab=_73830_/B }
C {devices/lab_pin.sym} 5440 -12720 0 1 {name=p5224 lab=_66071_/X }
C {sky130_stdcells/and2_4.sym} 5380 -12720 0 0 {name=X_66071_ }
C {devices/lab_pin.sym} 5320 -12600 0 0 {name=p5225 lab=_84562_/Q }
C {devices/lab_pin.sym} 5320 -12560 0 0 {name=p5226 lab=_78057_/B }
C {devices/lab_pin.sym} 5440 -12580 0 1 {name=p5227 lab=_78057_/X }
C {sky130_stdcells/xor2_4.sym} 5380 -12580 0 0 {name=X_78057_ }
C {devices/lab_pin.sym} 5340 -12450 0 0 {name=p5228 lab=_44352_/X }
C {devices/lab_pin.sym} 5420 -12450 0 1 {name=p5229 lab=_44449_/X }
C {sky130_stdcells/buf_2.sym} 5380 -12450 0 0 {name=X_44449_ }
C {devices/lab_pin.sym} 5300 -12370 0 0 {name=p5230 lab=_63248_/X }
C {devices/lab_pin.sym} 5300 -12330 0 0 {name=p5231 lab=_63278_/Y }
C {devices/lab_pin.sym} 5300 -12290 0 0 {name=p5232 lab=_63279_/X }
C {devices/lab_pin.sym} 5300 -12250 0 0 {name=p5233 lab=_63280_/Y }
C {devices/lab_pin.sym} 5300 -12220 0 0 {name=p5234 lab=_63282_/Y }
C {devices/lab_pin.sym} 5460 -12290 0 1 {name=p5235 lab=_63283_/X }
C {sky130_stdcells/a41o_4.sym} 5380 -12290 0 0 {name=X_63283_ }
C {devices/lab_pin.sym} 5320 -12140 0 0 {name=p5236 lab=_75269_/A }
C {devices/lab_pin.sym} 5320 -12100 0 0 {name=p5237 lab=_80944_/D }
C {devices/lab_pin.sym} 5440 -12120 0 1 {name=p5238 lab=_75269_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -12120 0 0 {name=X_75269_ }
C {devices/lab_pin.sym} 5300 -12010 0 0 {name=p5239 lab=_60476_/C }
C {devices/lab_pin.sym} 5300 -11970 0 0 {name=p5240 lab=_60570_/B }
C {devices/lab_pin.sym} 5300 -11930 0 0 {name=p5241 lab=_72590_/A }
C {devices/lab_pin.sym} 5460 -11970 0 1 {name=p5242 lab=_60495_/X }
C {sky130_stdcells/o21a_4.sym} 5380 -11970 0 0 {name=X_60495_ }
C {devices/lab_pin.sym} 5340 -11830 0 0 {name=p5243 lab=_64766_/A }
C {devices/lab_pin.sym} 5420 -11830 0 1 {name=p5244 lab=_65022_/X }
C {sky130_stdcells/buf_2.sym} 5380 -11830 0 0 {name=X_65022_ }
C {devices/lab_pin.sym} 5320 -11720 0 0 {name=p5245 lab=_77009_/A }
C {devices/lab_pin.sym} 5320 -11680 0 0 {name=p5246 lab=_82276_/D }
C {devices/lab_pin.sym} 5440 -11700 0 1 {name=p5247 lab=_77019_/A }
C {sky130_stdcells/nor2_4.sym} 5380 -11700 0 0 {name=X_77008_ }
C {devices/lab_pin.sym} 5320 -11600 0 0 {name=p5248 lab=_62362_/A }
C {devices/lab_pin.sym} 5320 -11560 0 0 {name=p5249 lab=_62234_/B }
C {devices/lab_pin.sym} 5320 -11520 0 0 {name=p5250 lab=_62229_/Y }
C {devices/lab_pin.sym} 5320 -11480 0 0 {name=p5251 lab=_62234_/D }
C {devices/lab_pin.sym} 5440 -11540 0 1 {name=p5252 lab=_62234_/Y }
C {sky130_stdcells/nand4_4.sym} 5380 -11540 0 0 {name=X_62234_ }
C {devices/lab_pin.sym} 5300 -11410 0 0 {name=p5253 lab=_86663_/Q }
C {devices/lab_pin.sym} 5300 -11370 0 0 {name=p5254 lab=_47145_/X }
C {devices/lab_pin.sym} 5300 -11330 0 0 {name=p5255 lab=_47167_/Y }
C {devices/lab_pin.sym} 5460 -11370 0 1 {name=p5256 lab=_47168_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -11370 0 0 {name=X_47168_ }
C {devices/lab_pin.sym} 5340 -11230 0 0 {name=p5257 lab=_46119_/A }
C {devices/lab_pin.sym} 5420 -11230 0 1 {name=p5258 lab=_46120_/B }
C {sky130_stdcells/buf_2.sym} 5380 -11230 0 0 {name=X_46119_ }
C {devices/lab_pin.sym} 5300 -11130 0 0 {name=p5259 lab=_81966_/D }
C {devices/lab_pin.sym} 5300 -11090 0 0 {name=p5260 lab=_69763_/X }
C {devices/lab_pin.sym} 5300 -11050 0 0 {name=p5261 lab=_69829_/X }
C {devices/lab_pin.sym} 5460 -11090 0 1 {name=p5262 lab=_69830_/X }
C {sky130_stdcells/a21bo_4.sym} 5380 -11090 0 0 {name=X_69830_ }
C {devices/lab_pin.sym} 5300 -10990 0 0 {name=p5263 lab=_62157_/X }
C {devices/lab_pin.sym} 5300 -10950 0 0 {name=p5264 lab=_62159_/X }
C {devices/lab_pin.sym} 5300 -10910 0 0 {name=p5265 lab=_62164_/Y }
C {devices/lab_pin.sym} 5300 -10870 0 0 {name=p5266 lab=_84868_/Q }
C {devices/lab_pin.sym} 5300 -10830 0 0 {name=p5267 lab=_62117_/X }
C {devices/lab_pin.sym} 5460 -10910 0 1 {name=p5268 lab=_62165_/Y }
C {sky130_stdcells/o32ai_4.sym} 5380 -10910 0 0 {name=X_62165_ }
C {devices/lab_pin.sym} 5340 -10750 0 0 {name=p5269 lab=_53369_/B }
C {devices/lab_pin.sym} 5420 -10750 0 1 {name=p5270 lab=_52855_/B }
C {sky130_stdcells/buf_2.sym} 5380 -10750 0 0 {name=X_47099_ }
C {devices/lab_pin.sym} 5340 -10630 0 0 {name=p5271 lab=_64474_/A }
C {devices/lab_pin.sym} 5420 -10630 0 1 {name=p5272 lab=_64546_/A }
C {sky130_stdcells/buf_2.sym} 5380 -10630 0 0 {name=X_61116_ }
C {devices/lab_pin.sym} 5340 -10510 0 0 {name=p5273 lab=clkbuf_9_326_0_CLK/X }
C {devices/lab_pin.sym} 5420 -10510 0 1 {name=p5274 lab=_87188_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 5380 -10510 0 0 {name=Xclkbuf_10_653_0_CLK }
C {devices/lab_pin.sym} 5300 -10410 0 0 {name=p5275 lab=_81971_/D }
C {devices/lab_pin.sym} 5300 -10370 0 0 {name=p5276 lab=_69696_/X }
C {devices/lab_pin.sym} 5300 -10330 0 0 {name=p5277 lab=_69760_/X }
C {devices/lab_pin.sym} 5460 -10370 0 1 {name=p5278 lab=_83899_/D }
C {sky130_stdcells/a21bo_4.sym} 5380 -10370 0 0 {name=X_69761_ }
C {devices/lab_pin.sym} 5320 -10240 0 0 {name=p5279 lab=_66972_/X }
C {devices/lab_pin.sym} 5320 -10200 0 0 {name=p5280 lab=_87618_/Q }
C {devices/lab_pin.sym} 5440 -10220 0 1 {name=p5281 lab=_66973_/X }
C {sky130_stdcells/and2_4.sym} 5380 -10220 0 0 {name=X_66973_ }
C {devices/lab_pin.sym} 5320 -10120 0 0 {name=p5282 lab=_84785_/Q }
C {devices/lab_pin.sym} 5320 -10080 0 0 {name=p5283 lab=_62128_/B }
C {devices/lab_pin.sym} 5320 -10040 0 0 {name=p5284 lab=_62128_/C }
C {devices/lab_pin.sym} 5320 -10000 0 0 {name=p5285 lab=_62060_/X }
C {devices/lab_pin.sym} 5440 -10060 0 1 {name=p5286 lab=_62096_/Y }
C {sky130_stdcells/nand4_4.sym} 5380 -10060 0 0 {name=X_62096_ }
C {devices/lab_pin.sym} 5340 -9910 0 0 {name=p5287 lab=_82643_/Q }
C {devices/lab_pin.sym} 5420 -9910 0 1 {name=p5288 lab=_78959_/Y }
C {sky130_stdcells/inv_2.sym} 5380 -9910 0 0 {name=X_78959_ }
C {devices/lab_pin.sym} 5300 -9810 0 0 {name=p5289 lab=_83964_/Q }
C {devices/lab_pin.sym} 5300 -9770 0 0 {name=p5290 lab=_68586_/X }
C {devices/lab_pin.sym} 5300 -9730 0 0 {name=p5291 lab=_68711_/X }
C {devices/lab_pin.sym} 5460 -9770 0 1 {name=p5292 lab=_68712_/X }
C {sky130_stdcells/a21bo_4.sym} 5380 -9770 0 0 {name=X_68712_ }
C {devices/lab_pin.sym} 5340 -9630 0 0 {name=p5293 lab=_65660_/A }
C {devices/lab_pin.sym} 5420 -9630 0 1 {name=p5294 lab=_65924_/X }
C {sky130_stdcells/buf_2.sym} 5380 -9630 0 0 {name=X_65924_ }
C {devices/lab_pin.sym} 5320 -9530 0 0 {name=p5295 lab=_61055_/A }
C {devices/lab_pin.sym} 5320 -9490 0 0 {name=p5296 lab=_61000_/X }
C {devices/lab_pin.sym} 5320 -9450 0 0 {name=p5297 lab=_76977_/A }
C {devices/lab_pin.sym} 5440 -9490 0 1 {name=p5298 lab=_61047_/X }
C {sky130_stdcells/or3_4.sym} 5380 -9490 0 0 {name=X_61047_ }
C {devices/lab_pin.sym} 5340 -9350 0 0 {name=p5299 lab=clkbuf_8_72_0_CLK/X }
C {devices/lab_pin.sym} 5420 -9350 0 1 {name=p5300 lab=clkbuf_9_144_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 5380 -9350 0 0 {name=Xclkbuf_9_144_0_CLK }
C {devices/lab_pin.sym} 5290 -9230 0 0 {name=p5301 lab=_81970_/CLK }
C {devices/lab_pin.sym} 5290 -9210 0 0 {name=p5302 lab=_83898_/Q }
C {devices/lab_pin.sym} 5470 -9230 0 1 {name=p5303 lab=_77732_/B }
C {sky130_stdcells/dfxtp_4.sym} 5380 -9220 0 0 {name=X_81970_ }
C {devices/lab_pin.sym} 5300 -9120 0 0 {name=p5304 lab=_44539_/A }
C {devices/lab_pin.sym} 5300 -9080 0 0 {name=p5305 lab=_69690_/X }
C {devices/lab_pin.sym} 5300 -9040 0 0 {name=p5306 lab=_69611_/X }
C {devices/lab_pin.sym} 5300 -9000 0 0 {name=p5307 lab=_69691_/X }
C {devices/lab_pin.sym} 5460 -9060 0 1 {name=p5308 lab=_69692_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -9060 0 0 {name=X_69692_ }
C {devices/lab_pin.sym} 5340 -8910 0 0 {name=p5309 lab=clkbuf_9_71_0_CLK/A }
C {devices/lab_pin.sym} 5420 -8910 0 1 {name=p5310 lab=clkbuf_9_71_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 5380 -8910 0 0 {name=Xclkbuf_9_71_0_CLK }
C {devices/lab_pin.sym} 5320 -8800 0 0 {name=p5311 lab=_49809_/A }
C {devices/lab_pin.sym} 5320 -8760 0 0 {name=p5312 lab=_53021_/B }
C {devices/lab_pin.sym} 5440 -8780 0 1 {name=p5313 lab=_49809_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -8780 0 0 {name=X_49809_ }
C {devices/lab_pin.sym} 5290 -8650 0 0 {name=p5314 lab=_84105_/CLK }
C {devices/lab_pin.sym} 5290 -8630 0 0 {name=p5315 lab=_80921_/D }
C {devices/lab_pin.sym} 5470 -8650 0 1 {name=p5316 lab=_75778_/A }
C {sky130_stdcells/dfxtp_4.sym} 5380 -8640 0 0 {name=X_80921_ }
C {devices/lab_pin.sym} 5300 -8530 0 0 {name=p5317 lab=_68639_/X }
C {devices/lab_pin.sym} 5300 -8490 0 0 {name=p5318 lab=_68642_/X }
C {devices/lab_pin.sym} 5300 -8450 0 0 {name=p5319 lab=_68442_/X }
C {devices/lab_pin.sym} 5460 -8490 0 1 {name=p5320 lab=_68647_/A }
C {sky130_stdcells/a21o_4.sym} 5380 -8490 0 0 {name=X_68643_ }
C {devices/lab_pin.sym} 5320 -8370 0 0 {name=p5321 lab=_65855_/A }
C {devices/lab_pin.sym} 5320 -8330 0 0 {name=p5322 lab=_65916_/B }
C {devices/lab_pin.sym} 5320 -8290 0 0 {name=p5323 lab=_65855_/C }
C {devices/lab_pin.sym} 5440 -8330 0 1 {name=p5324 lab=_65855_/X }
C {sky130_stdcells/and3_4.sym} 5380 -8330 0 0 {name=X_65855_ }
C {devices/lab_pin.sym} 5340 -8190 0 0 {name=p5325 lab=clkbuf_9_334_0_CLK/X }
C {devices/lab_pin.sym} 5420 -8190 0 1 {name=p5326 lab=_88386_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 5380 -8190 0 0 {name=Xclkbuf_10_668_0_CLK }
C {devices/lab_pin.sym} 5340 -8070 0 0 {name=p5327 lab=_52515_/A }
C {devices/lab_pin.sym} 5420 -8070 0 1 {name=p5328 lab=_52821_/A }
C {sky130_stdcells/buf_2.sym} 5380 -8070 0 0 {name=X_52820_ }
C {devices/lab_pin.sym} 5340 -7950 0 0 {name=p5329 lab=_64806_/A }
C {devices/lab_pin.sym} 5420 -7950 0 1 {name=p5330 lab=_64807_/A }
C {sky130_stdcells/buf_2.sym} 5380 -7950 0 0 {name=X_64806_ }
C {devices/lab_pin.sym} 5290 -7830 0 0 {name=p5331 lab=_86424_/CLK }
C {devices/lab_pin.sym} 5290 -7810 0 0 {name=p5332 lab=_83640_/D }
C {devices/lab_pin.sym} 5470 -7830 0 1 {name=p5333 lab=_83640_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -7820 0 0 {name=X_83640_ }
C {devices/lab_pin.sym} 5290 -7690 0 0 {name=p5334 lab=_80854_/CLK }
C {devices/lab_pin.sym} 5290 -7670 0 0 {name=p5335 lab=_80852_/D }
C {devices/lab_pin.sym} 5470 -7690 0 1 {name=p5336 lab=_74989_/C }
C {sky130_stdcells/dfxtp_4.sym} 5380 -7680 0 0 {name=X_80852_ }
C {devices/lab_pin.sym} 5320 -7560 0 0 {name=p5337 lab=_68574_/A }
C {devices/lab_pin.sym} 5320 -7520 0 0 {name=p5338 lab=_68573_/X }
C {devices/lab_pin.sym} 5440 -7540 0 1 {name=p5339 lab=_68574_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -7540 0 0 {name=X_68574_ }
C {devices/lab_pin.sym} 5300 -7430 0 0 {name=p5340 lab=_65516_/X }
C {devices/lab_pin.sym} 5300 -7390 0 0 {name=p5341 lab=_65208_/Y }
C {devices/lab_pin.sym} 5300 -7350 0 0 {name=p5342 lab=_65785_/Y }
C {devices/lab_pin.sym} 5460 -7390 0 1 {name=p5343 lab=_65786_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -7390 0 0 {name=X_65786_ }
C {devices/lab_pin.sym} 5320 -7260 0 0 {name=p5344 lab=_58403_/A }
C {devices/lab_pin.sym} 5320 -7220 0 0 {name=p5345 lab=_60493_/X }
C {devices/lab_pin.sym} 5440 -7240 0 1 {name=p5346 lab=_62998_/Y }
C {sky130_stdcells/nor2_4.sym} 5380 -7240 0 0 {name=X_62998_ }
C {devices/lab_pin.sym} 5340 -7110 0 0 {name=p5347 lab=clkbuf_8_79_0_CLK/X }
C {devices/lab_pin.sym} 5420 -7110 0 1 {name=p5348 lab=clkbuf_9_159_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 5380 -7110 0 0 {name=Xclkbuf_9_159_0_CLK }
C {devices/lab_pin.sym} 5320 -7000 0 0 {name=p5349 lab=_67497_/A }
C {devices/lab_pin.sym} 5320 -6960 0 0 {name=p5350 lab=_87723_/Q }
C {devices/lab_pin.sym} 5440 -6980 0 1 {name=p5351 lab=_67525_/X }
C {sky130_stdcells/and2_4.sym} 5380 -6980 0 0 {name=X_67525_ }
C {devices/lab_pin.sym} 5300 -6870 0 0 {name=p5352 lab=_52749_/Y }
C {devices/lab_pin.sym} 5300 -6830 0 0 {name=p5353 lab=_52728_/X }
C {devices/lab_pin.sym} 5300 -6790 0 0 {name=p5354 lab=_52750_/X }
C {devices/lab_pin.sym} 5460 -6830 0 1 {name=p5355 lab=_52751_/Y }
C {sky130_stdcells/a21oi_4.sym} 5380 -6830 0 0 {name=X_52751_ }
C {devices/lab_pin.sym} 5290 -6690 0 0 {name=p5356 lab=_86500_/CLK }
C {devices/lab_pin.sym} 5290 -6670 0 0 {name=p5357 lab=_71212_/Y }
C {devices/lab_pin.sym} 5470 -6690 0 1 {name=p5358 lab=_48602_/A }
C {sky130_stdcells/dfxtp_4.sym} 5380 -6680 0 0 {name=X_83571_ }
C {devices/lab_pin.sym} 5320 -6560 0 0 {name=p5359 lab=_64737_/A }
C {devices/lab_pin.sym} 5320 -6520 0 0 {name=p5360 lab=_64736_/Y }
C {devices/lab_pin.sym} 5440 -6540 0 1 {name=p5361 lab=_64737_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -6540 0 0 {name=X_64737_ }
C {devices/lab_pin.sym} 5340 -6410 0 0 {name=p5362 lab=clkbuf_2_2_2_CLK/A }
C {devices/lab_pin.sym} 5420 -6410 0 1 {name=p5363 lab=clkbuf_2_2_2_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 5380 -6410 0 0 {name=Xclkbuf_2_2_2_CLK }
C {devices/lab_pin.sym} 5340 -6290 0 0 {name=p5364 lab=clkbuf_9_87_0_CLK/A }
C {devices/lab_pin.sym} 5420 -6290 0 1 {name=p5365 lab=clkbuf_9_86_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 5380 -6290 0 0 {name=Xclkbuf_9_86_0_CLK }
C {devices/lab_pin.sym} 5320 -6200 0 0 {name=p5366 lab=_61949_/A }
C {devices/lab_pin.sym} 5320 -6160 0 0 {name=p5367 lab=_61949_/B }
C {devices/lab_pin.sym} 5320 -6120 0 0 {name=p5368 lab=_61949_/C }
C {devices/lab_pin.sym} 5320 -6080 0 0 {name=p5369 lab=_63168_/B }
C {devices/lab_pin.sym} 5440 -6140 0 1 {name=p5370 lab=_61949_/X }
C {sky130_stdcells/and4_4.sym} 5380 -6140 0 0 {name=X_61949_ }
C {devices/lab_pin.sym} 5290 -5990 0 0 {name=p5371 lab=_80849_/CLK }
C {devices/lab_pin.sym} 5290 -5970 0 0 {name=p5372 lab=_80783_/D }
C {devices/lab_pin.sym} 5470 -5990 0 1 {name=p5373 lab=_80783_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -5980 0 0 {name=X_80783_ }
C {devices/lab_pin.sym} 5290 -5850 0 0 {name=p5374 lab=_83001_/CLK }
C {devices/lab_pin.sym} 5290 -5830 0 0 {name=p5375 lab=_56024_/Y }
C {devices/lab_pin.sym} 5470 -5850 0 1 {name=p5376 lab=_55963_/B }
C {sky130_stdcells/dfxtp_4.sym} 5380 -5840 0 0 {name=X_85310_ }
C {devices/lab_pin.sym} 5340 -5710 0 0 {name=p5377 lab=_50222_/X }
C {devices/lab_pin.sym} 5420 -5710 0 1 {name=p5378 lab=_51717_/A }
C {sky130_stdcells/buf_2.sym} 5380 -5710 0 0 {name=X_51702_ }
C {devices/lab_pin.sym} 5290 -5590 0 0 {name=p5379 lab=_82711_/CLK }
C {devices/lab_pin.sym} 5290 -5570 0 0 {name=p5380 lab=_79021_/B }
C {devices/lab_pin.sym} 5470 -5590 0 1 {name=p5381 lab=_82522_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -5580 0 0 {name=X_82522_ }
C {devices/lab_pin.sym} 5320 -5460 0 0 {name=p5382 lab=_55470_/A }
C {devices/lab_pin.sym} 5320 -5420 0 0 {name=p5383 lab=_55470_/B }
C {devices/lab_pin.sym} 5440 -5440 0 1 {name=p5384 lab=_55470_/Y }
C {sky130_stdcells/nor2_4.sym} 5380 -5440 0 0 {name=X_55470_ }
C {devices/lab_pin.sym} 5320 -5320 0 0 {name=p5385 lab=_67364_/X }
C {devices/lab_pin.sym} 5320 -5280 0 0 {name=p5386 lab=_67456_/B }
C {devices/lab_pin.sym} 5440 -5300 0 1 {name=p5387 lab=_67456_/X }
C {sky130_stdcells/and2_4.sym} 5380 -5300 0 0 {name=X_67456_ }
C {devices/lab_pin.sym} 5290 -5170 0 0 {name=p5388 lab=_86610_/CLK }
C {devices/lab_pin.sym} 5290 -5150 0 0 {name=p5389 lab=_49970_/Y }
C {devices/lab_pin.sym} 5470 -5170 0 1 {name=p5390 lab=_72301_/B }
C {sky130_stdcells/dfxtp_4.sym} 5380 -5160 0 0 {name=X_86290_ }
C {devices/lab_pin.sym} 5300 -5050 0 0 {name=p5391 lab=_52678_/Y }
C {devices/lab_pin.sym} 5300 -5010 0 0 {name=p5392 lab=_52673_/X }
C {devices/lab_pin.sym} 5300 -4970 0 0 {name=p5393 lab=_52681_/X }
C {devices/lab_pin.sym} 5460 -5010 0 1 {name=p5394 lab=_52682_/Y }
C {sky130_stdcells/a21oi_4.sym} 5380 -5010 0 0 {name=X_52682_ }
C {devices/lab_pin.sym} 5320 -4880 0 0 {name=p5395 lab=_64767_/A }
C {devices/lab_pin.sym} 5320 -4840 0 0 {name=p5396 lab=_85822_/Q }
C {devices/lab_pin.sym} 5440 -4860 0 1 {name=p5397 lab=_64668_/X }
C {sky130_stdcells/and2_4.sym} 5380 -4860 0 0 {name=X_64668_ }
C {devices/lab_pin.sym} 5340 -4730 0 0 {name=p5398 lab=_54284_/A }
C {devices/lab_pin.sym} 5420 -4730 0 1 {name=p5399 lab=_54475_/A }
C {sky130_stdcells/buf_2.sym} 5380 -4730 0 0 {name=X_54421_ }
C {devices/lab_pin.sym} 5320 -4630 0 0 {name=p5400 lab=_66389_/A }
C {devices/lab_pin.sym} 5320 -4590 0 0 {name=p5401 lab=_66402_/B }
C {devices/lab_pin.sym} 5320 -4550 0 0 {name=p5402 lab=_66407_/C }
C {devices/lab_pin.sym} 5440 -4590 0 1 {name=p5403 lab=_66407_/Y }
C {sky130_stdcells/nor3_4.sym} 5380 -4590 0 0 {name=X_66407_ }
C {devices/lab_pin.sym} 5290 -4450 0 0 {name=p5404 lab=_85241_/CLK }
C {devices/lab_pin.sym} 5290 -4430 0 0 {name=p5405 lab=_56310_/Y }
C {devices/lab_pin.sym} 5470 -4450 0 1 {name=p5406 lab=_85241_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -4440 0 0 {name=X_85241_ }
C {devices/lab_pin.sym} 5300 -4330 0 0 {name=p5407 lab=_85974_/Q }
C {devices/lab_pin.sym} 5300 -4290 0 0 {name=p5408 lab=_51621_/X }
C {devices/lab_pin.sym} 5300 -4250 0 0 {name=p5409 lab=_51632_/Y }
C {devices/lab_pin.sym} 5460 -4290 0 1 {name=p5410 lab=_51633_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -4290 0 0 {name=X_51633_ }
C {devices/lab_pin.sym} 5300 -4180 0 0 {name=p5411 lab=_58268_/A }
C {devices/lab_pin.sym} 5300 -4140 0 0 {name=p5412 lab=_60671_/C }
C {devices/lab_pin.sym} 5300 -4100 0 0 {name=p5413 lab=_62057_/D }
C {devices/lab_pin.sym} 5300 -4060 0 0 {name=p5414 lab=_63371_/A }
C {devices/lab_pin.sym} 5460 -4120 0 1 {name=p5415 lab=_63619_/X }
C {sky130_stdcells/a2bb2o_4.sym} 5380 -4120 0 0 {name=X_63619_ }
C {devices/lab_pin.sym} 5290 -3970 0 0 {name=p5416 lab=_82248_/CLK }
C {devices/lab_pin.sym} 5290 -3950 0 0 {name=p5417 lab=_79145_/X }
C {devices/lab_pin.sym} 5470 -3970 0 1 {name=p5418 lab=_82453_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5380 -3960 0 0 {name=X_82453_ }
C {devices/lab_pin.sym} 5320 -3840 0 0 {name=p5419 lab=_67387_/A }
C {devices/lab_pin.sym} 5320 -3800 0 0 {name=p5420 lab=_67386_/X }
C {devices/lab_pin.sym} 5440 -3820 0 1 {name=p5421 lab=_67387_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -3820 0 0 {name=X_67387_ }
C {devices/lab_pin.sym} 5340 -3690 0 0 {name=p5422 lab=_64598_/X }
C {devices/lab_pin.sym} 5420 -3690 0 1 {name=p5423 lab=_64599_/X }
C {sky130_stdcells/buf_2.sym} 5380 -3690 0 0 {name=X_64599_ }
C {devices/lab_pin.sym} 5290 -3570 0 0 {name=p5424 lab=_81322_/CLK }
C {devices/lab_pin.sym} 5290 -3550 0 0 {name=p5425 lab=_81404_/D }
C {devices/lab_pin.sym} 5470 -3570 0 1 {name=p5426 lab=_76735_/B }
C {sky130_stdcells/dfxtp_4.sym} 5380 -3560 0 0 {name=X_81404_ }
C {devices/lab_pin.sym} 5320 -3460 0 0 {name=p5427 lab=_57140_/A }
C {devices/lab_pin.sym} 5320 -3420 0 0 {name=p5428 lab=_57140_/B }
C {devices/lab_pin.sym} 5320 -3380 0 0 {name=p5429 lab=_83322_/Q }
C {devices/lab_pin.sym} 5320 -3340 0 0 {name=p5430 lab=_57129_/Y }
C {devices/lab_pin.sym} 5440 -3400 0 1 {name=p5431 lab=_57141_/A }
C {sky130_stdcells/and4_4.sym} 5380 -3400 0 0 {name=X_57140_ }
C {devices/lab_pin.sym} 5300 -3280 0 0 {name=p5432 lab=_87476_/Q }
C {devices/lab_pin.sym} 5300 -3240 0 0 {name=p5433 lab=_69098_/X }
C {devices/lab_pin.sym} 5300 -3200 0 0 {name=p5434 lab=_69124_/X }
C {devices/lab_pin.sym} 5300 -3160 0 0 {name=p5435 lab=_69125_/X }
C {devices/lab_pin.sym} 5460 -3220 0 1 {name=p5436 lab=_69126_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -3220 0 0 {name=X_69126_ }
C {devices/lab_pin.sym} 5300 -3090 0 0 {name=p5437 lab=_85458_/Q }
C {devices/lab_pin.sym} 5300 -3050 0 0 {name=p5438 lab=_54349_/X }
C {devices/lab_pin.sym} 5300 -3010 0 0 {name=p5439 lab=_54351_/Y }
C {devices/lab_pin.sym} 5460 -3050 0 1 {name=p5440 lab=_54352_/Y }
C {sky130_stdcells/o21ai_4.sym} 5380 -3050 0 0 {name=X_54352_ }
C {devices/lab_pin.sym} 5300 -2930 0 0 {name=p5441 lab=_66335_/X }
C {devices/lab_pin.sym} 5300 -2890 0 0 {name=p5442 lab=_66337_/X }
C {devices/lab_pin.sym} 5300 -2850 0 0 {name=p5443 lab=_64701_/X }
C {devices/lab_pin.sym} 5460 -2890 0 1 {name=p5444 lab=_66338_/X }
C {sky130_stdcells/a21o_4.sym} 5380 -2890 0 0 {name=X_66338_ }
C {devices/lab_pin.sym} 5290 -2750 0 0 {name=p5445 lab=_85168_/CLK }
C {devices/lab_pin.sym} 5290 -2730 0 0 {name=p5446 lab=_56502_/Y }
C {devices/lab_pin.sym} 5470 -2750 0 1 {name=p5447 lab=_56501_/C }
C {sky130_stdcells/dfxtp_4.sym} 5380 -2740 0 0 {name=X_85172_ }
C {devices/lab_pin.sym} 5300 -2630 0 0 {name=p5448 lab=_51562_/Y }
C {devices/lab_pin.sym} 5300 -2590 0 0 {name=p5449 lab=_51557_/X }
C {devices/lab_pin.sym} 5300 -2550 0 0 {name=p5450 lab=_51563_/X }
C {devices/lab_pin.sym} 5460 -2590 0 1 {name=p5451 lab=_51564_/Y }
C {sky130_stdcells/a21oi_4.sym} 5380 -2590 0 0 {name=X_51564_ }
C {devices/lab_pin.sym} 5290 -2450 0 0 {name=p5452 lab=_83703_/CLK }
C {devices/lab_pin.sym} 5290 -2430 0 0 {name=p5453 lab=_82192_/Q }
C {devices/lab_pin.sym} 5470 -2450 0 1 {name=p5454 lab=_47083_/A }
C {sky130_stdcells/dfxtp_4.sym} 5380 -2440 0 0 {name=X_82384_ }
C {devices/lab_pin.sym} 5320 -2340 0 0 {name=p5455 lab=_53293_/A }
C {devices/lab_pin.sym} 5320 -2300 0 0 {name=p5456 lab=_53293_/B }
C {devices/lab_pin.sym} 5320 -2260 0 0 {name=p5457 lab=_53302_/X }
C {devices/lab_pin.sym} 5320 -2220 0 0 {name=p5458 lab=_52785_/D }
C {devices/lab_pin.sym} 5440 -2280 0 1 {name=p5459 lab=_53303_/X }
C {sky130_stdcells/and4_4.sym} 5380 -2280 0 0 {name=X_53303_ }
C {devices/lab_pin.sym} 5340 -2130 0 0 {name=p5460 lab=clkbuf_9_303_0_CLK/X }
C {devices/lab_pin.sym} 5420 -2130 0 1 {name=p5461 lab=_81954_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 5380 -2130 0 0 {name=Xclkbuf_10_606_0_CLK }
C {devices/lab_pin.sym} 5290 -2010 0 0 {name=p5462 lab=_84210_/CLK }
C {devices/lab_pin.sym} 5290 -1990 0 0 {name=p5463 lab=_84123_/D }
C {devices/lab_pin.sym} 5470 -2010 0 1 {name=p5464 lab=_66435_/A }
C {sky130_stdcells/dfxtp_4.sym} 5380 -2000 0 0 {name=X_84123_ }
C {devices/lab_pin.sym} 5320 -1890 0 0 {name=p5465 lab=_52218_/A }
C {devices/lab_pin.sym} 5320 -1850 0 0 {name=p5466 lab=_50526_/B }
C {devices/lab_pin.sym} 5320 -1810 0 0 {name=p5467 lab=_50526_/C }
C {devices/lab_pin.sym} 5440 -1850 0 1 {name=p5468 lab=_50515_/X }
C {sky130_stdcells/and3_4.sym} 5380 -1850 0 0 {name=X_50515_ }
C {devices/lab_pin.sym} 5320 -1720 0 0 {name=p5469 lab=_57179_/A }
C {devices/lab_pin.sym} 5320 -1680 0 0 {name=p5470 lab=_57071_/B }
C {devices/lab_pin.sym} 5440 -1700 0 1 {name=p5471 lab=_57071_/Y }
C {sky130_stdcells/nand2_4.sym} 5380 -1700 0 0 {name=X_57071_ }
C {devices/lab_pin.sym} 5290 -1570 0 0 {name=p5472 lab=_81352_/CLK }
C {devices/lab_pin.sym} 5290 -1550 0 0 {name=p5473 lab=_76469_/X }
C {devices/lab_pin.sym} 5470 -1570 0 1 {name=p5474 lab=_81711_/D }
C {sky130_stdcells/dfxtp_4.sym} 5380 -1560 0 0 {name=X_81335_ }
C {devices/lab_pin.sym} 5300 -1450 0 0 {name=p5475 lab=_69054_/X }
C {devices/lab_pin.sym} 5300 -1410 0 0 {name=p5476 lab=_69056_/X }
C {devices/lab_pin.sym} 5300 -1370 0 0 {name=p5477 lab=_69035_/X }
C {devices/lab_pin.sym} 5460 -1410 0 1 {name=p5478 lab=_69057_/X }
C {sky130_stdcells/a21o_4.sym} 5380 -1410 0 0 {name=X_69057_ }
C {devices/lab_pin.sym} 5340 -1270 0 0 {name=p5479 lab=_43177_/Y }
C {devices/lab_pin.sym} 5420 -1270 0 1 {name=p5480 lab=_54284_/A }
C {sky130_stdcells/buf_2.sym} 5380 -1270 0 0 {name=X_54283_ }
C {devices/lab_pin.sym} 5300 -1180 0 0 {name=p5481 lab=_66266_/X }
C {devices/lab_pin.sym} 5300 -1140 0 0 {name=p5482 lab=_86216_/Q }
C {devices/lab_pin.sym} 5300 -1100 0 0 {name=p5483 lab=_66180_/X }
C {devices/lab_pin.sym} 5300 -1060 0 0 {name=p5484 lab=_66268_/X }
C {devices/lab_pin.sym} 5460 -1120 0 1 {name=p5485 lab=_66269_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -1120 0 0 {name=X_66269_ }
C {devices/lab_pin.sym} 5300 -990 0 0 {name=p5486 lab=_51492_/Y }
C {devices/lab_pin.sym} 5300 -950 0 0 {name=p5487 lab=_51477_/X }
C {devices/lab_pin.sym} 5300 -910 0 0 {name=p5488 lab=_51494_/X }
C {devices/lab_pin.sym} 5460 -950 0 1 {name=p5489 lab=_86000_/D }
C {sky130_stdcells/a21oi_4.sym} 5380 -950 0 0 {name=X_51495_ }
C {devices/lab_pin.sym} 5340 -810 0 0 {name=p5490 lab=_56142_/A }
C {devices/lab_pin.sym} 5420 -810 0 1 {name=p5491 lab=_56023_/A }
C {sky130_stdcells/buf_2.sym} 5380 -810 0 0 {name=X_56022_ }
C {devices/lab_pin.sym} 5300 -720 0 0 {name=p5492 lab=_87895_/Q }
C {devices/lab_pin.sym} 5300 -680 0 0 {name=p5493 lab=_68006_/X }
C {devices/lab_pin.sym} 5300 -640 0 0 {name=p5494 lab=_67984_/X }
C {devices/lab_pin.sym} 5300 -600 0 0 {name=p5495 lab=_68007_/X }
C {devices/lab_pin.sym} 5460 -660 0 1 {name=p5496 lab=_68008_/X }
C {sky130_stdcells/a211o_4.sym} 5380 -660 0 0 {name=X_68008_ }
C {devices/lab_pin.sym} 6240 -42180 0 0 {name=p5497 lab=_53217_/A }
C {devices/lab_pin.sym} 6240 -42140 0 0 {name=p5498 lab=_53244_/B }
C {devices/lab_pin.sym} 6240 -42100 0 0 {name=p5499 lab=_53222_/X }
C {devices/lab_pin.sym} 6240 -42060 0 0 {name=p5500 lab=_53234_/D }
C {devices/lab_pin.sym} 6360 -42120 0 1 {name=p5501 lab=_53234_/X }
C {sky130_stdcells/and4_4.sym} 6300 -42120 0 0 {name=X_53234_ }
C {devices/lab_pin.sym} 6210 -41970 0 0 {name=p5502 lab=_81492_/CLK }
C {devices/lab_pin.sym} 6210 -41950 0 0 {name=p5503 lab=_84054_/D }
C {devices/lab_pin.sym} 6390 -41970 0 1 {name=p5504 lab=_81486_/D }
C {sky130_stdcells/dfxtp_4.sym} 6300 -41960 0 0 {name=X_84054_ }
C {devices/lab_pin.sym} 6220 -41850 0 0 {name=p5505 lab=_86199_/Q }
C {devices/lab_pin.sym} 6220 -41810 0 0 {name=p5506 lab=_50437_/X }
C {devices/lab_pin.sym} 6220 -41770 0 0 {name=p5507 lab=_50445_/Y }
C {devices/lab_pin.sym} 6380 -41810 0 1 {name=p5508 lab=_50446_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -41810 0 0 {name=X_50446_ }
C {devices/lab_pin.sym} 6210 -41670 0 0 {name=p5509 lab=_81362_/CLK }
C {devices/lab_pin.sym} 6210 -41650 0 0 {name=p5510 lab=_81298_/Q }
C {devices/lab_pin.sym} 6390 -41670 0 1 {name=p5511 lab=_81266_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -41660 0 0 {name=X_81266_ }
C {devices/lab_pin.sym} 6260 -41530 0 0 {name=p5512 lab=clkbuf_9_25_0_CLK/A }
C {devices/lab_pin.sym} 6340 -41530 0 1 {name=p5513 lab=clkbuf_9_24_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 6300 -41530 0 0 {name=Xclkbuf_9_24_0_CLK }
C {devices/lab_pin.sym} 6210 -41410 0 0 {name=p5514 lab=_85050_/CLK }
C {devices/lab_pin.sym} 6210 -41390 0 0 {name=p5515 lab=_83005_/D }
C {devices/lab_pin.sym} 6390 -41410 0 1 {name=p5516 lab=_83005_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -41400 0 0 {name=X_83005_ }
C {devices/lab_pin.sym} 6240 -41280 0 0 {name=p5517 lab=_80213_/X }
C {devices/lab_pin.sym} 6240 -41240 0 0 {name=p5518 lab=_80216_/Y }
C {devices/lab_pin.sym} 6360 -41260 0 1 {name=p5519 lab=_80244_/A }
C {sky130_stdcells/xor2_4.sym} 6300 -41260 0 0 {name=X_80217_ }
C {devices/lab_pin.sym} 6240 -41160 0 0 {name=p5520 lab=_53181_/A }
C {devices/lab_pin.sym} 6240 -41120 0 0 {name=p5521 lab=_53159_/B }
C {devices/lab_pin.sym} 6240 -41080 0 0 {name=p5522 lab=_53143_/X }
C {devices/lab_pin.sym} 6240 -41040 0 0 {name=p5523 lab=_53165_/D }
C {devices/lab_pin.sym} 6360 -41100 0 1 {name=p5524 lab=_53165_/X }
C {sky130_stdcells/and4_4.sym} 6300 -41100 0 0 {name=X_53165_ }
C {devices/lab_pin.sym} 6220 -40970 0 0 {name=p5525 lab=_50375_/Y }
C {devices/lab_pin.sym} 6220 -40930 0 0 {name=p5526 lab=_50351_/X }
C {devices/lab_pin.sym} 6220 -40890 0 0 {name=p5527 lab=_50376_/Y }
C {devices/lab_pin.sym} 6380 -40930 0 1 {name=p5528 lab=_50377_/Y }
C {sky130_stdcells/a21boi_4.sym} 6300 -40930 0 0 {name=X_50377_ }
C {devices/lab_pin.sym} 6210 -40790 0 0 {name=p5529 lab=_81197_/CLK }
C {devices/lab_pin.sym} 6210 -40770 0 0 {name=p5530 lab=_74978_/X }
C {devices/lab_pin.sym} 6390 -40790 0 1 {name=p5531 lab=_81197_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -40780 0 0 {name=X_81197_ }
C {devices/lab_pin.sym} 6220 -40670 0 0 {name=p5532 lab=_85885_/Q }
C {devices/lab_pin.sym} 6220 -40630 0 0 {name=p5533 lab=_52075_/X }
C {devices/lab_pin.sym} 6220 -40590 0 0 {name=p5534 lab=_52115_/Y }
C {devices/lab_pin.sym} 6380 -40630 0 1 {name=p5535 lab=_52116_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -40630 0 0 {name=X_52116_ }
C {devices/lab_pin.sym} 6210 -40490 0 0 {name=p5536 lab=_87813_/CLK }
C {devices/lab_pin.sym} 6210 -40470 0 0 {name=p5537 lab=_87813_/D }
C {devices/lab_pin.sym} 6390 -40490 0 1 {name=p5538 lab=_87813_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -40480 0 0 {name=X_87813_ }
C {devices/lab_pin.sym} 6220 -40370 0 0 {name=p5539 lab=_80139_/Y }
C {devices/lab_pin.sym} 6220 -40330 0 0 {name=p5540 lab=_80135_/X }
C {devices/lab_pin.sym} 6220 -40290 0 0 {name=p5541 lab=_80147_/X }
C {devices/lab_pin.sym} 6380 -40330 0 1 {name=p5542 lab=_80149_/B }
C {sky130_stdcells/a21boi_4.sym} 6300 -40330 0 0 {name=X_80148_ }
C {devices/lab_pin.sym} 6220 -40230 0 0 {name=p5543 lab=_57868_/X }
C {devices/lab_pin.sym} 6220 -40190 0 0 {name=p5544 lab=_57971_/Y }
C {devices/lab_pin.sym} 6220 -40150 0 0 {name=p5545 lab=_57972_/Y }
C {devices/lab_pin.sym} 6220 -40110 0 0 {name=p5546 lab=_57899_/X }
C {devices/lab_pin.sym} 6220 -40070 0 0 {name=p5547 lab=_57872_/X }
C {devices/lab_pin.sym} 6380 -40150 0 1 {name=p5548 lab=_57973_/X }
C {sky130_stdcells/o32a_4.sym} 6300 -40150 0 0 {name=X_57973_ }
C {devices/lab_pin.sym} 6220 -40010 0 0 {name=p5549 lab=_85698_/Q }
C {devices/lab_pin.sym} 6220 -39970 0 0 {name=p5550 lab=_53093_/X }
C {devices/lab_pin.sym} 6220 -39930 0 0 {name=p5551 lab=_53095_/Y }
C {devices/lab_pin.sym} 6380 -39970 0 1 {name=p5552 lab=_53096_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -39970 0 0 {name=X_53096_ }
C {devices/lab_pin.sym} 6220 -39860 0 0 {name=p5553 lab=_88053_/Q }
C {devices/lab_pin.sym} 6220 -39820 0 0 {name=p5554 lab=_69468_/X }
C {devices/lab_pin.sym} 6220 -39780 0 0 {name=p5555 lab=_68745_/X }
C {devices/lab_pin.sym} 6220 -39740 0 0 {name=p5556 lab=_69958_/Y }
C {devices/lab_pin.sym} 6380 -39800 0 1 {name=p5557 lab=_69959_/X }
C {sky130_stdcells/a211o_4.sym} 6300 -39800 0 0 {name=X_69959_ }
C {devices/lab_pin.sym} 6220 -39690 0 0 {name=p5558 lab=_60403_/C }
C {devices/lab_pin.sym} 6220 -39650 0 0 {name=p5559 lab=_59790_/B }
C {devices/lab_pin.sym} 6220 -39610 0 0 {name=p5560 lab=_60414_/B }
C {devices/lab_pin.sym} 6220 -39570 0 0 {name=p5561 lab=_59710_/Y }
C {devices/lab_pin.sym} 6220 -39540 0 0 {name=p5562 lab=_59711_/Y }
C {devices/lab_pin.sym} 6380 -39610 0 1 {name=p5563 lab=_59712_/Y }
C {sky130_stdcells/a41oi_4.sym} 6300 -39610 0 0 {name=X_59712_ }
C {devices/lab_pin.sym} 6240 -39460 0 0 {name=p5564 lab=_52014_/X }
C {devices/lab_pin.sym} 6240 -39420 0 0 {name=p5565 lab=_52047_/B }
C {devices/lab_pin.sym} 6360 -39440 0 1 {name=p5566 lab=_52047_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -39440 0 0 {name=X_52047_ }
C {devices/lab_pin.sym} 6220 -39330 0 0 {name=p5567 lab=_72718_/C }
C {devices/lab_pin.sym} 6220 -39290 0 0 {name=p5568 lab=_72718_/D }
C {devices/lab_pin.sym} 6220 -39250 0 0 {name=p5569 lab=_83314_/Q }
C {devices/lab_pin.sym} 6380 -39290 0 1 {name=p5570 lab=_56924_/X }
C {sky130_stdcells/a21o_4.sym} 6300 -39290 0 0 {name=X_56924_ }
C {devices/lab_pin.sym} 6210 -39150 0 0 {name=p5571 lab=_87748_/CLK }
C {devices/lab_pin.sym} 6210 -39130 0 0 {name=p5572 lab=_87744_/D }
C {devices/lab_pin.sym} 6390 -39150 0 1 {name=p5573 lab=_68848_/B }
C {sky130_stdcells/dfxtp_4.sym} 6300 -39140 0 0 {name=X_87744_ }
C {devices/lab_pin.sym} 6260 -39010 0 0 {name=p5574 lab=clkbuf_9_39_0_CLK/A }
C {devices/lab_pin.sym} 6340 -39010 0 1 {name=p5575 lab=clkbuf_9_39_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 6300 -39010 0 0 {name=Xclkbuf_9_39_0_CLK }
C {devices/lab_pin.sym} 6260 -38890 0 0 {name=p5576 lab=_74140_/A }
C {devices/lab_pin.sym} 6340 -38890 0 1 {name=p5577 lab=_72970_/X }
C {sky130_stdcells/buf_2.sym} 6300 -38890 0 0 {name=X_72970_ }
C {devices/lab_pin.sym} 6210 -38770 0 0 {name=p5578 lab=_84892_/CLK }
C {devices/lab_pin.sym} 6210 -38750 0 0 {name=p5579 lab=_57676_/X }
C {devices/lab_pin.sym} 6390 -38770 0 1 {name=p5580 lab=_63524_/B }
C {sky130_stdcells/dfxtp_4.sym} 6300 -38760 0 0 {name=X_84956_ }
C {devices/lab_pin.sym} 6240 -38640 0 0 {name=p5581 lab=_84936_/Q }
C {devices/lab_pin.sym} 6240 -38600 0 0 {name=p5582 lab=_65698_/C }
C {devices/lab_pin.sym} 6360 -38620 0 1 {name=p5583 lab=_80079_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -38620 0 0 {name=X_80079_ }
C {devices/lab_pin.sym} 6240 -38510 0 0 {name=p5584 lab=_71586_/A }
C {devices/lab_pin.sym} 6240 -38470 0 0 {name=p5585 lab=_71930_/B }
C {devices/lab_pin.sym} 6240 -38430 0 0 {name=p5586 lab=_71574_/C }
C {devices/lab_pin.sym} 6360 -38470 0 1 {name=p5587 lab=_71921_/Y }
C {sky130_stdcells/nor3_4.sym} 6300 -38470 0 0 {name=X_71921_ }
C {devices/lab_pin.sym} 6240 -38350 0 0 {name=p5588 lab=_59635_/Y }
C {devices/lab_pin.sym} 6240 -38310 0 0 {name=p5589 lab=_59642_/X }
C {devices/lab_pin.sym} 6240 -38270 0 0 {name=p5590 lab=_59604_/X }
C {devices/lab_pin.sym} 6360 -38310 0 1 {name=p5591 lab=_59797_/B }
C {sky130_stdcells/and3_4.sym} 6300 -38310 0 0 {name=X_59643_ }
C {devices/lab_pin.sym} 6210 -38170 0 0 {name=p5592 lab=_83905_/CLK }
C {devices/lab_pin.sym} 6210 -38150 0 0 {name=p5593 lab=_83907_/D }
C {devices/lab_pin.sym} 6390 -38170 0 1 {name=p5594 lab=_83907_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -38160 0 0 {name=X_83907_ }
C {devices/lab_pin.sym} 6220 -38050 0 0 {name=p5595 lab=_56568_/X }
C {devices/lab_pin.sym} 6220 -38010 0 0 {name=p5596 lab=_57050_/A }
C {devices/lab_pin.sym} 6220 -37970 0 0 {name=p5597 lab=_56854_/X }
C {devices/lab_pin.sym} 6380 -38010 0 1 {name=p5598 lab=_56855_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -38010 0 0 {name=X_56855_ }
C {devices/lab_pin.sym} 6210 -37870 0 0 {name=p5599 lab=_87675_/CLK }
C {devices/lab_pin.sym} 6210 -37850 0 0 {name=p5600 lab=_87675_/D }
C {devices/lab_pin.sym} 6390 -37870 0 1 {name=p5601 lab=_87675_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -37860 0 0 {name=X_87675_ }
C {devices/lab_pin.sym} 6210 -37730 0 0 {name=p5602 lab=_84921_/CLK }
C {devices/lab_pin.sym} 6210 -37710 0 0 {name=p5603 lab=_58289_/X }
C {devices/lab_pin.sym} 6390 -37730 0 1 {name=p5604 lab=_58287_/A }
C {sky130_stdcells/dfxtp_4.sym} 6300 -37720 0 0 {name=X_84887_ }
C {devices/lab_pin.sym} 6220 -37630 0 0 {name=p5605 lab=_43810_/X }
C {devices/lab_pin.sym} 6220 -37590 0 0 {name=p5606 lab=_43797_/X }
C {devices/lab_pin.sym} 6220 -37550 0 0 {name=p5607 lab=_41116_/X }
C {devices/lab_pin.sym} 6220 -37510 0 0 {name=p5608 lab=_87251_/Q }
C {devices/lab_pin.sym} 6220 -37470 0 0 {name=p5609 lab=_43811_/X }
C {devices/lab_pin.sym} 6380 -37550 0 1 {name=p5610 lab=_43821_/A }
C {sky130_stdcells/o32ai_4.sym} 6300 -37550 0 0 {name=X_43820_ }
C {devices/lab_pin.sym} 6220 -37420 0 0 {name=p5611 lab=_85197_/Q }
C {devices/lab_pin.sym} 6220 -37380 0 0 {name=p5612 lab=_55342_/X }
C {devices/lab_pin.sym} 6220 -37340 0 0 {name=p5613 lab=_55457_/X }
C {devices/lab_pin.sym} 6220 -37300 0 0 {name=p5614 lab=_55805_/X }
C {devices/lab_pin.sym} 6380 -37360 0 1 {name=p5615 lab=_55806_/X }
C {sky130_stdcells/a211o_4.sym} 6300 -37360 0 0 {name=X_55806_ }
C {devices/lab_pin.sym} 6260 -37210 0 0 {name=p5616 lab=_74627_/Y }
C {devices/lab_pin.sym} 6340 -37210 0 1 {name=p5617 lab=_74685_/C }
C {sky130_stdcells/inv_2.sym} 6300 -37210 0 0 {name=X_74640_ }
C {devices/lab_pin.sym} 6210 -37090 0 0 {name=p5618 lab=_84922_/CLK }
C {devices/lab_pin.sym} 6210 -37070 0 0 {name=p5619 lab=_86626_/D }
C {devices/lab_pin.sym} 6390 -37090 0 1 {name=p5620 lab=_58136_/A }
C {sky130_stdcells/dfxtp_4.sym} 6300 -37080 0 0 {name=X_86626_ }
C {devices/lab_pin.sym} 6260 -36950 0 0 {name=p5621 lab=_71711_/A }
C {devices/lab_pin.sym} 6340 -36950 0 1 {name=p5622 lab=_71857_/D }
C {sky130_stdcells/buf_2.sym} 6300 -36950 0 0 {name=X_71852_ }
C {devices/lab_pin.sym} 6210 -36830 0 0 {name=p5623 lab=_83835_/CLK }
C {devices/lab_pin.sym} 6210 -36810 0 0 {name=p5624 lab=_70206_/X }
C {devices/lab_pin.sym} 6390 -36830 0 1 {name=p5625 lab=_83838_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -36820 0 0 {name=X_83838_ }
C {devices/lab_pin.sym} 6260 -36690 0 0 {name=p5626 lab=_59574_/A }
C {devices/lab_pin.sym} 6340 -36690 0 1 {name=p5627 lab=_60620_/C }
C {sky130_stdcells/buf_2.sym} 6300 -36690 0 0 {name=X_59574_ }
C {devices/lab_pin.sym} 6260 -36570 0 0 {name=p5628 lab=_56786_/A }
C {devices/lab_pin.sym} 6340 -36570 0 1 {name=p5629 lab=_56786_/Y }
C {sky130_stdcells/inv_2.sym} 6300 -36570 0 0 {name=X_56786_ }
C {devices/lab_pin.sym} 6240 -36460 0 0 {name=p5630 lab=_53998_/A }
C {devices/lab_pin.sym} 6240 -36420 0 0 {name=p5631 lab=_52478_/B }
C {devices/lab_pin.sym} 6360 -36440 0 1 {name=p5632 lab=_53998_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -36440 0 0 {name=X_53998_ }
C {devices/lab_pin.sym} 6260 -36310 0 0 {name=p5633 lab=_71221_/A }
C {devices/lab_pin.sym} 6340 -36310 0 1 {name=p5634 lab=_70804_/A }
C {sky130_stdcells/buf_2.sym} 6300 -36310 0 0 {name=X_70803_ }
C {devices/lab_pin.sym} 6220 -36210 0 0 {name=p5635 lab=_58517_/X }
C {devices/lab_pin.sym} 6220 -36170 0 0 {name=p5636 lab=_58522_/Y }
C {devices/lab_pin.sym} 6220 -36130 0 0 {name=p5637 lab=_58524_/Y }
C {devices/lab_pin.sym} 6380 -36170 0 1 {name=p5638 lab=_84828_/D }
C {sky130_stdcells/a21oi_4.sym} 6300 -36170 0 0 {name=X_58525_ }
C {devices/lab_pin.sym} 6260 -36030 0 0 {name=p5639 lab=_43602_/X }
C {devices/lab_pin.sym} 6340 -36030 0 1 {name=p5640 lab=_43752_/A }
C {sky130_stdcells/buf_2.sym} 6300 -36030 0 0 {name=X_43751_ }
C {devices/lab_pin.sym} 6220 -35940 0 0 {name=p5641 lab=_56280_/C }
C {devices/lab_pin.sym} 6220 -35900 0 0 {name=p5642 lab=_55278_/A }
C {devices/lab_pin.sym} 6220 -35860 0 0 {name=p5643 lab=_44043_/X }
C {devices/lab_pin.sym} 6220 -35820 0 0 {name=p5644 lab=_55736_/X }
C {devices/lab_pin.sym} 6380 -35880 0 1 {name=p5645 lab=_55737_/X }
C {sky130_stdcells/a211o_4.sym} 6300 -35880 0 0 {name=X_55737_ }
C {devices/lab_pin.sym} 6220 -35760 0 0 {name=p5646 lab=_74559_/X }
C {devices/lab_pin.sym} 6220 -35720 0 0 {name=p5647 lab=_74569_/X }
C {devices/lab_pin.sym} 6220 -35680 0 0 {name=p5648 lab=_56059_/Y }
C {devices/lab_pin.sym} 6220 -35640 0 0 {name=p5649 lab=_74570_/X }
C {devices/lab_pin.sym} 6380 -35700 0 1 {name=p5650 lab=_74571_/X }
C {sky130_stdcells/a211o_4.sym} 6300 -35700 0 0 {name=X_74571_ }
C {devices/lab_pin.sym} 6210 -35550 0 0 {name=p5651 lab=_86558_/CLK }
C {devices/lab_pin.sym} 6210 -35530 0 0 {name=p5652 lab=_48202_/Y }
C {devices/lab_pin.sym} 6390 -35550 0 1 {name=p5653 lab=_86557_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -35540 0 0 {name=X_86557_ }
C {devices/lab_pin.sym} 6220 -35430 0 0 {name=p5654 lab=_40931_/X }
C {devices/lab_pin.sym} 6220 -35390 0 0 {name=p5655 lab=_81724_/Q }
C {devices/lab_pin.sym} 6220 -35350 0 0 {name=p5656 lab=_40962_/X }
C {devices/lab_pin.sym} 6380 -35390 0 1 {name=p5657 lab=_40964_/A }
C {sky130_stdcells/o21ai_4.sym} 6300 -35390 0 0 {name=X_40963_ }
C {devices/lab_pin.sym} 6220 -35270 0 0 {name=p5658 lab=_52945_/Y }
C {devices/lab_pin.sym} 6220 -35230 0 0 {name=p5659 lab=_52946_/X }
C {devices/lab_pin.sym} 6220 -35190 0 0 {name=p5660 lab=_52948_/X }
C {devices/lab_pin.sym} 6380 -35230 0 1 {name=p5661 lab=_85725_/D }
C {sky130_stdcells/a21oi_4.sym} 6300 -35230 0 0 {name=X_52949_ }
C {devices/lab_pin.sym} 6240 -35120 0 0 {name=p5662 lab=_71783_/A }
C {devices/lab_pin.sym} 6240 -35080 0 0 {name=p5663 lab=_71507_/A }
C {devices/lab_pin.sym} 6240 -35040 0 0 {name=p5664 lab=_71783_/C }
C {devices/lab_pin.sym} 6240 -35000 0 0 {name=p5665 lab=_70361_/A }
C {devices/lab_pin.sym} 6360 -35060 0 1 {name=p5666 lab=_71783_/Y }
C {sky130_stdcells/nor4_4.sym} 6300 -35060 0 0 {name=X_71783_ }
C {devices/lab_pin.sym} 6210 -34910 0 0 {name=p5667 lab=_83476_/CLK }
C {devices/lab_pin.sym} 6210 -34890 0 0 {name=p5668 lab=_70465_/Y }
C {devices/lab_pin.sym} 6390 -34910 0 1 {name=p5669 lab=_58342_/A }
C {sky130_stdcells/dfxtp_4.sym} 6300 -34900 0 0 {name=X_83769_ }
C {devices/lab_pin.sym} 6220 -34790 0 0 {name=p5670 lab=_76296_/A }
C {devices/lab_pin.sym} 6220 -34750 0 0 {name=p5671 lab=_76295_/Y }
C {devices/lab_pin.sym} 6220 -34710 0 0 {name=p5672 lab=_76309_/X }
C {devices/lab_pin.sym} 6380 -34750 0 1 {name=p5673 lab=_76310_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -34750 0 0 {name=X_76310_ }
C {devices/lab_pin.sym} 6260 -34610 0 0 {name=p5674 lab=_42701_/Y }
C {devices/lab_pin.sym} 6340 -34610 0 1 {name=p5675 lab=_42702_/Y }
C {sky130_stdcells/inv_2.sym} 6300 -34610 0 0 {name=X_42702_ }
C {devices/lab_pin.sym} 6240 -34500 0 0 {name=p5676 lab=_48694_/A }
C {devices/lab_pin.sym} 6240 -34460 0 0 {name=p5677 lab=_73521_/Y }
C {devices/lab_pin.sym} 6360 -34480 0 1 {name=p5678 lab=_73522_/X }
C {sky130_stdcells/xor2_4.sym} 6300 -34480 0 0 {name=X_73522_ }
C {devices/lab_pin.sym} 6210 -34350 0 0 {name=p5679 lab=_85507_/CLK }
C {devices/lab_pin.sym} 6210 -34330 0 0 {name=p5680 lab=_85508_/D }
C {devices/lab_pin.sym} 6390 -34350 0 1 {name=p5681 lab=_85508_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -34340 0 0 {name=X_85508_ }
C {devices/lab_pin.sym} 6220 -34230 0 0 {name=p5682 lab=_46423_/X }
C {devices/lab_pin.sym} 6220 -34190 0 0 {name=p5683 lab=_49077_/A }
C {devices/lab_pin.sym} 6220 -34150 0 0 {name=p5684 lab=_46469_/Y }
C {devices/lab_pin.sym} 6380 -34190 0 1 {name=p5685 lab=_46471_/A }
C {sky130_stdcells/o21ai_4.sym} 6300 -34190 0 0 {name=X_46470_ }
C {devices/lab_pin.sym} 6260 -34050 0 0 {name=p5686 lab=_70733_/Y }
C {devices/lab_pin.sym} 6340 -34050 0 1 {name=p5687 lab=_71263_/D }
C {sky130_stdcells/buf_2.sym} 6300 -34050 0 0 {name=X_70734_ }
C {devices/lab_pin.sym} 6260 -33930 0 0 {name=p5688 lab=_58510_/A }
C {devices/lab_pin.sym} 6340 -33930 0 1 {name=p5689 lab=_58474_/B }
C {sky130_stdcells/buf_2.sym} 6300 -33930 0 0 {name=X_58456_ }
C {devices/lab_pin.sym} 6240 -33820 0 0 {name=p5690 lab=_77318_/A }
C {devices/lab_pin.sym} 6240 -33780 0 0 {name=p5691 lab=_77290_/B }
C {devices/lab_pin.sym} 6360 -33800 0 1 {name=p5692 lab=_82182_/D }
C {sky130_stdcells/xnor2_4.sym} 6300 -33800 0 0 {name=X_77290_ }
C {devices/lab_pin.sym} 6240 -33690 0 0 {name=p5693 lab=_55288_/B }
C {devices/lab_pin.sym} 6240 -33650 0 0 {name=p5694 lab=_55288_/A }
C {devices/lab_pin.sym} 6240 -33610 0 0 {name=p5695 lab=_55287_/X }
C {devices/lab_pin.sym} 6360 -33650 0 1 {name=p5696 lab=_55669_/A }
C {sky130_stdcells/nand3_4.sym} 6300 -33650 0 0 {name=X_55668_ }
C {devices/lab_pin.sym} 6260 -33510 0 0 {name=p5697 lab=_87311_/Q }
C {devices/lab_pin.sym} 6340 -33510 0 1 {name=p5698 lab=_69622_/B }
C {sky130_stdcells/inv_2.sym} 6300 -33510 0 0 {name=X_43682_ }
C {devices/lab_pin.sym} 6210 -33390 0 0 {name=p5699 lab=_85879_/CLK }
C {devices/lab_pin.sym} 6210 -33370 0 0 {name=p5700 lab=_86488_/D }
C {devices/lab_pin.sym} 6390 -33390 0 1 {name=p5701 lab=_73012_/B }
C {sky130_stdcells/dfxtp_4.sym} 6300 -33380 0 0 {name=X_86488_ }
C {devices/lab_pin.sym} 6260 -33250 0 0 {name=p5702 lab=_40894_/A }
C {devices/lab_pin.sym} 6340 -33250 0 1 {name=p5703 lab=_40894_/X }
C {sky130_stdcells/buf_2.sym} 6300 -33250 0 0 {name=X_40894_ }
C {devices/lab_pin.sym} 6220 -33160 0 0 {name=p5704 lab=_55483_/Y }
C {devices/lab_pin.sym} 6220 -33120 0 0 {name=p5705 lab=_57391_/Y }
C {devices/lab_pin.sym} 6220 -33080 0 0 {name=p5706 lab=_44318_/A }
C {devices/lab_pin.sym} 6220 -33040 0 0 {name=p5707 lab=_56667_/Y }
C {devices/lab_pin.sym} 6380 -33100 0 1 {name=p5708 lab=_57407_/X }
C {sky130_stdcells/a2bb2o_4.sym} 6300 -33100 0 0 {name=X_57407_ }
C {devices/lab_pin.sym} 6220 -32970 0 0 {name=p5709 lab=_45415_/X }
C {devices/lab_pin.sym} 6220 -32930 0 0 {name=p5710 lab=_45418_/X }
C {devices/lab_pin.sym} 6220 -32890 0 0 {name=p5711 lab=_45420_/Y }
C {devices/lab_pin.sym} 6380 -32930 0 1 {name=p5712 lab=_86878_/D }
C {sky130_stdcells/a21oi_4.sym} 6300 -32930 0 0 {name=X_45421_ }
C {devices/lab_pin.sym} 6220 -32810 0 0 {name=p5713 lab=_76207_/Y }
C {devices/lab_pin.sym} 6220 -32770 0 0 {name=p5714 lab=_76221_/Y }
C {devices/lab_pin.sym} 6220 -32730 0 0 {name=p5715 lab=_76220_/Y }
C {devices/lab_pin.sym} 6380 -32770 0 1 {name=p5716 lab=_76241_/X }
C {sky130_stdcells/a21o_4.sym} 6300 -32770 0 0 {name=X_76241_ }
C {devices/lab_pin.sym} 6210 -32630 0 0 {name=p5717 lab=_88232_/CLK }
C {devices/lab_pin.sym} 6210 -32610 0 0 {name=p5718 lab=_88227_/D }
C {devices/lab_pin.sym} 6390 -32630 0 1 {name=p5719 lab=_67732_/B }
C {sky130_stdcells/dfxtp_4.sym} 6300 -32620 0 0 {name=X_88227_ }
C {devices/lab_pin.sym} 6240 -32520 0 0 {name=p5720 lab=_54625_/A }
C {devices/lab_pin.sym} 6240 -32480 0 0 {name=p5721 lab=_54607_/B }
C {devices/lab_pin.sym} 6240 -32440 0 0 {name=p5722 lab=_54618_/X }
C {devices/lab_pin.sym} 6240 -32400 0 0 {name=p5723 lab=_47227_/A }
C {devices/lab_pin.sym} 6360 -32460 0 1 {name=p5724 lab=_54619_/X }
C {sky130_stdcells/and4_4.sym} 6300 -32460 0 0 {name=X_54619_ }
C {devices/lab_pin.sym} 6260 -32310 0 0 {name=p5725 lab=_42680_/A }
C {devices/lab_pin.sym} 6340 -32310 0 1 {name=p5726 lab=_42634_/A }
C {sky130_stdcells/buf_2.sym} 6300 -32310 0 0 {name=X_42633_ }
C {devices/lab_pin.sym} 6220 -32220 0 0 {name=p5727 lab=_73449_/X }
C {devices/lab_pin.sym} 6220 -32180 0 0 {name=p5728 lab=_85574_/Q }
C {devices/lab_pin.sym} 6220 -32140 0 0 {name=p5729 lab=_73450_/X }
C {devices/lab_pin.sym} 6220 -32100 0 0 {name=p5730 lab=_73452_/X }
C {devices/lab_pin.sym} 6380 -32160 0 1 {name=p5731 lab=_73453_/X }
C {sky130_stdcells/a211o_4.sym} 6300 -32160 0 0 {name=X_73453_ }
C {devices/lab_pin.sym} 6210 -32010 0 0 {name=p5732 lab=_85439_/CLK }
C {devices/lab_pin.sym} 6210 -31990 0 0 {name=p5733 lab=_85439_/D }
C {devices/lab_pin.sym} 6390 -32010 0 1 {name=p5734 lab=_85439_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -32000 0 0 {name=X_85439_ }
C {devices/lab_pin.sym} 6260 -31870 0 0 {name=p5735 lab=_70534_/Y }
C {devices/lab_pin.sym} 6340 -31870 0 1 {name=p5736 lab=_70670_/A }
C {sky130_stdcells/buf_2.sym} 6300 -31870 0 0 {name=X_70665_ }
C {devices/lab_pin.sym} 6220 -31770 0 0 {name=p5737 lab=_58366_/X }
C {devices/lab_pin.sym} 6220 -31730 0 0 {name=p5738 lab=_83350_/Q }
C {devices/lab_pin.sym} 6220 -31690 0 0 {name=p5739 lab=_58386_/Y }
C {devices/lab_pin.sym} 6380 -31730 0 1 {name=p5740 lab=_84862_/D }
C {sky130_stdcells/o21a_4.sym} 6300 -31730 0 0 {name=X_58387_ }
C {devices/lab_pin.sym} 6240 -31600 0 0 {name=p5741 lab=_55908_/A }
C {devices/lab_pin.sym} 6240 -31560 0 0 {name=p5742 lab=_55599_/B }
C {devices/lab_pin.sym} 6360 -31580 0 1 {name=p5743 lab=_55599_/X }
C {sky130_stdcells/and2_4.sym} 6300 -31580 0 0 {name=X_55599_ }
C {devices/lab_pin.sym} 6260 -31450 0 0 {name=p5744 lab=_83531_/Q }
C {devices/lab_pin.sym} 6340 -31450 0 1 {name=p5745 lab=_48141_/A }
C {sky130_stdcells/inv_2.sym} 6300 -31450 0 0 {name=X_48140_ }
C {devices/lab_pin.sym} 6240 -31340 0 0 {name=p5746 lab=_72347_/A }
C {devices/lab_pin.sym} 6240 -31300 0 0 {name=p5747 lab=_86281_/Q }
C {devices/lab_pin.sym} 6360 -31320 0 1 {name=p5748 lab=_72404_/Y }
C {sky130_stdcells/nor2_4.sym} 6300 -31320 0 0 {name=X_72404_ }
C {devices/lab_pin.sym} 6220 -31210 0 0 {name=p5749 lab=_45350_/X }
C {devices/lab_pin.sym} 6220 -31170 0 0 {name=p5750 lab=_61673_/B }
C {devices/lab_pin.sym} 6220 -31130 0 0 {name=p5751 lab=_45294_/X }
C {devices/lab_pin.sym} 6380 -31170 0 1 {name=p5752 lab=_45352_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -31170 0 0 {name=X_45352_ }
C {devices/lab_pin.sym} 6220 -31050 0 0 {name=p5753 lab=_57337_/Y }
C {devices/lab_pin.sym} 6220 -31010 0 0 {name=p5754 lab=_56659_/Y }
C {devices/lab_pin.sym} 6220 -30970 0 0 {name=p5755 lab=_56788_/X }
C {devices/lab_pin.sym} 6380 -31010 0 1 {name=p5756 lab=_57338_/Y }
C {sky130_stdcells/a21oi_4.sym} 6300 -31010 0 0 {name=X_57338_ }
C {devices/lab_pin.sym} 6260 -30870 0 0 {name=p5757 lab=_76171_/Y }
C {devices/lab_pin.sym} 6340 -30870 0 1 {name=p5758 lab=_76174_/A }
C {sky130_stdcells/inv_2.sym} 6300 -30870 0 0 {name=X_76172_ }
C {devices/lab_pin.sym} 6260 -30750 0 0 {name=p5759 lab=_87818_/Q }
C {devices/lab_pin.sym} 6340 -30750 0 1 {name=p5760 lab=_42564_/Y }
C {sky130_stdcells/inv_2.sym} 6300 -30750 0 0 {name=X_42564_ }
C {devices/lab_pin.sym} 6210 -30630 0 0 {name=p5761 lab=_88158_/CLK }
C {devices/lab_pin.sym} 6210 -30610 0 0 {name=p5762 lab=_88158_/D }
C {devices/lab_pin.sym} 6390 -30630 0 1 {name=p5763 lab=_67840_/B }
C {sky130_stdcells/dfxtp_4.sym} 6300 -30620 0 0 {name=X_88158_ }
C {devices/lab_pin.sym} 6220 -30510 0 0 {name=p5764 lab=_73380_/X }
C {devices/lab_pin.sym} 6220 -30470 0 0 {name=p5765 lab=_73382_/X }
C {devices/lab_pin.sym} 6220 -30430 0 0 {name=p5766 lab=_73383_/X }
C {devices/lab_pin.sym} 6380 -30470 0 1 {name=p5767 lab=_73384_/X }
C {sky130_stdcells/a21o_4.sym} 6300 -30470 0 0 {name=X_73384_ }
C {devices/lab_pin.sym} 6220 -30350 0 0 {name=p5768 lab=_52969_/B }
C {devices/lab_pin.sym} 6220 -30310 0 0 {name=p5769 lab=_70584_/X }
C {devices/lab_pin.sym} 6220 -30270 0 0 {name=p5770 lab=_70595_/Y }
C {devices/lab_pin.sym} 6380 -30310 0 1 {name=p5771 lab=_83745_/D }
C {sky130_stdcells/o21ai_4.sym} 6300 -30310 0 0 {name=X_70596_ }
C {devices/lab_pin.sym} 6260 -30170 0 0 {name=p5772 lab=_44231_/A }
C {devices/lab_pin.sym} 6340 -30170 0 1 {name=p5773 lab=_46228_/A }
C {sky130_stdcells/buf_2.sym} 6300 -30170 0 0 {name=X_44303_ }
C {devices/lab_pin.sym} 6240 -30060 0 0 {name=p5774 lab=_80773_/Q }
C {devices/lab_pin.sym} 6240 -30020 0 0 {name=p5775 lab=_75122_/A }
C {devices/lab_pin.sym} 6360 -30040 0 1 {name=p5776 lab=_80741_/D }
C {sky130_stdcells/xnor2_4.sym} 6300 -30040 0 0 {name=X_75123_ }
C {devices/lab_pin.sym} 6260 -29910 0 0 {name=p5777 lab=_41514_/X }
C {devices/lab_pin.sym} 6340 -29910 0 1 {name=p5778 lab=_41515_/X }
C {sky130_stdcells/buf_2.sym} 6300 -29910 0 0 {name=X_41515_ }
C {devices/lab_pin.sym} 6210 -29790 0 0 {name=p5779 lab=_87417_/CLK }
C {devices/lab_pin.sym} 6210 -29770 0 0 {name=p5780 lab=_44437_/Y }
C {devices/lab_pin.sym} 6390 -29790 0 1 {name=p5781 lab=_87109_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -29780 0 0 {name=X_87109_ }
C {devices/lab_pin.sym} 6260 -29650 0 0 {name=p5782 lab=_83538_/Q }
C {devices/lab_pin.sym} 6340 -29650 0 1 {name=p5783 lab=_57605_/B }
C {sky130_stdcells/inv_2.sym} 6300 -29650 0 0 {name=X_48071_ }
C {devices/lab_pin.sym} 6240 -29540 0 0 {name=p5784 lab=_72347_/A }
C {devices/lab_pin.sym} 6240 -29500 0 0 {name=p5785 lab=_86287_/Q }
C {devices/lab_pin.sym} 6360 -29520 0 1 {name=p5786 lab=_72335_/Y }
C {sky130_stdcells/nor2_4.sym} 6300 -29520 0 0 {name=X_72335_ }
C {devices/lab_pin.sym} 6220 -29410 0 0 {name=p5787 lab=_85256_/Q }
C {devices/lab_pin.sym} 6220 -29370 0 0 {name=p5788 lab=_45222_/X }
C {devices/lab_pin.sym} 6220 -29330 0 0 {name=p5789 lab=_45282_/X }
C {devices/lab_pin.sym} 6380 -29370 0 1 {name=p5790 lab=_45283_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -29370 0 0 {name=X_45283_ }
C {devices/lab_pin.sym} 6240 -29260 0 0 {name=p5791 lab=_57268_/X }
C {devices/lab_pin.sym} 6240 -29220 0 0 {name=p5792 lab=_57149_/B }
C {devices/lab_pin.sym} 6240 -29180 0 0 {name=p5793 lab=_57149_/C }
C {devices/lab_pin.sym} 6240 -29140 0 0 {name=p5794 lab=_57149_/D }
C {devices/lab_pin.sym} 6360 -29200 0 1 {name=p5795 lab=_57271_/A }
C {sky130_stdcells/and4_4.sym} 6300 -29200 0 0 {name=X_57269_ }
C {devices/lab_pin.sym} 6210 -29050 0 0 {name=p5796 lab=_87588_/CLK }
C {devices/lab_pin.sym} 6210 -29030 0 0 {name=p5797 lab=_88089_/D }
C {devices/lab_pin.sym} 6390 -29050 0 1 {name=p5798 lab=_88089_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -29040 0 0 {name=X_88089_ }
C {devices/lab_pin.sym} 6260 -28910 0 0 {name=p5799 lab=_42610_/A }
C {devices/lab_pin.sym} 6340 -28910 0 1 {name=p5800 lab=_42495_/X }
C {sky130_stdcells/buf_2.sym} 6300 -28910 0 0 {name=X_42495_ }
C {devices/lab_pin.sym} 6240 -28800 0 0 {name=p5801 lab=_86688_/Q }
C {devices/lab_pin.sym} 6240 -28760 0 0 {name=p5802 lab=_59008_/B }
C {devices/lab_pin.sym} 6360 -28780 0 1 {name=p5803 lab=_59008_/Y }
C {sky130_stdcells/nor2_4.sym} 6300 -28780 0 0 {name=X_59008_ }
C {devices/lab_pin.sym} 6220 -28670 0 0 {name=p5804 lab=_47018_/Y }
C {devices/lab_pin.sym} 6220 -28630 0 0 {name=p5805 lab=_46987_/X }
C {devices/lab_pin.sym} 6220 -28590 0 0 {name=p5806 lab=_47021_/X }
C {devices/lab_pin.sym} 6380 -28630 0 1 {name=p5807 lab=_47022_/Y }
C {sky130_stdcells/a21oi_4.sym} 6300 -28630 0 0 {name=X_47022_ }
C {devices/lab_pin.sym} 6260 -28490 0 0 {name=p5808 lab=_73181_/A }
C {devices/lab_pin.sym} 6340 -28490 0 1 {name=p5809 lab=_72881_/A }
C {sky130_stdcells/buf_2.sym} 6300 -28490 0 0 {name=X_44234_ }
C {devices/lab_pin.sym} 6240 -28380 0 0 {name=p5810 lab=_80958_/Q }
C {devices/lab_pin.sym} 6240 -28340 0 0 {name=p5811 lab=_75053_/X }
C {devices/lab_pin.sym} 6360 -28360 0 1 {name=p5812 lab=_75054_/X }
C {sky130_stdcells/xor2_4.sym} 6300 -28360 0 0 {name=X_75054_ }
C {devices/lab_pin.sym} 6240 -28240 0 0 {name=p5813 lab=_79929_/Y }
C {devices/lab_pin.sym} 6240 -28200 0 0 {name=p5814 lab=_79931_/B }
C {devices/lab_pin.sym} 6360 -28220 0 1 {name=p5815 lab=_79932_/B }
C {sky130_stdcells/nand2_4.sym} 6300 -28220 0 0 {name=X_79931_ }
C {devices/lab_pin.sym} 6220 -28110 0 0 {name=p5816 lab=_41412_/X }
C {devices/lab_pin.sym} 6220 -28070 0 0 {name=p5817 lab=_82883_/Q }
C {devices/lab_pin.sym} 6220 -28030 0 0 {name=p5818 lab=_41445_/X }
C {devices/lab_pin.sym} 6380 -28070 0 1 {name=p5819 lab=_41446_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -28070 0 0 {name=X_41446_ }
C {devices/lab_pin.sym} 6240 -27960 0 0 {name=p5820 lab=_60168_/A }
C {devices/lab_pin.sym} 6240 -27920 0 0 {name=p5821 lab=_60251_/A }
C {devices/lab_pin.sym} 6240 -27880 0 0 {name=p5822 lab=_60179_/A }
C {devices/lab_pin.sym} 6240 -27840 0 0 {name=p5823 lab=_60204_/A }
C {devices/lab_pin.sym} 6360 -27900 0 1 {name=p5824 lab=_60281_/A }
C {sky130_stdcells/and4_4.sym} 6300 -27900 0 0 {name=X_60280_ }
C {devices/lab_pin.sym} 6220 -27770 0 0 {name=p5825 lab=_72264_/X }
C {devices/lab_pin.sym} 6220 -27730 0 0 {name=p5826 lab=_85365_/Q }
C {devices/lab_pin.sym} 6220 -27690 0 0 {name=p5827 lab=_72265_/X }
C {devices/lab_pin.sym} 6380 -27730 0 1 {name=p5828 lab=_72266_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -27730 0 0 {name=X_72266_ }
C {devices/lab_pin.sym} 6240 -27600 0 0 {name=p5829 lab=_74005_/A }
C {devices/lab_pin.sym} 6240 -27560 0 0 {name=p5830 lab=_74244_/B }
C {devices/lab_pin.sym} 6360 -27580 0 1 {name=p5831 lab=_74005_/Y }
C {sky130_stdcells/nor2_4.sym} 6300 -27580 0 0 {name=X_74005_ }
C {devices/lab_pin.sym} 6240 -27470 0 0 {name=p5832 lab=_71219_/A }
C {devices/lab_pin.sym} 6240 -27430 0 0 {name=p5833 lab=_71217_/B }
C {devices/lab_pin.sym} 6240 -27390 0 0 {name=p5834 lab=_71219_/C }
C {devices/lab_pin.sym} 6360 -27430 0 1 {name=p5835 lab=_71217_/Y }
C {sky130_stdcells/nand3_4.sym} 6300 -27430 0 0 {name=X_71217_ }
C {devices/lab_pin.sym} 6260 -27290 0 0 {name=p5836 lab=_64850_/A }
C {devices/lab_pin.sym} 6340 -27290 0 1 {name=p5837 lab=_64619_/A }
C {sky130_stdcells/buf_2.sym} 6300 -27290 0 0 {name=X_44165_ }
C {devices/lab_pin.sym} 6240 -27180 0 0 {name=p5838 lab=_64663_/C }
C {devices/lab_pin.sym} 6240 -27140 0 0 {name=p5839 lab=_83279_/Q }
C {devices/lab_pin.sym} 6360 -27160 0 1 {name=p5840 lab=_79862_/X }
C {sky130_stdcells/xor2_4.sym} 6300 -27160 0 0 {name=X_79862_ }
C {devices/lab_pin.sym} 6220 -27070 0 0 {name=p5841 lab=_41337_/X }
C {devices/lab_pin.sym} 6220 -27030 0 0 {name=p5842 lab=_41338_/X }
C {devices/lab_pin.sym} 6220 -26990 0 0 {name=p5843 lab=_41376_/X }
C {devices/lab_pin.sym} 6220 -26950 0 0 {name=p5844 lab=_67756_/B }
C {devices/lab_pin.sym} 6220 -26910 0 0 {name=p5845 lab=_41333_/X }
C {devices/lab_pin.sym} 6380 -26990 0 1 {name=p5846 lab=_41378_/A }
C {sky130_stdcells/o32ai_4.sym} 6300 -26990 0 0 {name=X_41377_ }
C {devices/lab_pin.sym} 6220 -26850 0 0 {name=p5847 lab=_72196_/X }
C {devices/lab_pin.sym} 6220 -26810 0 0 {name=p5848 lab=_85339_/Q }
C {devices/lab_pin.sym} 6220 -26770 0 0 {name=p5849 lab=_72120_/X }
C {devices/lab_pin.sym} 6380 -26810 0 1 {name=p5850 lab=_72197_/X }
C {sky130_stdcells/o21a_4.sym} 6300 -26810 0 0 {name=X_72197_ }
C {devices/lab_pin.sym} 6220 -26710 0 0 {name=p5851 lab=_43105_/X }
C {devices/lab_pin.sym} 6220 -26670 0 0 {name=p5852 lab=_43106_/X }
C {devices/lab_pin.sym} 6220 -26630 0 0 {name=p5853 lab=_40771_/X }
C {devices/lab_pin.sym} 6220 -26590 0 0 {name=p5854 lab=_43115_/Y }
C {devices/lab_pin.sym} 6220 -26550 0 0 {name=p5855 lab=_43108_/X }
C {devices/lab_pin.sym} 6380 -26630 0 1 {name=p5856 lab=_87570_/D }
C {sky130_stdcells/o32ai_4.sym} 6300 -26630 0 0 {name=X_43116_ }
C {devices/lab_pin.sym} 6260 -26470 0 0 {name=p5857 lab=_82835_/Q }
C {devices/lab_pin.sym} 6340 -26470 0 1 {name=p5858 lab=_78814_/A }
C {sky130_stdcells/inv_2.sym} 6300 -26470 0 0 {name=X_78813_ }
C {devices/lab_pin.sym} 6260 -26350 0 0 {name=p5859 lab=_40878_/A }
C {devices/lab_pin.sym} 6340 -26350 0 1 {name=p5860 lab=_40402_/A }
C {sky130_stdcells/buf_2.sym} 6300 -26350 0 0 {name=X_40328_ }
C {devices/lab_pin.sym} 6220 -26250 0 0 {name=p5861 lab=_48380_/X }
C {devices/lab_pin.sym} 6220 -26210 0 0 {name=p5862 lab=_71138_/X }
C {devices/lab_pin.sym} 6220 -26170 0 0 {name=p5863 lab=_71147_/Y }
C {devices/lab_pin.sym} 6380 -26210 0 1 {name=p5864 lab=_71148_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -26210 0 0 {name=X_71148_ }
C {devices/lab_pin.sym} 6260 -26070 0 0 {name=p5865 lab=_48973_/A }
C {devices/lab_pin.sym} 6340 -26070 0 1 {name=p5866 lab=_52307_/B }
C {sky130_stdcells/buf_2.sym} 6300 -26070 0 0 {name=X_48973_ }
C {devices/lab_pin.sym} 6260 -25950 0 0 {name=p5867 lab=_44095_/X }
C {devices/lab_pin.sym} 6340 -25950 0 1 {name=p5868 lab=_44096_/X }
C {sky130_stdcells/buf_2.sym} 6300 -25950 0 0 {name=X_44096_ }
C {devices/lab_pin.sym} 6240 -25840 0 0 {name=p5869 lab=_79793_/A }
C {devices/lab_pin.sym} 6240 -25800 0 0 {name=p5870 lab=_79793_/B }
C {devices/lab_pin.sym} 6360 -25820 0 1 {name=p5871 lab=_79793_/X }
C {sky130_stdcells/xor2_4.sym} 6300 -25820 0 0 {name=X_79793_ }
C {devices/lab_pin.sym} 6240 -25700 0 0 {name=p5872 lab=_47912_/A }
C {devices/lab_pin.sym} 6240 -25660 0 0 {name=p5873 lab=_47924_/B }
C {devices/lab_pin.sym} 6360 -25680 0 1 {name=p5874 lab=_47924_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -25680 0 0 {name=X_47924_ }
C {devices/lab_pin.sym} 6260 -25550 0 0 {name=p5875 lab=_43047_/A }
C {devices/lab_pin.sym} 6340 -25550 0 1 {name=p5876 lab=_43047_/X }
C {sky130_stdcells/buf_2.sym} 6300 -25550 0 0 {name=X_43047_ }
C {devices/lab_pin.sym} 6240 -25450 0 0 {name=p5877 lab=_78742_/X }
C {devices/lab_pin.sym} 6240 -25410 0 0 {name=p5878 lab=_78718_/Y }
C {devices/lab_pin.sym} 6240 -25370 0 0 {name=p5879 lab=_78744_/C }
C {devices/lab_pin.sym} 6360 -25410 0 1 {name=p5880 lab=_78745_/A }
C {sky130_stdcells/and3_4.sym} 6300 -25410 0 0 {name=X_78744_ }
C {devices/lab_pin.sym} 6260 -25270 0 0 {name=p5881 lab=_60984_/A }
C {devices/lab_pin.sym} 6340 -25270 0 1 {name=p5882 lab=_64033_/D }
C {sky130_stdcells/buf_2.sym} 6300 -25270 0 0 {name=X_63970_ }
C {devices/lab_pin.sym} 6220 -25170 0 0 {name=p5883 lab=_48982_/X }
C {devices/lab_pin.sym} 6220 -25130 0 0 {name=p5884 lab=_71070_/X }
C {devices/lab_pin.sym} 6220 -25090 0 0 {name=p5885 lab=_71078_/Y }
C {devices/lab_pin.sym} 6380 -25130 0 1 {name=p5886 lab=_71079_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -25130 0 0 {name=X_71079_ }
C {devices/lab_pin.sym} 6240 -25010 0 0 {name=p5887 lab=_75948_/Y }
C {devices/lab_pin.sym} 6240 -24970 0 0 {name=p5888 lab=_75949_/A }
C {devices/lab_pin.sym} 6240 -24930 0 0 {name=p5889 lab=_75954_/A }
C {devices/lab_pin.sym} 6360 -24970 0 1 {name=p5890 lab=_75956_/Y }
C {sky130_stdcells/nand3_4.sym} 6300 -24970 0 0 {name=X_75956_ }
C {devices/lab_pin.sym} 6240 -24850 0 0 {name=p5891 lab=_62930_/A }
C {devices/lab_pin.sym} 6240 -24810 0 0 {name=p5892 lab=_62930_/B }
C {devices/lab_pin.sym} 6240 -24770 0 0 {name=p5893 lab=_62921_/C }
C {devices/lab_pin.sym} 6360 -24810 0 1 {name=p5894 lab=_62921_/Y }
C {sky130_stdcells/nor3_4.sym} 6300 -24810 0 0 {name=X_62921_ }
C {devices/lab_pin.sym} 6240 -24680 0 0 {name=p5895 lab=_81131_/D }
C {devices/lab_pin.sym} 6240 -24640 0 0 {name=p5896 lab=_74916_/B }
C {devices/lab_pin.sym} 6360 -24660 0 1 {name=p5897 lab=_74910_/A }
C {sky130_stdcells/xor2_4.sym} 6300 -24660 0 0 {name=X_74907_ }
C {devices/lab_pin.sym} 6240 -24540 0 0 {name=p5898 lab=_47855_/A }
C {devices/lab_pin.sym} 6240 -24500 0 0 {name=p5899 lab=_50232_/B }
C {devices/lab_pin.sym} 6360 -24520 0 1 {name=p5900 lab=_47855_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -24520 0 0 {name=X_47855_ }
C {devices/lab_pin.sym} 6240 -24400 0 0 {name=p5901 lab=_78701_/B }
C {devices/lab_pin.sym} 6240 -24360 0 0 {name=p5902 lab=_78675_/B }
C {devices/lab_pin.sym} 6360 -24380 0 1 {name=p5903 lab=_82778_/D }
C {sky130_stdcells/xor2_4.sym} 6300 -24380 0 0 {name=X_78675_ }
C {devices/lab_pin.sym} 6260 -24250 0 0 {name=p5904 lab=_75887_/A }
C {devices/lab_pin.sym} 6340 -24250 0 1 {name=p5905 lab=_75887_/Y }
C {sky130_stdcells/inv_2.sym} 6300 -24250 0 0 {name=X_75887_ }
C {devices/lab_pin.sym} 6240 -24140 0 0 {name=p5906 lab=_46806_/A }
C {devices/lab_pin.sym} 6240 -24100 0 0 {name=p5907 lab=_46805_/X }
C {devices/lab_pin.sym} 6360 -24120 0 1 {name=p5908 lab=_46806_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -24120 0 0 {name=X_46806_ }
C {devices/lab_pin.sym} 6240 -24000 0 0 {name=p5909 lab=_65704_/A }
C {devices/lab_pin.sym} 6240 -23960 0 0 {name=p5910 lab=_86483_/Q }
C {devices/lab_pin.sym} 6360 -23980 0 1 {name=p5911 lab=_65640_/X }
C {sky130_stdcells/and2_4.sym} 6300 -23980 0 0 {name=X_65640_ }
C {devices/lab_pin.sym} 6220 -23870 0 0 {name=p5912 lab=_77596_/B }
C {devices/lab_pin.sym} 6220 -23830 0 0 {name=p5913 lab=_77622_/X }
C {devices/lab_pin.sym} 6220 -23790 0 0 {name=p5914 lab=_77625_/X }
C {devices/lab_pin.sym} 6380 -23830 0 1 {name=p5915 lab=_77626_/Y }
C {sky130_stdcells/a21boi_4.sym} 6300 -23830 0 0 {name=X_77626_ }
C {devices/lab_pin.sym} 6240 -23710 0 0 {name=p5916 lab=_46196_/A }
C {devices/lab_pin.sym} 6240 -23670 0 0 {name=p5917 lab=_74842_/B }
C {devices/lab_pin.sym} 6240 -23630 0 0 {name=p5918 lab=_46195_/Y }
C {devices/lab_pin.sym} 6360 -23670 0 1 {name=p5919 lab=_80670_/D }
C {sky130_stdcells/and3_4.sym} 6300 -23670 0 0 {name=X_74838_ }
C {devices/lab_pin.sym} 6260 -23530 0 0 {name=p5920 lab=_63306_/A }
C {devices/lab_pin.sym} 6340 -23530 0 1 {name=p5921 lab=_62852_/X }
C {sky130_stdcells/buf_2.sym} 6300 -23530 0 0 {name=X_62852_ }
C {devices/lab_pin.sym} 6220 -23430 0 0 {name=p5922 lab=_47782_/Y }
C {devices/lab_pin.sym} 6220 -23390 0 0 {name=p5923 lab=_47745_/X }
C {devices/lab_pin.sym} 6220 -23350 0 0 {name=p5924 lab=_47785_/X }
C {devices/lab_pin.sym} 6380 -23390 0 1 {name=p5925 lab=_86598_/D }
C {sky130_stdcells/a21oi_4.sym} 6300 -23390 0 0 {name=X_47786_ }
C {devices/lab_pin.sym} 6260 -23250 0 0 {name=p5926 lab=_45824_/B }
C {devices/lab_pin.sym} 6340 -23250 0 1 {name=p5927 lab=_44998_/X }
C {sky130_stdcells/buf_2.sym} 6300 -23250 0 0 {name=X_44998_ }
C {devices/lab_pin.sym} 6260 -23130 0 0 {name=p5928 lab=_49444_/A }
C {devices/lab_pin.sym} 6340 -23130 0 1 {name=p5929 lab=_49546_/A }
C {sky130_stdcells/buf_2.sym} 6300 -23130 0 0 {name=X_49525_ }
C {devices/lab_pin.sym} 6220 -23030 0 0 {name=p5930 lab=_61800_/Y }
C {devices/lab_pin.sym} 6220 -22990 0 0 {name=p5931 lab=_61801_/X }
C {devices/lab_pin.sym} 6220 -22950 0 0 {name=p5932 lab=_61802_/Y }
C {devices/lab_pin.sym} 6380 -22990 0 1 {name=p5933 lab=_61803_/Y }
C {sky130_stdcells/a21oi_4.sym} 6300 -22990 0 0 {name=X_61803_ }
C {devices/lab_pin.sym} 6240 -22880 0 0 {name=p5934 lab=_46737_/A }
C {devices/lab_pin.sym} 6240 -22840 0 0 {name=p5935 lab=_46717_/B }
C {devices/lab_pin.sym} 6240 -22800 0 0 {name=p5936 lab=_46717_/C }
C {devices/lab_pin.sym} 6240 -22760 0 0 {name=p5937 lab=_46736_/X }
C {devices/lab_pin.sym} 6360 -22820 0 1 {name=p5938 lab=_46737_/X }
C {sky130_stdcells/and4_4.sym} 6300 -22820 0 0 {name=X_46737_ }
C {devices/lab_pin.sym} 6240 -22690 0 0 {name=p5939 lab=_66044_/A }
C {devices/lab_pin.sym} 6240 -22650 0 0 {name=p5940 lab=_65631_/B }
C {devices/lab_pin.sym} 6240 -22610 0 0 {name=p5941 lab=_65570_/X }
C {devices/lab_pin.sym} 6360 -22650 0 1 {name=p5942 lab=_65571_/Y }
C {sky130_stdcells/nand3_4.sym} 6300 -22650 0 0 {name=X_65571_ }
C {devices/lab_pin.sym} 6220 -22530 0 0 {name=p5943 lab=_77553_/X }
C {devices/lab_pin.sym} 6220 -22490 0 0 {name=p5944 lab=_77558_/C }
C {devices/lab_pin.sym} 6220 -22450 0 0 {name=p5945 lab=_77556_/Y }
C {devices/lab_pin.sym} 6380 -22490 0 1 {name=p5946 lab=_77559_/A }
C {sky130_stdcells/a21o_4.sym} 6300 -22490 0 0 {name=X_77557_ }
C {devices/lab_pin.sym} 6220 -22380 0 0 {name=p5947 lab=_87180_/Q }
C {devices/lab_pin.sym} 6220 -22340 0 0 {name=p5948 lab=_43987_/B }
C {devices/lab_pin.sym} 6220 -22300 0 0 {name=p5949 lab=_43945_/Y }
C {devices/lab_pin.sym} 6220 -22260 0 0 {name=p5950 lab=_43948_/Y }
C {devices/lab_pin.sym} 6380 -22320 0 1 {name=p5951 lab=_43949_/X }
C {sky130_stdcells/a211o_4.sym} 6300 -22320 0 0 {name=X_43949_ }
C {devices/lab_pin.sym} 6240 -22200 0 0 {name=p5952 lab=_62819_/A }
C {devices/lab_pin.sym} 6240 -22160 0 0 {name=p5953 lab=_84830_/Q }
C {devices/lab_pin.sym} 6240 -22120 0 0 {name=p5954 lab=_62737_/X }
C {devices/lab_pin.sym} 6240 -22080 0 0 {name=p5955 lab=_62782_/X }
C {devices/lab_pin.sym} 6360 -22140 0 1 {name=p5956 lab=_62783_/X }
C {sky130_stdcells/and4_4.sym} 6300 -22140 0 0 {name=X_62783_ }
C {devices/lab_pin.sym} 6240 -22020 0 0 {name=p5957 lab=_74769_/A }
C {devices/lab_pin.sym} 6240 -21980 0 0 {name=p5958 lab=_74804_/C }
C {devices/lab_pin.sym} 6240 -21940 0 0 {name=p5959 lab=_74744_/X }
C {devices/lab_pin.sym} 6240 -21900 0 0 {name=p5960 lab=_74769_/D }
C {devices/lab_pin.sym} 6360 -21960 0 1 {name=p5961 lab=_74772_/B }
C {sky130_stdcells/nand4_4.sym} 6300 -21960 0 0 {name=X_74769_ }
C {devices/lab_pin.sym} 6220 -21830 0 0 {name=p5962 lab=_67307_/X }
C {devices/lab_pin.sym} 6220 -21790 0 0 {name=p5963 lab=_67309_/X }
C {devices/lab_pin.sym} 6220 -21750 0 0 {name=p5964 lab=_67264_/X }
C {devices/lab_pin.sym} 6380 -21790 0 1 {name=p5965 lab=_67316_/A }
C {sky130_stdcells/a21o_4.sym} 6300 -21790 0 0 {name=X_67310_ }
C {devices/lab_pin.sym} 6240 -21660 0 0 {name=p5966 lab=_58360_/A }
C {devices/lab_pin.sym} 6240 -21620 0 0 {name=p5967 lab=_64521_/X }
C {devices/lab_pin.sym} 6360 -21640 0 1 {name=p5968 lab=_64522_/Y }
C {sky130_stdcells/nor2_4.sym} 6300 -21640 0 0 {name=X_64522_ }
C {devices/lab_pin.sym} 6260 -21510 0 0 {name=p5969 lab=_76508_/A }
C {devices/lab_pin.sym} 6340 -21510 0 1 {name=p5970 lab=_76510_/B }
C {sky130_stdcells/inv_2.sym} 6300 -21510 0 0 {name=X_76508_ }
C {devices/lab_pin.sym} 6240 -21420 0 0 {name=p5971 lab=_49447_/A }
C {devices/lab_pin.sym} 6240 -21380 0 0 {name=p5972 lab=_49456_/B }
C {devices/lab_pin.sym} 6240 -21340 0 0 {name=p5973 lab=_49447_/C }
C {devices/lab_pin.sym} 6240 -21300 0 0 {name=p5974 lab=_46783_/X }
C {devices/lab_pin.sym} 6360 -21360 0 1 {name=p5975 lab=_49456_/X }
C {sky130_stdcells/and4_4.sym} 6300 -21360 0 0 {name=X_49456_ }
C {devices/lab_pin.sym} 6220 -21250 0 0 {name=p5976 lab=_58221_/X }
C {devices/lab_pin.sym} 6220 -21210 0 0 {name=p5977 lab=_61728_/X }
C {devices/lab_pin.sym} 6220 -21170 0 0 {name=p5978 lab=_62183_/D }
C {devices/lab_pin.sym} 6220 -21130 0 0 {name=p5979 lab=_59591_/A }
C {devices/lab_pin.sym} 6220 -21100 0 0 {name=p5980 lab=_61733_/X }
C {devices/lab_pin.sym} 6380 -21170 0 1 {name=p5981 lab=_61734_/X }
C {sky130_stdcells/a41o_4.sym} 6300 -21170 0 0 {name=X_61734_ }
C {devices/lab_pin.sym} 6220 -21030 0 0 {name=p5982 lab=_82639_/D }
C {devices/lab_pin.sym} 6220 -20990 0 0 {name=p5983 lab=_68279_/X }
C {devices/lab_pin.sym} 6220 -20950 0 0 {name=p5984 lab=_68289_/X }
C {devices/lab_pin.sym} 6380 -20990 0 1 {name=p5985 lab=_83991_/D }
C {sky130_stdcells/a21bo_4.sym} 6300 -20990 0 0 {name=X_68290_ }
C {devices/lab_pin.sym} 6260 -20850 0 0 {name=p5986 lab=_82972_/Q }
C {devices/lab_pin.sym} 6340 -20850 0 1 {name=p5987 lab=_54298_/D }
C {sky130_stdcells/inv_2.sym} 6300 -20850 0 0 {name=X_46668_ }
C {devices/lab_pin.sym} 6240 -20740 0 0 {name=p5988 lab=_77488_/A }
C {devices/lab_pin.sym} 6240 -20700 0 0 {name=p5989 lab=_77488_/B }
C {devices/lab_pin.sym} 6360 -20720 0 1 {name=p5990 lab=_77488_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -20720 0 0 {name=X_77488_ }
C {devices/lab_pin.sym} 6260 -20590 0 0 {name=p5991 lab=_48407_/A }
C {devices/lab_pin.sym} 6340 -20590 0 1 {name=p5992 lab=_52119_/B }
C {sky130_stdcells/buf_2.sym} 6300 -20590 0 0 {name=X_48407_ }
C {devices/lab_pin.sym} 6240 -20480 0 0 {name=p5993 lab=_67241_/A }
C {devices/lab_pin.sym} 6240 -20440 0 0 {name=p5994 lab=_86810_/Q }
C {devices/lab_pin.sym} 6360 -20460 0 1 {name=p5995 lab=_67241_/X }
C {sky130_stdcells/and2_4.sym} 6300 -20460 0 0 {name=X_67241_ }
C {devices/lab_pin.sym} 6260 -20330 0 0 {name=p5996 lab=_79227_/A }
C {devices/lab_pin.sym} 6340 -20330 0 1 {name=p5997 lab=_82822_/D }
C {sky130_stdcells/inv_2.sym} 6300 -20330 0 0 {name=X_79227_ }
C {devices/lab_pin.sym} 6220 -20230 0 0 {name=p5998 lab=_45614_/X }
C {devices/lab_pin.sym} 6220 -20190 0 0 {name=p5999 lab=_45618_/X }
C {devices/lab_pin.sym} 6220 -20150 0 0 {name=p6000 lab=_45602_/X }
C {devices/lab_pin.sym} 6380 -20190 0 1 {name=p6001 lab=_45619_/X }
C {sky130_stdcells/a21o_4.sym} 6300 -20190 0 0 {name=X_45619_ }
C {devices/lab_pin.sym} 6240 -20060 0 0 {name=p6002 lab=_76459_/A }
C {devices/lab_pin.sym} 6240 -20020 0 0 {name=p6003 lab=_81526_/D }
C {devices/lab_pin.sym} 6360 -20040 0 1 {name=p6004 lab=_76439_/X }
C {sky130_stdcells/xor2_4.sym} 6300 -20040 0 0 {name=X_76439_ }
C {devices/lab_pin.sym} 6220 -19930 0 0 {name=p6005 lab=_84245_/Q }
C {devices/lab_pin.sym} 6220 -19890 0 0 {name=p6006 lab=_64429_/X }
C {devices/lab_pin.sym} 6220 -19850 0 0 {name=p6007 lab=_64452_/X }
C {devices/lab_pin.sym} 6380 -19890 0 1 {name=p6008 lab=_64453_/X }
C {sky130_stdcells/a21o_4.sym} 6300 -19890 0 0 {name=X_64453_ }
C {devices/lab_pin.sym} 6220 -19770 0 0 {name=p6009 lab=_49383_/Y }
C {devices/lab_pin.sym} 6220 -19730 0 0 {name=p6010 lab=_49378_/X }
C {devices/lab_pin.sym} 6220 -19690 0 0 {name=p6011 lab=_49386_/X }
C {devices/lab_pin.sym} 6380 -19730 0 1 {name=p6012 lab=_86397_/D }
C {sky130_stdcells/a21oi_4.sym} 6300 -19730 0 0 {name=X_49387_ }
C {devices/lab_pin.sym} 6240 -19610 0 0 {name=p6013 lab=_61292_/A }
C {devices/lab_pin.sym} 6240 -19570 0 0 {name=p6014 lab=_61665_/B }
C {devices/lab_pin.sym} 6240 -19530 0 0 {name=p6015 lab=_61675_/C }
C {devices/lab_pin.sym} 6360 -19570 0 1 {name=p6016 lab=_61665_/Y }
C {sky130_stdcells/nand3_4.sym} 6300 -19570 0 0 {name=X_61665_ }
C {devices/lab_pin.sym} 6260 -19430 0 0 {name=p6017 lab=_81186_/Q }
C {devices/lab_pin.sym} 6340 -19430 0 1 {name=p6018 lab=_46600_/B }
C {sky130_stdcells/inv_2.sym} 6300 -19430 0 0 {name=X_46599_ }
C {devices/lab_pin.sym} 6260 -19310 0 0 {name=p6019 lab=_63528_/A }
C {devices/lab_pin.sym} 6340 -19310 0 1 {name=p6020 lab=_63456_/A }
C {sky130_stdcells/buf_2.sym} 6300 -19310 0 0 {name=X_63404_ }
C {devices/lab_pin.sym} 6240 -19200 0 0 {name=p6021 lab=_48348_/A }
C {devices/lab_pin.sym} 6240 -19160 0 0 {name=p6022 lab=_52079_/B }
C {devices/lab_pin.sym} 6360 -19180 0 1 {name=p6023 lab=_48338_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -19180 0 0 {name=X_48338_ }
C {devices/lab_pin.sym} 6240 -19060 0 0 {name=p6024 lab=_60593_/B }
C {devices/lab_pin.sym} 6240 -19020 0 0 {name=p6025 lab=_60616_/B }
C {devices/lab_pin.sym} 6360 -19040 0 1 {name=p6026 lab=_60616_/Y }
C {sky130_stdcells/nor2_4.sym} 6300 -19040 0 0 {name=X_60616_ }
C {devices/lab_pin.sym} 6220 -18930 0 0 {name=p6027 lab=_67169_/X }
C {devices/lab_pin.sym} 6220 -18890 0 0 {name=p6028 lab=_67171_/X }
C {devices/lab_pin.sym} 6220 -18850 0 0 {name=p6029 lab=_67147_/X }
C {devices/lab_pin.sym} 6380 -18890 0 1 {name=p6030 lab=_67172_/X }
C {sky130_stdcells/a21o_4.sym} 6300 -18890 0 0 {name=X_67172_ }
C {devices/lab_pin.sym} 6240 -18760 0 0 {name=p6031 lab=_79158_/A }
C {devices/lab_pin.sym} 6240 -18720 0 0 {name=p6032 lab=_79158_/B }
C {devices/lab_pin.sym} 6360 -18740 0 1 {name=p6033 lab=_79158_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -18740 0 0 {name=X_79158_ }
C {devices/lab_pin.sym} 6260 -18610 0 0 {name=p6034 lab=_64267_/A }
C {devices/lab_pin.sym} 6340 -18610 0 1 {name=p6035 lab=_64384_/X }
C {sky130_stdcells/buf_2.sym} 6300 -18610 0 0 {name=X_64384_ }
C {devices/lab_pin.sym} 6260 -18490 0 0 {name=p6036 lab=_61340_/A }
C {devices/lab_pin.sym} 6340 -18490 0 1 {name=p6037 lab=_61611_/C }
C {sky130_stdcells/buf_2.sym} 6300 -18490 0 0 {name=X_61596_ }
C {devices/lab_pin.sym} 6240 -18390 0 0 {name=p6038 lab=_66123_/A }
C {devices/lab_pin.sym} 6240 -18350 0 0 {name=p6039 lab=_66004_/B }
C {devices/lab_pin.sym} 6240 -18310 0 0 {name=p6040 lab=_80481_/B }
C {devices/lab_pin.sym} 6360 -18350 0 1 {name=p6041 lab=_66123_/X }
C {sky130_stdcells/and3_4.sym} 6300 -18350 0 0 {name=X_66123_ }
C {devices/lab_pin.sym} 6240 -18220 0 0 {name=p6042 lab=_82566_/Q }
C {devices/lab_pin.sym} 6240 -18180 0 0 {name=p6043 lab=_78102_/B }
C {devices/lab_pin.sym} 6360 -18200 0 1 {name=p6044 lab=_78109_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -18200 0 0 {name=X_78109_ }
C {devices/lab_pin.sym} 6240 -18100 0 0 {name=p6045 lab=_63335_/A }
C {devices/lab_pin.sym} 6240 -18060 0 0 {name=p6046 lab=_63344_/B }
C {devices/lab_pin.sym} 6240 -18020 0 0 {name=p6047 lab=_60588_/X }
C {devices/lab_pin.sym} 6240 -17980 0 0 {name=p6048 lab=_63344_/D }
C {devices/lab_pin.sym} 6360 -18040 0 1 {name=p6049 lab=_63335_/X }
C {sky130_stdcells/or4_4.sym} 6300 -18040 0 0 {name=X_63335_ }
C {devices/lab_pin.sym} 6240 -17910 0 0 {name=p6050 lab=_60526_/A }
C {devices/lab_pin.sym} 6240 -17870 0 0 {name=p6051 lab=_60526_/B }
C {devices/lab_pin.sym} 6240 -17830 0 0 {name=p6052 lab=_79142_/A }
C {devices/lab_pin.sym} 6360 -17870 0 1 {name=p6053 lab=_60547_/Y }
C {sky130_stdcells/nor3_4.sym} 6300 -17870 0 0 {name=X_60547_ }
C {devices/lab_pin.sym} 6240 -17750 0 0 {name=p6054 lab=_50314_/A }
C {devices/lab_pin.sym} 6240 -17710 0 0 {name=p6055 lab=_48201_/B }
C {devices/lab_pin.sym} 6240 -17670 0 0 {name=p6056 lab=_48287_/C }
C {devices/lab_pin.sym} 6360 -17710 0 1 {name=p6057 lab=_48269_/X }
C {sky130_stdcells/and3_4.sym} 6300 -17710 0 0 {name=X_48269_ }
C {devices/lab_pin.sym} 6260 -17570 0 0 {name=p6058 lab=_79089_/A }
C {devices/lab_pin.sym} 6340 -17570 0 1 {name=p6059 lab=_82527_/D }
C {sky130_stdcells/inv_2.sym} 6300 -17570 0 0 {name=X_79089_ }
C {devices/lab_pin.sym} 6240 -17460 0 0 {name=p6060 lab=_50279_/X }
C {devices/lab_pin.sym} 6240 -17420 0 0 {name=p6061 lab=_50300_/B }
C {devices/lab_pin.sym} 6360 -17440 0 1 {name=p6062 lab=_50300_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -17440 0 0 {name=X_50300_ }
C {devices/lab_pin.sym} 6210 -17310 0 0 {name=p6063 lab=_81834_/CLK }
C {devices/lab_pin.sym} 6210 -17290 0 0 {name=p6064 lab=_79879_/X }
C {devices/lab_pin.sym} 6390 -17310 0 1 {name=p6065 lab=_81120_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -17300 0 0 {name=X_81120_ }
C {devices/lab_pin.sym} 6260 -17170 0 0 {name=p6066 lab=_65877_/A }
C {devices/lab_pin.sym} 6340 -17170 0 1 {name=p6067 lab=_66054_/X }
C {sky130_stdcells/buf_2.sym} 6300 -17170 0 0 {name=X_66054_ }
C {devices/lab_pin.sym} 6240 -17060 0 0 {name=p6068 lab=_51280_/A }
C {devices/lab_pin.sym} 6240 -17020 0 0 {name=p6069 lab=_46356_/X }
C {devices/lab_pin.sym} 6360 -17040 0 1 {name=p6070 lab=_51280_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -17040 0 0 {name=X_51280_ }
C {devices/lab_pin.sym} 6220 -16950 0 0 {name=p6071 lab=_63260_/Y }
C {devices/lab_pin.sym} 6220 -16910 0 0 {name=p6072 lab=_63261_/X }
C {devices/lab_pin.sym} 6220 -16870 0 0 {name=p6073 lab=_63263_/X }
C {devices/lab_pin.sym} 6220 -16830 0 0 {name=p6074 lab=_63265_/X }
C {devices/lab_pin.sym} 6220 -16790 0 0 {name=p6075 lab=_63242_/X }
C {devices/lab_pin.sym} 6380 -16870 0 1 {name=p6076 lab=_63266_/Y }
C {sky130_stdcells/o41ai_4.sym} 6300 -16870 0 0 {name=X_63266_ }
C {devices/lab_pin.sym} 6220 -16750 0 0 {name=p6077 lab=_60465_/Y }
C {devices/lab_pin.sym} 6220 -16710 0 0 {name=p6078 lab=_60471_/X }
C {devices/lab_pin.sym} 6220 -16670 0 0 {name=p6079 lab=_60586_/A }
C {devices/lab_pin.sym} 6220 -16630 0 0 {name=p6080 lab=_60476_/Y }
C {devices/lab_pin.sym} 6220 -16600 0 0 {name=p6081 lab=_60477_/Y }
C {devices/lab_pin.sym} 6380 -16670 0 1 {name=p6082 lab=_60478_/Y }
C {sky130_stdcells/a41oi_4.sym} 6300 -16670 0 0 {name=X_60478_ }
C {devices/lab_pin.sym} 6260 -16510 0 0 {name=p6083 lab=_64602_/A }
C {devices/lab_pin.sym} 6340 -16510 0 1 {name=p6084 lab=_65005_/X }
C {sky130_stdcells/buf_2.sym} 6300 -16510 0 0 {name=X_65005_ }
C {devices/lab_pin.sym} 6220 -16410 0 0 {name=p6085 lab=_50225_/Y }
C {devices/lab_pin.sym} 6220 -16370 0 0 {name=p6086 lab=_50227_/X }
C {devices/lab_pin.sym} 6220 -16330 0 0 {name=p6087 lab=_50230_/Y }
C {devices/lab_pin.sym} 6380 -16370 0 1 {name=p6088 lab=_50231_/Y }
C {sky130_stdcells/a21boi_4.sym} 6300 -16370 0 0 {name=X_50231_ }
C {devices/lab_pin.sym} 6220 -16250 0 0 {name=p6089 lab=_62215_/Y }
C {devices/lab_pin.sym} 6220 -16210 0 0 {name=p6090 lab=_62166_/X }
C {devices/lab_pin.sym} 6220 -16170 0 0 {name=p6091 lab=_62216_/Y }
C {devices/lab_pin.sym} 6380 -16210 0 1 {name=p6092 lab=_84425_/D }
C {sky130_stdcells/a21oi_4.sym} 6300 -16210 0 0 {name=X_62217_ }
C {devices/lab_pin.sym} 6210 -16070 0 0 {name=p6093 lab=_81082_/CLK }
C {devices/lab_pin.sym} 6210 -16050 0 0 {name=p6094 lab=_75451_/Y }
C {devices/lab_pin.sym} 6390 -16070 0 1 {name=p6095 lab=_81051_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -16060 0 0 {name=X_81051_ }
C {devices/lab_pin.sym} 6260 -15930 0 0 {name=p6096 lab=clkbuf_9_296_0_CLK/X }
C {devices/lab_pin.sym} 6340 -15930 0 1 {name=p6097 lab=_81061_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 6300 -15930 0 0 {name=Xclkbuf_10_592_0_CLK }
C {devices/lab_pin.sym} 6220 -15850 0 0 {name=p6098 lab=_63191_/Y }
C {devices/lab_pin.sym} 6220 -15810 0 0 {name=p6099 lab=_63192_/X }
C {devices/lab_pin.sym} 6220 -15770 0 0 {name=p6100 lab=_63194_/X }
C {devices/lab_pin.sym} 6220 -15730 0 0 {name=p6101 lab=_63196_/X }
C {devices/lab_pin.sym} 6220 -15690 0 0 {name=p6102 lab=_63183_/X }
C {devices/lab_pin.sym} 6380 -15770 0 1 {name=p6103 lab=_63197_/Y }
C {sky130_stdcells/o41ai_4.sym} 6300 -15770 0 0 {name=X_63197_ }
C {devices/lab_pin.sym} 6240 -15620 0 0 {name=p6104 lab=_80000_/X }
C {devices/lab_pin.sym} 6240 -15580 0 0 {name=p6105 lab=_80002_/B }
C {devices/lab_pin.sym} 6360 -15600 0 1 {name=p6106 lab=_80002_/X }
C {sky130_stdcells/xor2_4.sym} 6300 -15600 0 0 {name=X_80002_ }
C {devices/lab_pin.sym} 6240 -15480 0 0 {name=p6107 lab=_69810_/X }
C {devices/lab_pin.sym} 6240 -15440 0 0 {name=p6108 lab=_69813_/B }
C {devices/lab_pin.sym} 6360 -15460 0 1 {name=p6109 lab=_69813_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -15460 0 0 {name=X_69813_ }
C {devices/lab_pin.sym} 6260 -15330 0 0 {name=p6110 lab=_50113_/A }
C {devices/lab_pin.sym} 6340 -15330 0 1 {name=p6111 lab=_50162_/X }
C {sky130_stdcells/buf_2.sym} 6300 -15330 0 0 {name=X_50162_ }
C {devices/lab_pin.sym} 6220 -15250 0 0 {name=p6112 lab=_58201_/X }
C {devices/lab_pin.sym} 6220 -15210 0 0 {name=p6113 lab=_62105_/X }
C {devices/lab_pin.sym} 6220 -15170 0 0 {name=p6114 lab=_62065_/D }
C {devices/lab_pin.sym} 6220 -15130 0 0 {name=p6115 lab=_61948_/X }
C {devices/lab_pin.sym} 6220 -15100 0 0 {name=p6116 lab=_62147_/X }
C {devices/lab_pin.sym} 6380 -15170 0 1 {name=p6117 lab=_62148_/X }
C {sky130_stdcells/a41o_4.sym} 6300 -15170 0 0 {name=X_62148_ }
C {devices/lab_pin.sym} 6210 -15010 0 0 {name=p6118 lab=_82973_/CLK }
C {devices/lab_pin.sym} 6210 -14990 0 0 {name=p6119 lab=_84810_/D }
C {devices/lab_pin.sym} 6390 -15010 0 1 {name=p6120 lab=_58653_/A }
C {sky130_stdcells/dfxtp_4.sym} 6300 -15000 0 0 {name=X_84810_ }
C {devices/lab_pin.sym} 6220 -14900 0 0 {name=p6121 lab=_69324_/Y }
C {devices/lab_pin.sym} 6220 -14860 0 0 {name=p6122 lab=_69732_/X }
C {devices/lab_pin.sym} 6220 -14820 0 0 {name=p6123 lab=_69733_/X }
C {devices/lab_pin.sym} 6220 -14780 0 0 {name=p6124 lab=_69743_/Y }
C {devices/lab_pin.sym} 6380 -14840 0 1 {name=p6125 lab=_69744_/X }
C {sky130_stdcells/a211o_4.sym} 6300 -14840 0 0 {name=X_69744_ }
C {devices/lab_pin.sym} 6220 -14710 0 0 {name=p6126 lab=_50599_/A }
C {devices/lab_pin.sym} 6220 -14670 0 0 {name=p6127 lab=_50599_/B }
C {devices/lab_pin.sym} 6220 -14630 0 0 {name=p6128 lab=_47848_/X }
C {devices/lab_pin.sym} 6380 -14670 0 1 {name=p6129 lab=_50093_/X }
C {sky130_stdcells/o21a_4.sym} 6300 -14670 0 0 {name=X_50093_ }
C {devices/lab_pin.sym} 6220 -14550 0 0 {name=p6130 lab=_85343_/Q }
C {devices/lab_pin.sym} 6220 -14510 0 0 {name=p6131 lab=_54967_/X }
C {devices/lab_pin.sym} 6220 -14470 0 0 {name=p6132 lab=_54969_/Y }
C {devices/lab_pin.sym} 6380 -14510 0 1 {name=p6133 lab=_54970_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -14510 0 0 {name=X_54970_ }
C {devices/lab_pin.sym} 6240 -14380 0 0 {name=p6134 lab=_66956_/A }
C {devices/lab_pin.sym} 6240 -14340 0 0 {name=p6135 lab=_88131_/Q }
C {devices/lab_pin.sym} 6360 -14360 0 1 {name=p6136 lab=_66956_/X }
C {sky130_stdcells/and2_4.sym} 6300 -14360 0 0 {name=X_66956_ }
C {devices/lab_pin.sym} 6240 -14250 0 0 {name=p6137 lab=_62050_/X }
C {devices/lab_pin.sym} 6240 -14210 0 0 {name=p6138 lab=_62090_/B }
C {devices/lab_pin.sym} 6240 -14170 0 0 {name=p6139 lab=_78058_/B }
C {devices/lab_pin.sym} 6360 -14210 0 1 {name=p6140 lab=_62079_/Y }
C {sky130_stdcells/nor3_4.sym} 6300 -14210 0 0 {name=X_62079_ }
C {devices/lab_pin.sym} 6210 -14070 0 0 {name=p6141 lab=_84807_/CLK }
C {devices/lab_pin.sym} 6210 -14050 0 0 {name=p6142 lab=_85790_/D }
C {devices/lab_pin.sym} 6390 -14070 0 1 {name=p6143 lab=_85790_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -14060 0 0 {name=X_85790_ }
C {devices/lab_pin.sym} 6260 -13930 0 0 {name=p6144 lab=_53921_/A }
C {devices/lab_pin.sym} 6340 -13930 0 1 {name=p6145 lab=_53921_/X }
C {sky130_stdcells/buf_2.sym} 6300 -13930 0 0 {name=X_53921_ }
C {devices/lab_pin.sym} 6220 -13840 0 0 {name=p6146 lab=_65845_/X }
C {devices/lab_pin.sym} 6220 -13800 0 0 {name=p6147 lab=_86241_/Q }
C {devices/lab_pin.sym} 6220 -13760 0 0 {name=p6148 lab=_65904_/X }
C {devices/lab_pin.sym} 6220 -13720 0 0 {name=p6149 lab=_65906_/X }
C {devices/lab_pin.sym} 6380 -13780 0 1 {name=p6150 lab=_65907_/X }
C {sky130_stdcells/a211o_4.sym} 6300 -13780 0 0 {name=X_65907_ }
C {devices/lab_pin.sym} 6210 -13630 0 0 {name=p6151 lab=_83766_/CLK }
C {devices/lab_pin.sym} 6210 -13610 0 0 {name=p6152 lab=_84741_/D }
C {devices/lab_pin.sym} 6390 -13630 0 1 {name=p6153 lab=_84741_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -13620 0 0 {name=X_84741_ }
C {devices/lab_pin.sym} 6210 -13490 0 0 {name=p6154 lab=_82124_/CLK }
C {devices/lab_pin.sym} 6210 -13470 0 0 {name=p6155 lab=_78028_/X }
C {devices/lab_pin.sym} 6390 -13490 0 1 {name=p6156 lab=_77721_/A }
C {sky130_stdcells/dfxtp_4.sym} 6300 -13480 0 0 {name=X_81953_ }
C {devices/lab_pin.sym} 6260 -13350 0 0 {name=p6157 lab=_68386_/A }
C {devices/lab_pin.sym} 6340 -13350 0 1 {name=p6158 lab=_69687_/A }
C {sky130_stdcells/buf_2.sym} 6300 -13350 0 0 {name=X_69675_ }
C {devices/lab_pin.sym} 6240 -13240 0 0 {name=p6159 lab=_66912_/A }
C {devices/lab_pin.sym} 6240 -13200 0 0 {name=p6160 lab=_87622_/Q }
C {devices/lab_pin.sym} 6360 -13220 0 1 {name=p6161 lab=_66887_/X }
C {sky130_stdcells/and2_4.sym} 6300 -13220 0 0 {name=X_66887_ }
C {devices/lab_pin.sym} 6260 -13090 0 0 {name=p6162 lab=_56552_/Y }
C {devices/lab_pin.sym} 6340 -13090 0 1 {name=p6163 lab=_56753_/A }
C {sky130_stdcells/buf_2.sym} 6300 -13090 0 0 {name=X_56640_ }
C {devices/lab_pin.sym} 6210 -12970 0 0 {name=p6164 lab=_83933_/CLK }
C {devices/lab_pin.sym} 6210 -12950 0 0 {name=p6165 lab=_84080_/Q }
C {devices/lab_pin.sym} 6390 -12970 0 1 {name=p6166 lab=_75619_/A }
C {sky130_stdcells/dfxtp_4.sym} 6300 -12960 0 0 {name=X_80904_ }
C {devices/lab_pin.sym} 6260 -12830 0 0 {name=p6167 lab=_68757_/A }
C {devices/lab_pin.sym} 6340 -12830 0 1 {name=p6168 lab=_68626_/X }
C {sky130_stdcells/buf_2.sym} 6300 -12830 0 0 {name=X_68626_ }
C {devices/lab_pin.sym} 6210 -12710 0 0 {name=p6169 lab=_87149_/CLK }
C {devices/lab_pin.sym} 6210 -12690 0 0 {name=p6170 lab=_87460_/D }
C {devices/lab_pin.sym} 6390 -12710 0 1 {name=p6171 lab=_87460_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -12700 0 0 {name=X_87460_ }
C {devices/lab_pin.sym} 6240 -12580 0 0 {name=p6172 lab=_53848_/A }
C {devices/lab_pin.sym} 6240 -12540 0 0 {name=p6173 lab=_53852_/B }
C {devices/lab_pin.sym} 6360 -12560 0 1 {name=p6174 lab=_53852_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -12560 0 0 {name=X_53852_ }
C {devices/lab_pin.sym} 6220 -12450 0 0 {name=p6175 lab=_65835_/X }
C {devices/lab_pin.sym} 6220 -12410 0 0 {name=p6176 lab=_65837_/X }
C {devices/lab_pin.sym} 6220 -12370 0 0 {name=p6177 lab=_64574_/X }
C {devices/lab_pin.sym} 6380 -12410 0 1 {name=p6178 lab=_65838_/X }
C {sky130_stdcells/a21o_4.sym} 6300 -12410 0 0 {name=X_65838_ }
C {devices/lab_pin.sym} 6210 -12270 0 0 {name=p6179 lab=_84672_/CLK }
C {devices/lab_pin.sym} 6210 -12250 0 0 {name=p6180 lab=_60041_/Y }
C {devices/lab_pin.sym} 6390 -12270 0 1 {name=p6181 lab=_80153_/A }
C {sky130_stdcells/dfxtp_4.sym} 6300 -12260 0 0 {name=X_84672_ }
C {devices/lab_pin.sym} 6210 -12130 0 0 {name=p6182 lab=_81872_/CLK }
C {devices/lab_pin.sym} 6210 -12110 0 0 {name=p6183 lab=_78075_/X }
C {devices/lab_pin.sym} 6390 -12130 0 1 {name=p6184 lab=_81852_/D }
C {sky130_stdcells/dfxtp_4.sym} 6300 -12120 0 0 {name=X_81884_ }
C {devices/lab_pin.sym} 6210 -11990 0 0 {name=p6185 lab=_86733_/CLK }
C {devices/lab_pin.sym} 6210 -11970 0 0 {name=p6186 lab=_86411_/D }
C {devices/lab_pin.sym} 6390 -11990 0 1 {name=p6187 lab=_86411_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -11980 0 0 {name=X_86411_ }
C {devices/lab_pin.sym} 6240 -11860 0 0 {name=p6188 lab=_52803_/A }
C {devices/lab_pin.sym} 6240 -11820 0 0 {name=p6189 lab=_52803_/B }
C {devices/lab_pin.sym} 6360 -11840 0 1 {name=p6190 lab=_52803_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -11840 0 0 {name=X_52803_ }
C {devices/lab_pin.sym} 6210 -11710 0 0 {name=p6191 lab=_83623_/CLK }
C {devices/lab_pin.sym} 6210 -11690 0 0 {name=p6192 lab=_71056_/Y }
C {devices/lab_pin.sym} 6390 -11710 0 1 {name=p6193 lab=_83623_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -11700 0 0 {name=X_83623_ }
C {devices/lab_pin.sym} 6260 -11570 0 0 {name=p6194 lab=_56570_/Y }
C {devices/lab_pin.sym} 6340 -11570 0 1 {name=p6195 lab=_56571_/X }
C {sky130_stdcells/buf_2.sym} 6300 -11570 0 0 {name=X_56571_ }
C {devices/lab_pin.sym} 6210 -11450 0 0 {name=p6196 lab=_80835_/CLK }
C {devices/lab_pin.sym} 6210 -11430 0 0 {name=p6197 lab=_80835_/D }
C {devices/lab_pin.sym} 6390 -11450 0 1 {name=p6198 lab=_80835_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -11440 0 0 {name=X_80835_ }
C {devices/lab_pin.sym} 6220 -11340 0 0 {name=p6199 lab=_88108_/Q }
C {devices/lab_pin.sym} 6220 -11300 0 0 {name=p6200 lab=_68504_/X }
C {devices/lab_pin.sym} 6220 -11260 0 0 {name=p6201 lab=_68555_/X }
C {devices/lab_pin.sym} 6220 -11220 0 0 {name=p6202 lab=_68556_/Y }
C {devices/lab_pin.sym} 6380 -11280 0 1 {name=p6203 lab=_68557_/X }
C {sky130_stdcells/a211o_4.sym} 6300 -11280 0 0 {name=X_68557_ }
C {devices/lab_pin.sym} 6260 -11130 0 0 {name=p6204 lab=clkbuf_9_265_0_CLK/X }
C {devices/lab_pin.sym} 6340 -11130 0 1 {name=p6205 lab=_81352_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 6300 -11130 0 0 {name=Xclkbuf_10_530_0_CLK }
C {devices/lab_pin.sym} 6210 -11010 0 0 {name=p6206 lab=_87898_/CLK }
C {devices/lab_pin.sym} 6210 -10990 0 0 {name=p6207 lab=_43497_/Y }
C {devices/lab_pin.sym} 6390 -11010 0 1 {name=p6208 lab=_87391_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -11000 0 0 {name=X_87391_ }
C {devices/lab_pin.sym} 6220 -10890 0 0 {name=p6209 lab=_53781_/Y }
C {devices/lab_pin.sym} 6220 -10850 0 0 {name=p6210 lab=_53773_/X }
C {devices/lab_pin.sym} 6220 -10810 0 0 {name=p6211 lab=_53782_/X }
C {devices/lab_pin.sym} 6380 -10850 0 1 {name=p6212 lab=_53783_/Y }
C {sky130_stdcells/a21oi_4.sym} 6300 -10850 0 0 {name=X_53783_ }
C {devices/lab_pin.sym} 6240 -10720 0 0 {name=p6213 lab=_65769_/A }
C {devices/lab_pin.sym} 6240 -10680 0 0 {name=p6214 lab=_86507_/Q }
C {devices/lab_pin.sym} 6360 -10700 0 1 {name=p6215 lab=_65769_/X }
C {sky130_stdcells/and2_4.sym} 6300 -10700 0 0 {name=X_65769_ }
C {devices/lab_pin.sym} 6260 -10570 0 0 {name=p6216 lab=clkbuf_6_21_0_CLK/A }
C {devices/lab_pin.sym} 6340 -10570 0 1 {name=p6217 lab=clkbuf_7_42_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 6300 -10570 0 0 {name=Xclkbuf_6_21_0_CLK }
C {devices/lab_pin.sym} 6220 -10470 0 0 {name=p6218 lab=_86093_/Q }
C {devices/lab_pin.sym} 6220 -10430 0 0 {name=p6219 lab=_50992_/X }
C {devices/lab_pin.sym} 6220 -10390 0 0 {name=p6220 lab=_50994_/Y }
C {devices/lab_pin.sym} 6380 -10430 0 1 {name=p6221 lab=_50995_/Y }
C {sky130_stdcells/o21ai_4.sym} 6300 -10430 0 0 {name=X_50995_ }
C {devices/lab_pin.sym} 6260 -10290 0 0 {name=p6222 lab=_58328_/A }
C {devices/lab_pin.sym} 6340 -10290 0 1 {name=p6223 lab=_58310_/X }
C {sky130_stdcells/buf_2.sym} 6300 -10290 0 0 {name=X_58310_ }
C {devices/lab_pin.sym} 6260 -10170 0 0 {name=p6224 lab=_55489_/A }
C {devices/lab_pin.sym} 6340 -10170 0 1 {name=p6225 lab=_55522_/X }
C {sky130_stdcells/buf_2.sym} 6300 -10170 0 0 {name=X_55522_ }
C {devices/lab_pin.sym} 6260 -10050 0 0 {name=p6226 lab=_67270_/X }
C {devices/lab_pin.sym} 6340 -10050 0 1 {name=p6227 lab=_67508_/X }
C {sky130_stdcells/buf_2.sym} 6300 -10050 0 0 {name=X_67508_ }
C {devices/lab_pin.sym} 6210 -9930 0 0 {name=p6228 lab=_86342_/CLK }
C {devices/lab_pin.sym} 6210 -9910 0 0 {name=p6229 lab=_49686_/Y }
C {devices/lab_pin.sym} 6390 -9930 0 1 {name=p6230 lab=_59327_/B }
C {sky130_stdcells/dfxtp_4.sym} 6300 -9920 0 0 {name=X_86342_ }
C {devices/lab_pin.sym} 6260 -9790 0 0 {name=p6231 lab=_52708_/A }
C {devices/lab_pin.sym} 6340 -9790 0 1 {name=p6232 lab=_52746_/C }
C {sky130_stdcells/buf_2.sym} 6300 -9790 0 0 {name=X_52734_ }
C {devices/lab_pin.sym} 6220 -9700 0 0 {name=p6233 lab=_84754_/Q }
C {devices/lab_pin.sym} 6220 -9660 0 0 {name=p6234 lab=_59268_/X }
C {devices/lab_pin.sym} 6220 -9620 0 0 {name=p6235 lab=_59283_/X }
C {devices/lab_pin.sym} 6220 -9580 0 0 {name=p6236 lab=_59289_/X }
C {devices/lab_pin.sym} 6380 -9640 0 1 {name=p6237 lab=_84754_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 6300 -9640 0 0 {name=X_59290_ }
C {devices/lab_pin.sym} 6210 -9490 0 0 {name=p6238 lab=_86554_/CLK }
C {devices/lab_pin.sym} 6210 -9470 0 0 {name=p6239 lab=_71262_/Y }
C {devices/lab_pin.sym} 6390 -9490 0 1 {name=p6240 lab=_47910_/A }
C {sky130_stdcells/dfxtp_4.sym} 6300 -9480 0 0 {name=X_83554_ }
C {devices/lab_pin.sym} 6210 -9350 0 0 {name=p6241 lab=_80991_/CLK }
C {devices/lab_pin.sym} 6210 -9330 0 0 {name=p6242 lab=_75514_/X }
C {devices/lab_pin.sym} 6390 -9350 0 1 {name=p6243 lab=_80766_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -9340 0 0 {name=X_80766_ }
C {devices/lab_pin.sym} 6220 -9240 0 0 {name=p6244 lab=_68376_/X }
C {devices/lab_pin.sym} 6220 -9200 0 0 {name=p6245 lab=_66524_/B }
C {devices/lab_pin.sym} 6220 -9160 0 0 {name=p6246 lab=_68478_/Y }
C {devices/lab_pin.sym} 6220 -9120 0 0 {name=p6247 lab=_68487_/Y }
C {devices/lab_pin.sym} 6380 -9180 0 1 {name=p6248 lab=_68488_/X }
C {sky130_stdcells/a211o_4.sym} 6300 -9180 0 0 {name=X_68488_ }
C {devices/lab_pin.sym} 6260 -9030 0 0 {name=p6249 lab=_64283_/C }
C {devices/lab_pin.sym} 6340 -9030 0 1 {name=p6250 lab=_58241_/X }
C {sky130_stdcells/buf_2.sym} 6300 -9030 0 0 {name=X_58241_ }
C {devices/lab_pin.sym} 6210 -8910 0 0 {name=p6251 lab=_82671_/CLK }
C {devices/lab_pin.sym} 6210 -8890 0 0 {name=p6252 lab=_78877_/A }
C {devices/lab_pin.sym} 6390 -8910 0 1 {name=p6253 lab=_78416_/A }
C {sky130_stdcells/dfxtp_4.sym} 6300 -8900 0 0 {name=X_82505_ }
C {devices/lab_pin.sym} 6260 -8770 0 0 {name=p6254 lab=_55311_/X }
C {devices/lab_pin.sym} 6340 -8770 0 1 {name=p6255 lab=_55453_/X }
C {sky130_stdcells/buf_2.sym} 6300 -8770 0 0 {name=X_55453_ }
C {devices/lab_pin.sym} 6260 -8650 0 0 {name=p6256 lab=_67082_/A }
C {devices/lab_pin.sym} 6340 -8650 0 1 {name=p6257 lab=_67513_/A }
C {sky130_stdcells/buf_2.sym} 6300 -8650 0 0 {name=X_67439_ }
C {devices/lab_pin.sym} 6210 -8530 0 0 {name=p6258 lab=_83623_/CLK }
C {devices/lab_pin.sym} 6210 -8510 0 0 {name=p6259 lab=_86273_/D }
C {devices/lab_pin.sym} 6390 -8530 0 1 {name=p6260 lab=_86273_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -8520 0 0 {name=X_86273_ }
C {devices/lab_pin.sym} 6240 -8420 0 0 {name=p6261 lab=_52648_/X }
C {devices/lab_pin.sym} 6240 -8380 0 0 {name=p6262 lab=_52661_/B }
C {devices/lab_pin.sym} 6240 -8340 0 0 {name=p6263 lab=_52654_/C }
C {devices/lab_pin.sym} 6240 -8300 0 0 {name=p6264 lab=_46775_/X }
C {devices/lab_pin.sym} 6360 -8360 0 1 {name=p6265 lab=_52665_/X }
C {sky130_stdcells/and4_4.sym} 6300 -8360 0 0 {name=X_52665_ }
C {devices/lab_pin.sym} 6210 -8210 0 0 {name=p6266 lab=_83482_/CLK }
C {devices/lab_pin.sym} 6210 -8190 0 0 {name=p6267 lab=_83485_/D }
C {devices/lab_pin.sym} 6390 -8210 0 1 {name=p6268 lab=_83485_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -8200 0 0 {name=X_83485_ }
C {devices/lab_pin.sym} 6210 -8070 0 0 {name=p6269 lab=_80697_/CLK }
C {devices/lab_pin.sym} 6210 -8050 0 0 {name=p6270 lab=_80729_/Q }
C {devices/lab_pin.sym} 6390 -8070 0 1 {name=p6271 lab=_75411_/A }
C {sky130_stdcells/dfxtp_4.sym} 6300 -8060 0 0 {name=X_80697_ }
C {sky130_stdcells/decap_3.sym} 6300 -7900 0 0 {name=XPHY_703 }
C {devices/lab_pin.sym} 6210 -7750 0 0 {name=p6272 lab=_88012_/CLK }
C {devices/lab_pin.sym} 6210 -7730 0 0 {name=p6273 lab=_42146_/X }
C {devices/lab_pin.sym} 6390 -7750 0 1 {name=p6274 lab=_88012_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -7740 0 0 {name=X_88012_ }
C {sky130_stdcells/decap_3.sym} 6300 -7580 0 0 {name=XPHY_714 }
C {devices/lab_pin.sym} 6260 -7430 0 0 {name=p6275 lab=_54376_/A }
C {devices/lab_pin.sym} 6340 -7430 0 1 {name=p6276 lab=_54404_/X }
C {sky130_stdcells/buf_2.sym} 6300 -7430 0 0 {name=X_54404_ }
C {devices/lab_pin.sym} 6210 -7310 0 0 {name=p6277 lab=_85192_/CLK }
C {devices/lab_pin.sym} 6210 -7290 0 0 {name=p6278 lab=_56355_/Y }
C {devices/lab_pin.sym} 6390 -7310 0 1 {name=p6279 lab=_55748_/B }
C {sky130_stdcells/dfxtp_4.sym} 6300 -7300 0 0 {name=X_85224_ }
C {devices/lab_pin.sym} 6220 -7190 0 0 {name=p6280 lab=_51612_/Y }
C {devices/lab_pin.sym} 6220 -7150 0 0 {name=p6281 lab=_51613_/X }
C {devices/lab_pin.sym} 6220 -7110 0 0 {name=p6282 lab=_51615_/X }
C {devices/lab_pin.sym} 6380 -7150 0 1 {name=p6283 lab=_85978_/D }
C {sky130_stdcells/a21oi_4.sym} 6300 -7150 0 0 {name=X_51616_ }
C {devices/lab_pin.sym} 6240 -7030 0 0 {name=p6284 lab=_71650_/A }
C {devices/lab_pin.sym} 6240 -6990 0 0 {name=p6285 lab=_74533_/A }
C {devices/lab_pin.sym} 6240 -6950 0 0 {name=p6286 lab=_71194_/C }
C {devices/lab_pin.sym} 6360 -6990 0 1 {name=p6287 lab=_70450_/Y }
C {sky130_stdcells/nand3_4.sym} 6300 -6990 0 0 {name=X_70450_ }
C {devices/lab_pin.sym} 6260 -6850 0 0 {name=p6288 lab=clkbuf_9_272_0_CLK/X }
C {devices/lab_pin.sym} 6340 -6850 0 1 {name=p6289 lab=_81755_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 6300 -6850 0 0 {name=Xclkbuf_10_545_0_CLK }
C {devices/lab_pin.sym} 6260 -6730 0 0 {name=p6290 lab=_84915_/Q }
C {devices/lab_pin.sym} 6340 -6730 0 1 {name=p6291 lab=_63081_/A }
C {sky130_stdcells/inv_2.sym} 6300 -6730 0 0 {name=X_58172_ }
C {devices/lab_pin.sym} 6210 -6610 0 0 {name=p6292 lab=_82436_/CLK }
C {devices/lab_pin.sym} 6210 -6590 0 0 {name=p6293 lab=_79128_/X }
C {devices/lab_pin.sym} 6390 -6610 0 1 {name=p6294 lab=_82436_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -6600 0 0 {name=X_82436_ }
C {devices/lab_pin.sym} 6260 -6470 0 0 {name=p6295 lab=_55384_/A }
C {devices/lab_pin.sym} 6340 -6470 0 1 {name=p6296 lab=_55384_/Y }
C {sky130_stdcells/inv_2.sym} 6300 -6470 0 0 {name=X_55384_ }
C {devices/lab_pin.sym} 6260 -6350 0 0 {name=p6297 lab=clkbuf_6_37_0_CLK/A }
C {devices/lab_pin.sym} 6340 -6350 0 1 {name=p6298 lab=clkbuf_6_36_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 6300 -6350 0 0 {name=Xclkbuf_6_36_0_CLK }
C {devices/lab_pin.sym} 6240 -6240 0 0 {name=p6299 lab=_52590_/A }
C {devices/lab_pin.sym} 6240 -6200 0 0 {name=p6300 lab=_46650_/A }
C {devices/lab_pin.sym} 6360 -6220 0 1 {name=p6301 lab=_52596_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -6220 0 0 {name=X_52596_ }
C {devices/lab_pin.sym} 6220 -6110 0 0 {name=p6302 lab=_56893_/B }
C {devices/lab_pin.sym} 6220 -6070 0 0 {name=p6303 lab=_57193_/D }
C {devices/lab_pin.sym} 6220 -6030 0 0 {name=p6304 lab=_57086_/X }
C {devices/lab_pin.sym} 6380 -6070 0 1 {name=p6305 lab=_57123_/Y }
C {sky130_stdcells/a21oi_4.sym} 6300 -6070 0 0 {name=X_57123_ }
C {devices/lab_pin.sym} 6260 -5930 0 0 {name=p6306 lab=_60111_/X }
C {devices/lab_pin.sym} 6340 -5930 0 1 {name=p6307 lab=_69109_/X }
C {sky130_stdcells/buf_2.sym} 6300 -5930 0 0 {name=X_69109_ }
C {devices/lab_pin.sym} 6220 -5830 0 0 {name=p6308 lab=_54333_/Y }
C {devices/lab_pin.sym} 6220 -5790 0 0 {name=p6309 lab=_54311_/X }
C {devices/lab_pin.sym} 6220 -5750 0 0 {name=p6310 lab=_54334_/X }
C {devices/lab_pin.sym} 6380 -5790 0 1 {name=p6311 lab=_54335_/Y }
C {sky130_stdcells/a21oi_4.sym} 6300 -5790 0 0 {name=X_54335_ }
C {devices/lab_pin.sym} 6210 -5650 0 0 {name=p6312 lab=_85250_/CLK }
C {devices/lab_pin.sym} 6210 -5630 0 0 {name=p6313 lab=_85155_/D }
C {devices/lab_pin.sym} 6390 -5650 0 1 {name=p6314 lab=_55715_/B }
C {sky130_stdcells/dfxtp_4.sym} 6300 -5640 0 0 {name=X_85155_ }
C {devices/lab_pin.sym} 6260 -5510 0 0 {name=p6315 lab=_51629_/A }
C {devices/lab_pin.sym} 6340 -5510 0 1 {name=p6316 lab=_51553_/A }
C {sky130_stdcells/buf_2.sym} 6300 -5510 0 0 {name=X_51547_ }
C {devices/lab_pin.sym} 6260 -5390 0 0 {name=p6317 lab=DATA_TO_HASH[4] }
C {devices/lab_pin.sym} 6340 -5390 0 1 {name=p6318 lab=_70382_/A }
C {sky130_stdcells/buf_2.sym} 6300 -5390 0 0 {name=X_70381_ }
C {devices/lab_pin.sym} 6210 -5270 0 0 {name=p6319 lab=_84115_/CLK }
C {devices/lab_pin.sym} 6210 -5250 0 0 {name=p6320 lab=_77028_/X }
C {devices/lab_pin.sym} 6390 -5270 0 1 {name=p6321 lab=_82367_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -5260 0 0 {name=X_82367_ }
C {devices/lab_pin.sym} 6240 -5140 0 0 {name=p6322 lab=_81758_/Q }
C {devices/lab_pin.sym} 6240 -5100 0 0 {name=p6323 lab=_41292_/B }
C {devices/lab_pin.sym} 6360 -5120 0 1 {name=p6324 lab=_41300_/X }
C {sky130_stdcells/or2_4.sym} 6300 -5120 0 0 {name=X_41300_ }
C {devices/lab_pin.sym} 6260 -4990 0 0 {name=p6325 lab=_72255_/A }
C {devices/lab_pin.sym} 6340 -4990 0 1 {name=p6326 lab=_72120_/X }
C {sky130_stdcells/buf_2.sym} 6300 -4990 0 0 {name=X_72120_ }
C {devices/lab_pin.sym} 6210 -4870 0 0 {name=p6327 lab=_84111_/CLK }
C {devices/lab_pin.sym} 6210 -4850 0 0 {name=p6328 lab=_84106_/D }
C {devices/lab_pin.sym} 6390 -4870 0 1 {name=p6329 lab=_66524_/C }
C {sky130_stdcells/dfxtp_4.sym} 6300 -4860 0 0 {name=X_84106_ }
C {devices/lab_pin.sym} 6260 -4730 0 0 {name=p6330 lab=_57346_/C }
C {devices/lab_pin.sym} 6340 -4730 0 1 {name=p6331 lab=_57055_/A }
C {sky130_stdcells/inv_2.sym} 6300 -4730 0 0 {name=X_57054_ }
C {devices/lab_pin.sym} 6210 -4610 0 0 {name=p6332 lab=_84079_/CLK }
C {devices/lab_pin.sym} 6210 -4590 0 0 {name=p6333 lab=_76213_/X }
C {devices/lab_pin.sym} 6390 -4610 0 1 {name=p6334 lab=_81726_/D }
C {sky130_stdcells/dfxtp_4.sym} 6300 -4600 0 0 {name=X_81318_ }
C {devices/lab_pin.sym} 6220 -4510 0 0 {name=p6335 lab=_42279_/X }
C {devices/lab_pin.sym} 6220 -4470 0 0 {name=p6336 lab=_42275_/X }
C {devices/lab_pin.sym} 6220 -4430 0 0 {name=p6337 lab=_41520_/X }
C {devices/lab_pin.sym} 6220 -4390 0 0 {name=p6338 lab=_87943_/Q }
C {devices/lab_pin.sym} 6220 -4350 0 0 {name=p6339 lab=_42276_/X }
C {devices/lab_pin.sym} 6380 -4430 0 1 {name=p6340 lab=_42281_/A }
C {sky130_stdcells/o32ai_4.sym} 6300 -4430 0 0 {name=X_42280_ }
C {devices/lab_pin.sym} 6260 -4270 0 0 {name=p6341 lab=_54320_/A }
C {devices/lab_pin.sym} 6340 -4270 0 1 {name=p6342 lab=_54266_/X }
C {sky130_stdcells/buf_2.sym} 6300 -4270 0 0 {name=X_54266_ }
C {devices/lab_pin.sym} 6210 -4150 0 0 {name=p6343 lab=_83008_/CLK }
C {devices/lab_pin.sym} 6210 -4130 0 0 {name=p6344 lab=_85086_/D }
C {devices/lab_pin.sym} 6390 -4150 0 1 {name=p6345 lab=_85086_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -4140 0 0 {name=X_85086_ }
C {devices/lab_pin.sym} 6260 -4010 0 0 {name=p6346 lab=_51504_/A }
C {devices/lab_pin.sym} 6340 -4010 0 1 {name=p6347 lab=_51494_/B }
C {sky130_stdcells/buf_2.sym} 6300 -4010 0 0 {name=X_51478_ }
C {devices/lab_pin.sym} 6210 -3890 0 0 {name=p6348 lab=_82343_/CLK }
C {devices/lab_pin.sym} 6210 -3870 0 0 {name=p6349 lab=_77170_/B }
C {devices/lab_pin.sym} 6390 -3890 0 1 {name=p6350 lab=_40800_/B }
C {sky130_stdcells/dfxtp_4.sym} 6300 -3880 0 0 {name=X_82298_ }
C {devices/lab_pin.sym} 6260 -3750 0 0 {name=p6351 lab=_56004_/X }
C {devices/lab_pin.sym} 6340 -3750 0 1 {name=p6352 lab=_56005_/X }
C {sky130_stdcells/buf_2.sym} 6300 -3750 0 0 {name=X_56005_ }
C {devices/lab_pin.sym} 6220 -3660 0 0 {name=p6353 lab=_41230_/X }
C {devices/lab_pin.sym} 6220 -3620 0 0 {name=p6354 lab=_41181_/X }
C {devices/lab_pin.sym} 6220 -3580 0 0 {name=p6355 lab=_68924_/B }
C {devices/lab_pin.sym} 6220 -3540 0 0 {name=p6356 lab=_41182_/X }
C {devices/lab_pin.sym} 6380 -3600 0 1 {name=p6357 lab=_88253_/D }
C {sky130_stdcells/a2bb2o_4.sym} 6300 -3600 0 0 {name=X_41231_ }
C {devices/lab_pin.sym} 6240 -3480 0 0 {name=p6358 lab=_53217_/A }
C {devices/lab_pin.sym} 6240 -3440 0 0 {name=p6359 lab=_53211_/B }
C {devices/lab_pin.sym} 6240 -3400 0 0 {name=p6360 lab=_53195_/X }
C {devices/lab_pin.sym} 6240 -3360 0 0 {name=p6361 lab=_53217_/D }
C {devices/lab_pin.sym} 6360 -3420 0 1 {name=p6362 lab=_53217_/X }
C {sky130_stdcells/and4_4.sym} 6300 -3420 0 0 {name=X_53217_ }
C {devices/lab_pin.sym} 6260 -3270 0 0 {name=p6363 lab=_71985_/A }
C {devices/lab_pin.sym} 6340 -3270 0 1 {name=p6364 lab=_72051_/X }
C {sky130_stdcells/buf_2.sym} 6300 -3270 0 0 {name=X_72051_ }
C {devices/lab_pin.sym} 6210 -3150 0 0 {name=p6365 lab=_81160_/CLK }
C {devices/lab_pin.sym} 6210 -3130 0 0 {name=p6366 lab=_68109_/X }
C {devices/lab_pin.sym} 6390 -3150 0 1 {name=p6367 lab=_84037_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -3140 0 0 {name=X_84037_ }
C {devices/lab_pin.sym} 6260 -3010 0 0 {name=p6368 lab=_50491_/A }
C {devices/lab_pin.sym} 6340 -3010 0 1 {name=p6369 lab=_50429_/X }
C {sky130_stdcells/buf_2.sym} 6300 -3010 0 0 {name=X_50429_ }
C {devices/lab_pin.sym} 6210 -2890 0 0 {name=p6370 lab=_85334_/CLK }
C {devices/lab_pin.sym} 6210 -2870 0 0 {name=p6371 lab=_81057_/Q }
C {devices/lab_pin.sym} 6390 -2890 0 1 {name=p6372 lab=_81249_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -2880 0 0 {name=X_81249_ }
C {devices/lab_pin.sym} 6260 -2750 0 0 {name=p6373 lab=_53436_/X }
C {devices/lab_pin.sym} 6340 -2750 0 1 {name=p6374 lab=_54197_/X }
C {sky130_stdcells/buf_2.sym} 6300 -2750 0 0 {name=X_54197_ }
C {devices/lab_pin.sym} 6220 -2650 0 0 {name=p6375 lab=_50832_/B }
C {devices/lab_pin.sym} 6220 -2610 0 0 {name=p6376 lab=_70983_/A }
C {devices/lab_pin.sym} 6220 -2570 0 0 {name=p6377 lab=_71001_/Y }
C {devices/lab_pin.sym} 6380 -2610 0 1 {name=p6378 lab=_83636_/D }
C {sky130_stdcells/o21ai_4.sym} 6300 -2610 0 0 {name=X_71002_ }
C {devices/lab_pin.sym} 6220 -2500 0 0 {name=p6379 lab=_41161_/X }
C {devices/lab_pin.sym} 6220 -2460 0 0 {name=p6380 lab=_41152_/X }
C {devices/lab_pin.sym} 6220 -2420 0 0 {name=p6381 lab=_68607_/B }
C {devices/lab_pin.sym} 6220 -2380 0 0 {name=p6382 lab=_41153_/X }
C {devices/lab_pin.sym} 6380 -2440 0 1 {name=p6383 lab=_88266_/D }
C {sky130_stdcells/a2bb2o_4.sym} 6300 -2440 0 0 {name=X_41162_ }
C {devices/lab_pin.sym} 6240 -2300 0 0 {name=p6384 lab=_53147_/X }
C {devices/lab_pin.sym} 6240 -2260 0 0 {name=p6385 lab=_53148_/B }
C {devices/lab_pin.sym} 6360 -2280 0 1 {name=p6386 lab=_53148_/Y }
C {sky130_stdcells/nand2_4.sym} 6300 -2280 0 0 {name=X_53148_ }
C {devices/lab_pin.sym} 6240 -2170 0 0 {name=p6387 lab=_75810_/A }
C {devices/lab_pin.sym} 6240 -2130 0 0 {name=p6388 lab=_75810_/B }
C {devices/lab_pin.sym} 6240 -2090 0 0 {name=p6389 lab=_75810_/C }
C {devices/lab_pin.sym} 6360 -2130 0 1 {name=p6390 lab=_75810_/Y }
C {sky130_stdcells/nand3_4.sym} 6300 -2130 0 0 {name=X_75810_ }
C {devices/lab_pin.sym} 6220 -2020 0 0 {name=p6391 lab=_40390_/Y }
C {devices/lab_pin.sym} 6220 -1980 0 0 {name=p6392 lab=_45963_/X }
C {devices/lab_pin.sym} 6220 -1940 0 0 {name=p6393 lab=_86834_/Q }
C {devices/lab_pin.sym} 6220 -1900 0 0 {name=p6394 lab=_45964_/X }
C {devices/lab_pin.sym} 6380 -1960 0 1 {name=p6395 lab=_86834_/D }
C {sky130_stdcells/a2bb2o_4.sym} 6300 -1960 0 0 {name=X_45970_ }
C {devices/lab_pin.sym} 6260 -1810 0 0 {name=p6396 lab=_41092_/Y }
C {devices/lab_pin.sym} 6340 -1810 0 1 {name=p6397 lab=_41093_/X }
C {sky130_stdcells/buf_2.sym} 6300 -1810 0 0 {name=X_41093_ }
C {devices/lab_pin.sym} 6220 -1710 0 0 {name=p6398 lab=_53077_/Y }
C {devices/lab_pin.sym} 6220 -1670 0 0 {name=p6399 lab=_53056_/X }
C {devices/lab_pin.sym} 6220 -1630 0 0 {name=p6400 lab=_53078_/X }
C {devices/lab_pin.sym} 6380 -1670 0 1 {name=p6401 lab=_53079_/Y }
C {sky130_stdcells/a21oi_4.sym} 6300 -1670 0 0 {name=X_53079_ }
C {devices/lab_pin.sym} 6220 -1570 0 0 {name=p6402 lab=_57781_/X }
C {devices/lab_pin.sym} 6220 -1530 0 0 {name=p6403 lab=_57952_/Y }
C {devices/lab_pin.sym} 6220 -1490 0 0 {name=p6404 lab=_57955_/Y }
C {devices/lab_pin.sym} 6220 -1450 0 0 {name=p6405 lab=_57893_/X }
C {devices/lab_pin.sym} 6220 -1410 0 0 {name=p6406 lab=_57795_/X }
C {devices/lab_pin.sym} 6380 -1490 0 1 {name=p6407 lab=_57956_/X }
C {sky130_stdcells/o32a_4.sym} 6300 -1490 0 0 {name=X_57956_ }
C {devices/lab_pin.sym} 6240 -1340 0 0 {name=p6408 lab=_76790_/A }
C {devices/lab_pin.sym} 6240 -1300 0 0 {name=p6409 lab=_76790_/B }
C {devices/lab_pin.sym} 6360 -1320 0 1 {name=p6410 lab=_76790_/X }
C {sky130_stdcells/xor2_4.sym} 6300 -1320 0 0 {name=X_76790_ }
C {devices/lab_pin.sym} 6210 -1190 0 0 {name=p6411 lab=_85700_/CLK }
C {devices/lab_pin.sym} 6210 -1170 0 0 {name=p6412 lab=_85988_/D }
C {devices/lab_pin.sym} 6390 -1190 0 1 {name=p6413 lab=_85988_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6300 -1180 0 0 {name=X_85988_ }
C {devices/lab_pin.sym} 6220 -1070 0 0 {name=p6414 lab=_44917_/Y }
C {devices/lab_pin.sym} 6220 -1030 0 0 {name=p6415 lab=_44920_/Y }
C {devices/lab_pin.sym} 6220 -990 0 0 {name=p6416 lab=_44901_/X }
C {devices/lab_pin.sym} 6380 -1030 0 1 {name=p6417 lab=_44921_/X }
C {sky130_stdcells/o21a_4.sym} 6300 -1030 0 0 {name=X_44921_ }
C {devices/lab_pin.sym} 6260 -890 0 0 {name=p6418 lab=_56906_/X }
C {devices/lab_pin.sym} 6340 -890 0 1 {name=p6419 lab=_56907_/X }
C {sky130_stdcells/buf_2.sym} 6300 -890 0 0 {name=X_56907_ }
C {devices/lab_pin.sym} 6240 -780 0 0 {name=p6420 lab=_81012_/Q }
C {devices/lab_pin.sym} 6240 -740 0 0 {name=p6421 lab=_75741_/B }
C {devices/lab_pin.sym} 6360 -760 0 1 {name=p6422 lab=_80980_/D }
C {sky130_stdcells/xor2_4.sym} 6300 -760 0 0 {name=X_75741_ }
C {devices/lab_pin.sym} 7130 -42150 0 0 {name=p6423 lab=_87472_/CLK }
C {devices/lab_pin.sym} 7130 -42130 0 0 {name=p6424 lab=_42770_/X }
C {devices/lab_pin.sym} 7310 -42150 0 1 {name=p6425 lab=_67437_/B }
C {sky130_stdcells/dfxtp_4.sym} 7220 -42140 0 0 {name=X_87727_ }
C {devices/lab_pin.sym} 7140 -42030 0 0 {name=p6426 lab=_88332_/Q }
C {devices/lab_pin.sym} 7140 -41990 0 0 {name=p6427 lab=_72803_/X }
C {devices/lab_pin.sym} 7140 -41950 0 0 {name=p6428 lab=_72776_/X }
C {devices/lab_pin.sym} 7300 -41990 0 1 {name=p6429 lab=_72953_/Y }
C {sky130_stdcells/o21ai_4.sym} 7220 -41990 0 0 {name=X_72953_ }
C {devices/lab_pin.sym} 7130 -41850 0 0 {name=p6430 lab=_84939_/CLK }
C {devices/lab_pin.sym} 7130 -41830 0 0 {name=p6431 lab=_57933_/Y }
C {devices/lab_pin.sym} 7310 -41850 0 1 {name=p6432 lab=_84939_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -41840 0 0 {name=X_84939_ }
C {devices/lab_pin.sym} 7140 -41730 0 0 {name=p6433 lab=_57773_/X }
C {devices/lab_pin.sym} 7140 -41690 0 0 {name=p6434 lab=_85718_/Q }
C {devices/lab_pin.sym} 7140 -41650 0 0 {name=p6435 lab=_44177_/X }
C {devices/lab_pin.sym} 7300 -41690 0 1 {name=p6436 lab=_57887_/X }
C {sky130_stdcells/o21a_4.sym} 7220 -41690 0 0 {name=X_57887_ }
C {devices/lab_pin.sym} 7180 -41550 0 0 {name=p6437 lab=_47639_/Y }
C {devices/lab_pin.sym} 7260 -41550 0 1 {name=p6438 lab=_53161_/B }
C {sky130_stdcells/buf_2.sym} 7220 -41550 0 0 {name=X_47640_ }
C {devices/lab_pin.sym} 7140 -41450 0 0 {name=p6439 lab=_57055_/A }
C {devices/lab_pin.sym} 7140 -41410 0 0 {name=p6440 lab=_71892_/X }
C {devices/lab_pin.sym} 7140 -41370 0 0 {name=p6441 lab=_71903_/Y }
C {devices/lab_pin.sym} 7300 -41410 0 1 {name=p6442 lab=_83334_/D }
C {sky130_stdcells/o21ai_4.sym} 7220 -41410 0 0 {name=X_71904_ }
C {devices/lab_pin.sym} 7180 -41270 0 0 {name=p6443 lab=_59664_/A }
C {devices/lab_pin.sym} 7260 -41270 0 1 {name=p6444 lab=_61755_/A }
C {sky130_stdcells/buf_2.sym} 7220 -41270 0 0 {name=X_59626_ }
C {devices/lab_pin.sym} 7180 -41150 0 0 {name=p6445 lab=_78460_/A }
C {devices/lab_pin.sym} 7260 -41150 0 1 {name=p6446 lab=_78460_/Y }
C {sky130_stdcells/inv_2.sym} 7220 -41150 0 0 {name=X_78460_ }
C {devices/lab_pin.sym} 7140 -41070 0 0 {name=p6447 lab=_44832_/X }
C {devices/lab_pin.sym} 7140 -41030 0 0 {name=p6448 lab=_44844_/X }
C {devices/lab_pin.sym} 7140 -40990 0 0 {name=p6449 lab=_41756_/X }
C {devices/lab_pin.sym} 7140 -40950 0 0 {name=p6450 lab=_67915_/B }
C {devices/lab_pin.sym} 7140 -40910 0 0 {name=p6451 lab=_44833_/X }
C {devices/lab_pin.sym} 7300 -40990 0 1 {name=p6452 lab=_44852_/Y }
C {sky130_stdcells/o32ai_4.sym} 7220 -40990 0 0 {name=X_44852_ }
C {devices/lab_pin.sym} 7160 -40850 0 0 {name=p6453 lab=_56838_/A }
C {devices/lab_pin.sym} 7160 -40810 0 0 {name=p6454 lab=_44135_/X }
C {devices/lab_pin.sym} 7160 -40770 0 0 {name=p6455 lab=_56837_/X }
C {devices/lab_pin.sym} 7280 -40810 0 1 {name=p6456 lab=_56838_/Y }
C {sky130_stdcells/nand3_4.sym} 7220 -40810 0 0 {name=X_56838_ }
C {devices/lab_pin.sym} 7140 -40690 0 0 {name=p6457 lab=_75665_/A }
C {devices/lab_pin.sym} 7140 -40650 0 0 {name=p6458 lab=_75665_/B }
C {devices/lab_pin.sym} 7140 -40610 0 0 {name=p6459 lab=_75666_/A }
C {devices/lab_pin.sym} 7300 -40650 0 1 {name=p6460 lab=_75672_/Y }
C {sky130_stdcells/a21boi_4.sym} 7220 -40650 0 0 {name=X_75672_ }
C {devices/lab_pin.sym} 7130 -40510 0 0 {name=p6461 lab=_86932_/CLK }
C {devices/lab_pin.sym} 7130 -40490 0 0 {name=p6462 lab=_42908_/X }
C {devices/lab_pin.sym} 7310 -40510 0 1 {name=p6463 lab=_67556_/B }
C {sky130_stdcells/dfxtp_4.sym} 7220 -40500 0 0 {name=X_87658_ }
C {devices/lab_pin.sym} 7160 -40380 0 0 {name=p6464 lab=_74383_/B }
C {devices/lab_pin.sym} 7160 -40340 0 0 {name=p6465 lab=_72884_/B }
C {devices/lab_pin.sym} 7280 -40360 0 1 {name=p6466 lab=_72884_/X }
C {sky130_stdcells/xor2_4.sym} 7220 -40360 0 0 {name=X_72884_ }
C {devices/lab_pin.sym} 7180 -40230 0 0 {name=p6467 lab=_77410_/Y }
C {devices/lab_pin.sym} 7260 -40230 0 1 {name=p6468 lab=_77412_/C }
C {sky130_stdcells/inv_2.sym} 7220 -40230 0 0 {name=X_77411_ }
C {devices/lab_pin.sym} 7140 -40140 0 0 {name=p6469 lab=_41064_/X }
C {devices/lab_pin.sym} 7140 -40100 0 0 {name=p6470 lab=_43801_/X }
C {devices/lab_pin.sym} 7140 -40060 0 0 {name=p6471 lab=_87260_/Q }
C {devices/lab_pin.sym} 7140 -40020 0 0 {name=p6472 lab=_43802_/X }
C {devices/lab_pin.sym} 7300 -40080 0 1 {name=p6473 lab=_87260_/D }
C {sky130_stdcells/a2bb2o_4.sym} 7220 -40080 0 0 {name=X_43803_ }
C {devices/lab_pin.sym} 7140 -39960 0 0 {name=p6474 lab=_58253_/A }
C {devices/lab_pin.sym} 7140 -39920 0 0 {name=p6475 lab=_74613_/X }
C {devices/lab_pin.sym} 7140 -39880 0 0 {name=p6476 lab=_56168_/A }
C {devices/lab_pin.sym} 7140 -39840 0 0 {name=p6477 lab=_74614_/X }
C {devices/lab_pin.sym} 7300 -39900 0 1 {name=p6478 lab=_74623_/X }
C {sky130_stdcells/a211o_4.sym} 7220 -39900 0 0 {name=X_74623_ }
C {devices/lab_pin.sym} 7130 -39750 0 0 {name=p6479 lab=_86611_/CLK }
C {devices/lab_pin.sym} 7130 -39730 0 0 {name=p6480 lab=_86609_/D }
C {devices/lab_pin.sym} 7310 -39750 0 1 {name=p6481 lab=_86609_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -39740 0 0 {name=X_86609_ }
C {devices/lab_pin.sym} 7180 -39610 0 0 {name=p6482 lab=_47525_/A }
C {devices/lab_pin.sym} 7260 -39610 0 1 {name=p6483 lab=_47574_/A }
C {sky130_stdcells/buf_2.sym} 7220 -39610 0 0 {name=X_47571_ }
C {devices/lab_pin.sym} 7160 -39520 0 0 {name=p6484 lab=_71829_/X }
C {devices/lab_pin.sym} 7160 -39480 0 0 {name=p6485 lab=_71839_/B }
C {devices/lab_pin.sym} 7160 -39440 0 0 {name=p6486 lab=_70778_/A }
C {devices/lab_pin.sym} 7160 -39400 0 0 {name=p6487 lab=_71826_/X }
C {devices/lab_pin.sym} 7280 -39460 0 1 {name=p6488 lab=_71835_/X }
C {sky130_stdcells/and4_4.sym} 7220 -39460 0 0 {name=X_71835_ }
C {devices/lab_pin.sym} 7180 -39310 0 0 {name=p6489 lab=_59557_/A }
C {devices/lab_pin.sym} 7260 -39310 0 1 {name=p6490 lab=_59557_/X }
C {sky130_stdcells/buf_2.sym} 7220 -39310 0 0 {name=X_59557_ }
C {devices/lab_pin.sym} 7180 -39190 0 0 {name=p6491 lab=_78375_/B }
C {devices/lab_pin.sym} 7260 -39190 0 1 {name=p6492 lab=_78391_/Y }
C {sky130_stdcells/inv_2.sym} 7220 -39190 0 0 {name=X_78391_ }
C {devices/lab_pin.sym} 7180 -39070 0 0 {name=p6493 lab=_44783_/A }
C {devices/lab_pin.sym} 7260 -39070 0 1 {name=p6494 lab=_44783_/Y }
C {sky130_stdcells/inv_2.sym} 7220 -39070 0 0 {name=X_44783_ }
C {devices/lab_pin.sym} 7180 -38950 0 0 {name=p6495 lab=_56768_/Y }
C {devices/lab_pin.sym} 7260 -38950 0 1 {name=p6496 lab=_57163_/C }
C {sky130_stdcells/buf_2.sym} 7220 -38950 0 0 {name=X_56769_ }
C {devices/lab_pin.sym} 7130 -38830 0 0 {name=p6497 lab=_88111_/CLK }
C {devices/lab_pin.sym} 7130 -38810 0 0 {name=p6498 lab=_87589_/D }
C {devices/lab_pin.sym} 7310 -38830 0 1 {name=p6499 lab=_73895_/A }
C {sky130_stdcells/dfxtp_4.sym} 7220 -38820 0 0 {name=X_87589_ }
C {devices/lab_pin.sym} 7140 -38730 0 0 {name=p6500 lab=_41982_/X }
C {devices/lab_pin.sym} 7140 -38690 0 0 {name=p6501 lab=_41993_/X }
C {devices/lab_pin.sym} 7140 -38650 0 0 {name=p6502 lab=_40792_/X }
C {devices/lab_pin.sym} 7140 -38610 0 0 {name=p6503 lab=_41994_/Y }
C {devices/lab_pin.sym} 7140 -38570 0 0 {name=p6504 lab=_41984_/X }
C {devices/lab_pin.sym} 7300 -38650 0 1 {name=p6505 lab=_88078_/D }
C {sky130_stdcells/o32ai_4.sym} 7220 -38650 0 0 {name=X_41995_ }
C {devices/lab_pin.sym} 7160 -38500 0 0 {name=p6506 lab=_49302_/A }
C {devices/lab_pin.sym} 7160 -38460 0 0 {name=p6507 lab=_50832_/B }
C {devices/lab_pin.sym} 7280 -38480 0 1 {name=p6508 lab=_49310_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -38480 0 0 {name=X_49310_ }
C {devices/lab_pin.sym} 7140 -38370 0 0 {name=p6509 lab=_86729_/Q }
C {devices/lab_pin.sym} 7140 -38330 0 0 {name=p6510 lab=_46430_/X }
C {devices/lab_pin.sym} 7140 -38290 0 0 {name=p6511 lab=_46521_/Y }
C {devices/lab_pin.sym} 7300 -38330 0 1 {name=p6512 lab=_46522_/Y }
C {sky130_stdcells/o21ai_4.sym} 7220 -38330 0 0 {name=X_46522_ }
C {devices/lab_pin.sym} 7180 -38190 0 0 {name=p6513 lab=_58508_/A }
C {devices/lab_pin.sym} 7260 -38190 0 1 {name=p6514 lab=_58508_/Y }
C {sky130_stdcells/inv_2.sym} 7220 -38190 0 0 {name=X_58508_ }
C {devices/lab_pin.sym} 7180 -38070 0 0 {name=p6515 lab=_77341_/X }
C {devices/lab_pin.sym} 7260 -38070 0 1 {name=p6516 lab=_77342_/Y }
C {sky130_stdcells/inv_2.sym} 7220 -38070 0 0 {name=X_77342_ }
C {devices/lab_pin.sym} 7180 -37950 0 0 {name=p6517 lab=_43733_/X }
C {devices/lab_pin.sym} 7260 -37950 0 1 {name=p6518 lab=_87291_/D }
C {sky130_stdcells/inv_2.sym} 7220 -37950 0 0 {name=X_43734_ }
C {devices/lab_pin.sym} 7180 -37830 0 0 {name=p6519 lab=_74600_/A }
C {devices/lab_pin.sym} 7260 -37830 0 1 {name=p6520 lab=_74554_/X }
C {sky130_stdcells/buf_2.sym} 7220 -37830 0 0 {name=X_74554_ }
C {devices/lab_pin.sym} 7180 -37710 0 0 {name=p6521 lab=_40946_/A }
C {devices/lab_pin.sym} 7260 -37710 0 1 {name=p6522 lab=_40946_/X }
C {sky130_stdcells/buf_2.sym} 7220 -37710 0 0 {name=X_40946_ }
C {devices/lab_pin.sym} 7180 -37590 0 0 {name=p6523 lab=_83430_/Q }
C {devices/lab_pin.sym} 7260 -37590 0 1 {name=p6524 lab=_59488_/Y }
C {sky130_stdcells/inv_2.sym} 7220 -37590 0 0 {name=X_59488_ }
C {devices/lab_pin.sym} 7160 -37490 0 0 {name=p6525 lab=_71763_/X }
C {devices/lab_pin.sym} 7160 -37450 0 0 {name=p6526 lab=_71424_/C }
C {devices/lab_pin.sym} 7160 -37410 0 0 {name=p6527 lab=_70794_/X }
C {devices/lab_pin.sym} 7280 -37450 0 1 {name=p6528 lab=_71766_/X }
C {sky130_stdcells/and3_4.sym} 7220 -37450 0 0 {name=X_71766_ }
C {devices/lab_pin.sym} 7160 -37320 0 0 {name=p6529 lab=_49241_/A }
C {devices/lab_pin.sym} 7160 -37280 0 0 {name=p6530 lab=_49241_/B }
C {devices/lab_pin.sym} 7280 -37300 0 1 {name=p6531 lab=_49241_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -37300 0 0 {name=X_49241_ }
C {devices/lab_pin.sym} 7160 -37180 0 0 {name=p6532 lab=_73339_/A }
C {devices/lab_pin.sym} 7160 -37140 0 0 {name=p6533 lab=_73505_/B }
C {devices/lab_pin.sym} 7280 -37160 0 1 {name=p6534 lab=_73505_/Y }
C {sky130_stdcells/nor2_4.sym} 7220 -37160 0 0 {name=X_73505_ }
C {devices/lab_pin.sym} 7160 -37050 0 0 {name=p6535 lab=_50812_/A }
C {devices/lab_pin.sym} 7160 -37010 0 0 {name=p6536 lab=_46428_/B }
C {devices/lab_pin.sym} 7160 -36970 0 0 {name=p6537 lab=_46472_/C }
C {devices/lab_pin.sym} 7280 -37010 0 1 {name=p6538 lab=_46453_/X }
C {sky130_stdcells/and3_4.sym} 7220 -37010 0 0 {name=X_46453_ }
C {devices/lab_pin.sym} 7160 -36900 0 0 {name=p6539 lab=_70717_/A }
C {devices/lab_pin.sym} 7160 -36860 0 0 {name=p6540 lab=_70713_/X }
C {devices/lab_pin.sym} 7160 -36820 0 0 {name=p6541 lab=_70727_/C }
C {devices/lab_pin.sym} 7160 -36780 0 0 {name=p6542 lab=_70710_/D }
C {devices/lab_pin.sym} 7280 -36840 0 1 {name=p6543 lab=_70717_/Y }
C {sky130_stdcells/nand4_4.sym} 7220 -36840 0 0 {name=X_70717_ }
C {devices/lab_pin.sym} 7140 -36710 0 0 {name=p6544 lab=_58423_/X }
C {devices/lab_pin.sym} 7140 -36670 0 0 {name=p6545 lab=_83480_/Q }
C {devices/lab_pin.sym} 7140 -36630 0 0 {name=p6546 lab=_58438_/Y }
C {devices/lab_pin.sym} 7300 -36670 0 1 {name=p6547 lab=_58439_/X }
C {sky130_stdcells/o21a_4.sym} 7220 -36670 0 0 {name=X_58439_ }
C {devices/lab_pin.sym} 7140 -36550 0 0 {name=p6548 lab=_77270_/X }
C {devices/lab_pin.sym} 7140 -36510 0 0 {name=p6549 lab=_77274_/B }
C {devices/lab_pin.sym} 7140 -36470 0 0 {name=p6550 lab=_77272_/Y }
C {devices/lab_pin.sym} 7300 -36510 0 1 {name=p6551 lab=_77273_/X }
C {sky130_stdcells/a21o_4.sym} 7220 -36510 0 0 {name=X_77273_ }
C {devices/lab_pin.sym} 7140 -36400 0 0 {name=p6552 lab=_40734_/X }
C {devices/lab_pin.sym} 7140 -36360 0 0 {name=p6553 lab=_43656_/X }
C {devices/lab_pin.sym} 7140 -36320 0 0 {name=p6554 lab=_74166_/A }
C {devices/lab_pin.sym} 7140 -36280 0 0 {name=p6555 lab=_43657_/X }
C {devices/lab_pin.sym} 7300 -36340 0 1 {name=p6556 lab=_87321_/D }
C {sky130_stdcells/a2bb2o_4.sym} 7220 -36340 0 0 {name=X_43665_ }
C {devices/lab_pin.sym} 7160 -36200 0 0 {name=p6557 lab=_74490_/A }
C {devices/lab_pin.sym} 7160 -36160 0 0 {name=p6558 lab=_48639_/A }
C {devices/lab_pin.sym} 7280 -36180 0 1 {name=p6559 lab=_74485_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -36180 0 0 {name=X_74485_ }
C {devices/lab_pin.sym} 7180 -36050 0 0 {name=p6560 lab=_40365_/X }
C {devices/lab_pin.sym} 7260 -36050 0 1 {name=p6561 lab=_40877_/X }
C {sky130_stdcells/buf_2.sym} 7220 -36050 0 0 {name=X_40877_ }
C {devices/lab_pin.sym} 7140 -35950 0 0 {name=p6562 lab=_58283_/Y }
C {devices/lab_pin.sym} 7140 -35910 0 0 {name=p6563 lab=_71695_/X }
C {devices/lab_pin.sym} 7140 -35870 0 0 {name=p6564 lab=_71696_/Y }
C {devices/lab_pin.sym} 7300 -35910 0 1 {name=p6565 lab=_71697_/Y }
C {sky130_stdcells/o21ai_4.sym} 7220 -35910 0 0 {name=X_71697_ }
C {devices/lab_pin.sym} 7180 -35770 0 0 {name=p6566 lab=_79012_/A }
C {devices/lab_pin.sym} 7260 -35770 0 1 {name=p6567 lab=_79012_/Y }
C {sky130_stdcells/inv_2.sym} 7220 -35770 0 0 {name=X_79012_ }
C {devices/lab_pin.sym} 7160 -35660 0 0 {name=p6568 lab=_45403_/Y }
C {devices/lab_pin.sym} 7160 -35620 0 0 {name=p6569 lab=_45590_/B }
C {devices/lab_pin.sym} 7280 -35640 0 1 {name=p6570 lab=_45404_/X }
C {sky130_stdcells/and2_4.sym} 7220 -35640 0 0 {name=X_45404_ }
C {devices/lab_pin.sym} 7140 -35530 0 0 {name=p6571 lab=_76206_/Y }
C {devices/lab_pin.sym} 7140 -35490 0 0 {name=p6572 lab=_76211_/Y }
C {devices/lab_pin.sym} 7140 -35450 0 0 {name=p6573 lab=_76207_/Y }
C {devices/lab_pin.sym} 7300 -35490 0 1 {name=p6574 lab=_76225_/B }
C {sky130_stdcells/o21ai_4.sym} 7220 -35490 0 0 {name=X_76224_ }
C {devices/lab_pin.sym} 7140 -35390 0 0 {name=p6575 lab=_42614_/X }
C {devices/lab_pin.sym} 7140 -35350 0 0 {name=p6576 lab=_42615_/X }
C {devices/lab_pin.sym} 7140 -35310 0 0 {name=p6577 lab=_40909_/X }
C {devices/lab_pin.sym} 7140 -35270 0 0 {name=p6578 lab=_69917_/A }
C {devices/lab_pin.sym} 7140 -35230 0 0 {name=p6579 lab=_42597_/X }
C {devices/lab_pin.sym} 7300 -35310 0 1 {name=p6580 lab=_42616_/Y }
C {sky130_stdcells/o32ai_4.sym} 7220 -35310 0 0 {name=X_42616_ }
C {devices/lab_pin.sym} 7180 -35150 0 0 {name=p6581 lab=_61342_/X }
C {devices/lab_pin.sym} 7260 -35150 0 1 {name=p6582 lab=_61451_/D }
C {sky130_stdcells/buf_2.sym} 7220 -35150 0 0 {name=X_61450_ }
C {devices/lab_pin.sym} 7180 -35030 0 0 {name=p6583 lab=_49172_/A }
C {devices/lab_pin.sym} 7260 -35030 0 1 {name=p6584 lab=_50710_/B }
C {sky130_stdcells/buf_2.sym} 7220 -35030 0 0 {name=X_49172_ }
C {devices/lab_pin.sym} 7140 -34930 0 0 {name=p6585 lab=_83151_/Q }
C {devices/lab_pin.sym} 7140 -34890 0 0 {name=p6586 lab=_73318_/X }
C {devices/lab_pin.sym} 7140 -34850 0 0 {name=p6587 lab=_73435_/Y }
C {devices/lab_pin.sym} 7300 -34890 0 1 {name=p6588 lab=_83151_/D }
C {sky130_stdcells/a21o_4.sym} 7220 -34890 0 0 {name=X_73436_ }
C {devices/lab_pin.sym} 7140 -34770 0 0 {name=p6589 lab=_46379_/Y }
C {devices/lab_pin.sym} 7140 -34730 0 0 {name=p6590 lab=_46346_/X }
C {devices/lab_pin.sym} 7140 -34690 0 0 {name=p6591 lab=_46383_/Y }
C {devices/lab_pin.sym} 7300 -34730 0 1 {name=p6592 lab=_46384_/Y }
C {sky130_stdcells/a21boi_4.sym} 7220 -34730 0 0 {name=X_46384_ }
C {devices/lab_pin.sym} 7140 -34610 0 0 {name=p6593 lab=_53025_/B }
C {devices/lab_pin.sym} 7140 -34570 0 0 {name=p6594 lab=_70632_/X }
C {devices/lab_pin.sym} 7140 -34530 0 0 {name=p6595 lab=_70647_/Y }
C {devices/lab_pin.sym} 7300 -34570 0 1 {name=p6596 lab=_83734_/D }
C {sky130_stdcells/o21ai_4.sym} 7220 -34570 0 0 {name=X_70648_ }
C {devices/lab_pin.sym} 7180 -34430 0 0 {name=p6597 lab=_43596_/A }
C {devices/lab_pin.sym} 7260 -34430 0 1 {name=p6598 lab=_68387_/B }
C {sky130_stdcells/inv_2.sym} 7220 -34430 0 0 {name=X_43596_ }
C {devices/lab_pin.sym} 7180 -34310 0 0 {name=p6599 lab=clkbuf_8_5_0_CLK/A }
C {devices/lab_pin.sym} 7260 -34310 0 1 {name=p6600 lab=clkbuf_8_4_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 7220 -34310 0 0 {name=Xclkbuf_8_4_0_CLK }
C {devices/lab_pin.sym} 7180 -34190 0 0 {name=p6601 lab=_60400_/Y }
C {devices/lab_pin.sym} 7260 -34190 0 1 {name=p6602 lab=_60472_/A }
C {sky130_stdcells/buf_2.sym} 7220 -34190 0 0 {name=X_60401_ }
C {devices/lab_pin.sym} 7180 -34070 0 0 {name=p6603 lab=_48122_/Y }
C {devices/lab_pin.sym} 7260 -34070 0 1 {name=p6604 lab=_48335_/B }
C {sky130_stdcells/buf_2.sym} 7220 -34070 0 0 {name=X_48123_ }
C {devices/lab_pin.sym} 7140 -33970 0 0 {name=p6605 lab=_45277_/X }
C {devices/lab_pin.sym} 7140 -33930 0 0 {name=p6606 lab=_61663_/B }
C {devices/lab_pin.sym} 7140 -33890 0 0 {name=p6607 lab=_45294_/X }
C {devices/lab_pin.sym} 7300 -33930 0 1 {name=p6608 lab=_45335_/Y }
C {sky130_stdcells/o21ai_4.sym} 7220 -33930 0 0 {name=X_45335_ }
C {devices/lab_pin.sym} 7160 -33800 0 0 {name=p6609 lab=_76155_/A }
C {devices/lab_pin.sym} 7160 -33760 0 0 {name=p6610 lab=_76155_/B }
C {devices/lab_pin.sym} 7280 -33780 0 1 {name=p6611 lab=_76155_/X }
C {sky130_stdcells/xor2_4.sym} 7220 -33780 0 0 {name=X_76155_ }
C {devices/lab_pin.sym} 7180 -33650 0 0 {name=p6612 lab=_42547_/A }
C {devices/lab_pin.sym} 7260 -33650 0 1 {name=p6613 lab=_42547_/X }
C {sky130_stdcells/buf_2.sym} 7220 -33650 0 0 {name=X_42547_ }
C {devices/lab_pin.sym} 7160 -33560 0 0 {name=p6614 lab=_64257_/A }
C {devices/lab_pin.sym} 7160 -33520 0 0 {name=p6615 lab=_61368_/B }
C {devices/lab_pin.sym} 7160 -33480 0 0 {name=p6616 lab=_61368_/C }
C {devices/lab_pin.sym} 7160 -33440 0 0 {name=p6617 lab=_61391_/D }
C {devices/lab_pin.sym} 7280 -33500 0 1 {name=p6618 lab=_61381_/Y }
C {sky130_stdcells/nand4_4.sym} 7220 -33500 0 0 {name=X_61381_ }
C {devices/lab_pin.sym} 7180 -33350 0 0 {name=p6619 lab=_73367_/A }
C {devices/lab_pin.sym} 7260 -33350 0 1 {name=p6620 lab=_73367_/X }
C {sky130_stdcells/buf_2.sym} 7220 -33350 0 0 {name=X_73367_ }
C {devices/lab_pin.sym} 7160 -33240 0 0 {name=p6621 lab=HASH_ADDR[3] }
C {devices/lab_pin.sym} 7160 -33200 0 0 {name=p6622 lab=_70356_/Y }
C {devices/lab_pin.sym} 7280 -33220 0 1 {name=p6623 lab=_70579_/Y }
C {sky130_stdcells/nor2_4.sym} 7220 -33220 0 0 {name=X_70579_ }
C {devices/lab_pin.sym} 7180 -33090 0 0 {name=p6624 lab=_60607_/A }
C {devices/lab_pin.sym} 7260 -33090 0 1 {name=p6625 lab=_63121_/D }
C {sky130_stdcells/buf_2.sym} 7220 -33090 0 0 {name=X_63120_ }
C {devices/lab_pin.sym} 7160 -32980 0 0 {name=p6626 lab=_75106_/A }
C {devices/lab_pin.sym} 7160 -32940 0 0 {name=p6627 lab=_75105_/Y }
C {devices/lab_pin.sym} 7280 -32960 0 1 {name=p6628 lab=_75107_/B }
C {sky130_stdcells/nor2_4.sym} 7220 -32960 0 0 {name=X_75106_ }
C {devices/lab_pin.sym} 7140 -32850 0 0 {name=p6629 lab=_66211_/B }
C {devices/lab_pin.sym} 7140 -32810 0 0 {name=p6630 lab=_48049_/X }
C {devices/lab_pin.sym} 7140 -32770 0 0 {name=p6631 lab=_48053_/Y }
C {devices/lab_pin.sym} 7300 -32810 0 1 {name=p6632 lab=_48054_/Y }
C {sky130_stdcells/o21ai_4.sym} 7220 -32810 0 0 {name=X_48054_ }
C {devices/lab_pin.sym} 7160 -32690 0 0 {name=p6633 lab=_60317_/A }
C {devices/lab_pin.sym} 7160 -32650 0 0 {name=p6634 lab=_60319_/X }
C {devices/lab_pin.sym} 7160 -32610 0 0 {name=p6635 lab=_79680_/A }
C {devices/lab_pin.sym} 7280 -32650 0 1 {name=p6636 lab=_60332_/Y }
C {sky130_stdcells/nor3_4.sym} 7220 -32650 0 0 {name=X_60332_ }
C {devices/lab_pin.sym} 7140 -32530 0 0 {name=p6637 lab=_72315_/Y }
C {devices/lab_pin.sym} 7140 -32490 0 0 {name=p6638 lab=_72317_/Y }
C {devices/lab_pin.sym} 7140 -32450 0 0 {name=p6639 lab=_72292_/X }
C {devices/lab_pin.sym} 7300 -32490 0 1 {name=p6640 lab=_72318_/X }
C {sky130_stdcells/a21o_4.sym} 7220 -32490 0 0 {name=X_72318_ }
C {devices/lab_pin.sym} 7140 -32370 0 0 {name=p6641 lab=_85161_/Q }
C {devices/lab_pin.sym} 7140 -32330 0 0 {name=p6642 lab=_45209_/X }
C {devices/lab_pin.sym} 7140 -32290 0 0 {name=p6643 lab=_45265_/X }
C {devices/lab_pin.sym} 7300 -32330 0 1 {name=p6644 lab=_45266_/X }
C {sky130_stdcells/o21a_4.sym} 7220 -32330 0 0 {name=X_45266_ }
C {devices/lab_pin.sym} 7160 -32200 0 0 {name=p6645 lab=_76096_/A }
C {devices/lab_pin.sym} 7160 -32160 0 0 {name=p6646 lab=_76097_/B }
C {devices/lab_pin.sym} 7280 -32180 0 1 {name=p6647 lab=_76086_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -32180 0 0 {name=X_76086_ }
C {devices/lab_pin.sym} 7180 -32050 0 0 {name=p6648 lab=_73750_/A }
C {devices/lab_pin.sym} 7260 -32050 0 1 {name=p6649 lab=_68567_/B }
C {sky130_stdcells/inv_2.sym} 7220 -32050 0 0 {name=X_42478_ }
C {devices/lab_pin.sym} 7180 -31930 0 0 {name=p6650 lab=_72829_/X }
C {devices/lab_pin.sym} 7260 -31930 0 1 {name=p6651 lab=_73298_/X }
C {sky130_stdcells/buf_2.sym} 7220 -31930 0 0 {name=X_73298_ }
C {devices/lab_pin.sym} 7180 -31810 0 0 {name=p6652 lab=_46909_/X }
C {devices/lab_pin.sym} 7260 -31810 0 1 {name=p6653 lab=_47008_/A }
C {sky130_stdcells/buf_2.sym} 7220 -31810 0 0 {name=X_47005_ }
C {devices/lab_pin.sym} 7180 -31690 0 0 {name=p6654 lab=_43959_/B }
C {devices/lab_pin.sym} 7260 -31690 0 1 {name=p6655 lab=_44217_/X }
C {sky130_stdcells/buf_2.sym} 7220 -31690 0 0 {name=X_44217_ }
C {devices/lab_pin.sym} 7160 -31600 0 0 {name=p6656 lab=_63041_/A }
C {devices/lab_pin.sym} 7160 -31560 0 0 {name=p6657 lab=_63051_/B }
C {devices/lab_pin.sym} 7160 -31520 0 0 {name=p6658 lab=_63030_/C }
C {devices/lab_pin.sym} 7160 -31480 0 0 {name=p6659 lab=_60541_/C }
C {devices/lab_pin.sym} 7280 -31540 0 1 {name=p6660 lab=_63051_/X }
C {sky130_stdcells/and4_4.sym} 7220 -31540 0 0 {name=X_63051_ }
C {devices/lab_pin.sym} 7160 -31400 0 0 {name=p6661 lab=_80956_/Q }
C {devices/lab_pin.sym} 7160 -31360 0 0 {name=p6662 lab=_75036_/X }
C {devices/lab_pin.sym} 7280 -31380 0 1 {name=p6663 lab=_75037_/X }
C {sky130_stdcells/xor2_4.sym} 7220 -31380 0 0 {name=X_75037_ }
C {devices/lab_pin.sym} 7160 -31260 0 0 {name=p6664 lab=_79912_/Y }
C {devices/lab_pin.sym} 7160 -31220 0 0 {name=p6665 lab=_79914_/B }
C {devices/lab_pin.sym} 7280 -31240 0 1 {name=p6666 lab=_79915_/B }
C {sky130_stdcells/nand2_4.sym} 7220 -31240 0 0 {name=X_79914_ }
C {devices/lab_pin.sym} 7180 -31110 0 0 {name=p6667 lab=_41428_/Y }
C {devices/lab_pin.sym} 7260 -31110 0 1 {name=p6668 lab=_41429_/X }
C {sky130_stdcells/buf_2.sym} 7220 -31110 0 0 {name=X_41429_ }
C {devices/lab_pin.sym} 7160 -31010 0 0 {name=p6669 lab=_60263_/A }
C {devices/lab_pin.sym} 7160 -30970 0 0 {name=p6670 lab=_60268_/A }
C {devices/lab_pin.sym} 7160 -30930 0 0 {name=p6671 lab=_60263_/C }
C {devices/lab_pin.sym} 7280 -30970 0 1 {name=p6672 lab=_60263_/Y }
C {sky130_stdcells/nor3_4.sym} 7220 -30970 0 0 {name=X_60263_ }
C {devices/lab_pin.sym} 7140 -30860 0 0 {name=p6673 lab=_72236_/Y }
C {devices/lab_pin.sym} 7140 -30820 0 0 {name=p6674 lab=_72237_/X }
C {devices/lab_pin.sym} 7140 -30780 0 0 {name=p6675 lab=_72244_/X }
C {devices/lab_pin.sym} 7140 -30740 0 0 {name=p6676 lab=_72248_/X }
C {devices/lab_pin.sym} 7300 -30800 0 1 {name=p6677 lab=_72249_/Y }
C {sky130_stdcells/a22oi_4.sym} 7220 -30800 0 0 {name=X_72249_ }
C {devices/lab_pin.sym} 7180 -30650 0 0 {name=p6678 lab=_45197_/A }
C {devices/lab_pin.sym} 7260 -30650 0 1 {name=p6679 lab=_45272_/A }
C {sky130_stdcells/buf_2.sym} 7220 -30650 0 0 {name=X_45197_ }
C {devices/lab_pin.sym} 7160 -30550 0 0 {name=p6680 lab=_62002_/A }
C {devices/lab_pin.sym} 7160 -30510 0 0 {name=p6681 lab=_62002_/B }
C {devices/lab_pin.sym} 7160 -30470 0 0 {name=p6682 lab=_78063_/B }
C {devices/lab_pin.sym} 7280 -30510 0 1 {name=p6683 lab=_62002_/Y }
C {sky130_stdcells/nor3_4.sym} 7220 -30510 0 0 {name=X_62002_ }
C {devices/lab_pin.sym} 7180 -30370 0 0 {name=p6684 lab=_44148_/A }
C {devices/lab_pin.sym} 7260 -30370 0 1 {name=p6685 lab=_44149_/A }
C {sky130_stdcells/buf_2.sym} 7220 -30370 0 0 {name=X_44148_ }
C {devices/lab_pin.sym} 7160 -30260 0 0 {name=p6686 lab=_84230_/Q }
C {devices/lab_pin.sym} 7160 -30220 0 0 {name=p6687 lab=_83278_/Q }
C {devices/lab_pin.sym} 7280 -30240 0 1 {name=p6688 lab=_79845_/X }
C {sky130_stdcells/xor2_4.sym} 7220 -30240 0 0 {name=X_79845_ }
C {devices/lab_pin.sym} 7180 -30110 0 0 {name=p6689 lab=_60239_/B }
C {devices/lab_pin.sym} 7260 -30110 0 1 {name=p6690 lab=_60253_/A }
C {sky130_stdcells/buf_2.sym} 7220 -30110 0 0 {name=X_60194_ }
C {devices/lab_pin.sym} 7160 -30000 0 0 {name=p6691 lab=_66785_/A }
C {devices/lab_pin.sym} 7160 -29960 0 0 {name=p6692 lab=_66810_/B }
C {devices/lab_pin.sym} 7280 -29980 0 1 {name=p6693 lab=_66810_/X }
C {sky130_stdcells/and2_4.sym} 7220 -29980 0 0 {name=X_66810_ }
C {devices/lab_pin.sym} 7160 -29860 0 0 {name=p6694 lab=_48964_/A }
C {devices/lab_pin.sym} 7160 -29820 0 0 {name=p6695 lab=_48955_/X }
C {devices/lab_pin.sym} 7280 -29840 0 1 {name=p6696 lab=_48956_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -29840 0 0 {name=X_48956_ }
C {devices/lab_pin.sym} 7180 -29710 0 0 {name=p6697 lab=_55817_/A }
C {devices/lab_pin.sym} 7260 -29710 0 1 {name=p6698 lab=_44079_/X }
C {sky130_stdcells/buf_2.sym} 7220 -29710 0 0 {name=X_44079_ }
C {devices/lab_pin.sym} 7160 -29600 0 0 {name=p6699 lab=_67790_/A }
C {devices/lab_pin.sym} 7160 -29560 0 0 {name=p6700 lab=_88160_/Q }
C {devices/lab_pin.sym} 7280 -29580 0 1 {name=p6701 lab=_67790_/X }
C {sky130_stdcells/and2_4.sym} 7220 -29580 0 0 {name=X_67790_ }
C {devices/lab_pin.sym} 7160 -29460 0 0 {name=p6702 lab=_79774_/X }
C {devices/lab_pin.sym} 7160 -29420 0 0 {name=p6703 lab=_79781_/B }
C {devices/lab_pin.sym} 7280 -29440 0 1 {name=p6704 lab=_79776_/Y }
C {sky130_stdcells/xnor2_4.sym} 7220 -29440 0 0 {name=X_79776_ }
C {devices/lab_pin.sym} 7160 -29320 0 0 {name=p6705 lab=_84540_/Q }
C {devices/lab_pin.sym} 7160 -29280 0 0 {name=p6706 lab=_84412_/Q }
C {devices/lab_pin.sym} 7280 -29300 0 1 {name=p6707 lab=_76988_/X }
C {sky130_stdcells/xor2_4.sym} 7220 -29300 0 0 {name=X_76988_ }
C {devices/lab_pin.sym} 7140 -29190 0 0 {name=p6708 lab=_47904_/X }
C {devices/lab_pin.sym} 7140 -29150 0 0 {name=p6709 lab=_82939_/Q }
C {devices/lab_pin.sym} 7140 -29110 0 0 {name=p6710 lab=_47906_/X }
C {devices/lab_pin.sym} 7300 -29150 0 1 {name=p6711 lab=_48212_/A }
C {sky130_stdcells/o21ai_4.sym} 7220 -29150 0 0 {name=X_47907_ }
C {devices/lab_pin.sym} 7160 -29020 0 0 {name=p6712 lab=_66669_/A }
C {devices/lab_pin.sym} 7160 -28980 0 0 {name=p6713 lab=_88140_/Q }
C {devices/lab_pin.sym} 7280 -29000 0 1 {name=p6714 lab=_66741_/X }
C {sky130_stdcells/and2_4.sym} 7220 -29000 0 0 {name=X_66741_ }
C {devices/lab_pin.sym} 7160 -28880 0 0 {name=p6715 lab=_78727_/A }
C {devices/lab_pin.sym} 7160 -28840 0 0 {name=p6716 lab=_78726_/Y }
C {devices/lab_pin.sym} 7280 -28860 0 1 {name=p6717 lab=_82493_/D }
C {sky130_stdcells/xnor2_4.sym} 7220 -28860 0 0 {name=X_78727_ }
C {devices/lab_pin.sym} 7160 -28740 0 0 {name=p6718 lab=_81508_/Q }
C {devices/lab_pin.sym} 7160 -28700 0 0 {name=p6719 lab=_75939_/B }
C {devices/lab_pin.sym} 7280 -28720 0 1 {name=p6720 lab=_75939_/Y }
C {sky130_stdcells/xnor2_4.sym} 7220 -28720 0 0 {name=X_75939_ }
C {devices/lab_pin.sym} 7160 -28620 0 0 {name=p6721 lab=_57672_/X }
C {devices/lab_pin.sym} 7160 -28580 0 0 {name=p6722 lab=_63902_/B }
C {devices/lab_pin.sym} 7160 -28540 0 0 {name=p6723 lab=_63902_/C }
C {devices/lab_pin.sym} 7160 -28500 0 0 {name=p6724 lab=_64016_/D }
C {devices/lab_pin.sym} 7280 -28560 0 1 {name=p6725 lab=_63954_/D }
C {sky130_stdcells/nand4_4.sym} 7220 -28560 0 0 {name=X_63953_ }
C {devices/lab_pin.sym} 7180 -28410 0 0 {name=p6726 lab=_83624_/Q }
C {devices/lab_pin.sym} 7260 -28410 0 1 {name=p6727 lab=_48887_/Y }
C {sky130_stdcells/inv_2.sym} 7220 -28410 0 0 {name=X_48887_ }
C {devices/lab_pin.sym} 7140 -28310 0 0 {name=p6728 lab=_62900_/X }
C {devices/lab_pin.sym} 7140 -28270 0 0 {name=p6729 lab=_62893_/X }
C {devices/lab_pin.sym} 7140 -28230 0 0 {name=p6730 lab=_62903_/Y }
C {devices/lab_pin.sym} 7300 -28270 0 1 {name=p6731 lab=_84372_/D }
C {sky130_stdcells/a21oi_4.sym} 7220 -28270 0 0 {name=X_62904_ }
C {devices/lab_pin.sym} 7140 -28160 0 0 {name=p6732 lab=_87016_/Q }
C {devices/lab_pin.sym} 7140 -28120 0 0 {name=p6733 lab=_69457_/X }
C {devices/lab_pin.sym} 7140 -28080 0 0 {name=p6734 lab=_69458_/X }
C {devices/lab_pin.sym} 7140 -28040 0 0 {name=p6735 lab=_69459_/X }
C {devices/lab_pin.sym} 7300 -28100 0 1 {name=p6736 lab=_69461_/B }
C {sky130_stdcells/a211o_4.sym} 7220 -28100 0 0 {name=X_69460_ }
C {devices/lab_pin.sym} 7180 -27950 0 0 {name=p6737 lab=_47832_/X }
C {devices/lab_pin.sym} 7260 -27950 0 1 {name=p6738 lab=_47838_/X }
C {sky130_stdcells/buf_2.sym} 7220 -27950 0 0 {name=X_47838_ }
C {devices/lab_pin.sym} 7180 -27830 0 0 {name=p6739 lab=_60781_/A }
C {devices/lab_pin.sym} 7260 -27830 0 1 {name=p6740 lab=_66672_/X }
C {sky130_stdcells/buf_2.sym} 7220 -27830 0 0 {name=X_66672_ }
C {devices/lab_pin.sym} 7160 -27720 0 0 {name=p6741 lab=_82521_/Q }
C {devices/lab_pin.sym} 7160 -27680 0 0 {name=p6742 lab=_82777_/D }
C {devices/lab_pin.sym} 7280 -27700 0 1 {name=p6743 lab=_82489_/D }
C {sky130_stdcells/xor2_4.sym} 7220 -27700 0 0 {name=X_78658_ }
C {devices/lab_pin.sym} 7160 -27600 0 0 {name=p6744 lab=_58506_/A }
C {devices/lab_pin.sym} 7160 -27560 0 0 {name=p6745 lab=_63900_/B }
C {devices/lab_pin.sym} 7160 -27520 0 0 {name=p6746 lab=_63900_/C }
C {devices/lab_pin.sym} 7160 -27480 0 0 {name=p6747 lab=_63900_/D }
C {devices/lab_pin.sym} 7280 -27540 0 1 {name=p6748 lab=_63884_/Y }
C {sky130_stdcells/nand4_4.sym} 7220 -27540 0 0 {name=X_63884_ }
C {devices/lab_pin.sym} 7140 -27410 0 0 {name=p6749 lab=_68407_/X }
C {devices/lab_pin.sym} 7140 -27370 0 0 {name=p6750 lab=_68410_/X }
C {devices/lab_pin.sym} 7140 -27330 0 0 {name=p6751 lab=_68331_/X }
C {devices/lab_pin.sym} 7300 -27370 0 1 {name=p6752 lab=_68411_/Y }
C {sky130_stdcells/a21oi_4.sym} 7220 -27370 0 0 {name=X_68411_ }
C {devices/lab_pin.sym} 7180 -27230 0 0 {name=p6753 lab=_64752_/A }
C {devices/lab_pin.sym} 7260 -27230 0 1 {name=p6754 lab=_65623_/X }
C {sky130_stdcells/buf_2.sym} 7220 -27230 0 0 {name=X_65623_ }
C {devices/lab_pin.sym} 7160 -27120 0 0 {name=p6755 lab=_77609_/A }
C {devices/lab_pin.sym} 7160 -27080 0 0 {name=p6756 lab=_82203_/D }
C {devices/lab_pin.sym} 7280 -27100 0 1 {name=p6757 lab=_81915_/D }
C {sky130_stdcells/xor2_4.sym} 7220 -27100 0 0 {name=X_77609_ }
C {devices/lab_pin.sym} 7180 -26970 0 0 {name=p6758 lab=_62717_/A }
C {devices/lab_pin.sym} 7260 -26970 0 1 {name=p6759 lab=_62880_/D }
C {sky130_stdcells/buf_2.sym} 7220 -26970 0 0 {name=X_62835_ }
C {devices/lab_pin.sym} 7140 -26880 0 0 {name=p6760 lab=_69329_/X }
C {devices/lab_pin.sym} 7140 -26840 0 0 {name=p6761 lab=_68822_/Y }
C {devices/lab_pin.sym} 7140 -26800 0 0 {name=p6762 lab=_69325_/X }
C {devices/lab_pin.sym} 7140 -26760 0 0 {name=p6763 lab=_69390_/Y }
C {devices/lab_pin.sym} 7300 -26820 0 1 {name=p6764 lab=_69391_/X }
C {sky130_stdcells/a211o_4.sym} 7220 -26820 0 0 {name=X_69391_ }
C {devices/lab_pin.sym} 7160 -26700 0 0 {name=p6765 lab=_47804_/A }
C {devices/lab_pin.sym} 7160 -26660 0 0 {name=p6766 lab=_47777_/B }
C {devices/lab_pin.sym} 7160 -26620 0 0 {name=p6767 lab=_47777_/C }
C {devices/lab_pin.sym} 7160 -26580 0 0 {name=p6768 lab=_53234_/D }
C {devices/lab_pin.sym} 7280 -26640 0 1 {name=p6769 lab=_47769_/X }
C {sky130_stdcells/and4_4.sym} 7220 -26640 0 0 {name=X_47769_ }
C {devices/lab_pin.sym} 7140 -26510 0 0 {name=p6770 lab=_78585_/Y }
C {devices/lab_pin.sym} 7140 -26470 0 0 {name=p6771 lab=_78587_/Y }
C {devices/lab_pin.sym} 7140 -26430 0 0 {name=p6772 lab=_78584_/Y }
C {devices/lab_pin.sym} 7300 -26470 0 1 {name=p6773 lab=_78589_/Y }
C {sky130_stdcells/o21ai_4.sym} 7220 -26470 0 0 {name=X_78589_ }
C {devices/lab_pin.sym} 7160 -26340 0 0 {name=p6774 lab=_49502_/A }
C {devices/lab_pin.sym} 7160 -26300 0 0 {name=p6775 lab=_51031_/B }
C {devices/lab_pin.sym} 7280 -26320 0 1 {name=p6776 lab=_49508_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -26320 0 0 {name=X_49508_ }
C {devices/lab_pin.sym} 7140 -26210 0 0 {name=p6777 lab=_80617_/Y }
C {devices/lab_pin.sym} 7140 -26170 0 0 {name=p6778 lab=_80600_/Y }
C {devices/lab_pin.sym} 7140 -26130 0 0 {name=p6779 lab=_80619_/X }
C {devices/lab_pin.sym} 7300 -26170 0 1 {name=p6780 lab=_80622_/A }
C {sky130_stdcells/o21ai_4.sym} 7220 -26170 0 0 {name=X_80620_ }
C {devices/lab_pin.sym} 7180 -26030 0 0 {name=p6781 lab=_68342_/A }
C {devices/lab_pin.sym} 7260 -26030 0 1 {name=p6782 lab=_69796_/A }
C {sky130_stdcells/buf_2.sym} 7220 -26030 0 0 {name=X_68342_ }
C {devices/lab_pin.sym} 7160 -25920 0 0 {name=p6783 lab=_65416_/X }
C {devices/lab_pin.sym} 7160 -25880 0 0 {name=p6784 lab=_72993_/B }
C {devices/lab_pin.sym} 7280 -25900 0 1 {name=p6785 lab=_65554_/X }
C {sky130_stdcells/and2_4.sym} 7220 -25900 0 0 {name=X_65554_ }
C {devices/lab_pin.sym} 7140 -25790 0 0 {name=p6786 lab=_50778_/Y }
C {devices/lab_pin.sym} 7140 -25750 0 0 {name=p6787 lab=_50768_/X }
C {devices/lab_pin.sym} 7140 -25710 0 0 {name=p6788 lab=_50779_/Y }
C {devices/lab_pin.sym} 7300 -25750 0 1 {name=p6789 lab=_50780_/Y }
C {sky130_stdcells/a21boi_4.sym} 7220 -25750 0 0 {name=X_50780_ }
C {devices/lab_pin.sym} 7160 -25630 0 0 {name=p6790 lab=_62766_/A }
C {devices/lab_pin.sym} 7160 -25590 0 0 {name=p6791 lab=_62766_/B }
C {devices/lab_pin.sym} 7160 -25550 0 0 {name=p6792 lab=_62766_/C }
C {devices/lab_pin.sym} 7280 -25590 0 1 {name=p6793 lab=_62766_/Y }
C {sky130_stdcells/nor3_4.sym} 7220 -25590 0 0 {name=X_62766_ }
C {devices/lab_pin.sym} 7160 -25470 0 0 {name=p6794 lab=_64455_/X }
C {devices/lab_pin.sym} 7160 -25430 0 0 {name=p6795 lab=_61637_/X }
C {devices/lab_pin.sym} 7160 -25390 0 0 {name=p6796 lab=_64211_/C }
C {devices/lab_pin.sym} 7280 -25430 0 1 {name=p6797 lab=_64505_/Y }
C {sky130_stdcells/nand3_4.sym} 7220 -25430 0 0 {name=X_64505_ }
C {devices/lab_pin.sym} 7140 -25310 0 0 {name=p6798 lab=_58750_/B }
C {devices/lab_pin.sym} 7140 -25270 0 0 {name=p6799 lab=_49415_/X }
C {devices/lab_pin.sym} 7140 -25230 0 0 {name=p6800 lab=_49438_/Y }
C {devices/lab_pin.sym} 7300 -25270 0 1 {name=p6801 lab=_49439_/Y }
C {sky130_stdcells/o21ai_4.sym} 7220 -25270 0 0 {name=X_49439_ }
C {devices/lab_pin.sym} 7140 -25160 0 0 {name=p6802 lab=_58403_/A }
C {devices/lab_pin.sym} 7140 -25120 0 0 {name=p6803 lab=_59858_/Y }
C {devices/lab_pin.sym} 7140 -25080 0 0 {name=p6804 lab=_61298_/B }
C {devices/lab_pin.sym} 7140 -25040 0 0 {name=p6805 lab=_61716_/X }
C {devices/lab_pin.sym} 7300 -25100 0 1 {name=p6806 lab=_61717_/X }
C {sky130_stdcells/a2bb2o_4.sym} 7220 -25100 0 0 {name=X_61717_ }
C {devices/lab_pin.sym} 7160 -24960 0 0 {name=p6807 lab=_80551_/A }
C {devices/lab_pin.sym} 7160 -24920 0 0 {name=p6808 lab=_80551_/B }
C {devices/lab_pin.sym} 7280 -24940 0 1 {name=p6809 lab=_80551_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -24940 0 0 {name=X_80551_ }
C {devices/lab_pin.sym} 7140 -24830 0 0 {name=p6810 lab=_67682_/X }
C {devices/lab_pin.sym} 7140 -24790 0 0 {name=p6811 lab=_67684_/X }
C {devices/lab_pin.sym} 7140 -24750 0 0 {name=p6812 lab=_68260_/X }
C {devices/lab_pin.sym} 7300 -24790 0 1 {name=p6813 lab=_68273_/Y }
C {sky130_stdcells/a21oi_4.sym} 7220 -24790 0 0 {name=X_68273_ }
C {devices/lab_pin.sym} 7180 -24650 0 0 {name=p6814 lab=_64567_/A }
C {devices/lab_pin.sym} 7260 -24650 0 1 {name=p6815 lab=_65486_/A }
C {sky130_stdcells/buf_2.sym} 7220 -24650 0 0 {name=X_65485_ }
C {devices/lab_pin.sym} 7160 -24550 0 0 {name=p6816 lab=_62673_/A }
C {devices/lab_pin.sym} 7160 -24510 0 0 {name=p6817 lab=_62673_/B }
C {devices/lab_pin.sym} 7160 -24470 0 0 {name=p6818 lab=_84390_/Q }
C {devices/lab_pin.sym} 7280 -24510 0 1 {name=p6819 lab=_62697_/Y }
C {sky130_stdcells/nor3_4.sym} 7220 -24510 0 0 {name=X_62697_ }
C {devices/lab_pin.sym} 7140 -24400 0 0 {name=p6820 lab=_87928_/Q }
C {devices/lab_pin.sym} 7140 -24360 0 0 {name=p6821 lab=_67176_/X }
C {devices/lab_pin.sym} 7140 -24320 0 0 {name=p6822 lab=_67153_/X }
C {devices/lab_pin.sym} 7140 -24280 0 0 {name=p6823 lab=_67223_/X }
C {devices/lab_pin.sym} 7300 -24340 0 1 {name=p6824 lab=_67224_/X }
C {sky130_stdcells/a211o_4.sym} 7220 -24340 0 0 {name=X_67224_ }
C {devices/lab_pin.sym} 7160 -24210 0 0 {name=p6825 lab=_50755_/A }
C {devices/lab_pin.sym} 7160 -24170 0 0 {name=p6826 lab=_52446_/B }
C {devices/lab_pin.sym} 7160 -24130 0 0 {name=p6827 lab=_52369_/X }
C {devices/lab_pin.sym} 7280 -24170 0 1 {name=p6828 lab=_52450_/X }
C {sky130_stdcells/and3_4.sym} 7220 -24170 0 0 {name=X_52450_ }
C {devices/lab_pin.sym} 7180 -24030 0 0 {name=p6829 lab=_61180_/A }
C {devices/lab_pin.sym} 7260 -24030 0 1 {name=p6830 lab=_64515_/A }
C {sky130_stdcells/buf_2.sym} 7220 -24030 0 0 {name=X_64436_ }
C {devices/lab_pin.sym} 7130 -23910 0 0 {name=p6831 lab=_83630_/CLK }
C {devices/lab_pin.sym} 7130 -23890 0 0 {name=p6832 lab=_83270_/D }
C {devices/lab_pin.sym} 7310 -23910 0 1 {name=p6833 lab=_83270_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -23900 0 0 {name=X_83270_ }
C {devices/lab_pin.sym} 7180 -23770 0 0 {name=p6834 lab=_72561_/C }
C {devices/lab_pin.sym} 7260 -23770 0 1 {name=p6835 lab=_61682_/C }
C {sky130_stdcells/buf_2.sym} 7220 -23770 0 0 {name=X_61648_ }
C {devices/lab_pin.sym} 7140 -23670 0 0 {name=p6836 lab=_80476_/A }
C {devices/lab_pin.sym} 7140 -23630 0 0 {name=p6837 lab=_80476_/B }
C {devices/lab_pin.sym} 7140 -23590 0 0 {name=p6838 lab=_80481_/Y }
C {devices/lab_pin.sym} 7300 -23630 0 1 {name=p6839 lab=_80482_/Y }
C {sky130_stdcells/a21boi_4.sym} 7220 -23630 0 0 {name=X_80482_ }
C {devices/lab_pin.sym} 7140 -23510 0 0 {name=p6840 lab=_51399_/Y }
C {devices/lab_pin.sym} 7140 -23470 0 0 {name=p6841 lab=_51229_/X }
C {devices/lab_pin.sym} 7140 -23430 0 0 {name=p6842 lab=_51400_/X }
C {devices/lab_pin.sym} 7300 -23470 0 1 {name=p6843 lab=_51401_/Y }
C {sky130_stdcells/a21oi_4.sym} 7220 -23470 0 0 {name=X_51401_ }
C {devices/lab_pin.sym} 7130 -23330 0 0 {name=p6844 lab=_82221_/CLK }
C {devices/lab_pin.sym} 7130 -23310 0 0 {name=p6845 lab=_82253_/Q }
C {devices/lab_pin.sym} 7310 -23330 0 1 {name=p6846 lab=_82221_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -23320 0 0 {name=X_82221_ }
C {devices/lab_pin.sym} 7140 -23220 0 0 {name=p6847 lab=_87931_/Q }
C {devices/lab_pin.sym} 7140 -23180 0 0 {name=p6848 lab=_67056_/X }
C {devices/lab_pin.sym} 7140 -23140 0 0 {name=p6849 lab=_67153_/X }
C {devices/lab_pin.sym} 7140 -23100 0 0 {name=p6850 lab=_67154_/X }
C {devices/lab_pin.sym} 7300 -23160 0 1 {name=p6851 lab=_67155_/X }
C {sky130_stdcells/a211o_4.sym} 7220 -23160 0 0 {name=X_67155_ }
C {devices/lab_pin.sym} 7160 -23020 0 0 {name=p6852 lab=_52385_/A }
C {devices/lab_pin.sym} 7160 -22980 0 0 {name=p6853 lab=_49121_/A }
C {devices/lab_pin.sym} 7280 -23000 0 1 {name=p6854 lab=_52381_/X }
C {sky130_stdcells/and2_4.sym} 7220 -23000 0 0 {name=X_52381_ }
C {devices/lab_pin.sym} 7180 -22870 0 0 {name=p6855 lab=_64367_/A }
C {devices/lab_pin.sym} 7260 -22870 0 1 {name=p6856 lab=_64367_/X }
C {sky130_stdcells/buf_2.sym} 7220 -22870 0 0 {name=X_64367_ }
C {devices/lab_pin.sym} 7160 -22770 0 0 {name=p6857 lab=_61329_/A }
C {devices/lab_pin.sym} 7160 -22730 0 0 {name=p6858 lab=_61579_/B }
C {devices/lab_pin.sym} 7160 -22690 0 0 {name=p6859 lab=_72549_/B }
C {devices/lab_pin.sym} 7280 -22730 0 1 {name=p6860 lab=_61579_/Y }
C {sky130_stdcells/nand3_4.sym} 7220 -22730 0 0 {name=X_61579_ }
C {devices/lab_pin.sym} 7140 -22610 0 0 {name=p6861 lab=_54116_/Y }
C {devices/lab_pin.sym} 7140 -22570 0 0 {name=p6862 lab=_54117_/X }
C {devices/lab_pin.sym} 7140 -22530 0 0 {name=p6863 lab=_54119_/X }
C {devices/lab_pin.sym} 7300 -22570 0 1 {name=p6864 lab=_85501_/D }
C {sky130_stdcells/a21oi_4.sym} 7220 -22570 0 0 {name=X_54120_ }
C {devices/lab_pin.sym} 7140 -22450 0 0 {name=p6865 lab=_66020_/X }
C {devices/lab_pin.sym} 7140 -22410 0 0 {name=p6866 lab=_66103_/Y }
C {devices/lab_pin.sym} 7140 -22370 0 0 {name=p6867 lab=_66105_/Y }
C {devices/lab_pin.sym} 7300 -22410 0 1 {name=p6868 lab=_66106_/Y }
C {sky130_stdcells/o21ai_4.sym} 7220 -22410 0 0 {name=X_66106_ }
C {devices/lab_pin.sym} 7180 -22270 0 0 {name=p6869 lab=_51259_/A }
C {devices/lab_pin.sym} 7260 -22270 0 1 {name=p6870 lab=_51332_/X }
C {sky130_stdcells/buf_2.sym} 7220 -22270 0 0 {name=X_51332_ }
C {devices/lab_pin.sym} 7140 -22170 0 0 {name=p6871 lab=_63315_/Y }
C {devices/lab_pin.sym} 7140 -22130 0 0 {name=p6872 lab=_63316_/X }
C {devices/lab_pin.sym} 7140 -22090 0 0 {name=p6873 lab=_63317_/X }
C {devices/lab_pin.sym} 7300 -22130 0 1 {name=p6874 lab=_63318_/X }
C {sky130_stdcells/a21o_4.sym} 7220 -22130 0 0 {name=X_63318_ }
C {devices/lab_pin.sym} 7130 -21990 0 0 {name=p6875 lab=_82152_/CLK }
C {devices/lab_pin.sym} 7130 -21970 0 0 {name=p6876 lab=_84144_/Q }
C {devices/lab_pin.sym} 7310 -21990 0 1 {name=p6877 lab=_82152_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -21980 0 0 {name=X_82152_ }
C {devices/lab_pin.sym} 7140 -21870 0 0 {name=p6878 lab=_67080_/X }
C {devices/lab_pin.sym} 7140 -21830 0 0 {name=p6879 lab=_67084_/X }
C {devices/lab_pin.sym} 7140 -21790 0 0 {name=p6880 lab=_67085_/X }
C {devices/lab_pin.sym} 7300 -21830 0 1 {name=p6881 lab=_67086_/X }
C {sky130_stdcells/a21o_4.sym} 7220 -21830 0 0 {name=X_67086_ }
C {devices/lab_pin.sym} 7140 -21730 0 0 {name=p6882 lab=_64293_/X }
C {devices/lab_pin.sym} 7140 -21690 0 0 {name=p6883 lab=_64294_/X }
C {devices/lab_pin.sym} 7140 -21650 0 0 {name=p6884 lab=_64295_/X }
C {devices/lab_pin.sym} 7140 -21610 0 0 {name=p6885 lab=_64297_/Y }
C {devices/lab_pin.sym} 7140 -21570 0 0 {name=p6886 lab=_64267_/X }
C {devices/lab_pin.sym} 7300 -21650 0 1 {name=p6887 lab=_64298_/X }
C {sky130_stdcells/o41a_4.sym} 7220 -21650 0 0 {name=X_64298_ }
C {devices/lab_pin.sym} 7130 -21490 0 0 {name=p6888 lab=_80817_/CLK }
C {devices/lab_pin.sym} 7130 -21470 0 0 {name=p6889 lab=_79696_/Y }
C {devices/lab_pin.sym} 7310 -21490 0 1 {name=p6890 lab=_75839_/A }
C {sky130_stdcells/dfxtp_4.sym} 7220 -21480 0 0 {name=X_81103_ }
C {devices/lab_pin.sym} 7180 -21350 0 0 {name=p6891 lab=_53773_/A }
C {devices/lab_pin.sym} 7260 -21350 0 1 {name=p6892 lab=_54051_/X }
C {sky130_stdcells/buf_2.sym} 7220 -21350 0 0 {name=X_54051_ }
C {devices/lab_pin.sym} 7160 -21240 0 0 {name=p6893 lab=_65878_/A }
C {devices/lab_pin.sym} 7160 -21200 0 0 {name=p6894 lab=_66037_/B }
C {devices/lab_pin.sym} 7280 -21220 0 1 {name=p6895 lab=_66037_/X }
C {sky130_stdcells/and2_4.sym} 7220 -21220 0 0 {name=X_66037_ }
C {devices/lab_pin.sym} 7180 -21090 0 0 {name=p6896 lab=_51263_/A }
C {devices/lab_pin.sym} 7260 -21090 0 1 {name=p6897 lab=_51263_/X }
C {sky130_stdcells/buf_2.sym} 7220 -21090 0 0 {name=X_51263_ }
C {devices/lab_pin.sym} 7130 -20970 0 0 {name=p6898 lab=_88232_/CLK }
C {devices/lab_pin.sym} 7130 -20950 0 0 {name=p6899 lab=_86960_/D }
C {devices/lab_pin.sym} 7310 -20970 0 1 {name=p6900 lab=_86960_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -20960 0 0 {name=X_86960_ }
C {devices/lab_pin.sym} 7130 -20830 0 0 {name=p6901 lab=_81954_/CLK }
C {devices/lab_pin.sym} 7130 -20810 0 0 {name=p6902 lab=_82083_/D }
C {devices/lab_pin.sym} 7310 -20830 0 1 {name=p6903 lab=_82083_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -20820 0 0 {name=X_82083_ }
C {devices/lab_pin.sym} 7140 -20720 0 0 {name=p6904 lab=_60555_/A }
C {devices/lab_pin.sym} 7140 -20680 0 0 {name=p6905 lab=_61582_/A }
C {devices/lab_pin.sym} 7140 -20640 0 0 {name=p6906 lab=_60608_/X }
C {devices/lab_pin.sym} 7140 -20600 0 0 {name=p6907 lab=_61579_/B }
C {devices/lab_pin.sym} 7300 -20660 0 1 {name=p6908 lab=_63249_/Y }
C {sky130_stdcells/a22oi_4.sym} 7220 -20660 0 0 {name=X_63249_ }
C {devices/lab_pin.sym} 7180 -20510 0 0 {name=p6909 lab=_52893_/X }
C {devices/lab_pin.sym} 7260 -20510 0 1 {name=p6910 lab=_53019_/A }
C {sky130_stdcells/buf_2.sym} 7220 -20510 0 0 {name=X_53002_ }
C {devices/lab_pin.sym} 7160 -20410 0 0 {name=p6911 lab=_50473_/A }
C {devices/lab_pin.sym} 7160 -20370 0 0 {name=p6912 lab=_57489_/B }
C {devices/lab_pin.sym} 7160 -20330 0 0 {name=p6913 lab=_50213_/X }
C {devices/lab_pin.sym} 7280 -20370 0 1 {name=p6914 lab=_50214_/Y }
C {sky130_stdcells/nand3_4.sym} 7220 -20370 0 0 {name=X_50214_ }
C {devices/lab_pin.sym} 7130 -20230 0 0 {name=p6915 lab=_86554_/CLK }
C {devices/lab_pin.sym} 7130 -20210 0 0 {name=p6916 lab=_85911_/D }
C {devices/lab_pin.sym} 7310 -20230 0 1 {name=p6917 lab=_85911_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -20220 0 0 {name=X_85911_ }
C {devices/lab_pin.sym} 7130 -20090 0 0 {name=p6918 lab=_81065_/CLK }
C {devices/lab_pin.sym} 7130 -20070 0 0 {name=p6919 lab=_81034_/D }
C {devices/lab_pin.sym} 7310 -20090 0 1 {name=p6920 lab=_81034_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -20080 0 0 {name=X_81034_ }
C {devices/lab_pin.sym} 7160 -19960 0 0 {name=p6921 lab=_51184_/X }
C {devices/lab_pin.sym} 7160 -19920 0 0 {name=p6922 lab=_52885_/B }
C {devices/lab_pin.sym} 7280 -19940 0 1 {name=p6923 lab=_51194_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -19940 0 0 {name=X_51194_ }
C {devices/lab_pin.sym} 7130 -19810 0 0 {name=p6924 lab=_80672_/CLK }
C {devices/lab_pin.sym} 7130 -19790 0 0 {name=p6925 lab=_45221_/Y }
C {devices/lab_pin.sym} 7310 -19810 0 1 {name=p6926 lab=_63238_/B }
C {sky130_stdcells/dfxtp_4.sym} 7220 -19800 0 0 {name=X_86891_ }
C {devices/lab_pin.sym} 7180 -19670 0 0 {name=p6927 lab=_86506_/CLK }
C {devices/lab_pin.sym} 7260 -19670 0 1 {name=p6928 lab=_86471_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 7220 -19670 0 0 {name=Xclkbuf_opt_22_CLK }
C {devices/lab_pin.sym} 7140 -19590 0 0 {name=p6929 lab=_57801_/X }
C {devices/lab_pin.sym} 7140 -19550 0 0 {name=p6930 lab=_57807_/Y }
C {devices/lab_pin.sym} 7140 -19510 0 0 {name=p6931 lab=_57808_/Y }
C {devices/lab_pin.sym} 7140 -19470 0 0 {name=p6932 lab=_57700_/X }
C {devices/lab_pin.sym} 7140 -19430 0 0 {name=p6933 lab=_57809_/X }
C {devices/lab_pin.sym} 7300 -19510 0 1 {name=p6934 lab=_57810_/X }
C {sky130_stdcells/o32a_4.sym} 7220 -19510 0 0 {name=X_57810_ }
C {devices/lab_pin.sym} 7140 -19370 0 0 {name=p6935 lab=_65084_/B }
C {devices/lab_pin.sym} 7140 -19330 0 0 {name=p6936 lab=_50137_/X }
C {devices/lab_pin.sym} 7140 -19290 0 0 {name=p6937 lab=_50144_/Y }
C {devices/lab_pin.sym} 7300 -19330 0 1 {name=p6938 lab=_50145_/Y }
C {sky130_stdcells/o21ai_4.sym} 7220 -19330 0 0 {name=X_50145_ }
C {devices/lab_pin.sym} 7130 -19190 0 0 {name=p6939 lab=_83303_/CLK }
C {devices/lab_pin.sym} 7130 -19170 0 0 {name=p6940 lab=_52342_/Y }
C {devices/lab_pin.sym} 7310 -19190 0 1 {name=p6941 lab=_85842_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -19180 0 0 {name=X_85842_ }
C {devices/lab_pin.sym} 7140 -19070 0 0 {name=p6942 lab=_58783_/Y }
C {devices/lab_pin.sym} 7140 -19030 0 0 {name=p6943 lab=_58789_/Y }
C {devices/lab_pin.sym} 7140 -18990 0 0 {name=p6944 lab=_58735_/X }
C {devices/lab_pin.sym} 7300 -19030 0 1 {name=p6945 lab=_58790_/X }
C {sky130_stdcells/a21o_4.sym} 7220 -19030 0 0 {name=X_58790_ }
C {devices/lab_pin.sym} 7160 -18900 0 0 {name=p6946 lab=_67914_/X }
C {devices/lab_pin.sym} 7160 -18860 0 0 {name=p6947 lab=_67988_/B }
C {devices/lab_pin.sym} 7280 -18880 0 1 {name=p6948 lab=_67988_/X }
C {sky130_stdcells/and2_4.sym} 7220 -18880 0 0 {name=X_67988_ }
C {devices/lab_pin.sym} 7140 -18770 0 0 {name=p6949 lab=_57726_/X }
C {devices/lab_pin.sym} 7140 -18730 0 0 {name=p6950 lab=_86015_/Q }
C {devices/lab_pin.sym} 7140 -18690 0 0 {name=p6951 lab=_57740_/X }
C {devices/lab_pin.sym} 7300 -18730 0 1 {name=p6952 lab=_57741_/Y }
C {sky130_stdcells/o21ai_4.sym} 7220 -18730 0 0 {name=X_57741_ }
C {devices/lab_pin.sym} 7160 -18600 0 0 {name=p6953 lab=_69727_/A }
C {devices/lab_pin.sym} 7160 -18560 0 0 {name=p6954 lab=_69727_/B }
C {devices/lab_pin.sym} 7280 -18580 0 1 {name=p6955 lab=_69727_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -18580 0 0 {name=X_69727_ }
C {devices/lab_pin.sym} 7140 -18470 0 0 {name=p6956 lab=_86269_/Q }
C {devices/lab_pin.sym} 7140 -18430 0 0 {name=p6957 lab=_50061_/X }
C {devices/lab_pin.sym} 7140 -18390 0 0 {name=p6958 lab=_50075_/Y }
C {devices/lab_pin.sym} 7300 -18430 0 1 {name=p6959 lab=_50076_/Y }
C {sky130_stdcells/o21ai_4.sym} 7220 -18430 0 0 {name=X_50076_ }
C {devices/lab_pin.sym} 7160 -18300 0 0 {name=p6960 lab=_53460_/A }
C {devices/lab_pin.sym} 7160 -18260 0 0 {name=p6961 lab=_47818_/A }
C {devices/lab_pin.sym} 7280 -18280 0 1 {name=p6962 lab=_54953_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -18280 0 0 {name=X_54953_ }
C {devices/lab_pin.sym} 7140 -18180 0 0 {name=p6963 lab=_87364_/Q }
C {devices/lab_pin.sym} 7140 -18140 0 0 {name=p6964 lab=_66915_/X }
C {devices/lab_pin.sym} 7140 -18100 0 0 {name=p6965 lab=_66863_/X }
C {devices/lab_pin.sym} 7140 -18060 0 0 {name=p6966 lab=_66938_/X }
C {devices/lab_pin.sym} 7300 -18120 0 1 {name=p6967 lab=_66939_/X }
C {sky130_stdcells/a211o_4.sym} 7220 -18120 0 0 {name=X_66939_ }
C {devices/lab_pin.sym} 7130 -17970 0 0 {name=p6968 lab=_85773_/CLK }
C {devices/lab_pin.sym} 7130 -17950 0 0 {name=p6969 lab=_52691_/Y }
C {devices/lab_pin.sym} 7310 -17970 0 1 {name=p6970 lab=_85773_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -17960 0 0 {name=X_85773_ }
C {devices/lab_pin.sym} 7130 -17830 0 0 {name=p6971 lab=_85096_/CLK }
C {devices/lab_pin.sym} 7130 -17810 0 0 {name=p6972 lab=_74687_/Y }
C {devices/lab_pin.sym} 7310 -17830 0 1 {name=p6973 lab=_82985_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -17820 0 0 {name=X_82985_ }
C {devices/lab_pin.sym} 7130 -17690 0 0 {name=p6974 lab=_87520_/CLK }
C {devices/lab_pin.sym} 7130 -17670 0 0 {name=p6975 lab=_43262_/Y }
C {devices/lab_pin.sym} 7310 -17690 0 1 {name=p6976 lab=_87512_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -17680 0 0 {name=X_87512_ }
C {devices/lab_pin.sym} 7160 -17560 0 0 {name=p6977 lab=_53898_/A }
C {devices/lab_pin.sym} 7160 -17520 0 0 {name=p6978 lab=_72077_/B }
C {devices/lab_pin.sym} 7280 -17540 0 1 {name=p6979 lab=_53904_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -17540 0 0 {name=X_53904_ }
C {devices/lab_pin.sym} 7130 -17410 0 0 {name=p6980 lab=_83464_/CLK }
C {devices/lab_pin.sym} 7130 -17390 0 0 {name=p6981 lab=_84724_/D }
C {devices/lab_pin.sym} 7310 -17410 0 1 {name=p6982 lab=_84724_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -17400 0 0 {name=X_84724_ }
C {devices/lab_pin.sym} 7180 -17270 0 0 {name=p6983 lab=_63524_/B }
C {devices/lab_pin.sym} 7260 -17270 0 1 {name=p6984 lab=_57672_/X }
C {sky130_stdcells/buf_2.sym} 7220 -17270 0 0 {name=X_57672_ }
C {devices/lab_pin.sym} 7130 -17150 0 0 {name=p6985 lab=_81985_/CLK }
C {devices/lab_pin.sym} 7130 -17130 0 0 {name=p6986 lab=_77866_/Y }
C {devices/lab_pin.sym} 7310 -17150 0 1 {name=p6987 lab=_77441_/A }
C {sky130_stdcells/dfxtp_4.sym} 7220 -17140 0 0 {name=X_81936_ }
C {devices/lab_pin.sym} 7140 -17030 0 0 {name=p6988 lab=_83907_/Q }
C {devices/lab_pin.sym} 7140 -16990 0 0 {name=p6989 lab=_69632_/X }
C {devices/lab_pin.sym} 7140 -16950 0 0 {name=p6990 lab=_69657_/X }
C {devices/lab_pin.sym} 7300 -16990 0 1 {name=p6991 lab=_83907_/D }
C {sky130_stdcells/a21bo_4.sym} 7220 -16990 0 0 {name=X_69658_ }
C {devices/lab_pin.sym} 7140 -16870 0 0 {name=p6992 lab=_54881_/Y }
C {devices/lab_pin.sym} 7140 -16830 0 0 {name=p6993 lab=_54882_/X }
C {devices/lab_pin.sym} 7140 -16790 0 0 {name=p6994 lab=_54883_/X }
C {devices/lab_pin.sym} 7300 -16830 0 1 {name=p6995 lab=_85360_/D }
C {sky130_stdcells/a21oi_4.sym} 7220 -16830 0 0 {name=X_54884_ }
C {devices/lab_pin.sym} 7160 -16700 0 0 {name=p6996 lab=_59411_/A }
C {devices/lab_pin.sym} 7160 -16660 0 0 {name=p6997 lab=_59399_/B }
C {devices/lab_pin.sym} 7280 -16680 0 1 {name=p6998 lab=_59411_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -16680 0 0 {name=X_59411_ }
C {devices/lab_pin.sym} 7160 -16560 0 0 {name=p6999 lab=_55526_/X }
C {devices/lab_pin.sym} 7160 -16520 0 0 {name=p7000 lab=_55536_/D }
C {devices/lab_pin.sym} 7280 -16540 0 1 {name=p7001 lab=_72662_/C }
C {sky130_stdcells/and2_4.sym} 7220 -16540 0 0 {name=X_56623_ }
C {devices/lab_pin.sym} 7140 -16430 0 0 {name=p7002 lab=_68606_/X }
C {devices/lab_pin.sym} 7140 -16390 0 0 {name=p7003 lab=_68608_/X }
C {devices/lab_pin.sym} 7140 -16350 0 0 {name=p7004 lab=_68512_/X }
C {devices/lab_pin.sym} 7300 -16390 0 1 {name=p7005 lab=_68609_/Y }
C {sky130_stdcells/a21oi_4.sym} 7220 -16390 0 0 {name=X_68609_ }
C {devices/lab_pin.sym} 7130 -16250 0 0 {name=p7006 lab=_87888_/CLK }
C {devices/lab_pin.sym} 7130 -16230 0 0 {name=p7007 lab=_87443_/D }
C {devices/lab_pin.sym} 7310 -16250 0 1 {name=p7008 lab=_87443_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -16240 0 0 {name=X_87443_ }
C {devices/lab_pin.sym} 7140 -16130 0 0 {name=p7009 lab=_53833_/Y }
C {devices/lab_pin.sym} 7140 -16090 0 0 {name=p7010 lab=_53799_/X }
C {devices/lab_pin.sym} 7140 -16050 0 0 {name=p7011 lab=_53834_/Y }
C {devices/lab_pin.sym} 7300 -16090 0 1 {name=p7012 lab=_53835_/Y }
C {sky130_stdcells/a21boi_4.sym} 7220 -16090 0 0 {name=X_53835_ }
C {devices/lab_pin.sym} 7130 -15950 0 0 {name=p7013 lab=_84672_/CLK }
C {devices/lab_pin.sym} 7130 -15930 0 0 {name=p7014 lab=_84655_/D }
C {devices/lab_pin.sym} 7310 -15950 0 1 {name=p7015 lab=_60136_/C }
C {sky130_stdcells/dfxtp_4.sym} 7220 -15940 0 0 {name=X_84655_ }
C {devices/lab_pin.sym} 7130 -15810 0 0 {name=p7016 lab=_82220_/CLK }
C {devices/lab_pin.sym} 7130 -15790 0 0 {name=p7017 lab=_78058_/X }
C {devices/lab_pin.sym} 7310 -15810 0 1 {name=p7018 lab=_81867_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -15800 0 0 {name=X_81867_ }
C {devices/lab_pin.sym} 7140 -15690 0 0 {name=p7019 lab=_69152_/X }
C {devices/lab_pin.sym} 7140 -15650 0 0 {name=p7020 lab=_69155_/X }
C {devices/lab_pin.sym} 7140 -15610 0 0 {name=p7021 lab=_69575_/X }
C {devices/lab_pin.sym} 7300 -15650 0 1 {name=p7022 lab=_69589_/Y }
C {sky130_stdcells/a21oi_4.sym} 7220 -15650 0 0 {name=X_69589_ }
C {devices/lab_pin.sym} 7160 -15520 0 0 {name=p7023 lab=_40817_/A }
C {devices/lab_pin.sym} 7160 -15480 0 0 {name=p7024 lab=_40800_/B }
C {devices/lab_pin.sym} 7280 -15500 0 1 {name=p7025 lab=_40800_/X }
C {sky130_stdcells/or2_4.sym} 7220 -15500 0 0 {name=X_40800_ }
C {devices/lab_pin.sym} 7130 -15370 0 0 {name=p7026 lab=_85554_/CLK }
C {devices/lab_pin.sym} 7130 -15350 0 0 {name=p7027 lab=_83606_/D }
C {devices/lab_pin.sym} 7310 -15370 0 1 {name=p7028 lab=_49072_/A }
C {sky130_stdcells/dfxtp_4.sym} 7220 -15360 0 0 {name=X_83606_ }
C {devices/lab_pin.sym} 7180 -15230 0 0 {name=p7029 lab=_59133_/A }
C {devices/lab_pin.sym} 7260 -15230 0 1 {name=p7030 lab=_59342_/X }
C {sky130_stdcells/buf_2.sym} 7220 -15230 0 0 {name=X_59342_ }
C {devices/lab_pin.sym} 7160 -15140 0 0 {name=p7031 lab=_71865_/A }
C {devices/lab_pin.sym} 7160 -15100 0 0 {name=p7032 lab=_70667_/A }
C {devices/lab_pin.sym} 7160 -15060 0 0 {name=p7033 lab=_71614_/C }
C {devices/lab_pin.sym} 7160 -15020 0 0 {name=p7034 lab=_71622_/D }
C {devices/lab_pin.sym} 7280 -15080 0 1 {name=p7035 lab=_71620_/Y }
C {sky130_stdcells/nor4_4.sym} 7220 -15080 0 0 {name=X_71620_ }
C {devices/lab_pin.sym} 7180 -14930 0 0 {name=p7036 lab=_55536_/X }
C {devices/lab_pin.sym} 7260 -14930 0 1 {name=p7037 lab=_56580_/B }
C {sky130_stdcells/buf_2.sym} 7220 -14930 0 0 {name=X_56554_ }
C {devices/lab_pin.sym} 7130 -14810 0 0 {name=p7038 lab=_80818_/CLK }
C {devices/lab_pin.sym} 7130 -14790 0 0 {name=p7039 lab=_80818_/D }
C {devices/lab_pin.sym} 7310 -14810 0 1 {name=p7040 lab=_80818_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -14800 0 0 {name=X_80818_ }
C {devices/lab_pin.sym} 7160 -14680 0 0 {name=p7041 lab=_82884_/Q }
C {devices/lab_pin.sym} 7160 -14640 0 0 {name=p7042 lab=_46240_/A }
C {devices/lab_pin.sym} 7280 -14660 0 1 {name=p7043 lab=_41780_/X }
C {sky130_stdcells/or2_4.sym} 7220 -14660 0 0 {name=X_41780_ }
C {devices/lab_pin.sym} 7130 -14530 0 0 {name=p7044 lab=_87373_/CLK }
C {devices/lab_pin.sym} 7130 -14510 0 0 {name=p7045 lab=_87374_/D }
C {devices/lab_pin.sym} 7310 -14530 0 1 {name=p7046 lab=_87374_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -14520 0 0 {name=X_87374_ }
C {devices/lab_pin.sym} 7160 -14400 0 0 {name=p7047 lab=_53766_/A }
C {devices/lab_pin.sym} 7160 -14360 0 0 {name=p7048 lab=_48683_/A }
C {devices/lab_pin.sym} 7280 -14380 0 1 {name=p7049 lab=_53766_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -14380 0 0 {name=X_53766_ }
C {devices/lab_pin.sym} 7130 -14250 0 0 {name=p7050 lab=_84590_/CLK }
C {devices/lab_pin.sym} 7130 -14230 0 0 {name=p7051 lab=_60613_/Y }
C {devices/lab_pin.sym} 7310 -14250 0 1 {name=p7052 lab=_60612_/C }
C {sky130_stdcells/dfxtp_4.sym} 7220 -14240 0 0 {name=X_84586_ }
C {devices/lab_pin.sym} 7180 -14110 0 0 {name=p7053 lab=_50952_/A }
C {devices/lab_pin.sym} 7260 -14110 0 1 {name=p7054 lab=_50985_/C }
C {sky130_stdcells/buf_2.sym} 7220 -14110 0 0 {name=X_50978_ }
C {devices/lab_pin.sym} 7130 -13990 0 0 {name=p7055 lab=_81671_/CLK }
C {devices/lab_pin.sym} 7130 -13970 0 0 {name=p7056 lab=_81606_/Q }
C {devices/lab_pin.sym} 7310 -13990 0 1 {name=p7057 lab=_47485_/A }
C {sky130_stdcells/dfxtp_4.sym} 7220 -13980 0 0 {name=X_81798_ }
C {devices/lab_pin.sym} 7180 -13850 0 0 {name=p7058 lab=_44063_/X }
C {devices/lab_pin.sym} 7260 -13850 0 1 {name=p7059 lab=_55505_/X }
C {sky130_stdcells/buf_2.sym} 7220 -13850 0 0 {name=X_55505_ }
C {devices/lab_pin.sym} 7130 -13730 0 0 {name=p7060 lab=_86322_/CLK }
C {devices/lab_pin.sym} 7130 -13710 0 0 {name=p7061 lab=_86325_/D }
C {devices/lab_pin.sym} 7310 -13730 0 1 {name=p7062 lab=_57897_/B }
C {sky130_stdcells/dfxtp_4.sym} 7220 -13720 0 0 {name=X_86325_ }
C {devices/lab_pin.sym} 7180 -13590 0 0 {name=p7063 lab=_40585_/A }
C {devices/lab_pin.sym} 7260 -13590 0 1 {name=p7064 lab=_40731_/X }
C {sky130_stdcells/buf_2.sym} 7220 -13590 0 0 {name=X_40731_ }
C {devices/lab_pin.sym} 7140 -13490 0 0 {name=p7065 lab=_52714_/Y }
C {devices/lab_pin.sym} 7140 -13450 0 0 {name=p7066 lab=_52702_/X }
C {devices/lab_pin.sym} 7140 -13410 0 0 {name=p7067 lab=_52716_/X }
C {devices/lab_pin.sym} 7300 -13450 0 1 {name=p7068 lab=_52717_/Y }
C {sky130_stdcells/a21oi_4.sym} 7220 -13450 0 0 {name=X_52717_ }
C {devices/lab_pin.sym} 7180 -13310 0 0 {name=p7069 lab=_58877_/A }
C {devices/lab_pin.sym} 7260 -13310 0 1 {name=p7070 lab=_59273_/X }
C {sky130_stdcells/buf_2.sym} 7220 -13310 0 0 {name=X_59273_ }
C {devices/lab_pin.sym} 7140 -13210 0 0 {name=p7071 lab=_71530_/Y }
C {devices/lab_pin.sym} 7140 -13170 0 0 {name=p7072 lab=_83459_/Q }
C {devices/lab_pin.sym} 7140 -13130 0 0 {name=p7073 lab=_71550_/Y }
C {devices/lab_pin.sym} 7300 -13170 0 1 {name=p7074 lab=_83459_/D }
C {sky130_stdcells/a21o_4.sym} 7220 -13170 0 0 {name=X_71551_ }
C {devices/lab_pin.sym} 7130 -13030 0 0 {name=p7075 lab=_86218_/CLK }
C {devices/lab_pin.sym} 7130 -13010 0 0 {name=p7076 lab=_83537_/D }
C {devices/lab_pin.sym} 7310 -13030 0 1 {name=p7077 lab=_83537_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -13020 0 0 {name=X_83537_ }
C {devices/lab_pin.sym} 7180 -12890 0 0 {name=p7078 lab=clkbuf_9_242_0_CLK/X }
C {devices/lab_pin.sym} 7260 -12890 0 1 {name=p7079 lab=_85679_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 7220 -12890 0 0 {name=Xclkbuf_10_484_0_CLK }
C {devices/lab_pin.sym} 7160 -12790 0 0 {name=p7080 lab=_56474_/X }
C {devices/lab_pin.sym} 7160 -12750 0 0 {name=p7081 lab=_56484_/X }
C {devices/lab_pin.sym} 7160 -12710 0 0 {name=p7082 lab=_85178_/Q }
C {devices/lab_pin.sym} 7280 -12750 0 1 {name=p7083 lab=_56485_/Y }
C {sky130_stdcells/nand3_4.sym} 7220 -12750 0 0 {name=X_56485_ }
C {devices/lab_pin.sym} 7130 -12610 0 0 {name=p7084 lab=_81125_/CLK }
C {devices/lab_pin.sym} 7130 -12590 0 0 {name=p7085 lab=_80749_/D }
C {devices/lab_pin.sym} 7310 -12610 0 1 {name=p7086 lab=_81125_/D }
C {sky130_stdcells/dfxtp_4.sym} 7220 -12600 0 0 {name=X_80749_ }
C {devices/lab_pin.sym} 7160 -12490 0 0 {name=p7087 lab=_48533_/A }
C {devices/lab_pin.sym} 7160 -12450 0 0 {name=p7088 lab=_53697_/B }
C {devices/lab_pin.sym} 7160 -12410 0 0 {name=p7089 lab=_53697_/C }
C {devices/lab_pin.sym} 7280 -12450 0 1 {name=p7090 lab=_53697_/Y }
C {sky130_stdcells/nand3_4.sym} 7220 -12450 0 0 {name=X_53697_ }
C {devices/lab_pin.sym} 7180 -12310 0 0 {name=p7091 lab=_58224_/A }
C {devices/lab_pin.sym} 7260 -12310 0 1 {name=p7092 lab=_58224_/Y }
C {sky130_stdcells/inv_2.sym} 7220 -12310 0 0 {name=X_58224_ }
C {devices/lab_pin.sym} 7180 -12190 0 0 {name=p7093 lab=_70502_/A }
C {devices/lab_pin.sym} 7260 -12190 0 1 {name=p7094 lab=_70502_/Y }
C {sky130_stdcells/inv_2.sym} 7220 -12190 0 0 {name=X_70502_ }
C {sky130_stdcells/decap_3.sym} 7220 -12040 0 0 {name=XPHY_500 }
C {devices/lab_pin.sym} 7140 -11930 0 0 {name=p7095 lab=_43449_/X }
C {devices/lab_pin.sym} 7140 -11890 0 0 {name=p7096 lab=_43426_/X }
C {devices/lab_pin.sym} 7140 -11850 0 0 {name=p7097 lab=_41606_/X }
C {devices/lab_pin.sym} 7140 -11810 0 0 {name=p7098 lab=_87415_/Q }
C {devices/lab_pin.sym} 7140 -11770 0 0 {name=p7099 lab=_43434_/X }
C {devices/lab_pin.sym} 7300 -11850 0 1 {name=p7100 lab=_43450_/Y }
C {sky130_stdcells/o32ai_4.sym} 7220 -11850 0 0 {name=X_43450_ }
C {devices/lab_pin.sym} 7160 -11710 0 0 {name=p7101 lab=_55383_/A }
C {devices/lab_pin.sym} 7160 -11670 0 0 {name=p7102 lab=_55377_/Y }
C {devices/lab_pin.sym} 7160 -11630 0 0 {name=p7103 lab=_55379_/Y }
C {devices/lab_pin.sym} 7280 -11670 0 1 {name=p7104 lab=_55436_/Y }
C {sky130_stdcells/nand3_4.sym} 7220 -11670 0 0 {name=X_55436_ }
C {devices/lab_pin.sym} 7130 -11530 0 0 {name=p7105 lab=_86256_/CLK }
C {devices/lab_pin.sym} 7130 -11510 0 0 {name=p7106 lab=_86256_/D }
C {devices/lab_pin.sym} 7310 -11530 0 1 {name=p7107 lab=_65061_/B }
C {sky130_stdcells/dfxtp_4.sym} 7220 -11520 0 0 {name=X_86256_ }
C {devices/lab_pin.sym} 7140 -11410 0 0 {name=p7108 lab=_86976_/Q }
C {devices/lab_pin.sym} 7140 -11370 0 0 {name=p7109 lab=_73916_/B }
C {devices/lab_pin.sym} 7140 -11330 0 0 {name=p7110 lab=_74269_/X }
C {devices/lab_pin.sym} 7300 -11370 0 1 {name=p7111 lab=_74281_/C }
C {sky130_stdcells/o21ai_4.sym} 7220 -11370 0 0 {name=X_74270_ }
C {sky130_stdcells/decap_3.sym} 7220 -11200 0 0 {name=XPHY_511 }
C {devices/lab_pin.sym} 7140 -11090 0 0 {name=p7112 lab=_40635_/X }
C {devices/lab_pin.sym} 7140 -11050 0 0 {name=p7113 lab=_40638_/X }
C {devices/lab_pin.sym} 7140 -11010 0 0 {name=p7114 lab=_40661_/X }
C {devices/lab_pin.sym} 7140 -10970 0 0 {name=p7115 lab=_68699_/B }
C {devices/lab_pin.sym} 7140 -10930 0 0 {name=p7116 lab=_40612_/X }
C {devices/lab_pin.sym} 7300 -11010 0 1 {name=p7117 lab=_40663_/A }
C {sky130_stdcells/o32ai_4.sym} 7220 -11010 0 0 {name=X_40662_ }
C {devices/lab_pin.sym} 7180 -10850 0 0 {name=p7118 lab=_52648_/A }
C {devices/lab_pin.sym} 7260 -10850 0 1 {name=p7119 lab=_52648_/X }
C {sky130_stdcells/buf_2.sym} 7220 -10850 0 0 {name=X_52648_ }
C {devices/lab_pin.sym} 7130 -10730 0 0 {name=p7120 lab=_85955_/CLK }
C {devices/lab_pin.sym} 7130 -10710 0 0 {name=p7121 lab=_83468_/D }
C {devices/lab_pin.sym} 7310 -10730 0 1 {name=p7122 lab=_47797_/A }
C {sky130_stdcells/dfxtp_4.sym} 7220 -10720 0 0 {name=X_83468_ }
C {devices/lab_pin.sym} 7140 -10610 0 0 {name=p7123 lab=_71463_/Y }
C {devices/lab_pin.sym} 7140 -10570 0 0 {name=p7124 lab=_83483_/Q }
C {devices/lab_pin.sym} 7140 -10530 0 0 {name=p7125 lab=_71481_/X }
C {devices/lab_pin.sym} 7300 -10570 0 1 {name=p7126 lab=_83483_/D }
C {sky130_stdcells/a21o_4.sym} 7220 -10570 0 0 {name=X_71482_ }
C {sky130_stdcells/decap_3.sym} 7220 -10400 0 0 {name=XPHY_522 }
C {sky130_stdcells/decap_3.sym} 7220 -10220 0 0 {name=XPHY_533 }
C {devices/lab_pin.sym} 7180 -10070 0 0 {name=p7127 lab=_42417_/A }
C {devices/lab_pin.sym} 7260 -10070 0 1 {name=p7128 lab=_42401_/X }
C {sky130_stdcells/buf_2.sym} 7220 -10070 0 0 {name=X_42401_ }
C {sky130_stdcells/decap_3.sym} 7220 -9920 0 0 {name=XPHY_544 }
C {devices/lab_pin.sym} 7180 -9770 0 0 {name=p7129 lab=_74140_/A }
C {devices/lab_pin.sym} 7260 -9770 0 1 {name=p7130 lab=_73221_/X }
C {sky130_stdcells/buf_2.sym} 7220 -9770 0 0 {name=X_73221_ }
C {devices/lab_pin.sym} 7130 -9650 0 0 {name=p7131 lab=_85269_/CLK }
C {devices/lab_pin.sym} 7130 -9630 0 0 {name=p7132 lab=_85207_/D }
C {devices/lab_pin.sym} 7310 -9650 0 1 {name=p7133 lab=_85207_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -9640 0 0 {name=X_85207_ }
C {devices/lab_pin.sym} 7160 -9530 0 0 {name=p7134 lab=_70442_/A }
C {devices/lab_pin.sym} 7160 -9490 0 0 {name=p7135 lab=_70374_/X }
C {devices/lab_pin.sym} 7160 -9450 0 0 {name=p7136 lab=_70431_/C }
C {devices/lab_pin.sym} 7280 -9490 0 1 {name=p7137 lab=_70433_/Y }
C {sky130_stdcells/nand3_4.sym} 7220 -9490 0 0 {name=X_70433_ }
C {devices/lab_pin.sym} 7180 -9350 0 0 {name=p7138 lab=_63033_/A }
C {devices/lab_pin.sym} 7260 -9350 0 1 {name=p7139 lab=_63389_/A }
C {sky130_stdcells/buf_2.sym} 7220 -9350 0 0 {name=X_58155_ }
C {sky130_stdcells/decap_3.sym} 7220 -9200 0 0 {name=XPHY_555 }
C {devices/lab_pin.sym} 7130 -9050 0 0 {name=p7140 lab=_82820_/CLK }
C {devices/lab_pin.sym} 7130 -9030 0 0 {name=p7141 lab=_82419_/D }
C {devices/lab_pin.sym} 7310 -9050 0 1 {name=p7142 lab=_78549_/A }
C {sky130_stdcells/dfxtp_4.sym} 7220 -9040 0 0 {name=X_82419_ }
C {devices/lab_pin.sym} 7140 -8940 0 0 {name=p7143 lab=_41416_/X }
C {devices/lab_pin.sym} 7140 -8900 0 0 {name=p7144 lab=_43371_/X }
C {devices/lab_pin.sym} 7140 -8860 0 0 {name=p7145 lab=_87451_/Q }
C {devices/lab_pin.sym} 7140 -8820 0 0 {name=p7146 lab=_43372_/X }
C {devices/lab_pin.sym} 7300 -8880 0 1 {name=p7147 lab=_43381_/X }
C {sky130_stdcells/a2bb2o_4.sym} 7220 -8880 0 0 {name=X_43381_ }
C {devices/lab_pin.sym} 7160 -8740 0 0 {name=p7148 lab=_55392_/B }
C {devices/lab_pin.sym} 7160 -8700 0 0 {name=p7149 lab=_55392_/A }
C {devices/lab_pin.sym} 7280 -8720 0 1 {name=p7150 lab=_55367_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -8720 0 0 {name=X_55367_ }
C {devices/lab_pin.sym} 7130 -8590 0 0 {name=p7151 lab=_86505_/CLK }
C {devices/lab_pin.sym} 7130 -8570 0 0 {name=p7152 lab=_86187_/D }
C {devices/lab_pin.sym} 7310 -8590 0 1 {name=p7153 lab=_86187_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -8580 0 0 {name=X_86187_ }
C {devices/lab_pin.sym} 7180 -8450 0 0 {name=p7154 lab=_48903_/A }
C {devices/lab_pin.sym} 7260 -8450 0 1 {name=p7155 lab=_48192_/A }
C {sky130_stdcells/inv_2.sym} 7220 -8450 0 0 {name=X_40593_ }
C {devices/lab_pin.sym} 7180 -8330 0 0 {name=p7156 lab=_52605_/A }
C {devices/lab_pin.sym} 7260 -8330 0 1 {name=p7157 lab=_52594_/B }
C {sky130_stdcells/buf_2.sym} 7220 -8330 0 0 {name=X_52579_ }
C {sky130_stdcells/decap_3.sym} 7220 -8180 0 0 {name=XPHY_566 }
C {devices/lab_pin.sym} 7130 -8030 0 0 {name=p7158 lab=_84939_/CLK }
C {devices/lab_pin.sym} 7130 -8010 0 0 {name=p7159 lab=_83399_/D }
C {devices/lab_pin.sym} 7310 -8030 0 1 {name=p7160 lab=_58224_/A }
C {sky130_stdcells/dfxtp_4.sym} 7220 -8020 0 0 {name=X_83399_ }
C {sky130_stdcells/decap_3.sym} 7220 -7860 0 0 {name=XPHY_577 }
C {devices/lab_pin.sym} 7180 -7710 0 0 {name=p7161 lab=_44895_/X }
C {devices/lab_pin.sym} 7260 -7710 0 1 {name=p7162 lab=_45120_/X }
C {sky130_stdcells/buf_2.sym} 7220 -7710 0 0 {name=X_45120_ }
C {sky130_stdcells/decap_3.sym} 7220 -7560 0 0 {name=XPHY_588 }
C {devices/lab_pin.sym} 7180 -7410 0 0 {name=p7163 lab=_57105_/Y }
C {devices/lab_pin.sym} 7260 -7410 0 1 {name=p7164 lab=_57106_/X }
C {sky130_stdcells/buf_2.sym} 7220 -7410 0 0 {name=X_57106_ }
C {devices/lab_pin.sym} 7180 -7290 0 0 {name=p7165 lab=_42331_/Y }
C {devices/lab_pin.sym} 7260 -7290 0 1 {name=p7166 lab=_87918_/D }
C {sky130_stdcells/inv_2.sym} 7220 -7290 0 0 {name=X_42332_ }
C {devices/lab_pin.sym} 7160 -7200 0 0 {name=p7167 lab=_54325_/A }
C {devices/lab_pin.sym} 7160 -7160 0 0 {name=p7168 lab=_54325_/B }
C {devices/lab_pin.sym} 7160 -7120 0 0 {name=p7169 lab=_54317_/X }
C {devices/lab_pin.sym} 7160 -7080 0 0 {name=p7170 lab=_46706_/Y }
C {devices/lab_pin.sym} 7280 -7140 0 1 {name=p7171 lab=_54318_/X }
C {sky130_stdcells/and4_4.sym} 7220 -7140 0 0 {name=X_54318_ }
C {devices/lab_pin.sym} 7180 -6990 0 0 {name=p7172 lab=clkbuf_9_249_0_CLK/X }
C {devices/lab_pin.sym} 7260 -6990 0 1 {name=p7173 lab=_83676_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 7220 -6990 0 0 {name=Xclkbuf_10_499_0_CLK }
C {sky130_stdcells/decap_3.sym} 7220 -6840 0 0 {name=XPHY_599 }
C {devices/lab_pin.sym} 7180 -6690 0 0 {name=p7174 lab=_44270_/X }
C {devices/lab_pin.sym} 7260 -6690 0 1 {name=p7175 lab=_73152_/X }
C {sky130_stdcells/buf_2.sym} 7220 -6690 0 0 {name=X_73152_ }
C {devices/lab_pin.sym} 7130 -6570 0 0 {name=p7176 lab=_85138_/CLK }
C {devices/lab_pin.sym} 7130 -6550 0 0 {name=p7177 lab=_85138_/D }
C {devices/lab_pin.sym} 7310 -6570 0 1 {name=p7178 lab=_85138_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -6560 0 0 {name=X_85138_ }
C {devices/lab_pin.sym} 7180 -6430 0 0 {name=p7179 lab=_70364_/A }
C {devices/lab_pin.sym} 7260 -6430 0 1 {name=p7180 lab=_70364_/X }
C {sky130_stdcells/buf_2.sym} 7220 -6430 0 0 {name=X_70364_ }
C {devices/lab_pin.sym} 7140 -6330 0 0 {name=p7181 lab=_58030_/X }
C {devices/lab_pin.sym} 7140 -6290 0 0 {name=p7182 lab=_85478_/Q }
C {devices/lab_pin.sym} 7140 -6250 0 0 {name=p7183 lab=_58062_/X }
C {devices/lab_pin.sym} 7300 -6290 0 1 {name=p7184 lab=_58086_/X }
C {sky130_stdcells/o21a_4.sym} 7220 -6290 0 0 {name=X_58086_ }
C {devices/lab_pin.sym} 7160 -6180 0 0 {name=p7185 lab=_55298_/A }
C {devices/lab_pin.sym} 7160 -6140 0 0 {name=p7186 lab=_55417_/A }
C {devices/lab_pin.sym} 7160 -6100 0 0 {name=p7187 lab=_55297_/X }
C {devices/lab_pin.sym} 7160 -6060 0 0 {name=p7188 lab=_55400_/A }
C {devices/lab_pin.sym} 7280 -6120 0 1 {name=p7189 lab=_55298_/X }
C {sky130_stdcells/and4_4.sym} 7220 -6120 0 0 {name=X_55298_ }
C {devices/lab_pin.sym} 7160 -5980 0 0 {name=p7190 lab=_74391_/A }
C {devices/lab_pin.sym} 7160 -5940 0 0 {name=p7191 lab=_50714_/B }
C {devices/lab_pin.sym} 7280 -5960 0 1 {name=p7192 lab=_72103_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -5960 0 0 {name=X_72103_ }
C {devices/lab_pin.sym} 7180 -5830 0 0 {name=p7193 lab=_45819_/A }
C {devices/lab_pin.sym} 7260 -5830 0 1 {name=p7194 lab=_45350_/A }
C {sky130_stdcells/buf_2.sym} 7220 -5830 0 0 {name=X_45051_ }
C {devices/lab_pin.sym} 7160 -5730 0 0 {name=p7195 lab=_56787_/X }
C {devices/lab_pin.sym} 7160 -5690 0 0 {name=p7196 lab=_56788_/A }
C {devices/lab_pin.sym} 7160 -5650 0 0 {name=p7197 lab=_57024_/D }
C {devices/lab_pin.sym} 7280 -5690 0 1 {name=p7198 lab=_57038_/B }
C {sky130_stdcells/nand3_4.sym} 7220 -5690 0 0 {name=X_57037_ }
C {devices/lab_pin.sym} 7180 -5550 0 0 {name=p7199 lab=_42262_/Y }
C {devices/lab_pin.sym} 7260 -5550 0 1 {name=p7200 lab=_42263_/Y }
C {sky130_stdcells/inv_2.sym} 7220 -5550 0 0 {name=X_42263_ }
C {devices/lab_pin.sym} 7180 -5430 0 0 {name=p7201 lab=_54249_/A }
C {devices/lab_pin.sym} 7260 -5430 0 1 {name=p7202 lab=_54249_/X }
C {sky130_stdcells/buf_2.sym} 7220 -5430 0 0 {name=X_54249_ }
C {devices/lab_pin.sym} 7160 -5330 0 0 {name=p7203 lab=_77950_/B }
C {devices/lab_pin.sym} 7160 -5290 0 0 {name=p7204 lab=_77950_/A }
C {devices/lab_pin.sym} 7160 -5250 0 0 {name=p7205 lab=_77960_/C }
C {devices/lab_pin.sym} 7280 -5290 0 1 {name=p7206 lab=_77960_/Y }
C {sky130_stdcells/nand3_4.sym} 7220 -5290 0 0 {name=X_77960_ }
C {devices/lab_pin.sym} 7160 -5160 0 0 {name=p7207 lab=_73083_/A }
C {devices/lab_pin.sym} 7160 -5120 0 0 {name=p7208 lab=_73198_/B }
C {devices/lab_pin.sym} 7280 -5140 0 1 {name=p7209 lab=_73083_/Y }
C {sky130_stdcells/nor2_4.sym} 7220 -5140 0 0 {name=X_73083_ }
C {devices/lab_pin.sym} 7130 -5010 0 0 {name=p7210 lab=_85103_/CLK }
C {devices/lab_pin.sym} 7130 -4990 0 0 {name=p7211 lab=_85069_/D }
C {devices/lab_pin.sym} 7310 -5010 0 1 {name=p7212 lab=_85069_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7220 -5000 0 0 {name=X_85069_ }
C {devices/lab_pin.sym} 7140 -4890 0 0 {name=p7213 lab=_70289_/X }
C {devices/lab_pin.sym} 7140 -4850 0 0 {name=p7214 lab=_83807_/Q }
C {devices/lab_pin.sym} 7140 -4810 0 0 {name=p7215 lab=_70294_/X }
C {devices/lab_pin.sym} 7300 -4850 0 1 {name=p7216 lab=_83807_/D }
C {sky130_stdcells/a21o_4.sym} 7220 -4850 0 0 {name=X_70295_ }
C {devices/lab_pin.sym} 7180 -4710 0 0 {name=p7217 lab=_62640_/C }
C {devices/lab_pin.sym} 7260 -4710 0 1 {name=p7218 lab=_62975_/D }
C {sky130_stdcells/buf_2.sym} 7220 -4710 0 0 {name=X_44002_ }
C {devices/lab_pin.sym} 7180 -4590 0 0 {name=p7219 lab=_41213_/X }
C {devices/lab_pin.sym} 7260 -4590 0 1 {name=p7220 lab=_41214_/X }
C {sky130_stdcells/buf_2.sym} 7220 -4590 0 0 {name=X_41214_ }
C {devices/lab_pin.sym} 7160 -4480 0 0 {name=p7221 lab=_72025_/A }
C {devices/lab_pin.sym} 7160 -4440 0 0 {name=p7222 lab=_53858_/B }
C {devices/lab_pin.sym} 7280 -4460 0 1 {name=p7223 lab=_72034_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -4460 0 0 {name=X_72034_ }
C {devices/lab_pin.sym} 7140 -4350 0 0 {name=p7224 lab=_76893_/A }
C {devices/lab_pin.sym} 7140 -4310 0 0 {name=p7225 lab=_76897_/Y }
C {devices/lab_pin.sym} 7140 -4270 0 0 {name=p7226 lab=_76899_/A }
C {devices/lab_pin.sym} 7300 -4310 0 1 {name=p7227 lab=_76911_/Y }
C {sky130_stdcells/a21oi_4.sym} 7220 -4310 0 0 {name=X_76911_ }
C {devices/lab_pin.sym} 7140 -4200 0 0 {name=p7228 lab=_41294_/X }
C {devices/lab_pin.sym} 7140 -4160 0 0 {name=p7229 lab=_42192_/X }
C {devices/lab_pin.sym} 7140 -4120 0 0 {name=p7230 lab=_87986_/Q }
C {devices/lab_pin.sym} 7140 -4080 0 0 {name=p7231 lab=_42193_/X }
C {devices/lab_pin.sym} 7300 -4140 0 1 {name=p7232 lab=_87986_/D }
C {sky130_stdcells/a2bb2o_4.sym} 7220 -4140 0 0 {name=X_42194_ }
C {devices/lab_pin.sym} 7180 -3990 0 0 {name=p7233 lab=clkbuf_9_211_0_CLK/X }
C {devices/lab_pin.sym} 7260 -3990 0 1 {name=p7234 lab=_82828_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 7220 -3990 0 0 {name=Xclkbuf_10_422_0_CLK }
C {devices/lab_pin.sym} 7160 -3880 0 0 {name=p7235 lab=_77891_/A }
C {devices/lab_pin.sym} 7160 -3840 0 0 {name=p7236 lab=_77890_/Y }
C {devices/lab_pin.sym} 7280 -3860 0 1 {name=p7237 lab=_77892_/A }
C {sky130_stdcells/xor2_4.sym} 7220 -3860 0 0 {name=X_77891_ }
C {devices/lab_pin.sym} 7180 -3730 0 0 {name=p7238 lab=_48837_/A }
C {devices/lab_pin.sym} 7260 -3730 0 1 {name=p7239 lab=_48831_/A }
C {sky130_stdcells/buf_2.sym} 7220 -3730 0 0 {name=X_48810_ }
C {devices/lab_pin.sym} 7180 -3610 0 0 {name=p7240 lab=_84914_/CLK }
C {devices/lab_pin.sym} 7260 -3610 0 1 {name=p7241 lab=_84716_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 7220 -3610 0 0 {name=Xclkbuf_opt_13_CLK }
C {devices/lab_pin.sym} 7160 -3500 0 0 {name=p7242 lab=_79630_/A }
C {devices/lab_pin.sym} 7160 -3460 0 0 {name=p7243 lab=_79629_/X }
C {devices/lab_pin.sym} 7280 -3480 0 1 {name=p7244 lab=_79630_/X }
C {sky130_stdcells/xor2_4.sym} 7220 -3480 0 0 {name=X_79630_ }
C {devices/lab_pin.sym} 7160 -3360 0 0 {name=p7245 lab=_81723_/Q }
C {devices/lab_pin.sym} 7160 -3320 0 0 {name=p7246 lab=_41145_/B }
C {devices/lab_pin.sym} 7280 -3340 0 1 {name=p7247 lab=_41145_/X }
C {sky130_stdcells/or2_4.sym} 7220 -3340 0 0 {name=X_41145_ }
C {devices/lab_pin.sym} 7160 -3220 0 0 {name=p7248 lab=_76829_/A }
C {devices/lab_pin.sym} 7160 -3180 0 0 {name=p7249 lab=_76828_/Y }
C {devices/lab_pin.sym} 7280 -3200 0 1 {name=p7250 lab=_76842_/Y }
C {sky130_stdcells/nor2_4.sym} 7220 -3200 0 0 {name=X_76842_ }
C {devices/lab_pin.sym} 7180 -3070 0 0 {name=p7251 lab=clkbuf_4_14_1_CLK/A }
C {devices/lab_pin.sym} 7260 -3070 0 1 {name=p7252 lab=clkbuf_4_14_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 7220 -3070 0 0 {name=Xclkbuf_4_14_1_CLK }
C {devices/lab_pin.sym} 7140 -2970 0 0 {name=p7253 lab=_49786_/Y }
C {devices/lab_pin.sym} 7140 -2930 0 0 {name=p7254 lab=_49787_/X }
C {devices/lab_pin.sym} 7140 -2890 0 0 {name=p7255 lab=_49789_/X }
C {devices/lab_pin.sym} 7300 -2930 0 1 {name=p7256 lab=_86323_/D }
C {sky130_stdcells/a21oi_4.sym} 7220 -2930 0 0 {name=X_49790_ }
C {devices/lab_pin.sym} 7160 -2800 0 0 {name=p7257 lab=_58987_/Y }
C {devices/lab_pin.sym} 7160 -2760 0 0 {name=p7258 lab=_58988_/B }
C {devices/lab_pin.sym} 7280 -2780 0 1 {name=p7259 lab=_58988_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -2780 0 0 {name=X_58988_ }
C {devices/lab_pin.sym} 7160 -2660 0 0 {name=p7260 lab=_48737_/A }
C {devices/lab_pin.sym} 7160 -2620 0 0 {name=p7261 lab=_52128_/B }
C {devices/lab_pin.sym} 7280 -2640 0 1 {name=p7262 lab=_48741_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -2640 0 0 {name=X_48741_ }
C {devices/lab_pin.sym} 7160 -2520 0 0 {name=p7263 lab=_79558_/Y }
C {devices/lab_pin.sym} 7160 -2480 0 0 {name=p7264 lab=_79548_/Y }
C {devices/lab_pin.sym} 7280 -2500 0 1 {name=p7265 lab=_79561_/Y }
C {sky130_stdcells/nand2_4.sym} 7220 -2500 0 0 {name=X_79561_ }
C {devices/lab_pin.sym} 7140 -2390 0 0 {name=p7266 lab=_45948_/Y }
C {devices/lab_pin.sym} 7140 -2350 0 0 {name=p7267 lab=_45950_/Y }
C {devices/lab_pin.sym} 7140 -2310 0 0 {name=p7268 lab=_45952_/X }
C {devices/lab_pin.sym} 7300 -2350 0 1 {name=p7269 lab=_86840_/D }
C {sky130_stdcells/o21a_4.sym} 7220 -2350 0 0 {name=X_45953_ }
C {devices/lab_pin.sym} 7180 -2210 0 0 {name=p7270 lab=_41076_/A }
C {devices/lab_pin.sym} 7260 -2210 0 1 {name=p7271 lab=_41076_/X }
C {sky130_stdcells/buf_2.sym} 7220 -2210 0 0 {name=X_41076_ }
C {devices/lab_pin.sym} 7180 -2090 0 0 {name=p7272 lab=_58618_/A }
C {devices/lab_pin.sym} 7260 -2090 0 1 {name=p7273 lab=_57939_/X }
C {sky130_stdcells/buf_2.sym} 7220 -2090 0 0 {name=X_57939_ }
C {devices/lab_pin.sym} 7160 -1980 0 0 {name=p7274 lab=_76773_/A }
C {devices/lab_pin.sym} 7160 -1940 0 0 {name=p7275 lab=_76773_/B }
C {devices/lab_pin.sym} 7280 -1960 0 1 {name=p7276 lab=_76773_/Y }
C {sky130_stdcells/xnor2_4.sym} 7220 -1960 0 0 {name=X_76773_ }
C {devices/lab_pin.sym} 7160 -1840 0 0 {name=p7277 lab=_73985_/A }
C {devices/lab_pin.sym} 7160 -1800 0 0 {name=p7278 lab=_73024_/B }
C {devices/lab_pin.sym} 7280 -1820 0 1 {name=p7279 lab=_73985_/Y }
C {sky130_stdcells/nor2_4.sym} 7220 -1820 0 0 {name=X_73985_ }
C {devices/lab_pin.sym} 7180 -1690 0 0 {name=p7280 lab=_78511_/X }
C {devices/lab_pin.sym} 7260 -1690 0 1 {name=p7281 lab=_78519_/A }
C {sky130_stdcells/inv_2.sym} 7220 -1690 0 0 {name=X_78512_ }
C {devices/lab_pin.sym} 7180 -1570 0 0 {name=p7282 lab=_44904_/A }
C {devices/lab_pin.sym} 7260 -1570 0 1 {name=p7283 lab=_44975_/A }
C {sky130_stdcells/buf_2.sym} 7220 -1570 0 0 {name=X_44904_ }
C {devices/lab_pin.sym} 7160 -1460 0 0 {name=p7284 lab=_81010_/Q }
C {devices/lab_pin.sym} 7160 -1420 0 0 {name=p7285 lab=_75724_/B }
C {devices/lab_pin.sym} 7280 -1440 0 1 {name=p7286 lab=_75724_/X }
C {sky130_stdcells/xor2_4.sym} 7220 -1440 0 0 {name=X_75724_ }
C {devices/lab_pin.sym} 7180 -1310 0 0 {name=p7287 lab=clkbuf_9_218_0_CLK/X }
C {devices/lab_pin.sym} 7260 -1310 0 1 {name=p7288 lab=_83550_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 7220 -1310 0 0 {name=Xclkbuf_10_437_0_CLK }
C {devices/lab_pin.sym} 7180 -1190 0 0 {name=p7289 lab=_48672_/A }
C {devices/lab_pin.sym} 7260 -1190 0 1 {name=p7290 lab=_48673_/B }
C {sky130_stdcells/buf_2.sym} 7220 -1190 0 0 {name=X_48672_ }
C {devices/lab_pin.sym} 7160 -1090 0 0 {name=p7291 lab=_64182_/D }
C {devices/lab_pin.sym} 7160 -1050 0 0 {name=p7292 lab=_60901_/A }
C {devices/lab_pin.sym} 7160 -1010 0 0 {name=p7293 lab=_60934_/X }
C {devices/lab_pin.sym} 7280 -1050 0 1 {name=p7294 lab=_60950_/Y }
C {sky130_stdcells/nor3_4.sym} 7220 -1050 0 0 {name=X_60950_ }
C {devices/lab_pin.sym} 7140 -940 0 0 {name=p7295 lab=_72755_/X }
C {devices/lab_pin.sym} 7140 -900 0 0 {name=p7296 lab=_83075_/Q }
C {devices/lab_pin.sym} 7140 -860 0 0 {name=p7297 lab=_72785_/X }
C {devices/lab_pin.sym} 7140 -820 0 0 {name=p7298 lab=_72935_/X }
C {devices/lab_pin.sym} 7300 -880 0 1 {name=p7299 lab=_72936_/X }
C {sky130_stdcells/a211o_4.sym} 7220 -880 0 0 {name=X_72936_ }
C {devices/lab_pin.sym} 7160 -740 0 0 {name=p7300 lab=_84815_/Q }
C {devices/lab_pin.sym} 7160 -700 0 0 {name=p7301 lab=_84135_/Q }
C {devices/lab_pin.sym} 7280 -720 0 1 {name=p7302 lab=_79494_/A }
C {sky130_stdcells/xor2_4.sym} 7220 -720 0 0 {name=X_79492_ }
C {devices/lab_pin.sym} 8100 -42150 0 0 {name=p7303 lab=_45884_/A }
C {devices/lab_pin.sym} 8180 -42150 0 1 {name=p7304 lab=_45884_/Y }
C {sky130_stdcells/inv_2.sym} 8140 -42150 0 0 {name=X_45884_ }
C {devices/lab_pin.sym} 8100 -42030 0 0 {name=p7305 lab=_47623_/A }
C {devices/lab_pin.sym} 8180 -42030 0 1 {name=p7306 lab=_53153_/B }
C {sky130_stdcells/buf_2.sym} 8140 -42030 0 0 {name=X_47623_ }
C {devices/lab_pin.sym} 8080 -41940 0 0 {name=p7307 lab=_59571_/B }
C {devices/lab_pin.sym} 8080 -41900 0 0 {name=p7308 lab=_59571_/C }
C {devices/lab_pin.sym} 8080 -41860 0 0 {name=p7309 lab=_59516_/A }
C {devices/lab_pin.sym} 8080 -41820 0 0 {name=p7310 lab=_59609_/D }
C {devices/lab_pin.sym} 8200 -41880 0 1 {name=p7311 lab=_59609_/X }
C {sky130_stdcells/and4_4.sym} 8140 -41880 0 0 {name=X_59609_ }
C {devices/lab_pin.sym} 8080 -41740 0 0 {name=p7312 lab=_78441_/X }
C {devices/lab_pin.sym} 8080 -41700 0 0 {name=p7313 lab=_78443_/B }
C {devices/lab_pin.sym} 8200 -41720 0 1 {name=p7314 lab=_82763_/D }
C {sky130_stdcells/xor2_4.sym} 8140 -41720 0 0 {name=X_78443_ }
C {devices/lab_pin.sym} 8100 -41590 0 0 {name=p7315 lab=_44835_/A }
C {devices/lab_pin.sym} 8180 -41590 0 1 {name=p7316 lab=_86929_/D }
C {sky130_stdcells/inv_2.sym} 8140 -41590 0 0 {name=X_44835_ }
C {devices/lab_pin.sym} 8080 -41480 0 0 {name=p7317 lab=_81003_/Q }
C {devices/lab_pin.sym} 8080 -41440 0 0 {name=p7318 lab=_75655_/B }
C {devices/lab_pin.sym} 8200 -41460 0 1 {name=p7319 lab=_75655_/X }
C {sky130_stdcells/xor2_4.sym} 8140 -41460 0 0 {name=X_75655_ }
C {devices/lab_pin.sym} 8080 -41350 0 0 {name=p7320 lab=_64102_/B }
C {devices/lab_pin.sym} 8080 -41310 0 0 {name=p7321 lab=_60881_/B }
C {devices/lab_pin.sym} 8080 -41270 0 0 {name=p7322 lab=_60880_/X }
C {devices/lab_pin.sym} 8200 -41310 0 1 {name=p7323 lab=_60881_/Y }
C {sky130_stdcells/nand3_4.sym} 8140 -41310 0 0 {name=X_60881_ }
C {devices/lab_pin.sym} 8060 -41190 0 0 {name=p7324 lab=_69627_/B }
C {devices/lab_pin.sym} 8060 -41150 0 0 {name=p7325 lab=_72865_/X }
C {devices/lab_pin.sym} 8060 -41110 0 0 {name=p7326 lab=_72866_/X }
C {devices/lab_pin.sym} 8220 -41150 0 1 {name=p7327 lab=_72867_/X }
C {sky130_stdcells/o21a_4.sym} 8140 -41150 0 0 {name=X_72867_ }
C {devices/lab_pin.sym} 8080 -41030 0 0 {name=p7328 lab=_62620_/A }
C {devices/lab_pin.sym} 8080 -40990 0 0 {name=p7329 lab=_63703_/B }
C {devices/lab_pin.sym} 8080 -40950 0 0 {name=p7330 lab=_62532_/X }
C {devices/lab_pin.sym} 8200 -40990 0 1 {name=p7331 lab=_62622_/C }
C {sky130_stdcells/nand3_4.sym} 8140 -40990 0 0 {name=X_62620_ }
C {devices/lab_pin.sym} 8060 -40880 0 0 {name=p7332 lab=_74605_/X }
C {devices/lab_pin.sym} 8060 -40840 0 0 {name=p7333 lab=_74599_/X }
C {devices/lab_pin.sym} 8060 -40800 0 0 {name=p7334 lab=_56134_/A }
C {devices/lab_pin.sym} 8060 -40760 0 0 {name=p7335 lab=_74600_/X }
C {devices/lab_pin.sym} 8220 -40820 0 1 {name=p7336 lab=_74606_/X }
C {sky130_stdcells/a211o_4.sym} 8140 -40820 0 0 {name=X_74606_ }
C {devices/lab_pin.sym} 8060 -40690 0 0 {name=p7337 lab=_72162_/A }
C {devices/lab_pin.sym} 8060 -40650 0 0 {name=p7338 lab=_47524_/X }
C {devices/lab_pin.sym} 8060 -40610 0 0 {name=p7339 lab=_47553_/Y }
C {devices/lab_pin.sym} 8220 -40650 0 1 {name=p7340 lab=_47554_/Y }
C {sky130_stdcells/o21ai_4.sym} 8140 -40650 0 0 {name=X_47554_ }
C {devices/lab_pin.sym} 8060 -40530 0 0 {name=p7341 lab=_71804_/Y }
C {devices/lab_pin.sym} 8060 -40490 0 0 {name=p7342 lab=_83364_/Q }
C {devices/lab_pin.sym} 8060 -40450 0 0 {name=p7343 lab=_71817_/X }
C {devices/lab_pin.sym} 8220 -40490 0 1 {name=p7344 lab=_83364_/D }
C {sky130_stdcells/a21o_4.sym} 8140 -40490 0 0 {name=X_71818_ }
C {devices/lab_pin.sym} 8060 -40370 0 0 {name=p7345 lab=_78375_/A }
C {devices/lab_pin.sym} 8060 -40330 0 0 {name=p7346 lab=_78375_/C }
C {devices/lab_pin.sym} 8060 -40290 0 0 {name=p7347 lab=_78375_/B }
C {devices/lab_pin.sym} 8220 -40330 0 1 {name=p7348 lab=_78374_/X }
C {sky130_stdcells/a21o_4.sym} 8140 -40330 0 0 {name=X_78374_ }
C {devices/lab_pin.sym} 8100 -40190 0 0 {name=p7349 lab=_44528_/A }
C {devices/lab_pin.sym} 8180 -40190 0 1 {name=p7350 lab=_44766_/X }
C {sky130_stdcells/buf_2.sym} 8140 -40190 0 0 {name=X_44766_ }
C {devices/lab_pin.sym} 8080 -40080 0 0 {name=p7351 lab=_75586_/A }
C {devices/lab_pin.sym} 8080 -40040 0 0 {name=p7352 lab=_75585_/Y }
C {devices/lab_pin.sym} 8200 -40060 0 1 {name=p7353 lab=_75587_/B }
C {sky130_stdcells/xnor2_4.sym} 8140 -40060 0 0 {name=X_75586_ }
C {devices/lab_pin.sym} 8060 -39970 0 0 {name=p7354 lab=_41960_/X }
C {devices/lab_pin.sym} 8060 -39930 0 0 {name=p7355 lab=_41951_/X }
C {devices/lab_pin.sym} 8060 -39890 0 0 {name=p7356 lab=_40762_/X }
C {devices/lab_pin.sym} 8060 -39850 0 0 {name=p7357 lab=_88084_/Q }
C {devices/lab_pin.sym} 8060 -39810 0 0 {name=p7358 lab=_41953_/X }
C {devices/lab_pin.sym} 8220 -39890 0 1 {name=p7359 lab=_41978_/Y }
C {sky130_stdcells/o32ai_4.sym} 8140 -39890 0 0 {name=X_41978_ }
C {devices/lab_pin.sym} 8100 -39730 0 0 {name=p7360 lab=_44130_/X }
C {devices/lab_pin.sym} 8180 -39730 0 1 {name=p7361 lab=_72798_/X }
C {sky130_stdcells/buf_2.sym} 8140 -39730 0 0 {name=X_72798_ }
C {devices/lab_pin.sym} 8080 -39620 0 0 {name=p7362 lab=_46505_/A }
C {devices/lab_pin.sym} 8080 -39580 0 0 {name=p7363 lab=_49110_/A }
C {devices/lab_pin.sym} 8200 -39600 0 1 {name=p7364 lab=_46505_/Y }
C {sky130_stdcells/nand2_4.sym} 8140 -39600 0 0 {name=X_46505_ }
C {devices/lab_pin.sym} 8100 -39470 0 0 {name=p7365 lab=_77325_/A }
C {devices/lab_pin.sym} 8180 -39470 0 1 {name=p7366 lab=_77325_/Y }
C {sky130_stdcells/inv_2.sym} 8140 -39470 0 0 {name=X_77325_ }
C {devices/lab_pin.sym} 8100 -39350 0 0 {name=p7367 lab=_43717_/A }
C {devices/lab_pin.sym} 8180 -39350 0 1 {name=p7368 lab=_69808_/B }
C {sky130_stdcells/inv_2.sym} 8140 -39350 0 0 {name=X_43717_ }
C {devices/lab_pin.sym} 8100 -39230 0 0 {name=p7369 lab=_62671_/A }
C {devices/lab_pin.sym} 8180 -39230 0 1 {name=p7370 lab=_62551_/X }
C {sky130_stdcells/buf_2.sym} 8140 -39230 0 0 {name=X_62551_ }
C {devices/lab_pin.sym} 8100 -39110 0 0 {name=p7371 lab=_74600_/A }
C {devices/lab_pin.sym} 8180 -39110 0 1 {name=p7372 lab=_74537_/Y }
C {sky130_stdcells/inv_2.sym} 8140 -39110 0 0 {name=X_74537_ }
C {devices/lab_pin.sym} 8100 -38990 0 0 {name=p7373 lab=_40929_/A }
C {devices/lab_pin.sym} 8180 -38990 0 1 {name=p7374 lab=_40929_/X }
C {sky130_stdcells/buf_2.sym} 8140 -38990 0 0 {name=X_40929_ }
C {devices/lab_pin.sym} 8080 -38900 0 0 {name=p7375 lab=_71175_/A }
C {devices/lab_pin.sym} 8080 -38860 0 0 {name=p7376 lab=_71753_/B }
C {devices/lab_pin.sym} 8080 -38820 0 0 {name=p7377 lab=_71744_/C }
C {devices/lab_pin.sym} 8080 -38780 0 0 {name=p7378 lab=_71744_/D }
C {devices/lab_pin.sym} 8200 -38840 0 1 {name=p7379 lab=_71749_/Y }
C {sky130_stdcells/nand4_4.sym} 8140 -38840 0 0 {name=X_71749_ }
C {devices/lab_pin.sym} 8100 -38690 0 0 {name=p7380 lab=_47485_/A }
C {devices/lab_pin.sym} 8180 -38690 0 1 {name=p7381 lab=_47486_/A }
C {sky130_stdcells/inv_2.sym} 8140 -38690 0 0 {name=X_47485_ }
C {devices/lab_pin.sym} 8100 -38570 0 0 {name=p7382 lab=_44697_/A }
C {devices/lab_pin.sym} 8180 -38570 0 1 {name=p7383 lab=_44697_/Y }
C {sky130_stdcells/inv_2.sym} 8140 -38570 0 0 {name=X_44697_ }
C {devices/lab_pin.sym} 8080 -38480 0 0 {name=p7384 lab=_61502_/A }
C {devices/lab_pin.sym} 8080 -38440 0 0 {name=p7385 lab=_61468_/B }
C {devices/lab_pin.sym} 8080 -38400 0 0 {name=p7386 lab=_61467_/X }
C {devices/lab_pin.sym} 8080 -38360 0 0 {name=p7387 lab=_61451_/D }
C {devices/lab_pin.sym} 8200 -38420 0 1 {name=p7388 lab=_61502_/Y }
C {sky130_stdcells/nand4_4.sym} 8140 -38420 0 0 {name=X_61502_ }
C {devices/lab_pin.sym} 8080 -38280 0 0 {name=p7389 lab=_49241_/A }
C {devices/lab_pin.sym} 8080 -38240 0 0 {name=p7390 lab=_50744_/B }
C {devices/lab_pin.sym} 8200 -38260 0 1 {name=p7391 lab=_49224_/Y }
C {sky130_stdcells/nand2_4.sym} 8140 -38260 0 0 {name=X_49224_ }
C {devices/lab_pin.sym} 8080 -38140 0 0 {name=p7392 lab=_46436_/A }
C {devices/lab_pin.sym} 8080 -38100 0 0 {name=p7393 lab=_46459_/B }
C {devices/lab_pin.sym} 8200 -38120 0 1 {name=p7394 lab=_46436_/X }
C {sky130_stdcells/or2_4.sym} 8140 -38120 0 0 {name=X_46436_ }
C {devices/lab_pin.sym} 8080 -38000 0 0 {name=p7395 lab=_65225_/A }
C {devices/lab_pin.sym} 8080 -37960 0 0 {name=p7396 lab=_65270_/B }
C {devices/lab_pin.sym} 8200 -37980 0 1 {name=p7397 lab=_65270_/X }
C {sky130_stdcells/and2_4.sym} 8140 -37980 0 0 {name=X_65270_ }
C {devices/lab_pin.sym} 8080 -37860 0 0 {name=p7398 lab=_77245_/C }
C {devices/lab_pin.sym} 8080 -37820 0 0 {name=p7399 lab=_77239_/C }
C {devices/lab_pin.sym} 8200 -37840 0 1 {name=p7400 lab=_77258_/A }
C {sky130_stdcells/nand2_4.sym} 8140 -37840 0 0 {name=X_77256_ }
C {devices/lab_pin.sym} 8100 -37710 0 0 {name=p7401 lab=_87327_/Q }
C {devices/lab_pin.sym} 8180 -37710 0 1 {name=p7402 lab=_68861_/B }
C {sky130_stdcells/inv_2.sym} 8140 -37710 0 0 {name=X_43648_ }
C {devices/lab_pin.sym} 8100 -37590 0 0 {name=p7403 lab=_61412_/A }
C {devices/lab_pin.sym} 8180 -37590 0 1 {name=p7404 lab=_62671_/A }
C {sky130_stdcells/buf_2.sym} 8140 -37590 0 0 {name=X_62482_ }
C {devices/lab_pin.sym} 8080 -37480 0 0 {name=p7405 lab=_46347_/A }
C {devices/lab_pin.sym} 8080 -37440 0 0 {name=p7406 lab=_50503_/B }
C {devices/lab_pin.sym} 8200 -37460 0 1 {name=p7407 lab=_74468_/Y }
C {sky130_stdcells/nand2_4.sym} 8140 -37460 0 0 {name=X_74468_ }
C {devices/lab_pin.sym} 8100 -37330 0 0 {name=p7408 lab=_64221_/A }
C {devices/lab_pin.sym} 8180 -37330 0 1 {name=p7409 lab=_64221_/X }
C {sky130_stdcells/buf_2.sym} 8140 -37330 0 0 {name=X_64221_ }
C {devices/lab_pin.sym} 8080 -37230 0 0 {name=p7410 lab=_76205_/Y }
C {devices/lab_pin.sym} 8080 -37190 0 0 {name=p7411 lab=_76202_/X }
C {devices/lab_pin.sym} 8080 -37150 0 0 {name=p7412 lab=_76219_/A }
C {devices/lab_pin.sym} 8200 -37190 0 1 {name=p7413 lab=_76207_/Y }
C {sky130_stdcells/nand3_4.sym} 8140 -37190 0 0 {name=X_76207_ }
C {devices/lab_pin.sym} 8100 -37050 0 0 {name=p7414 lab=_49416_/A }
C {devices/lab_pin.sym} 8180 -37050 0 1 {name=p7415 lab=_49205_/A }
C {sky130_stdcells/buf_2.sym} 8140 -37050 0 0 {name=X_49155_ }
C {devices/lab_pin.sym} 8060 -36970 0 0 {name=p7416 lab=_61427_/Y }
C {devices/lab_pin.sym} 8060 -36930 0 0 {name=p7417 lab=_61429_/Y }
C {devices/lab_pin.sym} 8060 -36890 0 0 {name=p7418 lab=_61403_/X }
C {devices/lab_pin.sym} 8060 -36850 0 0 {name=p7419 lab=_61430_/Y }
C {devices/lab_pin.sym} 8060 -36820 0 0 {name=p7420 lab=_61432_/Y }
C {devices/lab_pin.sym} 8220 -36890 0 1 {name=p7421 lab=_61433_/X }
C {sky130_stdcells/a41o_4.sym} 8140 -36890 0 0 {name=X_61433_ }
C {devices/lab_pin.sym} 8060 -36750 0 0 {name=p7422 lab=_73416_/X }
C {devices/lab_pin.sym} 8060 -36710 0 0 {name=p7423 lab=_73418_/X }
C {devices/lab_pin.sym} 8060 -36670 0 0 {name=p7424 lab=_73347_/X }
C {devices/lab_pin.sym} 8220 -36710 0 1 {name=p7425 lab=_73434_/B }
C {sky130_stdcells/a21o_4.sym} 8140 -36710 0 0 {name=X_73419_ }
C {devices/lab_pin.sym} 8100 -36570 0 0 {name=p7426 lab=_83647_/Q }
C {devices/lab_pin.sym} 8180 -36570 0 1 {name=p7427 lab=_46367_/Y }
C {sky130_stdcells/inv_2.sym} 8140 -36570 0 0 {name=X_46367_ }
C {devices/lab_pin.sym} 8080 -36460 0 0 {name=p7428 lab=_82011_/Q }
C {devices/lab_pin.sym} 8080 -36420 0 0 {name=p7429 lab=_82299_/D }
C {devices/lab_pin.sym} 8200 -36440 0 1 {name=p7430 lab=_77187_/Y }
C {sky130_stdcells/nor2_4.sym} 8140 -36440 0 0 {name=X_77187_ }
C {devices/lab_pin.sym} 8060 -36340 0 0 {name=p7431 lab=_40542_/X }
C {devices/lab_pin.sym} 8060 -36300 0 0 {name=p7432 lab=_53455_/A }
C {devices/lab_pin.sym} 8060 -36260 0 0 {name=p7433 lab=_87349_/Q }
C {devices/lab_pin.sym} 8060 -36220 0 0 {name=p7434 lab=_43185_/A }
C {devices/lab_pin.sym} 8220 -36280 0 1 {name=p7435 lab=_43579_/X }
C {sky130_stdcells/a2bb2o_4.sym} 8140 -36280 0 0 {name=X_43579_ }
C {devices/lab_pin.sym} 8060 -36150 0 0 {name=p7436 lab=_83074_/Q }
C {devices/lab_pin.sym} 8060 -36110 0 0 {name=p7437 lab=_74377_/X }
C {devices/lab_pin.sym} 8060 -36070 0 0 {name=p7438 lab=_74398_/Y }
C {devices/lab_pin.sym} 8220 -36110 0 1 {name=p7439 lab=_74399_/Y }
C {sky130_stdcells/o21ai_4.sym} 8140 -36110 0 0 {name=X_74399_ }
C {devices/lab_pin.sym} 8100 -35970 0 0 {name=p7440 lab=_53588_/B }
C {devices/lab_pin.sym} 8180 -35970 0 1 {name=p7441 lab=_50365_/B }
C {sky130_stdcells/buf_2.sym} 8140 -35970 0 0 {name=X_48106_ }
C {devices/lab_pin.sym} 8100 -35850 0 0 {name=p7442 lab=_83014_/Q }
C {devices/lab_pin.sym} 8180 -35850 0 1 {name=p7443 lab=_45319_/A }
C {sky130_stdcells/inv_2.sym} 8140 -35850 0 0 {name=X_45318_ }
C {devices/lab_pin.sym} 8060 -35770 0 0 {name=p7444 lab=_64147_/X }
C {devices/lab_pin.sym} 8060 -35730 0 0 {name=p7445 lab=_64048_/X }
C {devices/lab_pin.sym} 8060 -35690 0 0 {name=p7446 lab=_64149_/Y }
C {devices/lab_pin.sym} 8060 -35650 0 0 {name=p7447 lab=_64150_/Y }
C {devices/lab_pin.sym} 8060 -35620 0 0 {name=p7448 lab=_64151_/X }
C {devices/lab_pin.sym} 8220 -35690 0 1 {name=p7449 lab=_64152_/X }
C {sky130_stdcells/a41o_4.sym} 8140 -35690 0 0 {name=X_64152_ }
C {devices/lab_pin.sym} 8080 -35540 0 0 {name=p7450 lab=_81727_/D }
C {devices/lab_pin.sym} 8080 -35500 0 0 {name=p7451 lab=_76139_/B }
C {devices/lab_pin.sym} 8200 -35520 0 1 {name=p7452 lab=_76138_/Y }
C {sky130_stdcells/nor2_4.sym} 8140 -35520 0 0 {name=X_76138_ }
C {devices/lab_pin.sym} 8100 -35390 0 0 {name=p7453 lab=_48985_/A }
C {devices/lab_pin.sym} 8180 -35390 0 1 {name=p7454 lab=_49086_/X }
C {sky130_stdcells/buf_2.sym} 8140 -35390 0 0 {name=X_49086_ }
C {devices/lab_pin.sym} 8080 -35290 0 0 {name=p7455 lab=_61329_/A }
C {devices/lab_pin.sym} 8080 -35250 0 0 {name=p7456 lab=_61364_/B }
C {devices/lab_pin.sym} 8080 -35210 0 0 {name=p7457 lab=_61375_/C }
C {devices/lab_pin.sym} 8200 -35250 0 1 {name=p7458 lab=_61364_/Y }
C {sky130_stdcells/nand3_4.sym} 8140 -35250 0 0 {name=X_61364_ }
C {devices/lab_pin.sym} 8100 -35110 0 0 {name=p7459 lab=_46298_/A }
C {devices/lab_pin.sym} 8180 -35110 0 1 {name=p7460 lab=_46653_/A }
C {sky130_stdcells/buf_2.sym} 8140 -35110 0 0 {name=X_46298_ }
C {devices/lab_pin.sym} 8080 -35020 0 0 {name=p7461 lab=_63103_/A }
C {devices/lab_pin.sym} 8080 -34980 0 0 {name=p7462 lab=_63081_/B }
C {devices/lab_pin.sym} 8080 -34940 0 0 {name=p7463 lab=_63103_/C }
C {devices/lab_pin.sym} 8080 -34900 0 0 {name=p7464 lab=_63092_/D }
C {devices/lab_pin.sym} 8200 -34960 0 1 {name=p7465 lab=_63103_/X }
C {sky130_stdcells/or4_4.sym} 8140 -34960 0 0 {name=X_63103_ }
C {devices/lab_pin.sym} 8080 -34830 0 0 {name=p7466 lab=_48287_/A }
C {devices/lab_pin.sym} 8080 -34790 0 0 {name=p7467 lab=_48069_/B }
C {devices/lab_pin.sym} 8080 -34750 0 0 {name=p7468 lab=_47919_/X }
C {devices/lab_pin.sym} 8200 -34790 0 1 {name=p7469 lab=_48037_/X }
C {sky130_stdcells/and3_4.sym} 8140 -34790 0 0 {name=X_48037_ }
C {devices/lab_pin.sym} 8060 -34690 0 0 {name=p7470 lab=_60198_/Y }
C {devices/lab_pin.sym} 8060 -34650 0 0 {name=p7471 lab=_60174_/X }
C {devices/lab_pin.sym} 8060 -34610 0 0 {name=p7472 lab=_60241_/A }
C {devices/lab_pin.sym} 8060 -34570 0 0 {name=p7473 lab=_60313_/Y }
C {devices/lab_pin.sym} 8060 -34540 0 0 {name=p7474 lab=_60314_/Y }
C {devices/lab_pin.sym} 8220 -34610 0 1 {name=p7475 lab=_60315_/X }
C {sky130_stdcells/a41o_4.sym} 8140 -34610 0 0 {name=X_60315_ }
C {devices/lab_pin.sym} 8060 -34470 0 0 {name=p7476 lab=_45242_/X }
C {devices/lab_pin.sym} 8060 -34430 0 0 {name=p7477 lab=_45246_/Y }
C {devices/lab_pin.sym} 8060 -34390 0 0 {name=p7478 lab=_45248_/Y }
C {devices/lab_pin.sym} 8220 -34430 0 1 {name=p7479 lab=_45249_/Y }
C {sky130_stdcells/a21oi_4.sym} 8140 -34430 0 0 {name=X_45249_ }
C {devices/lab_pin.sym} 8060 -34310 0 0 {name=p7480 lab=_61582_/A }
C {devices/lab_pin.sym} 8060 -34270 0 0 {name=p7481 lab=_60967_/A }
C {devices/lab_pin.sym} 8060 -34230 0 0 {name=p7482 lab=_64082_/Y }
C {devices/lab_pin.sym} 8220 -34270 0 1 {name=p7483 lab=_64083_/X }
C {sky130_stdcells/a21o_4.sym} 8140 -34270 0 0 {name=X_64083_ }
C {devices/lab_pin.sym} 8060 -34160 0 0 {name=p7484 lab=_74123_/A }
C {devices/lab_pin.sym} 8060 -34120 0 0 {name=p7485 lab=_68958_/X }
C {devices/lab_pin.sym} 8060 -34080 0 0 {name=p7486 lab=_68494_/X }
C {devices/lab_pin.sym} 8060 -34040 0 0 {name=p7487 lab=_68959_/Y }
C {devices/lab_pin.sym} 8220 -34100 0 1 {name=p7488 lab=_68960_/X }
C {sky130_stdcells/a211o_4.sym} 8140 -34100 0 0 {name=X_68960_ }
C {devices/lab_pin.sym} 8080 -33960 0 0 {name=p7489 lab=_81526_/Q }
C {devices/lab_pin.sym} 8080 -33920 0 0 {name=p7490 lab=_76069_/B }
C {devices/lab_pin.sym} 8200 -33940 0 1 {name=p7491 lab=_76069_/X }
C {sky130_stdcells/xor2_4.sym} 8140 -33940 0 0 {name=X_76069_ }
C {devices/lab_pin.sym} 8080 -33820 0 0 {name=p7492 lab=_61295_/A }
C {devices/lab_pin.sym} 8080 -33780 0 0 {name=p7493 lab=_72540_/B }
C {devices/lab_pin.sym} 8200 -33800 0 1 {name=p7494 lab=_61302_/A }
C {sky130_stdcells/nor2_4.sym} 8140 -33800 0 0 {name=X_61295_ }
C {devices/lab_pin.sym} 8080 -33680 0 0 {name=p7495 lab=_67905_/X }
C {devices/lab_pin.sym} 8080 -33640 0 0 {name=p7496 lab=_67911_/B }
C {devices/lab_pin.sym} 8200 -33660 0 1 {name=p7497 lab=_67911_/Y }
C {sky130_stdcells/nand2_4.sym} 8140 -33660 0 0 {name=X_67911_ }
C {devices/lab_pin.sym} 8060 -33550 0 0 {name=p7498 lab=_63031_/Y }
C {devices/lab_pin.sym} 8060 -33510 0 0 {name=p7499 lab=_63033_/X }
C {devices/lab_pin.sym} 8060 -33470 0 0 {name=p7500 lab=_61194_/X }
C {devices/lab_pin.sym} 8220 -33510 0 1 {name=p7501 lab=_63034_/Y }
C {sky130_stdcells/a21oi_4.sym} 8140 -33510 0 0 {name=X_63034_ }
C {devices/lab_pin.sym} 8100 -33370 0 0 {name=p7502 lab=_59043_/A }
C {devices/lab_pin.sym} 8180 -33370 0 1 {name=p7503 lab=_60246_/X }
C {sky130_stdcells/buf_2.sym} 8140 -33370 0 0 {name=X_60246_ }
C {devices/lab_pin.sym} 8100 -33250 0 0 {name=p7504 lab=_44245_/A }
C {devices/lab_pin.sym} 8180 -33250 0 1 {name=p7505 lab=_68891_/X }
C {sky130_stdcells/buf_2.sym} 8140 -33250 0 0 {name=X_68891_ }
C {devices/lab_pin.sym} 8080 -33140 0 0 {name=p7506 lab=_79840_/A }
C {devices/lab_pin.sym} 8080 -33100 0 0 {name=p7507 lab=_79827_/Y }
C {devices/lab_pin.sym} 8200 -33120 0 1 {name=p7508 lab=_79828_/Y }
C {sky130_stdcells/xnor2_4.sym} 8140 -33120 0 0 {name=X_79828_ }
C {devices/lab_pin.sym} 8080 -33000 0 0 {name=p7509 lab=_67842_/A }
C {devices/lab_pin.sym} 8080 -32960 0 0 {name=p7510 lab=_67842_/B }
C {devices/lab_pin.sym} 8200 -32980 0 1 {name=p7511 lab=_67842_/Y }
C {sky130_stdcells/nand2_4.sym} 8140 -32980 0 0 {name=X_67842_ }
C {devices/lab_pin.sym} 8080 -32860 0 0 {name=p7512 lab=_60174_/X }
C {devices/lab_pin.sym} 8080 -32820 0 0 {name=p7513 lab=_61316_/A }
C {devices/lab_pin.sym} 8200 -32840 0 1 {name=p7514 lab=_60177_/X }
C {sky130_stdcells/and2_4.sym} 8140 -32840 0 0 {name=X_60177_ }
C {devices/lab_pin.sym} 8080 -32720 0 0 {name=p7515 lab=_50001_/A }
C {devices/lab_pin.sym} 8080 -32680 0 0 {name=p7516 lab=_53200_/B }
C {devices/lab_pin.sym} 8200 -32700 0 1 {name=p7517 lab=_49988_/Y }
C {sky130_stdcells/nand2_4.sym} 8140 -32700 0 0 {name=X_49988_ }
C {devices/lab_pin.sym} 8100 -32570 0 0 {name=p7518 lab=_48635_/A }
C {devices/lab_pin.sym} 8180 -32570 0 1 {name=p7519 lab=_48940_/B }
C {sky130_stdcells/buf_2.sym} 8140 -32570 0 0 {name=X_48939_ }
C {devices/lab_pin.sym} 8080 -32460 0 0 {name=p7520 lab=_67678_/X }
C {devices/lab_pin.sym} 8080 -32420 0 0 {name=p7521 lab=_67773_/B }
C {devices/lab_pin.sym} 8200 -32440 0 1 {name=p7522 lab=_67773_/X }
C {sky130_stdcells/and2_4.sym} 8140 -32440 0 0 {name=X_67773_ }
C {devices/lab_pin.sym} 8060 -32330 0 0 {name=p7523 lab=_79745_/Y }
C {devices/lab_pin.sym} 8060 -32290 0 0 {name=p7524 lab=_79750_/Y }
C {devices/lab_pin.sym} 8060 -32250 0 0 {name=p7525 lab=_79758_/X }
C {devices/lab_pin.sym} 8220 -32290 0 1 {name=p7526 lab=_79760_/B }
C {sky130_stdcells/o21ai_4.sym} 8140 -32290 0 0 {name=X_79759_ }
C {devices/lab_pin.sym} 8060 -32180 0 0 {name=p7527 lab=_64752_/X }
C {devices/lab_pin.sym} 8060 -32140 0 0 {name=p7528 lab=_86163_/Q }
C {devices/lab_pin.sym} 8060 -32100 0 0 {name=p7529 lab=_64902_/X }
C {devices/lab_pin.sym} 8060 -32060 0 0 {name=p7530 lab=_64984_/X }
C {devices/lab_pin.sym} 8220 -32120 0 1 {name=p7531 lab=_64985_/X }
C {sky130_stdcells/a211o_4.sym} 8140 -32120 0 0 {name=X_64985_ }
C {devices/lab_pin.sym} 8100 -31970 0 0 {name=p7532 lab=_69223_/A }
C {devices/lab_pin.sym} 8180 -31970 0 1 {name=p7533 lab=_69586_/A }
C {sky130_stdcells/buf_2.sym} 8140 -31970 0 0 {name=X_69512_ }
C {devices/lab_pin.sym} 8080 -31860 0 0 {name=p7534 lab=_66819_/A }
C {devices/lab_pin.sym} 8080 -31820 0 0 {name=p7535 lab=_86832_/Q }
C {devices/lab_pin.sym} 8200 -31840 0 1 {name=p7536 lab=_66724_/X }
C {sky130_stdcells/and2_4.sym} 8140 -31840 0 0 {name=X_66724_ }
C {devices/lab_pin.sym} 8100 -31710 0 0 {name=p7537 lab=_52618_/A }
C {devices/lab_pin.sym} 8180 -31710 0 1 {name=p7538 lab=_52486_/A }
C {sky130_stdcells/buf_2.sym} 8140 -31710 0 0 {name=X_51950_ }
C {devices/lab_pin.sym} 8100 -31590 0 0 {name=p7539 lab=clkbuf_8_65_0_CLK/A }
C {devices/lab_pin.sym} 8180 -31590 0 1 {name=p7540 lab=clkbuf_8_64_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 8140 -31590 0 0 {name=Xclkbuf_8_64_0_CLK }
C {devices/lab_pin.sym} 8100 -31470 0 0 {name=p7541 lab=_60926_/X }
C {devices/lab_pin.sym} 8180 -31470 0 1 {name=p7542 lab=_64015_/D }
C {sky130_stdcells/buf_2.sym} 8140 -31470 0 0 {name=X_63936_ }
C {devices/lab_pin.sym} 8050 -31350 0 0 {name=p7543 lab=_82961_/CLK }
C {devices/lab_pin.sym} 8050 -31330 0 0 {name=p7544 lab=_82770_/D }
C {devices/lab_pin.sym} 8230 -31350 0 1 {name=p7545 lab=_82770_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -31340 0 0 {name=X_82770_ }
C {devices/lab_pin.sym} 8060 -31230 0 0 {name=p7546 lab=_86110_/Q }
C {devices/lab_pin.sym} 8060 -31190 0 0 {name=p7547 lab=_50882_/X }
C {devices/lab_pin.sym} 8060 -31150 0 0 {name=p7548 lab=_50900_/Y }
C {devices/lab_pin.sym} 8220 -31190 0 1 {name=p7549 lab=_50901_/Y }
C {sky130_stdcells/o21ai_4.sym} 8140 -31190 0 0 {name=X_50901_ }
C {devices/lab_pin.sym} 8050 -31050 0 0 {name=p7550 lab=_81412_/CLK }
C {devices/lab_pin.sym} 8050 -31030 0 0 {name=p7551 lab=_81721_/D }
C {devices/lab_pin.sym} 8230 -31050 0 1 {name=p7552 lab=_81721_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -31040 0 0 {name=X_81721_ }
C {devices/lab_pin.sym} 8080 -30920 0 0 {name=p7553 lab=_69288_/A }
C {devices/lab_pin.sym} 8080 -30880 0 0 {name=p7554 lab=_69443_/B }
C {devices/lab_pin.sym} 8200 -30900 0 1 {name=p7555 lab=_69443_/X }
C {sky130_stdcells/and2_4.sym} 8140 -30900 0 0 {name=X_69443_ }
C {devices/lab_pin.sym} 8060 -30790 0 0 {name=p7556 lab=_66652_/X }
C {devices/lab_pin.sym} 8060 -30750 0 0 {name=p7557 lab=_66654_/X }
C {devices/lab_pin.sym} 8060 -30710 0 0 {name=p7558 lab=_66606_/X }
C {devices/lab_pin.sym} 8220 -30750 0 1 {name=p7559 lab=_66655_/X }
C {sky130_stdcells/a21o_4.sym} 8140 -30750 0 0 {name=X_66655_ }
C {devices/lab_pin.sym} 8060 -30630 0 0 {name=p7560 lab=_85929_/Q }
C {devices/lab_pin.sym} 8060 -30590 0 0 {name=p7561 lab=_51873_/X }
C {devices/lab_pin.sym} 8060 -30550 0 0 {name=p7562 lab=_51880_/Y }
C {devices/lab_pin.sym} 8220 -30590 0 1 {name=p7563 lab=_51881_/Y }
C {sky130_stdcells/o21ai_4.sym} 8140 -30590 0 0 {name=X_51881_ }
C {devices/lab_pin.sym} 8080 -30480 0 0 {name=p7564 lab=_61430_/A }
C {devices/lab_pin.sym} 8080 -30440 0 0 {name=p7565 lab=_63853_/B }
C {devices/lab_pin.sym} 8080 -30400 0 0 {name=p7566 lab=_63803_/C }
C {devices/lab_pin.sym} 8080 -30360 0 0 {name=p7567 lab=_63866_/X }
C {devices/lab_pin.sym} 8200 -30420 0 1 {name=p7568 lab=_63867_/Y }
C {sky130_stdcells/nand4_4.sym} 8140 -30420 0 0 {name=X_63867_ }
C {devices/lab_pin.sym} 8080 -30290 0 0 {name=p7569 lab=_53620_/A }
C {devices/lab_pin.sym} 8080 -30250 0 0 {name=p7570 lab=_53620_/B }
C {devices/lab_pin.sym} 8080 -30210 0 0 {name=p7571 lab=_53620_/C }
C {devices/lab_pin.sym} 8200 -30250 0 1 {name=p7572 lab=_53620_/X }
C {sky130_stdcells/and3_4.sym} 8140 -30250 0 0 {name=X_53620_ }
C {devices/lab_pin.sym} 8060 -30130 0 0 {name=p7573 lab=_65601_/Y }
C {devices/lab_pin.sym} 8060 -30090 0 0 {name=p7574 lab=_65602_/X }
C {devices/lab_pin.sym} 8060 -30050 0 0 {name=p7575 lab=_65605_/Y }
C {devices/lab_pin.sym} 8220 -30090 0 1 {name=p7576 lab=_65606_/X }
C {sky130_stdcells/a21o_4.sym} 8140 -30090 0 0 {name=X_65606_ }
C {devices/lab_pin.sym} 8050 -29950 0 0 {name=p7577 lab=_82221_/CLK }
C {devices/lab_pin.sym} 8050 -29930 0 0 {name=p7578 lab=_84440_/D }
C {devices/lab_pin.sym} 8230 -29950 0 1 {name=p7579 lab=_78063_/B }
C {sky130_stdcells/dfxtp_4.sym} 8140 -29940 0 0 {name=X_84440_ }
C {devices/lab_pin.sym} 8080 -29820 0 0 {name=p7580 lab=_50822_/A }
C {devices/lab_pin.sym} 8080 -29780 0 0 {name=p7581 lab=_50832_/B }
C {devices/lab_pin.sym} 8200 -29800 0 1 {name=p7582 lab=_50832_/Y }
C {sky130_stdcells/nand2_4.sym} 8140 -29800 0 0 {name=X_50832_ }
C {devices/lab_pin.sym} 8100 -29670 0 0 {name=p7583 lab=_60211_/A }
C {devices/lab_pin.sym} 8180 -29670 0 1 {name=p7584 lab=_62818_/X }
C {sky130_stdcells/buf_2.sym} 8140 -29670 0 0 {name=X_62818_ }
C {devices/lab_pin.sym} 8050 -29550 0 0 {name=p7585 lab=_81330_/CLK }
C {devices/lab_pin.sym} 8050 -29530 0 0 {name=p7586 lab=_81684_/Q }
C {devices/lab_pin.sym} 8230 -29550 0 1 {name=p7587 lab=_81652_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -29540 0 0 {name=X_81652_ }
C {devices/lab_pin.sym} 8060 -29430 0 0 {name=p7588 lab=_69370_/X }
C {devices/lab_pin.sym} 8060 -29390 0 0 {name=p7589 lab=_69373_/X }
C {devices/lab_pin.sym} 8060 -29350 0 0 {name=p7590 lab=_69138_/X }
C {devices/lab_pin.sym} 8220 -29390 0 1 {name=p7591 lab=_69374_/X }
C {sky130_stdcells/a21o_4.sym} 8140 -29390 0 0 {name=X_69374_ }
C {devices/lab_pin.sym} 8060 -29280 0 0 {name=p7592 lab=_66526_/X }
C {devices/lab_pin.sym} 8060 -29240 0 0 {name=p7593 lab=_66559_/Y }
C {devices/lab_pin.sym} 8060 -29200 0 0 {name=p7594 lab=_59782_/X }
C {devices/lab_pin.sym} 8060 -29160 0 0 {name=p7595 lab=_66585_/Y }
C {devices/lab_pin.sym} 8220 -29220 0 1 {name=p7596 lab=_66586_/X }
C {sky130_stdcells/a211o_4.sym} 8140 -29220 0 0 {name=X_66586_ }
C {devices/lab_pin.sym} 8080 -29090 0 0 {name=p7597 lab=_63765_/A }
C {devices/lab_pin.sym} 8080 -29050 0 0 {name=p7598 lab=_61368_/A }
C {devices/lab_pin.sym} 8080 -29010 0 0 {name=p7599 lab=_63765_/C }
C {devices/lab_pin.sym} 8200 -29050 0 1 {name=p7600 lab=_63798_/X }
C {sky130_stdcells/and3_4.sym} 8140 -29050 0 0 {name=X_63798_ }
C {devices/lab_pin.sym} 8060 -28930 0 0 {name=p7601 lab=_80587_/X }
C {devices/lab_pin.sym} 8060 -28890 0 0 {name=p7602 lab=_80589_/B }
C {devices/lab_pin.sym} 8060 -28850 0 0 {name=p7603 lab=_80602_/Y }
C {devices/lab_pin.sym} 8220 -28890 0 1 {name=p7604 lab=_80607_/A }
C {sky130_stdcells/a21boi_4.sym} 8140 -28890 0 0 {name=X_80603_ }
C {devices/lab_pin.sym} 8060 -28770 0 0 {name=p7605 lab=_83982_/Q }
C {devices/lab_pin.sym} 8060 -28730 0 0 {name=p7606 lab=_68318_/X }
C {devices/lab_pin.sym} 8060 -28690 0 0 {name=p7607 lab=_68324_/X }
C {devices/lab_pin.sym} 8220 -28730 0 1 {name=p7608 lab=_83982_/D }
C {sky130_stdcells/a21bo_4.sym} 8140 -28730 0 0 {name=X_68325_ }
C {devices/lab_pin.sym} 8100 -28590 0 0 {name=p7609 lab=clkbuf_8_79_0_CLK/A }
C {devices/lab_pin.sym} 8180 -28590 0 1 {name=p7610 lab=clkbuf_8_79_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 8140 -28590 0 0 {name=Xclkbuf_8_79_0_CLK }
C {devices/lab_pin.sym} 8080 -28480 0 0 {name=p7611 lab=_65592_/A }
C {devices/lab_pin.sym} 8080 -28440 0 0 {name=p7612 lab=_72960_/B }
C {devices/lab_pin.sym} 8200 -28460 0 1 {name=p7613 lab=_65537_/X }
C {sky130_stdcells/and2_4.sym} 8140 -28460 0 0 {name=X_65537_ }
C {devices/lab_pin.sym} 8060 -28350 0 0 {name=p7614 lab=_53549_/Y }
C {devices/lab_pin.sym} 8060 -28310 0 0 {name=p7615 lab=_53524_/X }
C {devices/lab_pin.sym} 8060 -28270 0 0 {name=p7616 lab=_53550_/Y }
C {devices/lab_pin.sym} 8220 -28310 0 1 {name=p7617 lab=_85615_/D }
C {sky130_stdcells/a21boi_4.sym} 8140 -28310 0 0 {name=X_53551_ }
C {devices/lab_pin.sym} 8050 -28170 0 0 {name=p7618 lab=_84449_/CLK }
C {devices/lab_pin.sym} 8050 -28150 0 0 {name=p7619 lab=_84371_/D }
C {devices/lab_pin.sym} 8230 -28170 0 1 {name=p7620 lab=_84371_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -28160 0 0 {name=X_84371_ }
C {devices/lab_pin.sym} 8100 -28030 0 0 {name=p7621 lab=_50718_/A }
C {devices/lab_pin.sym} 8180 -28030 0 1 {name=p7622 lab=_50764_/A }
C {sky130_stdcells/buf_2.sym} 8140 -28030 0 0 {name=X_50763_ }
C {devices/lab_pin.sym} 8050 -27910 0 0 {name=p7623 lab=_83918_/CLK }
C {devices/lab_pin.sym} 8050 -27890 0 0 {name=p7624 lab=_65713_/C }
C {devices/lab_pin.sym} 8230 -27910 0 1 {name=p7625 lab=_76771_/A }
C {sky130_stdcells/dfxtp_4.sym} 8140 -27900 0 0 {name=X_81583_ }
C {devices/lab_pin.sym} 8100 -27770 0 0 {name=p7626 lab=_60217_/A }
C {devices/lab_pin.sym} 8180 -27770 0 1 {name=p7627 lab=_62749_/X }
C {sky130_stdcells/buf_2.sym} 8140 -27770 0 0 {name=X_62749_ }
C {devices/lab_pin.sym} 8050 -27650 0 0 {name=p7628 lab=_84807_/CLK }
C {devices/lab_pin.sym} 8050 -27630 0 0 {name=p7629 lab=_50905_/Y }
C {devices/lab_pin.sym} 8230 -27650 0 1 {name=p7630 lab=_86110_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -27640 0 0 {name=X_86110_ }
C {devices/lab_pin.sym} 8080 -27520 0 0 {name=p7631 lab=_52501_/X }
C {devices/lab_pin.sym} 8080 -27480 0 0 {name=p7632 lab=_46433_/A }
C {devices/lab_pin.sym} 8200 -27500 0 1 {name=p7633 lab=_52502_/Y }
C {sky130_stdcells/nand2_4.sym} 8140 -27500 0 0 {name=X_52502_ }
C {devices/lab_pin.sym} 8050 -27370 0 0 {name=p7634 lab=_83322_/CLK }
C {devices/lab_pin.sym} 8050 -27350 0 0 {name=p7635 lab=_71937_/Y }
C {devices/lab_pin.sym} 8230 -27370 0 1 {name=p7636 lab=_83322_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -27360 0 0 {name=X_83322_ }
C {devices/lab_pin.sym} 8080 -27250 0 0 {name=p7637 lab=_56194_/X }
C {devices/lab_pin.sym} 8080 -27210 0 0 {name=p7638 lab=_56270_/B }
C {devices/lab_pin.sym} 8080 -27170 0 0 {name=p7639 lab=_56270_/C }
C {devices/lab_pin.sym} 8200 -27210 0 1 {name=p7640 lab=_56270_/Y }
C {sky130_stdcells/nand3_4.sym} 8140 -27210 0 0 {name=X_56270_ }
C {devices/lab_pin.sym} 8060 -27090 0 0 {name=p7641 lab=_80512_/Y }
C {devices/lab_pin.sym} 8060 -27050 0 0 {name=p7642 lab=_80530_/X }
C {devices/lab_pin.sym} 8060 -27010 0 0 {name=p7643 lab=_80533_/Y }
C {devices/lab_pin.sym} 8220 -27050 0 1 {name=p7644 lab=_80534_/Y }
C {sky130_stdcells/a21oi_4.sym} 8140 -27050 0 0 {name=X_80534_ }
C {devices/lab_pin.sym} 8060 -26940 0 0 {name=p7645 lab=_68254_/X }
C {devices/lab_pin.sym} 8060 -26900 0 0 {name=p7646 lab=_67577_/Y }
C {devices/lab_pin.sym} 8060 -26860 0 0 {name=p7647 lab=_68247_/X }
C {devices/lab_pin.sym} 8060 -26820 0 0 {name=p7648 lab=_68255_/Y }
C {devices/lab_pin.sym} 8220 -26880 0 1 {name=p7649 lab=_68256_/X }
C {sky130_stdcells/a211o_4.sym} 8140 -26880 0 0 {name=X_68256_ }
C {devices/lab_pin.sym} 8050 -26730 0 0 {name=p7650 lab=_88267_/CLK }
C {devices/lab_pin.sym} 8050 -26710 0 0 {name=p7651 lab=_44473_/X }
C {devices/lab_pin.sym} 8230 -26730 0 1 {name=p7652 lab=_87090_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -26720 0 0 {name=X_87090_ }
C {devices/lab_pin.sym} 8080 -26600 0 0 {name=p7653 lab=_53478_/A }
C {devices/lab_pin.sym} 8080 -26560 0 0 {name=p7654 lab=_73692_/A }
C {devices/lab_pin.sym} 8200 -26580 0 1 {name=p7655 lab=_53482_/Y }
C {sky130_stdcells/nand2_4.sym} 8140 -26580 0 0 {name=X_53482_ }
C {devices/lab_pin.sym} 8080 -26460 0 0 {name=p7656 lab=_65401_/A }
C {devices/lab_pin.sym} 8080 -26420 0 0 {name=p7657 lab=_72836_/B }
C {devices/lab_pin.sym} 8200 -26440 0 1 {name=p7658 lab=_65468_/X }
C {sky130_stdcells/and2_4.sym} 8140 -26440 0 0 {name=X_65468_ }
C {devices/lab_pin.sym} 8100 -26310 0 0 {name=p7659 lab=_50693_/X }
C {devices/lab_pin.sym} 8180 -26310 0 1 {name=p7660 lab=_53910_/A }
C {sky130_stdcells/buf_2.sym} 8140 -26310 0 0 {name=X_50694_ }
C {devices/lab_pin.sym} 8080 -26200 0 0 {name=p7661 lab=_55142_/A }
C {devices/lab_pin.sym} 8080 -26160 0 0 {name=p7662 lab=_55221_/B }
C {devices/lab_pin.sym} 8200 -26180 0 1 {name=p7663 lab=_55221_/Y }
C {sky130_stdcells/nor2_4.sym} 8140 -26180 0 0 {name=X_55221_ }
C {devices/lab_pin.sym} 8060 -26080 0 0 {name=p7664 lab=_88377_/Q }
C {devices/lab_pin.sym} 8060 -26040 0 0 {name=p7665 lab=_67110_/X }
C {devices/lab_pin.sym} 8060 -26000 0 0 {name=p7666 lab=_67160_/X }
C {devices/lab_pin.sym} 8060 -25960 0 0 {name=p7667 lab=_67206_/X }
C {devices/lab_pin.sym} 8220 -26020 0 1 {name=p7668 lab=_67207_/X }
C {sky130_stdcells/a211o_4.sym} 8140 -26020 0 0 {name=X_67207_ }
C {devices/lab_pin.sym} 8050 -25870 0 0 {name=p7669 lab=_85529_/CLK }
C {devices/lab_pin.sym} 8050 -25850 0 0 {name=p7670 lab=_51279_/Y }
C {devices/lab_pin.sym} 8230 -25870 0 1 {name=p7671 lab=_64820_/B }
C {sky130_stdcells/dfxtp_4.sym} 8140 -25860 0 0 {name=X_86041_ }
C {devices/lab_pin.sym} 8060 -25750 0 0 {name=p7672 lab=_52429_/Y }
C {devices/lab_pin.sym} 8060 -25710 0 0 {name=p7673 lab=_52430_/X }
C {devices/lab_pin.sym} 8060 -25670 0 0 {name=p7674 lab=_52432_/Y }
C {devices/lab_pin.sym} 8220 -25710 0 1 {name=p7675 lab=_52433_/Y }
C {sky130_stdcells/a21boi_4.sym} 8140 -25710 0 0 {name=X_52433_ }
C {devices/lab_pin.sym} 8080 -25580 0 0 {name=p7676 lab=_63586_/A }
C {devices/lab_pin.sym} 8080 -25540 0 0 {name=p7677 lab=_64419_/B }
C {devices/lab_pin.sym} 8200 -25560 0 1 {name=p7678 lab=_64419_/Y }
C {sky130_stdcells/nor2_4.sym} 8140 -25560 0 0 {name=X_64419_ }
C {devices/lab_pin.sym} 8050 -25430 0 0 {name=p7679 lab=_85317_/CLK }
C {devices/lab_pin.sym} 8050 -25410 0 0 {name=p7680 lab=_83253_/D }
C {devices/lab_pin.sym} 8230 -25430 0 1 {name=p7681 lab=_83253_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -25420 0 0 {name=X_83253_ }
C {devices/lab_pin.sym} 8080 -25300 0 0 {name=p7682 lab=_80472_/A }
C {devices/lab_pin.sym} 8080 -25260 0 0 {name=p7683 lab=_80472_/B }
C {devices/lab_pin.sym} 8200 -25280 0 1 {name=p7684 lab=_80478_/B }
C {sky130_stdcells/xnor2_4.sym} 8140 -25280 0 0 {name=X_80465_ }
C {devices/lab_pin.sym} 8100 -25150 0 0 {name=p7685 lab=_64636_/A }
C {devices/lab_pin.sym} 8180 -25150 0 1 {name=p7686 lab=_68376_/A }
C {sky130_stdcells/buf_2.sym} 8140 -25150 0 0 {name=X_68187_ }
C {devices/lab_pin.sym} 8100 -25030 0 0 {name=p7687 lab=_65198_/A }
C {devices/lab_pin.sym} 8180 -25030 0 1 {name=p7688 lab=_65399_/X }
C {sky130_stdcells/buf_2.sym} 8140 -25030 0 0 {name=X_65399_ }
C {devices/lab_pin.sym} 8050 -24910 0 0 {name=p7689 lab=_82961_/CLK }
C {devices/lab_pin.sym} 8050 -24890 0 0 {name=p7690 lab=_82204_/D }
C {devices/lab_pin.sym} 8230 -24910 0 1 {name=p7691 lab=_82204_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -24900 0 0 {name=X_82204_ }
C {devices/lab_pin.sym} 8100 -24770 0 0 {name=p7692 lab=_55152_/A }
C {devices/lab_pin.sym} 8180 -24770 0 1 {name=p7693 lab=_55152_/X }
C {sky130_stdcells/buf_2.sym} 8140 -24770 0 0 {name=X_55152_ }
C {devices/lab_pin.sym} 8060 -24670 0 0 {name=p7694 lab=_67135_/X }
C {devices/lab_pin.sym} 8060 -24630 0 0 {name=p7695 lab=_67137_/X }
C {devices/lab_pin.sym} 8060 -24590 0 0 {name=p7696 lab=_67113_/X }
C {devices/lab_pin.sym} 8220 -24630 0 1 {name=p7697 lab=_67138_/Y }
C {sky130_stdcells/a21oi_4.sym} 8140 -24630 0 0 {name=X_67138_ }
C {devices/lab_pin.sym} 8100 -24490 0 0 {name=p7698 lab=_52262_/A }
C {devices/lab_pin.sym} 8180 -24490 0 1 {name=p7699 lab=_52364_/X }
C {sky130_stdcells/buf_2.sym} 8140 -24490 0 0 {name=X_52364_ }
C {devices/lab_pin.sym} 8050 -24370 0 0 {name=p7700 lab=_83184_/CLK }
C {devices/lab_pin.sym} 8050 -24350 0 0 {name=p7701 lab=_72701_/X }
C {devices/lab_pin.sym} 8230 -24370 0 1 {name=p7702 lab=_83184_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -24360 0 0 {name=X_83184_ }
C {devices/lab_pin.sym} 8080 -24240 0 0 {name=p7703 lab=_80393_/X }
C {devices/lab_pin.sym} 8080 -24200 0 0 {name=p7704 lab=_80395_/Y }
C {devices/lab_pin.sym} 8200 -24220 0 1 {name=p7705 lab=_82251_/D }
C {sky130_stdcells/xnor2_4.sym} 8140 -24220 0 0 {name=X_80396_ }
C {devices/lab_pin.sym} 8060 -24110 0 0 {name=p7706 lab=_85503_/Q }
C {devices/lab_pin.sym} 8060 -24070 0 0 {name=p7707 lab=_53431_/X }
C {devices/lab_pin.sym} 8060 -24030 0 0 {name=p7708 lab=_54102_/Y }
C {devices/lab_pin.sym} 8220 -24070 0 1 {name=p7709 lab=_54103_/Y }
C {sky130_stdcells/o21ai_4.sym} 8140 -24070 0 0 {name=X_54103_ }
C {devices/lab_pin.sym} 8060 -23950 0 0 {name=p7710 lab=_51312_/Y }
C {devices/lab_pin.sym} 8060 -23910 0 0 {name=p7711 lab=_51313_/X }
C {devices/lab_pin.sym} 8060 -23870 0 0 {name=p7712 lab=_51314_/X }
C {devices/lab_pin.sym} 8220 -23910 0 1 {name=p7713 lab=_51315_/Y }
C {sky130_stdcells/a21oi_4.sym} 8140 -23910 0 0 {name=X_51315_ }
C {devices/lab_pin.sym} 8050 -23770 0 0 {name=p7714 lab=_82009_/CLK }
C {devices/lab_pin.sym} 8050 -23750 0 0 {name=p7715 lab=_82135_/D }
C {devices/lab_pin.sym} 8230 -23770 0 1 {name=p7716 lab=_82091_/D }
C {sky130_stdcells/dfxtp_4.sym} 8140 -23760 0 0 {name=X_82135_ }
C {devices/lab_pin.sym} 8080 -23660 0 0 {name=p7717 lab=_55083_/A }
C {devices/lab_pin.sym} 8080 -23620 0 0 {name=p7718 lab=_55104_/B }
C {devices/lab_pin.sym} 8080 -23580 0 0 {name=p7719 lab=_55083_/C }
C {devices/lab_pin.sym} 8080 -23540 0 0 {name=p7720 lab=_55083_/D }
C {devices/lab_pin.sym} 8200 -23600 0 1 {name=p7721 lab=_55083_/X }
C {sky130_stdcells/and4_4.sym} 8140 -23600 0 0 {name=X_55083_ }
C {devices/lab_pin.sym} 8080 -23470 0 0 {name=p7722 lab=_62515_/A }
C {devices/lab_pin.sym} 8080 -23430 0 0 {name=p7723 lab=_59913_/A }
C {devices/lab_pin.sym} 8080 -23390 0 0 {name=p7724 lab=_62621_/D }
C {devices/lab_pin.sym} 8200 -23430 0 1 {name=p7725 lab=_59962_/A }
C {sky130_stdcells/nand3_4.sym} 8140 -23430 0 0 {name=X_59960_ }
C {devices/lab_pin.sym} 8080 -23300 0 0 {name=p7726 lab=_66972_/X }
C {devices/lab_pin.sym} 8080 -23260 0 0 {name=p7727 lab=_87614_/Q }
C {devices/lab_pin.sym} 8200 -23280 0 1 {name=p7728 lab=_67069_/X }
C {sky130_stdcells/and2_4.sym} 8140 -23280 0 0 {name=X_67069_ }
C {devices/lab_pin.sym} 8080 -23160 0 0 {name=p7729 lab=_52295_/A }
C {devices/lab_pin.sym} 8080 -23120 0 0 {name=p7730 lab=_52295_/B }
C {devices/lab_pin.sym} 8200 -23140 0 1 {name=p7731 lab=_52295_/X }
C {sky130_stdcells/and2_4.sym} 8140 -23140 0 0 {name=X_52295_ }
C {devices/lab_pin.sym} 8050 -23010 0 0 {name=p7732 lab=_88002_/CLK }
C {devices/lab_pin.sym} 8050 -22990 0 0 {name=p7733 lab=_42185_/X }
C {devices/lab_pin.sym} 8230 -23010 0 1 {name=p7734 lab=_87992_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -23000 0 0 {name=X_87992_ }
C {devices/lab_pin.sym} 8100 -22870 0 0 {name=p7735 lab=_54034_/A }
C {devices/lab_pin.sym} 8180 -22870 0 1 {name=p7736 lab=_54320_/A }
C {sky130_stdcells/buf_2.sym} 8140 -22870 0 0 {name=X_54034_ }
C {devices/lab_pin.sym} 8060 -22790 0 0 {name=p7737 lab=_58828_/X }
C {devices/lab_pin.sym} 8060 -22750 0 0 {name=p7738 lab=_58909_/Y }
C {devices/lab_pin.sym} 8060 -22710 0 0 {name=p7739 lab=_58910_/Y }
C {devices/lab_pin.sym} 8060 -22670 0 0 {name=p7740 lab=_58874_/X }
C {devices/lab_pin.sym} 8060 -22630 0 0 {name=p7741 lab=_58832_/X }
C {devices/lab_pin.sym} 8220 -22710 0 1 {name=p7742 lab=_58911_/X }
C {sky130_stdcells/o32a_4.sym} 8140 -22710 0 0 {name=X_58911_ }
C {devices/lab_pin.sym} 8100 -22550 0 0 {name=p7743 lab=_51282_/A }
C {devices/lab_pin.sym} 8180 -22550 0 1 {name=p7744 lab=_51278_/A }
C {sky130_stdcells/buf_2.sym} 8140 -22550 0 0 {name=X_51246_ }
C {devices/lab_pin.sym} 8100 -22430 0 0 {name=p7745 lab=clkbuf_7_8_0_CLK/X }
C {devices/lab_pin.sym} 8180 -22430 0 1 {name=p7746 lab=clkbuf_9_35_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 8140 -22430 0 0 {name=Xclkbuf_8_17_0_CLK }
C {devices/lab_pin.sym} 8060 -22330 0 0 {name=p7747 lab=_82535_/D }
C {devices/lab_pin.sym} 8060 -22290 0 0 {name=p7748 lab=_70067_/X }
C {devices/lab_pin.sym} 8060 -22250 0 0 {name=p7749 lab=_70079_/Y }
C {devices/lab_pin.sym} 8220 -22290 0 1 {name=p7750 lab=_83855_/D }
C {sky130_stdcells/a21bo_4.sym} 8140 -22290 0 0 {name=X_70080_ }
C {devices/lab_pin.sym} 8050 -22150 0 0 {name=p7751 lab=_83987_/CLK }
C {devices/lab_pin.sym} 8050 -22130 0 0 {name=p7752 lab=_86943_/D }
C {devices/lab_pin.sym} 8230 -22150 0 1 {name=p7753 lab=_86943_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -22140 0 0 {name=X_86943_ }
C {devices/lab_pin.sym} 8050 -22010 0 0 {name=p7754 lab=_86807_/CLK }
C {devices/lab_pin.sym} 8050 -21990 0 0 {name=p7755 lab=_82066_/D }
C {devices/lab_pin.sym} 8230 -22010 0 1 {name=p7756 lab=_82066_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -22000 0 0 {name=X_82066_ }
C {devices/lab_pin.sym} 8080 -21890 0 0 {name=p7757 lab=_59602_/C }
C {devices/lab_pin.sym} 8080 -21850 0 0 {name=p7758 lab=_60171_/B }
C {devices/lab_pin.sym} 8080 -21810 0 0 {name=p7759 lab=_60171_/A }
C {devices/lab_pin.sym} 8200 -21850 0 1 {name=p7760 lab=_61066_/B }
C {sky130_stdcells/nand3_4.sym} 8140 -21850 0 0 {name=X_59891_ }
C {devices/lab_pin.sym} 8050 -21710 0 0 {name=p7761 lab=_84150_/CLK }
C {devices/lab_pin.sym} 8050 -21690 0 0 {name=p7762 lab=_84225_/Q }
C {devices/lab_pin.sym} 8230 -21710 0 1 {name=p7763 lab=_81017_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -21700 0 0 {name=X_81017_ }
C {devices/lab_pin.sym} 8060 -21600 0 0 {name=p7764 lab=_84796_/Q }
C {devices/lab_pin.sym} 8060 -21560 0 0 {name=p7765 lab=_58725_/X }
C {devices/lab_pin.sym} 8060 -21520 0 0 {name=p7766 lab=_58833_/X }
C {devices/lab_pin.sym} 8060 -21480 0 0 {name=p7767 lab=_58841_/X }
C {devices/lab_pin.sym} 8220 -21540 0 1 {name=p7768 lab=_84796_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 8140 -21540 0 0 {name=X_58842_ }
C {devices/lab_pin.sym} 8080 -21420 0 0 {name=p7769 lab=_51177_/A }
C {devices/lab_pin.sym} 8080 -21380 0 0 {name=p7770 lab=_51192_/B }
C {devices/lab_pin.sym} 8080 -21340 0 0 {name=p7771 lab=_51192_/C }
C {devices/lab_pin.sym} 8080 -21300 0 0 {name=p7772 lab=_52867_/D }
C {devices/lab_pin.sym} 8200 -21360 0 1 {name=p7773 lab=_51177_/X }
C {sky130_stdcells/and4_4.sym} 8140 -21360 0 0 {name=X_51177_ }
C {devices/lab_pin.sym} 8050 -21210 0 0 {name=p7774 lab=_86873_/CLK }
C {devices/lab_pin.sym} 8050 -21190 0 0 {name=p7775 lab=_45484_/Y }
C {devices/lab_pin.sym} 8230 -21210 0 1 {name=p7776 lab=_63066_/B }
C {sky130_stdcells/dfxtp_4.sym} 8140 -21200 0 0 {name=X_86874_ }
C {devices/lab_pin.sym} 8080 -21080 0 0 {name=p7777 lab=_50120_/A }
C {devices/lab_pin.sym} 8080 -21040 0 0 {name=p7778 lab=_52338_/B }
C {devices/lab_pin.sym} 8200 -21060 0 1 {name=p7779 lab=_50128_/Y }
C {sky130_stdcells/nand2_4.sym} 8140 -21060 0 0 {name=X_50128_ }
C {devices/lab_pin.sym} 8050 -20930 0 0 {name=p7780 lab=_86145_/CLK }
C {devices/lab_pin.sym} 8050 -20910 0 0 {name=p7781 lab=_85825_/D }
C {devices/lab_pin.sym} 8230 -20930 0 1 {name=p7782 lab=_85825_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -20920 0 0 {name=X_85825_ }
C {devices/lab_pin.sym} 8060 -20810 0 0 {name=p7783 lab=_58667_/X }
C {devices/lab_pin.sym} 8060 -20770 0 0 {name=p7784 lab=_86097_/Q }
C {devices/lab_pin.sym} 8060 -20730 0 0 {name=p7785 lab=_58772_/X }
C {devices/lab_pin.sym} 8220 -20770 0 1 {name=p7786 lab=_58773_/Y }
C {sky130_stdcells/o21ai_4.sym} 8140 -20770 0 0 {name=X_58773_ }
C {devices/lab_pin.sym} 8080 -20660 0 0 {name=p7787 lab=_56019_/B }
C {devices/lab_pin.sym} 8080 -20620 0 0 {name=p7788 lab=_55966_/X }
C {devices/lab_pin.sym} 8080 -20580 0 0 {name=p7789 lab=_55975_/X }
C {devices/lab_pin.sym} 8080 -20540 0 0 {name=p7790 lab=_74286_/C }
C {devices/lab_pin.sym} 8200 -20600 0 1 {name=p7791 lab=_55985_/Y }
C {sky130_stdcells/nand4_4.sym} 8140 -20600 0 0 {name=X_55985_ }
C {devices/lab_pin.sym} 8060 -20470 0 0 {name=p7792 lab=_57705_/X }
C {devices/lab_pin.sym} 8060 -20430 0 0 {name=p7793 lab=_85504_/Q }
C {devices/lab_pin.sym} 8060 -20390 0 0 {name=p7794 lab=_44031_/X }
C {devices/lab_pin.sym} 8220 -20430 0 1 {name=p7795 lab=_57724_/X }
C {sky130_stdcells/o21a_4.sym} 8140 -20430 0 0 {name=X_57724_ }
C {devices/lab_pin.sym} 8100 -20290 0 0 {name=p7796 lab=_42962_/A }
C {devices/lab_pin.sym} 8180 -20290 0 1 {name=p7797 lab=_42950_/X }
C {sky130_stdcells/buf_2.sym} 8140 -20290 0 0 {name=X_42950_ }
C {devices/lab_pin.sym} 8080 -20190 0 0 {name=p7798 lab=_48894_/A }
C {devices/lab_pin.sym} 8080 -20150 0 0 {name=p7799 lab=_48859_/B }
C {devices/lab_pin.sym} 8080 -20110 0 0 {name=p7800 lab=_50059_/C }
C {devices/lab_pin.sym} 8200 -20150 0 1 {name=p7801 lab=_50059_/X }
C {sky130_stdcells/and3_4.sym} 8140 -20150 0 0 {name=X_50059_ }
C {devices/lab_pin.sym} 8100 -20010 0 0 {name=p7802 lab=_54882_/A }
C {devices/lab_pin.sym} 8180 -20010 0 1 {name=p7803 lab=_54936_/X }
C {sky130_stdcells/buf_2.sym} 8140 -20010 0 0 {name=X_54936_ }
C {devices/lab_pin.sym} 8080 -19900 0 0 {name=p7804 lab=_88106_/Q }
C {devices/lab_pin.sym} 8080 -19860 0 0 {name=p7805 lab=_73649_/X }
C {devices/lab_pin.sym} 8200 -19880 0 1 {name=p7806 lab=_73770_/Y }
C {sky130_stdcells/nor2_4.sym} 8140 -19880 0 0 {name=X_73770_ }
C {devices/lab_pin.sym} 8050 -19750 0 0 {name=p7807 lab=_85757_/CLK }
C {devices/lab_pin.sym} 8050 -19730 0 0 {name=p7808 lab=_52780_/Y }
C {devices/lab_pin.sym} 8230 -19750 0 1 {name=p7809 lab=_85756_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -19740 0 0 {name=X_85756_ }
C {devices/lab_pin.sym} 8050 -19610 0 0 {name=p7810 lab=_82774_/CLK }
C {devices/lab_pin.sym} 8050 -19590 0 0 {name=p7811 lab=_82968_/D }
C {devices/lab_pin.sym} 8230 -19610 0 1 {name=p7812 lab=_82968_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -19600 0 0 {name=X_82968_ }
C {devices/lab_pin.sym} 8100 -19470 0 0 {name=p7813 lab=_70981_/X }
C {devices/lab_pin.sym} 8180 -19470 0 1 {name=p7814 lab=_70983_/A }
C {sky130_stdcells/buf_2.sym} 8140 -19470 0 0 {name=X_70982_ }
C {devices/lab_pin.sym} 8100 -19350 0 0 {name=p7815 lab=clkbuf_3_3_0_CLK/X }
C {devices/lab_pin.sym} 8180 -19350 0 1 {name=p7816 lab=clkbuf_4_7_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 8140 -19350 0 0 {name=Xclkbuf_3_3_1_CLK }
C {devices/lab_pin.sym} 8100 -19230 0 0 {name=p7817 lab=_43175_/B }
C {devices/lab_pin.sym} 8180 -19230 0 1 {name=p7818 lab=_46616_/A }
C {sky130_stdcells/buf_2.sym} 8140 -19230 0 0 {name=X_41901_ }
C {devices/lab_pin.sym} 8100 -19110 0 0 {name=p7819 lab=_73257_/A }
C {devices/lab_pin.sym} 8180 -19110 0 1 {name=p7820 lab=_72721_/X }
C {sky130_stdcells/buf_2.sym} 8140 -19110 0 0 {name=X_72721_ }
C {devices/lab_pin.sym} 8050 -18990 0 0 {name=p7821 lab=_84355_/CLK }
C {devices/lab_pin.sym} 8050 -18970 0 0 {name=p7822 lab=_84707_/D }
C {devices/lab_pin.sym} 8230 -18990 0 1 {name=p7823 lab=_80559_/A }
C {sky130_stdcells/dfxtp_4.sym} 8140 -18980 0 0 {name=X_84707_ }
C {devices/lab_pin.sym} 8100 -18850 0 0 {name=p7824 lab=_57655_/A }
C {devices/lab_pin.sym} 8180 -18850 0 1 {name=p7825 lab=_57655_/Y }
C {sky130_stdcells/inv_2.sym} 8140 -18850 0 0 {name=X_57655_ }
C {devices/lab_pin.sym} 8050 -18730 0 0 {name=p7826 lab=_82008_/CLK }
C {devices/lab_pin.sym} 8050 -18710 0 0 {name=p7827 lab=_77692_/Y }
C {devices/lab_pin.sym} 8230 -18730 0 1 {name=p7828 lab=_77157_/B }
C {sky130_stdcells/dfxtp_4.sym} 8140 -18720 0 0 {name=X_81919_ }
C {devices/lab_pin.sym} 8100 -18590 0 0 {name=p7829 lab=_42835_/X }
C {devices/lab_pin.sym} 8180 -18590 0 1 {name=p7830 lab=_42881_/X }
C {sky130_stdcells/buf_2.sym} 8140 -18590 0 0 {name=X_42881_ }
C {devices/lab_pin.sym} 8080 -18480 0 0 {name=p7831 lab=_54885_/A }
C {devices/lab_pin.sym} 8080 -18440 0 0 {name=p7832 lab=_54867_/B }
C {devices/lab_pin.sym} 8200 -18460 0 1 {name=p7833 lab=_54867_/Y }
C {sky130_stdcells/nand2_4.sym} 8140 -18460 0 0 {name=X_54867_ }
C {devices/lab_pin.sym} 8050 -18330 0 0 {name=p7834 lab=_84787_/CLK }
C {devices/lab_pin.sym} 8050 -18310 0 0 {name=p7835 lab=_85687_/D }
C {devices/lab_pin.sym} 8230 -18330 0 1 {name=p7836 lab=_85687_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -18320 0 0 {name=X_85687_ }
C {devices/lab_pin.sym} 8050 -18190 0 0 {name=p7837 lab=_82899_/CLK }
C {devices/lab_pin.sym} 8050 -18170 0 0 {name=p7838 lab=_78202_/B }
C {devices/lab_pin.sym} 8230 -18190 0 1 {name=p7839 lab=_82899_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -18180 0 0 {name=X_82899_ }
C {devices/lab_pin.sym} 8060 -18080 0 0 {name=p7840 lab=_40982_/A }
C {devices/lab_pin.sym} 8060 -18040 0 0 {name=p7841 lab=_44618_/X }
C {devices/lab_pin.sym} 8060 -18000 0 0 {name=p7842 lab=_87030_/Q }
C {devices/lab_pin.sym} 8060 -17960 0 0 {name=p7843 lab=_44619_/X }
C {devices/lab_pin.sym} 8220 -18020 0 1 {name=p7844 lab=_87030_/D }
C {sky130_stdcells/a2bb2o_4.sym} 8140 -18020 0 0 {name=X_44620_ }
C {devices/lab_pin.sym} 8080 -17880 0 0 {name=p7845 lab=_72652_/C }
C {devices/lab_pin.sym} 8080 -17840 0 0 {name=p7846 lab=_56556_/A }
C {devices/lab_pin.sym} 8200 -17860 0 1 {name=p7847 lab=_56607_/A }
C {sky130_stdcells/xor2_4.sym} 8140 -17860 0 0 {name=X_56606_ }
C {devices/lab_pin.sym} 8080 -17740 0 0 {name=p7848 lab=_80794_/Q }
C {devices/lab_pin.sym} 8080 -17700 0 0 {name=p7849 lab=_75440_/B }
C {devices/lab_pin.sym} 8200 -17720 0 1 {name=p7850 lab=_75440_/X }
C {sky130_stdcells/xor2_4.sym} 8140 -17720 0 0 {name=X_75440_ }
C {devices/lab_pin.sym} 8060 -17620 0 0 {name=p7851 lab=_40469_/X }
C {devices/lab_pin.sym} 8060 -17580 0 0 {name=p7852 lab=_41813_/X }
C {devices/lab_pin.sym} 8060 -17540 0 0 {name=p7853 lab=_88131_/Q }
C {devices/lab_pin.sym} 8060 -17500 0 0 {name=p7854 lab=_41814_/X }
C {devices/lab_pin.sym} 8220 -17560 0 1 {name=p7855 lab=_41832_/X }
C {sky130_stdcells/a2bb2o_4.sym} 8140 -17560 0 0 {name=X_41832_ }
C {devices/lab_pin.sym} 8050 -17410 0 0 {name=p7856 lab=_86784_/CLK }
C {devices/lab_pin.sym} 8050 -17390 0 0 {name=p7857 lab=_43429_/X }
C {devices/lab_pin.sym} 8230 -17410 0 1 {name=p7858 lab=_87426_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -17400 0 0 {name=X_87426_ }
C {devices/lab_pin.sym} 8100 -17270 0 0 {name=p7859 lab=_53956_/A }
C {devices/lab_pin.sym} 8180 -17270 0 1 {name=p7860 lab=_53819_/A }
C {sky130_stdcells/buf_2.sym} 8140 -17270 0 0 {name=X_53818_ }
C {devices/lab_pin.sym} 8080 -17170 0 0 {name=p7861 lab=_72656_/A }
C {devices/lab_pin.sym} 8080 -17130 0 0 {name=p7862 lab=_72656_/B }
C {devices/lab_pin.sym} 8080 -17090 0 0 {name=p7863 lab=_72652_/C }
C {devices/lab_pin.sym} 8200 -17130 0 1 {name=p7864 lab=_72652_/Y }
C {sky130_stdcells/nand3_4.sym} 8140 -17130 0 0 {name=X_72652_ }
C {devices/lab_pin.sym} 8050 -16990 0 0 {name=p7865 lab=_84620_/CLK }
C {devices/lab_pin.sym} 8050 -16970 0 0 {name=p7866 lab=_60307_/X }
C {devices/lab_pin.sym} 8230 -16990 0 1 {name=p7867 lab=_79764_/A }
C {sky130_stdcells/dfxtp_4.sym} 8140 -16980 0 0 {name=X_84638_ }
C {devices/lab_pin.sym} 8100 -16850 0 0 {name=p7868 lab=_50460_/A }
C {devices/lab_pin.sym} 8180 -16850 0 1 {name=p7869 lab=_71964_/A }
C {sky130_stdcells/buf_2.sym} 8140 -16850 0 0 {name=X_57586_ }
C {devices/lab_pin.sym} 8080 -16760 0 0 {name=p7870 lab=_54798_/A }
C {devices/lab_pin.sym} 8080 -16720 0 0 {name=p7871 lab=_54816_/B }
C {devices/lab_pin.sym} 8080 -16680 0 0 {name=p7872 lab=_54798_/C }
C {devices/lab_pin.sym} 8080 -16640 0 0 {name=p7873 lab=_53107_/D }
C {devices/lab_pin.sym} 8200 -16700 0 1 {name=p7874 lab=_54798_/X }
C {sky130_stdcells/and4_4.sym} 8140 -16700 0 0 {name=X_54798_ }
C {devices/lab_pin.sym} 8100 -16550 0 0 {name=p7875 lab=_71603_/A }
C {devices/lab_pin.sym} 8180 -16550 0 1 {name=p7876 lab=_71603_/Y }
C {sky130_stdcells/inv_2.sym} 8140 -16550 0 0 {name=X_71603_ }
C {devices/lab_pin.sym} 8100 -16430 0 0 {name=p7877 lab=_59325_/A }
C {devices/lab_pin.sym} 8180 -16430 0 1 {name=p7878 lab=_59325_/X }
C {sky130_stdcells/buf_2.sym} 8140 -16430 0 0 {name=X_59325_ }
C {devices/lab_pin.sym} 8100 -16310 0 0 {name=p7879 lab=_44551_/A }
C {devices/lab_pin.sym} 8180 -16310 0 1 {name=p7880 lab=_87058_/D }
C {sky130_stdcells/inv_2.sym} 8140 -16310 0 0 {name=X_44551_ }
C {devices/lab_pin.sym} 8060 -16210 0 0 {name=p7881 lab=_56153_/X }
C {devices/lab_pin.sym} 8060 -16170 0 0 {name=p7882 lab=_56528_/X }
C {devices/lab_pin.sym} 8060 -16130 0 0 {name=p7883 lab=_56536_/Y }
C {devices/lab_pin.sym} 8220 -16170 0 1 {name=p7884 lab=_85158_/D }
C {sky130_stdcells/o21ai_4.sym} 8140 -16170 0 0 {name=X_56537_ }
C {devices/lab_pin.sym} 8050 -16030 0 0 {name=p7885 lab=_86814_/CLK }
C {devices/lab_pin.sym} 8050 -16010 0 0 {name=p7886 lab=_43568_/Y }
C {devices/lab_pin.sym} 8230 -16030 0 1 {name=p7887 lab=_87357_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -16020 0 0 {name=X_87357_ }
C {devices/lab_pin.sym} 8080 -15900 0 0 {name=p7888 lab=_75371_/A }
C {devices/lab_pin.sym} 8080 -15860 0 0 {name=p7889 lab=_75370_/X }
C {devices/lab_pin.sym} 8200 -15880 0 1 {name=p7890 lab=_80758_/D }
C {sky130_stdcells/xor2_4.sym} 8140 -15880 0 0 {name=X_75371_ }
C {devices/lab_pin.sym} 8060 -15790 0 0 {name=p7891 lab=_41753_/X }
C {devices/lab_pin.sym} 8060 -15750 0 0 {name=p7892 lab=_41754_/X }
C {devices/lab_pin.sym} 8060 -15710 0 0 {name=p7893 lab=_41762_/X }
C {devices/lab_pin.sym} 8060 -15670 0 0 {name=p7894 lab=_67932_/B }
C {devices/lab_pin.sym} 8060 -15630 0 0 {name=p7895 lab=_41736_/X }
C {devices/lab_pin.sym} 8220 -15710 0 1 {name=p7896 lab=_41764_/A }
C {sky130_stdcells/o32ai_4.sym} 8140 -15710 0 0 {name=X_41763_ }
C {devices/lab_pin.sym} 8060 -15570 0 0 {name=p7897 lab=_53746_/Y }
C {devices/lab_pin.sym} 8060 -15530 0 0 {name=p7898 lab=_53747_/X }
C {devices/lab_pin.sym} 8060 -15490 0 0 {name=p7899 lab=_53748_/X }
C {devices/lab_pin.sym} 8220 -15530 0 1 {name=p7900 lab=_53749_/Y }
C {sky130_stdcells/a21oi_4.sym} 8140 -15530 0 0 {name=X_53749_ }
C {devices/lab_pin.sym} 8080 -15410 0 0 {name=p7901 lab=_72525_/A }
C {devices/lab_pin.sym} 8080 -15370 0 0 {name=p7902 lab=_72597_/B }
C {devices/lab_pin.sym} 8080 -15330 0 0 {name=p7903 lab=_72583_/C }
C {devices/lab_pin.sym} 8200 -15370 0 1 {name=p7904 lab=_72583_/Y }
C {sky130_stdcells/nand3_4.sym} 8140 -15370 0 0 {name=X_72583_ }
C {devices/lab_pin.sym} 8050 -15230 0 0 {name=p7905 lab=_82436_/CLK }
C {devices/lab_pin.sym} 8050 -15210 0 0 {name=p7906 lab=_84569_/D }
C {devices/lab_pin.sym} 8230 -15230 0 1 {name=p7907 lab=_78064_/A }
C {sky130_stdcells/dfxtp_4.sym} 8140 -15220 0 0 {name=X_84569_ }
C {devices/lab_pin.sym} 8080 -15100 0 0 {name=p7908 lab=_77110_/A }
C {devices/lab_pin.sym} 8080 -15060 0 0 {name=p7909 lab=_77110_/B }
C {devices/lab_pin.sym} 8200 -15080 0 1 {name=p7910 lab=_82346_/D }
C {sky130_stdcells/xor2_4.sym} 8140 -15080 0 0 {name=X_77110_ }
C {devices/lab_pin.sym} 8060 -14980 0 0 {name=p7911 lab=_41749_/X }
C {devices/lab_pin.sym} 8060 -14940 0 0 {name=p7912 lab=_43498_/X }
C {devices/lab_pin.sym} 8060 -14900 0 0 {name=p7913 lab=_87388_/Q }
C {devices/lab_pin.sym} 8060 -14860 0 0 {name=p7914 lab=_43499_/X }
C {devices/lab_pin.sym} 8220 -14920 0 1 {name=p7915 lab=_43502_/X }
C {sky130_stdcells/a2bb2o_4.sym} 8140 -14920 0 0 {name=X_43502_ }
C {devices/lab_pin.sym} 8050 -14770 0 0 {name=p7916 lab=_86627_/CLK }
C {devices/lab_pin.sym} 8050 -14750 0 0 {name=p7917 lab=_86308_/D }
C {devices/lab_pin.sym} 8230 -14770 0 1 {name=p7918 lab=_58116_/B }
C {sky130_stdcells/dfxtp_4.sym} 8140 -14760 0 0 {name=X_86308_ }
C {devices/lab_pin.sym} 8060 -14650 0 0 {name=p7919 lab=_70306_/C }
C {devices/lab_pin.sym} 8060 -14610 0 0 {name=p7920 lab=_74314_/X }
C {devices/lab_pin.sym} 8060 -14570 0 0 {name=p7921 lab=_74321_/Y }
C {devices/lab_pin.sym} 8220 -14610 0 1 {name=p7922 lab=_83099_/D }
C {sky130_stdcells/a21bo_4.sym} 8140 -14610 0 0 {name=X_74322_ }
C {devices/lab_pin.sym} 8080 -14480 0 0 {name=p7923 lab=_40714_/A }
C {devices/lab_pin.sym} 8080 -14440 0 0 {name=p7924 lab=_40623_/X }
C {devices/lab_pin.sym} 8200 -14460 0 1 {name=p7925 lab=_40714_/X }
C {sky130_stdcells/or2_4.sym} 8140 -14460 0 0 {name=X_40714_ }
C {devices/lab_pin.sym} 8060 -14350 0 0 {name=p7926 lab=_86652_/Q }
C {devices/lab_pin.sym} 8060 -14310 0 0 {name=p7927 lab=_47240_/X }
C {devices/lab_pin.sym} 8060 -14270 0 0 {name=p7928 lab=_47269_/Y }
C {devices/lab_pin.sym} 8220 -14310 0 1 {name=p7929 lab=_47270_/Y }
C {sky130_stdcells/o21ai_4.sym} 8140 -14310 0 0 {name=X_47270_ }
C {devices/lab_pin.sym} 8080 -14180 0 0 {name=p7930 lab=_59256_/A }
C {devices/lab_pin.sym} 8080 -14140 0 0 {name=p7931 lab=_59256_/B }
C {devices/lab_pin.sym} 8200 -14160 0 1 {name=p7932 lab=_59256_/Y }
C {sky130_stdcells/nor2_4.sym} 8140 -14160 0 0 {name=X_59256_ }
C {devices/lab_pin.sym} 8100 -14030 0 0 {name=p7933 lab=_71585_/A }
C {devices/lab_pin.sym} 8180 -14030 0 1 {name=p7934 lab=_71622_/D }
C {sky130_stdcells/buf_2.sym} 8140 -14030 0 0 {name=X_71534_ }
C {devices/lab_pin.sym} 8080 -13920 0 0 {name=p7935 lab=_78087_/Y }
C {devices/lab_pin.sym} 8080 -13880 0 0 {name=p7936 lab=_78090_/B }
C {devices/lab_pin.sym} 8200 -13900 0 1 {name=p7937 lab=_78090_/Y }
C {sky130_stdcells/nor2_4.sym} 8140 -13900 0 0 {name=X_78090_ }
C {devices/lab_pin.sym} 8100 -13770 0 0 {name=p7938 lab=_44548_/A }
C {devices/lab_pin.sym} 8180 -13770 0 1 {name=p7939 lab=_44482_/X }
C {sky130_stdcells/buf_2.sym} 8140 -13770 0 0 {name=X_44482_ }
C {devices/lab_pin.sym} 8100 -13650 0 0 {name=p7940 lab=_56538_/A }
C {devices/lab_pin.sym} 8180 -13650 0 1 {name=p7941 lab=_56468_/X }
C {sky130_stdcells/buf_2.sym} 8140 -13650 0 0 {name=X_56468_ }
C {devices/lab_pin.sym} 8060 -13560 0 0 {name=p7942 lab=_41693_/X }
C {devices/lab_pin.sym} 8060 -13520 0 0 {name=p7943 lab=_41682_/X }
C {devices/lab_pin.sym} 8060 -13480 0 0 {name=p7944 lab=_67608_/B }
C {devices/lab_pin.sym} 8060 -13440 0 0 {name=p7945 lab=_41684_/X }
C {devices/lab_pin.sym} 8220 -13500 0 1 {name=p7946 lab=_41694_/X }
C {sky130_stdcells/a2bb2o_4.sym} 8140 -13500 0 0 {name=X_41694_ }
C {devices/lab_pin.sym} 8050 -13350 0 0 {name=p7947 lab=_87288_/CLK }
C {devices/lab_pin.sym} 8050 -13330 0 0 {name=p7948 lab=_87288_/D }
C {devices/lab_pin.sym} 8230 -13350 0 1 {name=p7949 lab=_87288_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -13340 0 0 {name=X_87288_ }
C {devices/lab_pin.sym} 8080 -13240 0 0 {name=p7950 lab=_46143_/B }
C {devices/lab_pin.sym} 8080 -13200 0 0 {name=p7951 lab=_46101_/A }
C {devices/lab_pin.sym} 8080 -13160 0 0 {name=p7952 lab=_46162_/C }
C {devices/lab_pin.sym} 8080 -13120 0 0 {name=p7953 lab=_46217_/B }
C {devices/lab_pin.sym} 8200 -13180 0 1 {name=p7954 lab=_46221_/Y }
C {sky130_stdcells/nand4_4.sym} 8140 -13180 0 0 {name=X_46221_ }
C {sky130_stdcells/decap_3.sym} 8140 -13000 0 0 {name=XPHY_330 }
C {devices/lab_pin.sym} 8080 -12860 0 0 {name=p7955 lab=_58207_/A }
C {devices/lab_pin.sym} 8080 -12820 0 0 {name=p7956 lab=_58238_/B }
C {devices/lab_pin.sym} 8200 -12840 0 1 {name=p7957 lab=_58207_/Y }
C {sky130_stdcells/nor2_4.sym} 8140 -12840 0 0 {name=X_58207_ }
C {devices/lab_pin.sym} 8080 -12730 0 0 {name=p7958 lab=_77041_/A }
C {devices/lab_pin.sym} 8080 -12690 0 0 {name=p7959 lab=_77041_/B }
C {devices/lab_pin.sym} 8080 -12650 0 0 {name=p7960 lab=_77041_/C }
C {devices/lab_pin.sym} 8200 -12690 0 1 {name=p7961 lab=_77041_/Y }
C {sky130_stdcells/nand3_4.sym} 8140 -12690 0 0 {name=X_77041_ }
C {devices/lab_pin.sym} 8060 -12580 0 0 {name=p7962 lab=_41560_/X }
C {devices/lab_pin.sym} 8060 -12540 0 0 {name=p7963 lab=_43431_/X }
C {devices/lab_pin.sym} 8060 -12500 0 0 {name=p7964 lab=_87424_/Q }
C {devices/lab_pin.sym} 8060 -12460 0 0 {name=p7965 lab=_43432_/X }
C {devices/lab_pin.sym} 8220 -12520 0 1 {name=p7966 lab=_87424_/D }
C {sky130_stdcells/a2bb2o_4.sym} 8140 -12520 0 0 {name=X_43433_ }
C {devices/lab_pin.sym} 8100 -12370 0 0 {name=p7967 lab=_55423_/B }
C {devices/lab_pin.sym} 8180 -12370 0 1 {name=p7968 lab=_55421_/B }
C {sky130_stdcells/inv_2.sym} 8140 -12370 0 0 {name=X_55419_ }
C {devices/lab_pin.sym} 8080 -12260 0 0 {name=p7969 lab=_73972_/X }
C {devices/lab_pin.sym} 8080 -12220 0 0 {name=p7970 lab=_86563_/Q }
C {devices/lab_pin.sym} 8200 -12240 0 1 {name=p7971 lab=_74253_/X }
C {sky130_stdcells/and2_4.sym} 8140 -12240 0 0 {name=X_74253_ }
C {devices/lab_pin.sym} 8050 -12110 0 0 {name=p7972 lab=_86436_/CLK }
C {devices/lab_pin.sym} 8050 -12090 0 0 {name=p7973 lab=_50235_/Y }
C {devices/lab_pin.sym} 8230 -12110 0 1 {name=p7974 lab=_86239_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8140 -12100 0 0 {name=X_86239_ }
C {sky130_stdcells/decap_3.sym} 8140 -11940 0 0 {name=XPHY_341 }
C {devices/lab_pin.sym} 8060 -11810 0 0 {name=p7975 lab=_40585_/X }
C {devices/lab_pin.sym} 8060 -11770 0 0 {name=p7976 lab=_82871_/Q }
C {devices/lab_pin.sym} 8060 -11730 0 0 {name=p7977 lab=_40644_/X }
C {devices/lab_pin.sym} 8220 -11770 0 1 {name=p7978 lab=_40645_/Y }
C {sky130_stdcells/o21ai_4.sym} 8140 -11770 0 0 {name=X_40645_ }
C {devices/lab_pin.sym} 8100 -11630 0 0 {name=p7979 lab=_71429_/A }
C {devices/lab_pin.sym} 8180 -11630 0 1 {name=p7980 lab=_71476_/D }
C {sky130_stdcells/buf_2.sym} 8140 -11630 0 0 {name=X_71465_ }
C {devices/lab_pin.sym} 8060 -11530 0 0 {name=p7981 lab=_59184_/Y }
C {devices/lab_pin.sym} 8060 -11490 0 0 {name=p7982 lab=_59186_/Y }
C {devices/lab_pin.sym} 8060 -11450 0 0 {name=p7983 lab=_59165_/X }
C {devices/lab_pin.sym} 8220 -11490 0 1 {name=p7984 lab=_59187_/X }
C {sky130_stdcells/a21o_4.sym} 8140 -11490 0 0 {name=X_59187_ }
C {sky130_stdcells/decap_3.sym} 8140 -11320 0 0 {name=XPHY_352 }
C {devices/lab_pin.sym} 8080 -11190 0 0 {name=p7985 lab=_56397_/X }
C {devices/lab_pin.sym} 8080 -11150 0 0 {name=p7986 lab=_56399_/B }
C {devices/lab_pin.sym} 8080 -11110 0 0 {name=p7987 lab=_85209_/Q }
C {devices/lab_pin.sym} 8200 -11150 0 1 {name=p7988 lab=_56399_/Y }
C {sky130_stdcells/nand3_4.sym} 8140 -11150 0 0 {name=X_56399_ }
C {sky130_stdcells/decap_3.sym} 8140 -10980 0 0 {name=XPHY_363 }
C {sky130_stdcells/decap_3.sym} 8140 -10800 0 0 {name=XPHY_374 }
C {devices/lab_pin.sym} 8060 -10670 0 0 {name=p7989 lab=_87054_/Q }
C {devices/lab_pin.sym} 8060 -10630 0 0 {name=p7990 lab=_73129_/X }
C {devices/lab_pin.sym} 8060 -10590 0 0 {name=p7991 lab=_73203_/X }
C {devices/lab_pin.sym} 8220 -10630 0 1 {name=p7992 lab=_73220_/C }
C {sky130_stdcells/o21ai_4.sym} 8140 -10630 0 0 {name=X_73204_ }
C {devices/lab_pin.sym} 8100 -10490 0 0 {name=p7993 lab=HASH_ADDR[1] }
C {devices/lab_pin.sym} 8180 -10490 0 1 {name=p7994 lab=_70416_/Y }
C {sky130_stdcells/inv_2.sym} 8140 -10490 0 0 {name=X_70416_ }
C {devices/lab_pin.sym} 8100 -10370 0 0 {name=p7995 lab=_46166_/C }
C {devices/lab_pin.sym} 8180 -10370 0 1 {name=p7996 lab=_46170_/C }
C {sky130_stdcells/buf_2.sym} 8140 -10370 0 0 {name=X_46152_ }
C {devices/lab_pin.sym} 8060 -10270 0 0 {name=p7997 lab=_58100_/X }
C {devices/lab_pin.sym} 8060 -10230 0 0 {name=p7998 lab=_85474_/Q }
C {devices/lab_pin.sym} 8060 -10190 0 0 {name=p7999 lab=_58062_/X }
C {devices/lab_pin.sym} 8220 -10230 0 1 {name=p8000 lab=_58138_/X }
C {sky130_stdcells/o21a_4.sym} 8140 -10230 0 0 {name=X_58138_ }
C {sky130_stdcells/decap_3.sym} 8140 -10060 0 0 {name=XPHY_385 }
C {devices/lab_pin.sym} 8100 -9910 0 0 {name=p8001 lab=_43364_/A }
C {devices/lab_pin.sym} 8180 -9910 0 1 {name=p8002 lab=_87458_/D }
C {sky130_stdcells/inv_2.sym} 8140 -9910 0 0 {name=X_43364_ }
C {devices/lab_pin.sym} 8080 -9800 0 0 {name=p8003 lab=_74184_/A }
C {devices/lab_pin.sym} 8080 -9760 0 0 {name=p8004 lab=_73152_/X }
C {devices/lab_pin.sym} 8200 -9780 0 1 {name=p8005 lab=_74184_/Y }
C {sky130_stdcells/nor2_4.sym} 8140 -9780 0 0 {name=X_74184_ }
C {devices/lab_pin.sym} 8100 -9650 0 0 {name=p8006 lab=_47825_/A }
C {devices/lab_pin.sym} 8180 -9650 0 1 {name=p8007 lab=_49048_/A }
C {sky130_stdcells/buf_2.sym} 8140 -9650 0 0 {name=X_40576_ }
C {sky130_stdcells/decap_3.sym} 8140 -9500 0 0 {name=XPHY_396 }
C {devices/lab_pin.sym} 8100 -9350 0 0 {name=p8008 lab=_71395_/Y }
C {devices/lab_pin.sym} 8180 -9350 0 1 {name=p8009 lab=_71396_/Y }
C {sky130_stdcells/inv_2.sym} 8140 -9350 0 0 {name=X_71396_ }
C {devices/lab_pin.sym} 8060 -9250 0 0 {name=p8010 lab=_56501_/C }
C {devices/lab_pin.sym} 8060 -9210 0 0 {name=p8011 lab=_45060_/X }
C {devices/lab_pin.sym} 8060 -9170 0 0 {name=p8012 lab=_45040_/X }
C {devices/lab_pin.sym} 8220 -9210 0 1 {name=p8013 lab=_45103_/X }
C {sky130_stdcells/o21a_4.sym} 8140 -9210 0 0 {name=X_45103_ }
C {devices/lab_pin.sym} 8060 -9110 0 0 {name=p8014 lab=_42307_/X }
C {devices/lab_pin.sym} 8060 -9070 0 0 {name=p8015 lab=_42297_/X }
C {devices/lab_pin.sym} 8060 -9030 0 0 {name=p8016 lab=_41621_/X }
C {devices/lab_pin.sym} 8060 -8990 0 0 {name=p8017 lab=_87925_/Q }
C {devices/lab_pin.sym} 8060 -8950 0 0 {name=p8018 lab=_42298_/X }
C {devices/lab_pin.sym} 8220 -9030 0 1 {name=p8019 lab=_42316_/A }
C {sky130_stdcells/o32ai_4.sym} 8140 -9030 0 0 {name=X_42315_ }
C {devices/lab_pin.sym} 8080 -8880 0 0 {name=p8020 lab=_73260_/A }
C {devices/lab_pin.sym} 8080 -8840 0 0 {name=p8021 lab=_86483_/Q }
C {devices/lab_pin.sym} 8200 -8860 0 1 {name=p8022 lab=_73135_/X }
C {sky130_stdcells/and2_4.sym} 8140 -8860 0 0 {name=X_73135_ }
C {devices/lab_pin.sym} 8060 -8760 0 0 {name=p8023 lab=_41625_/Y }
C {devices/lab_pin.sym} 8060 -8720 0 0 {name=p8024 lab=_43586_/X }
C {devices/lab_pin.sym} 8060 -8680 0 0 {name=p8025 lab=_86775_/Q }
C {devices/lab_pin.sym} 8060 -8640 0 0 {name=p8026 lab=_43593_/X }
C {devices/lab_pin.sym} 8220 -8700 0 1 {name=p8027 lab=_86775_/D }
C {sky130_stdcells/a2bb2o_4.sym} 8140 -8700 0 0 {name=X_46083_ }
C {devices/lab_pin.sym} 8060 -8580 0 0 {name=p8028 lab=_84928_/Q }
C {devices/lab_pin.sym} 8060 -8540 0 0 {name=p8029 lab=_58025_/X }
C {devices/lab_pin.sym} 8060 -8500 0 0 {name=p8030 lab=_58061_/X }
C {devices/lab_pin.sym} 8060 -8460 0 0 {name=p8031 lab=_58068_/X }
C {devices/lab_pin.sym} 8220 -8520 0 1 {name=p8032 lab=_84928_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 8140 -8520 0 0 {name=X_58069_ }
C {devices/lab_pin.sym} 8060 -8390 0 0 {name=p8033 lab=_70337_/X }
C {devices/lab_pin.sym} 8060 -8350 0 0 {name=p8034 lab=_74760_/A }
C {devices/lab_pin.sym} 8060 -8310 0 0 {name=p8035 lab=_70346_/X }
C {devices/lab_pin.sym} 8220 -8350 0 1 {name=p8036 lab=_83788_/D }
C {sky130_stdcells/a21o_4.sym} 8140 -8350 0 0 {name=X_70347_ }
C {devices/lab_pin.sym} 8100 -8210 0 0 {name=p8037 lab=_40362_/X }
C {devices/lab_pin.sym} 8180 -8210 0 1 {name=p8038 lab=_43296_/A }
C {sky130_stdcells/buf_2.sym} 8140 -8210 0 0 {name=X_43295_ }
C {devices/lab_pin.sym} 8060 -8110 0 0 {name=p8039 lab=_78987_/Y }
C {devices/lab_pin.sym} 8060 -8070 0 0 {name=p8040 lab=_78979_/B }
C {devices/lab_pin.sym} 8060 -8030 0 0 {name=p8041 lab=_78991_/Y }
C {devices/lab_pin.sym} 8220 -8070 0 1 {name=p8042 lab=_78993_/B }
C {sky130_stdcells/o21ai_4.sym} 8140 -8070 0 0 {name=X_78992_ }
C {devices/lab_pin.sym} 8100 -7930 0 0 {name=p8043 lab=clkbuf_9_180_0_CLK/X }
C {devices/lab_pin.sym} 8180 -7930 0 1 {name=p8044 lab=_86312_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 8140 -7930 0 0 {name=Xclkbuf_10_361_0_CLK }
C {devices/lab_pin.sym} 8080 -7840 0 0 {name=p8045 lab=_59913_/A }
C {devices/lab_pin.sym} 8080 -7800 0 0 {name=p8046 lab=_59881_/X }
C {devices/lab_pin.sym} 8080 -7760 0 0 {name=p8047 lab=_59884_/X }
C {devices/lab_pin.sym} 8080 -7720 0 0 {name=p8048 lab=_59973_/A }
C {devices/lab_pin.sym} 8200 -7780 0 1 {name=p8049 lab=_60100_/Y }
C {sky130_stdcells/nand4_4.sym} 8140 -7780 0 0 {name=X_60100_ }
C {devices/lab_pin.sym} 8060 -7650 0 0 {name=p8050 lab=_49909_/Y }
C {devices/lab_pin.sym} 8060 -7610 0 0 {name=p8051 lab=_49897_/X }
C {devices/lab_pin.sym} 8060 -7570 0 0 {name=p8052 lab=_49910_/X }
C {devices/lab_pin.sym} 8220 -7610 0 1 {name=p8053 lab=_49911_/Y }
C {sky130_stdcells/a21oi_4.sym} 8140 -7610 0 0 {name=X_49911_ }
C {devices/lab_pin.sym} 8060 -7490 0 0 {name=p8054 lab=_45031_/X }
C {devices/lab_pin.sym} 8060 -7450 0 0 {name=p8055 lab=_45033_/Y }
C {devices/lab_pin.sym} 8060 -7410 0 0 {name=p8056 lab=_44973_/X }
C {devices/lab_pin.sym} 8220 -7450 0 1 {name=p8057 lab=_45034_/Y }
C {sky130_stdcells/a21oi_4.sym} 8140 -7450 0 0 {name=X_45034_ }
C {devices/lab_pin.sym} 8100 -7310 0 0 {name=p8058 lab=_42245_/Y }
C {devices/lab_pin.sym} 8180 -7310 0 1 {name=p8059 lab=_87962_/D }
C {sky130_stdcells/inv_2.sym} 8140 -7310 0 0 {name=X_42246_ }
C {devices/lab_pin.sym} 8060 -7220 0 0 {name=p8060 lab=_72959_/X }
C {devices/lab_pin.sym} 8060 -7180 0 0 {name=p8061 lab=_85590_/Q }
C {devices/lab_pin.sym} 8060 -7140 0 0 {name=p8062 lab=_72839_/X }
C {devices/lab_pin.sym} 8060 -7100 0 0 {name=p8063 lab=_73065_/X }
C {devices/lab_pin.sym} 8220 -7160 0 1 {name=p8064 lab=_73066_/X }
C {sky130_stdcells/a211o_4.sym} 8140 -7160 0 0 {name=X_73066_ }
C {devices/lab_pin.sym} 8080 -7020 0 0 {name=p8065 lab=_82250_/Q }
C {devices/lab_pin.sym} 8080 -6980 0 0 {name=p8066 lab=_81962_/Q }
C {devices/lab_pin.sym} 8200 -7000 0 1 {name=p8067 lab=_77944_/B }
C {sky130_stdcells/xor2_4.sym} 8140 -7000 0 0 {name=X_77943_ }
C {devices/lab_pin.sym} 8080 -6900 0 0 {name=p8068 lab=_61205_/B }
C {devices/lab_pin.sym} 8080 -6860 0 0 {name=p8069 lab=_61079_/Y }
C {devices/lab_pin.sym} 8080 -6820 0 0 {name=p8070 lab=_59662_/C }
C {devices/lab_pin.sym} 8080 -6780 0 0 {name=p8071 lab=_61070_/C }
C {devices/lab_pin.sym} 8200 -6840 0 1 {name=p8072 lab=_61081_/A }
C {sky130_stdcells/and4_4.sym} 8140 -6840 0 0 {name=X_61080_ }
C {devices/lab_pin.sym} 8100 -6690 0 0 {name=p8073 lab=clkbuf_9_495_0_CLK/X }
C {devices/lab_pin.sym} 8180 -6690 0 1 {name=p8074 lab=_85562_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 8140 -6690 0 0 {name=Xclkbuf_10_991_0_CLK }
C {devices/lab_pin.sym} 8060 -6590 0 0 {name=p8075 lab=_70269_/X }
C {devices/lab_pin.sym} 8060 -6550 0 0 {name=p8076 lab=_74775_/B }
C {devices/lab_pin.sym} 8060 -6510 0 0 {name=p8077 lab=_70277_/X }
C {devices/lab_pin.sym} 8220 -6550 0 1 {name=p8078 lab=_70278_/X }
C {sky130_stdcells/a21o_4.sym} 8140 -6550 0 0 {name=X_70278_ }
C {devices/lab_pin.sym} 8080 -6430 0 0 {name=p8079 lab=_59710_/Y }
C {devices/lab_pin.sym} 8080 -6390 0 0 {name=p8080 lab=_60620_/B }
C {devices/lab_pin.sym} 8080 -6350 0 0 {name=p8081 lab=_60620_/C }
C {devices/lab_pin.sym} 8200 -6390 0 1 {name=p8082 lab=_60031_/X }
C {sky130_stdcells/and3_4.sym} 8140 -6390 0 0 {name=X_60031_ }
C {devices/lab_pin.sym} 8100 -6250 0 0 {name=p8083 lab=_72017_/A }
C {devices/lab_pin.sym} 8180 -6250 0 1 {name=p8084 lab=_72017_/X }
C {sky130_stdcells/buf_2.sym} 8140 -6250 0 0 {name=X_72017_ }
C {devices/lab_pin.sym} 8060 -6150 0 0 {name=p8085 lab=_86313_/Q }
C {devices/lab_pin.sym} 8060 -6110 0 0 {name=p8086 lab=_49825_/X }
C {devices/lab_pin.sym} 8060 -6070 0 0 {name=p8087 lab=_49841_/Y }
C {devices/lab_pin.sym} 8220 -6110 0 1 {name=p8088 lab=_49842_/Y }
C {sky130_stdcells/o21ai_4.sym} 8140 -6110 0 0 {name=X_49842_ }
C {devices/lab_pin.sym} 8060 -6010 0 0 {name=p8089 lab=_42173_/X }
C {devices/lab_pin.sym} 8060 -5970 0 0 {name=p8090 lab=_42169_/X }
C {devices/lab_pin.sym} 8060 -5930 0 0 {name=p8091 lab=_41234_/X }
C {devices/lab_pin.sym} 8060 -5890 0 0 {name=p8092 lab=_87996_/Q }
C {devices/lab_pin.sym} 8060 -5850 0 0 {name=p8093 lab=_42170_/X }
C {devices/lab_pin.sym} 8220 -5930 0 1 {name=p8094 lab=_42178_/A }
C {sky130_stdcells/o32ai_4.sym} 8140 -5930 0 0 {name=X_42177_ }
C {devices/lab_pin.sym} 8100 -5770 0 0 {name=p8095 lab=clkbuf_9_483_0_CLK/A }
C {devices/lab_pin.sym} 8180 -5770 0 1 {name=p8096 lab=clkbuf_9_482_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 8140 -5770 0 0 {name=Xclkbuf_9_482_0_CLK }
C {devices/lab_pin.sym} 8080 -5660 0 0 {name=p8097 lab=_77861_/A }
C {devices/lab_pin.sym} 8080 -5620 0 0 {name=p8098 lab=_77869_/A }
C {devices/lab_pin.sym} 8200 -5640 0 1 {name=p8099 lab=_77874_/X }
C {sky130_stdcells/and2_4.sym} 8140 -5640 0 0 {name=X_77874_ }
C {devices/lab_pin.sym} 8080 -5520 0 0 {name=p8100 lab=_79611_/Y }
C {devices/lab_pin.sym} 8080 -5480 0 0 {name=p8101 lab=_79612_/Y }
C {devices/lab_pin.sym} 8200 -5500 0 1 {name=p8102 lab=_79613_/X }
C {sky130_stdcells/xor2_4.sym} 8140 -5500 0 0 {name=X_79613_ }
C {devices/lab_pin.sym} 8080 -5380 0 0 {name=p8103 lab=_81726_/Q }
C {devices/lab_pin.sym} 8080 -5340 0 0 {name=p8104 lab=_41102_/B }
C {devices/lab_pin.sym} 8200 -5360 0 1 {name=p8105 lab=_41128_/X }
C {sky130_stdcells/or2_4.sym} 8140 -5360 0 0 {name=X_41128_ }
C {devices/lab_pin.sym} 8080 -5240 0 0 {name=p8106 lab=_76825_/A }
C {devices/lab_pin.sym} 8080 -5200 0 0 {name=p8107 lab=_76824_/Y }
C {devices/lab_pin.sym} 8200 -5220 0 1 {name=p8108 lab=_76826_/B }
C {sky130_stdcells/xor2_4.sym} 8140 -5220 0 0 {name=X_76825_ }
C {devices/lab_pin.sym} 8100 -5090 0 0 {name=p8109 lab=clkbuf_9_188_0_CLK/X }
C {devices/lab_pin.sym} 8180 -5090 0 1 {name=p8110 lab=_86686_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 8140 -5090 0 0 {name=Xclkbuf_10_376_0_CLK }
C {devices/lab_pin.sym} 8060 -4990 0 0 {name=p8111 lab=_49771_/Y }
C {devices/lab_pin.sym} 8060 -4950 0 0 {name=p8112 lab=_49759_/X }
C {devices/lab_pin.sym} 8060 -4910 0 0 {name=p8113 lab=_49772_/X }
C {devices/lab_pin.sym} 8220 -4950 0 1 {name=p8114 lab=_49773_/Y }
C {sky130_stdcells/a21oi_4.sym} 8140 -4950 0 0 {name=X_49773_ }
C {devices/lab_pin.sym} 8080 -4820 0 0 {name=p8115 lab=_46959_/A }
C {devices/lab_pin.sym} 8080 -4780 0 0 {name=p8116 lab=_52787_/B }
C {devices/lab_pin.sym} 8200 -4800 0 1 {name=p8117 lab=_46985_/Y }
C {sky130_stdcells/nand2_4.sym} 8140 -4800 0 0 {name=X_46985_ }
C {devices/lab_pin.sym} 8060 -4690 0 0 {name=p8118 lab=_48722_/Y }
C {devices/lab_pin.sym} 8060 -4650 0 0 {name=p8119 lab=_48156_/X }
C {devices/lab_pin.sym} 8060 -4610 0 0 {name=p8120 lab=_48723_/X }
C {devices/lab_pin.sym} 8220 -4650 0 1 {name=p8121 lab=_86495_/D }
C {sky130_stdcells/a21oi_4.sym} 8140 -4650 0 0 {name=X_48724_ }
C {devices/lab_pin.sym} 8080 -4520 0 0 {name=p8122 lab=_79544_/A }
C {devices/lab_pin.sym} 8080 -4480 0 0 {name=p8123 lab=_79540_/C }
C {devices/lab_pin.sym} 8200 -4500 0 1 {name=p8124 lab=_79545_/B }
C {sky130_stdcells/nand2_4.sym} 8140 -4500 0 0 {name=X_79544_ }
C {devices/lab_pin.sym} 8060 -4390 0 0 {name=p8125 lab=_45919_/Y }
C {devices/lab_pin.sym} 8060 -4350 0 0 {name=p8126 lab=_45928_/X }
C {devices/lab_pin.sym} 8060 -4310 0 0 {name=p8127 lab=_45935_/X }
C {devices/lab_pin.sym} 8220 -4350 0 1 {name=p8128 lab=_86842_/D }
C {sky130_stdcells/a21oi_4.sym} 8140 -4350 0 0 {name=X_45936_ }
C {devices/lab_pin.sym} 8100 -4210 0 0 {name=p8129 lab=_41058_/Y }
C {devices/lab_pin.sym} 8180 -4210 0 1 {name=p8130 lab=_41059_/X }
C {sky130_stdcells/buf_2.sym} 8140 -4210 0 0 {name=X_41059_ }
C {devices/lab_pin.sym} 8060 -4120 0 0 {name=p8131 lab=_64615_/X }
C {devices/lab_pin.sym} 8060 -4080 0 0 {name=p8132 lab=_85563_/Q }
C {devices/lab_pin.sym} 8060 -4040 0 0 {name=p8133 lab=_64642_/X }
C {devices/lab_pin.sym} 8060 -4000 0 0 {name=p8134 lab=_64769_/X }
C {devices/lab_pin.sym} 8220 -4060 0 1 {name=p8135 lab=_64770_/X }
C {sky130_stdcells/a211o_4.sym} 8140 -4060 0 0 {name=X_64770_ }
C {devices/lab_pin.sym} 8080 -3920 0 0 {name=p8136 lab=_76768_/A }
C {devices/lab_pin.sym} 8080 -3880 0 0 {name=p8137 lab=_76755_/Y }
C {devices/lab_pin.sym} 8200 -3900 0 1 {name=p8138 lab=_76763_/A }
C {sky130_stdcells/xor2_4.sym} 8140 -3900 0 0 {name=X_76756_ }
C {devices/lab_pin.sym} 8060 -3800 0 0 {name=p8139 lab=_63562_/A }
C {devices/lab_pin.sym} 8060 -3760 0 0 {name=p8140 lab=_59841_/X }
C {devices/lab_pin.sym} 8060 -3720 0 0 {name=p8141 lab=_61528_/A }
C {devices/lab_pin.sym} 8060 -3680 0 0 {name=p8142 lab=_61981_/X }
C {devices/lab_pin.sym} 8220 -3740 0 1 {name=p8143 lab=_61982_/X }
C {sky130_stdcells/a2bb2o_4.sym} 8140 -3740 0 0 {name=X_61982_ }
C {devices/lab_pin.sym} 8060 -3610 0 0 {name=p8144 lab=_88354_/Q }
C {devices/lab_pin.sym} 8060 -3570 0 0 {name=p8145 lab=_73777_/X }
C {devices/lab_pin.sym} 8060 -3530 0 0 {name=p8146 lab=_73898_/X }
C {devices/lab_pin.sym} 8220 -3570 0 1 {name=p8147 lab=_73968_/X }
C {sky130_stdcells/o21a_4.sym} 8140 -3570 0 0 {name=X_73968_ }
C {devices/lab_pin.sym} 8080 -3460 0 0 {name=p8148 lab=_61714_/A }
C {devices/lab_pin.sym} 8080 -3420 0 0 {name=p8149 lab=_60870_/X }
C {devices/lab_pin.sym} 8080 -3380 0 0 {name=p8150 lab=_63721_/C }
C {devices/lab_pin.sym} 8080 -3340 0 0 {name=p8151 lab=_61012_/A }
C {devices/lab_pin.sym} 8200 -3400 0 1 {name=p8152 lab=_63721_/Y }
C {sky130_stdcells/nand4_4.sym} 8140 -3400 0 0 {name=X_63721_ }
C {devices/lab_pin.sym} 8080 -3260 0 0 {name=p8153 lab=_81121_/Q }
C {devices/lab_pin.sym} 8080 -3220 0 0 {name=p8154 lab=_75707_/B }
C {devices/lab_pin.sym} 8200 -3240 0 1 {name=p8155 lab=_75707_/Y }
C {sky130_stdcells/xnor2_4.sym} 8140 -3240 0 0 {name=X_75707_ }
C {devices/lab_pin.sym} 8100 -3110 0 0 {name=p8156 lab=clkbuf_9_497_0_CLK/A }
C {devices/lab_pin.sym} 8180 -3110 0 1 {name=p8157 lab=clkbuf_9_497_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 8140 -3110 0 0 {name=Xclkbuf_9_497_0_CLK }
C {devices/lab_pin.sym} 8060 -3010 0 0 {name=p8158 lab=_48652_/X }
C {devices/lab_pin.sym} 8060 -2970 0 0 {name=p8159 lab=_48110_/A }
C {devices/lab_pin.sym} 8060 -2930 0 0 {name=p8160 lab=_48654_/Y }
C {devices/lab_pin.sym} 8220 -2970 0 1 {name=p8161 lab=_48656_/A }
C {sky130_stdcells/o21ai_4.sym} 8140 -2970 0 0 {name=X_48655_ }
C {devices/lab_pin.sym} 8100 -2830 0 0 {name=p8162 lab=_60359_/A }
C {devices/lab_pin.sym} 8180 -2830 0 1 {name=p8163 lab=_60933_/X }
C {sky130_stdcells/buf_2.sym} 8140 -2830 0 0 {name=X_60933_ }
C {devices/lab_pin.sym} 8080 -2720 0 0 {name=p8164 lab=_73050_/A }
C {devices/lab_pin.sym} 8080 -2680 0 0 {name=p8165 lab=_72918_/Y }
C {devices/lab_pin.sym} 8200 -2700 0 1 {name=p8166 lab=_72919_/Y }
C {sky130_stdcells/nor2_4.sym} 8140 -2700 0 0 {name=X_72919_ }
C {devices/lab_pin.sym} 8080 -2580 0 0 {name=p8167 lab=_84814_/Q }
C {devices/lab_pin.sym} 8080 -2540 0 0 {name=p8168 lab=_84134_/Q }
C {devices/lab_pin.sym} 8200 -2560 0 1 {name=p8169 lab=_79475_/X }
C {sky130_stdcells/xor2_4.sym} 8140 -2560 0 0 {name=X_79475_ }
C {devices/lab_pin.sym} 8100 -2430 0 0 {name=p8170 lab=_85090_/Q }
C {devices/lab_pin.sym} 8180 -2430 0 1 {name=p8171 lab=_57084_/B }
C {sky130_stdcells/inv_2.sym} 8140 -2430 0 0 {name=X_45867_ }
C {devices/lab_pin.sym} 8060 -2330 0 0 {name=p8172 lab=_76680_/Y }
C {devices/lab_pin.sym} 8060 -2290 0 0 {name=p8173 lab=_76685_/Y }
C {devices/lab_pin.sym} 8060 -2250 0 0 {name=p8174 lab=_76686_/Y }
C {devices/lab_pin.sym} 8220 -2290 0 1 {name=p8175 lab=_76687_/Y }
C {sky130_stdcells/a21oi_4.sym} 8140 -2290 0 0 {name=X_76687_ }
C {devices/lab_pin.sym} 8060 -2170 0 0 {name=p8176 lab=_68735_/B }
C {devices/lab_pin.sym} 8060 -2130 0 0 {name=p8177 lab=_73777_/X }
C {devices/lab_pin.sym} 8060 -2090 0 0 {name=p8178 lab=_73898_/X }
C {devices/lab_pin.sym} 8220 -2130 0 1 {name=p8179 lab=_73899_/X }
C {sky130_stdcells/o21a_4.sym} 8140 -2130 0 0 {name=X_73899_ }
C {devices/lab_pin.sym} 8100 -1990 0 0 {name=p8180 lab=_55005_/D }
C {devices/lab_pin.sym} 8180 -1990 0 1 {name=p8181 lab=_53144_/D }
C {sky130_stdcells/buf_2.sym} 8140 -1990 0 0 {name=X_47606_ }
C {devices/lab_pin.sym} 8100 -1870 0 0 {name=p8182 lab=_66391_/A }
C {devices/lab_pin.sym} 8180 -1870 0 1 {name=p8183 lab=_66476_/B }
C {sky130_stdcells/buf_2.sym} 8140 -1870 0 0 {name=X_66440_ }
C {devices/lab_pin.sym} 8080 -1770 0 0 {name=p8184 lab=_78413_/Y }
C {devices/lab_pin.sym} 8080 -1730 0 0 {name=p8185 lab=_78426_/B }
C {devices/lab_pin.sym} 8080 -1690 0 0 {name=p8186 lab=_78426_/C }
C {devices/lab_pin.sym} 8200 -1730 0 1 {name=p8187 lab=_78426_/Y }
C {sky130_stdcells/nand3_4.sym} 8140 -1730 0 0 {name=X_78426_ }
C {devices/lab_pin.sym} 8100 -1590 0 0 {name=p8188 lab=_45964_/A }
C {devices/lab_pin.sym} 8180 -1590 0 1 {name=p8189 lab=_44818_/X }
C {sky130_stdcells/buf_2.sym} 8140 -1590 0 0 {name=X_44818_ }
C {devices/lab_pin.sym} 8060 -1510 0 0 {name=p8190 lab=_63648_/Y }
C {devices/lab_pin.sym} 8060 -1470 0 0 {name=p8191 lab=_63649_/X }
C {devices/lab_pin.sym} 8060 -1430 0 0 {name=p8192 lab=_63651_/X }
C {devices/lab_pin.sym} 8060 -1390 0 0 {name=p8193 lab=_58344_/A }
C {devices/lab_pin.sym} 8060 -1350 0 0 {name=p8194 lab=_63363_/X }
C {devices/lab_pin.sym} 8220 -1430 0 1 {name=p8195 lab=_63652_/Y }
C {sky130_stdcells/o32ai_4.sym} 8140 -1430 0 0 {name=X_63652_ }
C {devices/lab_pin.sym} 8080 -1280 0 0 {name=p8196 lab=_75638_/A }
C {devices/lab_pin.sym} 8080 -1240 0 0 {name=p8197 lab=_75637_/Y }
C {devices/lab_pin.sym} 8200 -1260 0 1 {name=p8198 lab=_75659_/A }
C {sky130_stdcells/xor2_4.sym} 8140 -1260 0 0 {name=X_75638_ }
C {devices/lab_pin.sym} 8100 -1130 0 0 {name=p8199 lab=_81773_/Q }
C {devices/lab_pin.sym} 8180 -1130 0 1 {name=p8200 lab=_48586_/Y }
C {sky130_stdcells/inv_2.sym} 8140 -1130 0 0 {name=X_48586_ }
C {devices/lab_pin.sym} 8100 -1010 0 0 {name=p8201 lab=_60863_/X }
C {devices/lab_pin.sym} 8180 -1010 0 1 {name=p8202 lab=_60864_/X }
C {sky130_stdcells/buf_2.sym} 8140 -1010 0 0 {name=X_60864_ }
C {devices/lab_pin.sym} 8100 -890 0 0 {name=p8203 lab=_45734_/A }
C {devices/lab_pin.sym} 8180 -890 0 1 {name=p8204 lab=_45798_/X }
C {sky130_stdcells/buf_2.sym} 8140 -890 0 0 {name=X_45798_ }
C {devices/lab_pin.sym} 8060 -810 0 0 {name=p8205 lab=_62596_/X }
C {devices/lab_pin.sym} 8060 -770 0 0 {name=p8206 lab=_62600_/Y }
C {devices/lab_pin.sym} 8060 -730 0 0 {name=p8207 lab=_62602_/X }
C {devices/lab_pin.sym} 8060 -690 0 0 {name=p8208 lab=_84869_/Q }
C {devices/lab_pin.sym} 8060 -650 0 0 {name=p8209 lab=_62572_/X }
C {devices/lab_pin.sym} 8220 -730 0 1 {name=p8210 lab=_62603_/Y }
C {sky130_stdcells/o32ai_4.sym} 8140 -730 0 0 {name=X_62603_ }
C {devices/lab_pin.sym} 9000 -42160 0 0 {name=p8211 lab=_47553_/A }
C {devices/lab_pin.sym} 9000 -42120 0 0 {name=p8212 lab=_53105_/B }
C {devices/lab_pin.sym} 9120 -42140 0 1 {name=p8213 lab=_47537_/Y }
C {sky130_stdcells/nand2_4.sym} 9060 -42140 0 0 {name=X_47537_ }
C {devices/lab_pin.sym} 9000 -42030 0 0 {name=p8214 lab=_65938_/X }
C {devices/lab_pin.sym} 9000 -41990 0 0 {name=p8215 lab=_66367_/B }
C {devices/lab_pin.sym} 9000 -41950 0 0 {name=p8216 lab=_65940_/X }
C {devices/lab_pin.sym} 9120 -41990 0 1 {name=p8217 lab=_66371_/Y }
C {sky130_stdcells/nand3_4.sym} 9060 -41990 0 0 {name=X_66371_ }
C {devices/lab_pin.sym} 9000 -41860 0 0 {name=p8218 lab=_78358_/A }
C {devices/lab_pin.sym} 9000 -41820 0 0 {name=p8219 lab=_78358_/B }
C {devices/lab_pin.sym} 9120 -41840 0 1 {name=p8220 lab=_78360_/A }
C {sky130_stdcells/or2_4.sym} 9060 -41840 0 0 {name=X_78357_ }
C {devices/lab_pin.sym} 8980 -41750 0 0 {name=p8221 lab=_44740_/X }
C {devices/lab_pin.sym} 8980 -41710 0 0 {name=p8222 lab=_44741_/X }
C {devices/lab_pin.sym} 8980 -41670 0 0 {name=p8223 lab=_40762_/X }
C {devices/lab_pin.sym} 8980 -41630 0 0 {name=p8224 lab=_86976_/Q }
C {devices/lab_pin.sym} 8980 -41590 0 0 {name=p8225 lab=_44742_/X }
C {devices/lab_pin.sym} 9140 -41670 0 1 {name=p8226 lab=_44749_/Y }
C {sky130_stdcells/o32ai_4.sym} 9060 -41670 0 0 {name=X_44749_ }
C {devices/lab_pin.sym} 8980 -41540 0 0 {name=p8227 lab=_58383_/A }
C {devices/lab_pin.sym} 8980 -41500 0 0 {name=p8228 lab=_63558_/X }
C {devices/lab_pin.sym} 8980 -41460 0 0 {name=p8229 lab=_61551_/A }
C {devices/lab_pin.sym} 8980 -41420 0 0 {name=p8230 lab=_63559_/X }
C {devices/lab_pin.sym} 9140 -41480 0 1 {name=p8231 lab=_63583_/X }
C {sky130_stdcells/a2bb2o_4.sym} 9060 -41480 0 0 {name=X_63583_ }
C {devices/lab_pin.sym} 9000 -41340 0 0 {name=p8232 lab=_75574_/A }
C {devices/lab_pin.sym} 9000 -41300 0 0 {name=p8233 lab=_80818_/Q }
C {devices/lab_pin.sym} 9120 -41320 0 1 {name=p8234 lab=_75887_/A }
C {sky130_stdcells/xnor2_4.sym} 9060 -41320 0 0 {name=X_75569_ }
C {devices/lab_pin.sym} 9020 -41190 0 0 {name=p8235 lab=clkbuf_8_210_0_CLK/X }
C {devices/lab_pin.sym} 9100 -41190 0 1 {name=p8236 lab=clkbuf_9_420_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 9060 -41190 0 0 {name=Xclkbuf_9_420_0_CLK }
C {devices/lab_pin.sym} 8980 -41090 0 0 {name=p8237 lab=_60660_/X }
C {devices/lab_pin.sym} 8980 -41050 0 0 {name=p8238 lab=_60725_/B }
C {devices/lab_pin.sym} 8980 -41010 0 0 {name=p8239 lab=_60778_/Y }
C {devices/lab_pin.sym} 9140 -41050 0 1 {name=p8240 lab=_60795_/X }
C {sky130_stdcells/o21a_4.sym} 9060 -41050 0 0 {name=X_60795_ }
C {devices/lab_pin.sym} 9020 -40910 0 0 {name=p8241 lab=_68089_/A }
C {devices/lab_pin.sym} 9100 -40910 0 1 {name=p8242 lab=_68110_/X }
C {sky130_stdcells/buf_2.sym} 9060 -40910 0 0 {name=X_68110_ }
C {devices/lab_pin.sym} 8980 -40810 0 0 {name=p8243 lab=_65312_/Y }
C {devices/lab_pin.sym} 8980 -40770 0 0 {name=p8244 lab=_65321_/Y }
C {devices/lab_pin.sym} 8980 -40730 0 0 {name=p8245 lab=_63231_/X }
C {devices/lab_pin.sym} 9140 -40770 0 1 {name=p8246 lab=_65322_/Y }
C {sky130_stdcells/a21oi_4.sym} 9060 -40770 0 0 {name=X_65322_ }
C {devices/lab_pin.sym} 9020 -40630 0 0 {name=p8247 lab=_77308_/A }
C {devices/lab_pin.sym} 9100 -40630 0 1 {name=p8248 lab=_77308_/Y }
C {sky130_stdcells/inv_2.sym} 9060 -40630 0 0 {name=X_77308_ }
C {devices/lab_pin.sym} 9020 -40510 0 0 {name=p8249 lab=_62534_/A }
C {devices/lab_pin.sym} 9100 -40510 0 1 {name=p8250 lab=_62534_/X }
C {sky130_stdcells/buf_2.sym} 9060 -40510 0 0 {name=X_62534_ }
C {devices/lab_pin.sym} 8980 -40420 0 0 {name=p8251 lab=_88085_/Q }
C {devices/lab_pin.sym} 8980 -40380 0 0 {name=p8252 lab=_68640_/X }
C {devices/lab_pin.sym} 8980 -40340 0 0 {name=p8253 lab=_69088_/X }
C {devices/lab_pin.sym} 8980 -40300 0 0 {name=p8254 lab=_69089_/Y }
C {devices/lab_pin.sym} 9140 -40360 0 1 {name=p8255 lab=_69090_/X }
C {sky130_stdcells/a211o_4.sym} 9060 -40360 0 0 {name=X_69090_ }
C {devices/lab_pin.sym} 9020 -40210 0 0 {name=p8256 lab=_47468_/A }
C {devices/lab_pin.sym} 9100 -40210 0 1 {name=p8257 lab=_47469_/A }
C {sky130_stdcells/inv_2.sym} 9060 -40210 0 0 {name=X_47468_ }
C {devices/lab_pin.sym} 9020 -40090 0 0 {name=p8258 lab=clkbuf_9_157_0_CLK/X }
C {devices/lab_pin.sym} 9100 -40090 0 1 {name=p8259 lab=_82251_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9060 -40090 0 0 {name=Xclkbuf_10_314_0_CLK }
C {devices/lab_pin.sym} 9000 -39980 0 0 {name=p8260 lab=_78296_/A }
C {devices/lab_pin.sym} 9000 -39940 0 0 {name=p8261 lab=_78296_/B }
C {devices/lab_pin.sym} 9120 -39960 0 1 {name=p8262 lab=_78292_/A }
C {sky130_stdcells/xnor2_4.sym} 9060 -39960 0 0 {name=X_78288_ }
C {devices/lab_pin.sym} 9000 -39840 0 0 {name=p8263 lab=_49232_/A }
C {devices/lab_pin.sym} 9000 -39800 0 0 {name=p8264 lab=_51235_/B }
C {devices/lab_pin.sym} 9120 -39820 0 1 {name=p8265 lab=_49207_/Y }
C {sky130_stdcells/nand2_4.sym} 9060 -39820 0 0 {name=X_49207_ }
C {devices/lab_pin.sym} 9020 -39690 0 0 {name=p8266 lab=_68637_/A }
C {devices/lab_pin.sym} 9100 -39690 0 1 {name=p8267 lab=_68437_/A }
C {sky130_stdcells/buf_2.sym} 9060 -39690 0 0 {name=X_68041_ }
C {devices/lab_pin.sym} 9020 -39570 0 0 {name=p8268 lab=_46419_/A }
C {devices/lab_pin.sym} 9100 -39570 0 1 {name=p8269 lab=_52494_/B }
C {sky130_stdcells/inv_2.sym} 9060 -39570 0 0 {name=X_46419_ }
C {devices/lab_pin.sym} 9000 -39460 0 0 {name=p8270 lab=_65206_/A }
C {devices/lab_pin.sym} 9000 -39420 0 0 {name=p8271 lab=_65253_/B }
C {devices/lab_pin.sym} 9120 -39440 0 1 {name=p8272 lab=_65253_/X }
C {sky130_stdcells/and2_4.sym} 9060 -39440 0 0 {name=X_65253_ }
C {devices/lab_pin.sym} 9020 -39310 0 0 {name=p8273 lab=clkbuf_9_472_0_CLK/X }
C {devices/lab_pin.sym} 9100 -39310 0 1 {name=p8274 lab=_88324_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9060 -39310 0 0 {name=Xclkbuf_10_944_0_CLK }
C {devices/lab_pin.sym} 9000 -39210 0 0 {name=p8275 lab=_77239_/A }
C {devices/lab_pin.sym} 9000 -39170 0 0 {name=p8276 lab=_77239_/B }
C {devices/lab_pin.sym} 9000 -39130 0 0 {name=p8277 lab=_77239_/C }
C {devices/lab_pin.sym} 9120 -39170 0 1 {name=p8278 lab=_77245_/C }
C {sky130_stdcells/nand3_4.sym} 9060 -39170 0 0 {name=X_77239_ }
C {devices/lab_pin.sym} 8980 -39070 0 0 {name=p8279 lab=_61538_/B }
C {devices/lab_pin.sym} 8980 -39030 0 0 {name=p8280 lab=_62462_/X }
C {devices/lab_pin.sym} 8980 -38990 0 0 {name=p8281 lab=_62436_/X }
C {devices/lab_pin.sym} 8980 -38950 0 0 {name=p8282 lab=_62407_/X }
C {devices/lab_pin.sym} 8980 -38920 0 0 {name=p8283 lab=_62464_/X }
C {devices/lab_pin.sym} 9140 -38990 0 1 {name=p8284 lab=_62465_/X }
C {sky130_stdcells/a41o_4.sym} 9060 -38990 0 0 {name=X_62465_ }
C {devices/lab_pin.sym} 9020 -38830 0 0 {name=p8285 lab=_47399_/A }
C {devices/lab_pin.sym} 9100 -38830 0 1 {name=p8286 lab=_53023_/D }
C {sky130_stdcells/buf_2.sym} 9060 -38830 0 0 {name=X_47399_ }
C {devices/lab_pin.sym} 9020 -38710 0 0 {name=p8287 lab=_64440_/A }
C {devices/lab_pin.sym} 9100 -38710 0 1 {name=p8288 lab=_64267_/A }
C {sky130_stdcells/buf_2.sym} 9060 -38710 0 0 {name=X_64204_ }
C {devices/lab_pin.sym} 9020 -38590 0 0 {name=p8289 lab=_48985_/A }
C {devices/lab_pin.sym} 9100 -38590 0 1 {name=p8290 lab=_49138_/X }
C {sky130_stdcells/buf_2.sym} 9060 -38590 0 0 {name=X_49138_ }
C {devices/lab_pin.sym} 8980 -38490 0 0 {name=p8291 lab=_61411_/X }
C {devices/lab_pin.sym} 8980 -38450 0 0 {name=p8292 lab=_61394_/X }
C {devices/lab_pin.sym} 8980 -38410 0 0 {name=p8293 lab=_61415_/Y }
C {devices/lab_pin.sym} 9140 -38450 0 1 {name=p8294 lab=_61416_/Y }
C {sky130_stdcells/a21oi_4.sym} 9060 -38450 0 0 {name=X_61416_ }
C {devices/lab_pin.sym} 9000 -38320 0 0 {name=p8295 lab=_80239_/Y }
C {devices/lab_pin.sym} 9000 -38280 0 0 {name=p8296 lab=_80242_/Y }
C {devices/lab_pin.sym} 9120 -38300 0 1 {name=p8297 lab=_80250_/X }
C {sky130_stdcells/or2_4.sym} 9060 -38300 0 0 {name=X_80250_ }
C {devices/lab_pin.sym} 9000 -38180 0 0 {name=p8298 lab=_65184_/A }
C {devices/lab_pin.sym} 9000 -38140 0 0 {name=p8299 lab=_85835_/Q }
C {devices/lab_pin.sym} 9120 -38160 0 1 {name=p8300 lab=_65184_/X }
C {sky130_stdcells/and2_4.sym} 9060 -38160 0 0 {name=X_65184_ }
C {devices/lab_pin.sym} 9020 -38030 0 0 {name=p8301 lab=clkbuf_9_435_0_CLK/A }
C {devices/lab_pin.sym} 9100 -38030 0 1 {name=p8302 lab=clkbuf_9_435_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 9060 -38030 0 0 {name=Xclkbuf_9_435_0_CLK }
C {devices/lab_pin.sym} 9020 -37910 0 0 {name=p8303 lab=_62395_/X }
C {devices/lab_pin.sym} 9100 -37910 0 1 {name=p8304 lab=_62396_/X }
C {sky130_stdcells/buf_2.sym} 9060 -37910 0 0 {name=X_62396_ }
C {devices/lab_pin.sym} 8980 -37810 0 0 {name=p8305 lab=_61640_/A }
C {devices/lab_pin.sym} 8980 -37770 0 0 {name=p8306 lab=_60967_/X }
C {devices/lab_pin.sym} 8980 -37730 0 0 {name=p8307 lab=_64134_/Y }
C {devices/lab_pin.sym} 9140 -37770 0 1 {name=p8308 lab=_64135_/X }
C {sky130_stdcells/a21bo_4.sym} 9060 -37770 0 0 {name=X_64135_ }
C {devices/lab_pin.sym} 9020 -37630 0 0 {name=p8309 lab=_49069_/A }
C {devices/lab_pin.sym} 9100 -37630 0 1 {name=p8310 lab=_52355_/A }
C {sky130_stdcells/buf_2.sym} 9060 -37630 0 0 {name=X_49069_ }
C {devices/lab_pin.sym} 9020 -37510 0 0 {name=p8311 lab=clkbuf_9_164_0_CLK/X }
C {devices/lab_pin.sym} 9100 -37510 0 1 {name=p8312 lab=_86008_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9060 -37510 0 0 {name=Xclkbuf_10_329_0_CLK }
C {devices/lab_pin.sym} 9020 -37390 0 0 {name=p8313 lab=_59961_/A }
C {devices/lab_pin.sym} 9100 -37390 0 1 {name=p8314 lab=_61348_/A }
C {sky130_stdcells/buf_2.sym} 9060 -37390 0 0 {name=X_61347_ }
C {devices/lab_pin.sym} 8980 -37290 0 0 {name=p8315 lab=_80178_/Y }
C {devices/lab_pin.sym} 8980 -37250 0 0 {name=p8316 lab=_80162_/B }
C {devices/lab_pin.sym} 8980 -37210 0 0 {name=p8317 lab=_80180_/X }
C {devices/lab_pin.sym} 9140 -37250 0 1 {name=p8318 lab=_80189_/A }
C {sky130_stdcells/o21ai_4.sym} 9060 -37250 0 0 {name=X_80181_ }
C {devices/lab_pin.sym} 9020 -37110 0 0 {name=p8319 lab=_59831_/X }
C {devices/lab_pin.sym} 9100 -37110 0 1 {name=p8320 lab=_69992_/X }
C {sky130_stdcells/buf_2.sym} 9060 -37110 0 0 {name=X_69992_ }
C {devices/lab_pin.sym} 8980 -37010 0 0 {name=p8321 lab=_51098_/Y }
C {devices/lab_pin.sym} 8980 -36970 0 0 {name=p8322 lab=_51093_/X }
C {devices/lab_pin.sym} 8980 -36930 0 0 {name=p8323 lab=_51099_/X }
C {devices/lab_pin.sym} 9140 -36970 0 1 {name=p8324 lab=_86074_/D }
C {sky130_stdcells/a21oi_4.sym} 9060 -36970 0 0 {name=X_51100_ }
C {devices/lab_pin.sym} 9020 -36830 0 0 {name=p8325 lab=clkbuf_9_479_0_CLK/X }
C {devices/lab_pin.sym} 9100 -36830 0 1 {name=p8326 lab=_86213_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9060 -36830 0 0 {name=Xclkbuf_10_959_0_CLK }
C {devices/lab_pin.sym} 8980 -36730 0 0 {name=p8327 lab=_52078_/Y }
C {devices/lab_pin.sym} 8980 -36690 0 0 {name=p8328 lab=_52066_/X }
C {devices/lab_pin.sym} 8980 -36650 0 0 {name=p8329 lab=_52079_/Y }
C {devices/lab_pin.sym} 9140 -36690 0 1 {name=p8330 lab=_52080_/Y }
C {sky130_stdcells/a21boi_4.sym} 9060 -36690 0 0 {name=X_52080_ }
C {devices/lab_pin.sym} 9020 -36550 0 0 {name=p8331 lab=_69357_/A }
C {devices/lab_pin.sym} 9100 -36550 0 1 {name=p8332 lab=_69011_/A }
C {sky130_stdcells/buf_2.sym} 9060 -36550 0 0 {name=X_68943_ }
C {devices/lab_pin.sym} 9000 -36460 0 0 {name=p8333 lab=_63610_/B }
C {devices/lab_pin.sym} 9000 -36420 0 0 {name=p8334 lab=_64095_/B }
C {devices/lab_pin.sym} 9000 -36380 0 0 {name=p8335 lab=_64095_/C }
C {devices/lab_pin.sym} 9000 -36340 0 0 {name=p8336 lab=_64095_/D }
C {devices/lab_pin.sym} 9120 -36400 0 1 {name=p8337 lab=_64066_/Y }
C {sky130_stdcells/nand4_4.sym} 9060 -36400 0 0 {name=X_64066_ }
C {devices/lab_pin.sym} 9000 -36270 0 0 {name=p8338 lab=_61278_/A }
C {devices/lab_pin.sym} 9000 -36230 0 0 {name=p8339 lab=_61278_/B }
C {devices/lab_pin.sym} 9000 -36190 0 0 {name=p8340 lab=_61281_/C }
C {devices/lab_pin.sym} 9120 -36230 0 1 {name=p8341 lab=_61312_/A }
C {sky130_stdcells/and3_4.sym} 9060 -36230 0 0 {name=X_61278_ }
C {devices/lab_pin.sym} 9000 -36100 0 0 {name=p8342 lab=_51022_/A }
C {devices/lab_pin.sym} 9000 -36060 0 0 {name=p8343 lab=_51031_/B }
C {devices/lab_pin.sym} 9120 -36080 0 1 {name=p8344 lab=_51031_/Y }
C {sky130_stdcells/nand2_4.sym} 9060 -36080 0 0 {name=X_51031_ }
C {devices/lab_pin.sym} 9000 -35980 0 0 {name=p8345 lab=_60476_/A }
C {devices/lab_pin.sym} 9000 -35940 0 0 {name=p8346 lab=_63017_/B }
C {devices/lab_pin.sym} 9000 -35900 0 0 {name=p8347 lab=_63030_/C }
C {devices/lab_pin.sym} 9000 -35860 0 0 {name=p8348 lab=_60541_/C }
C {devices/lab_pin.sym} 9120 -35920 0 1 {name=p8349 lab=_63017_/X }
C {sky130_stdcells/and4_4.sym} 9060 -35920 0 0 {name=X_63017_ }
C {devices/lab_pin.sym} 9000 -35790 0 0 {name=p8350 lab=_60224_/Y }
C {devices/lab_pin.sym} 9000 -35750 0 0 {name=p8351 lab=_60331_/B }
C {devices/lab_pin.sym} 9000 -35710 0 0 {name=p8352 lab=_60331_/D }
C {devices/lab_pin.sym} 9120 -35750 0 1 {name=p8353 lab=_60229_/Y }
C {sky130_stdcells/nand3_4.sym} 9060 -35750 0 0 {name=X_60229_ }
C {devices/lab_pin.sym} 8970 -35610 0 0 {name=p8354 lab=_83940_/CLK }
C {devices/lab_pin.sym} 8970 -35590 0 0 {name=p8355 lab=_83940_/D }
C {devices/lab_pin.sym} 9150 -35610 0 1 {name=p8356 lab=_81404_/D }
C {sky130_stdcells/dfxtp_4.sym} 9060 -35600 0 0 {name=X_83940_ }
C {devices/lab_pin.sym} 8980 -35490 0 0 {name=p8357 lab=_68869_/X }
C {devices/lab_pin.sym} 8980 -35450 0 0 {name=p8358 lab=_68873_/X }
C {devices/lab_pin.sym} 8980 -35410 0 0 {name=p8359 lab=_68806_/X }
C {devices/lab_pin.sym} 9140 -35450 0 1 {name=p8360 lab=_68874_/X }
C {sky130_stdcells/a21o_4.sym} 9060 -35450 0 0 {name=X_68874_ }
C {devices/lab_pin.sym} 9020 -35310 0 0 {name=p8361 lab=_67466_/X }
C {devices/lab_pin.sym} 9100 -35310 0 1 {name=p8362 lab=_67825_/X }
C {sky130_stdcells/buf_2.sym} 9060 -35310 0 0 {name=X_67825_ }
C {devices/lab_pin.sym} 8970 -35190 0 0 {name=p8363 lab=_82553_/CLK }
C {devices/lab_pin.sym} 8970 -35170 0 0 {name=p8364 lab=_70022_/X }
C {devices/lab_pin.sym} 9150 -35190 0 1 {name=p8365 lab=_83871_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -35180 0 0 {name=X_83871_ }
C {devices/lab_pin.sym} 8970 -35050 0 0 {name=p8366 lab=_84970_/CLK }
C {devices/lab_pin.sym} 8970 -35030 0 0 {name=p8367 lab=_85610_/D }
C {devices/lab_pin.sym} 9150 -35050 0 1 {name=p8368 lab=_85610_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -35040 0 0 {name=X_85610_ }
C {devices/lab_pin.sym} 8970 -34910 0 0 {name=p8369 lab=_82822_/CLK }
C {devices/lab_pin.sym} 8970 -34890 0 0 {name=p8370 lab=_82822_/D }
C {devices/lab_pin.sym} 9150 -34910 0 1 {name=p8371 lab=_82822_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -34900 0 0 {name=X_82822_ }
C {devices/lab_pin.sym} 8980 -34800 0 0 {name=p8372 lab=_83017_/Q }
C {devices/lab_pin.sym} 8980 -34760 0 0 {name=p8373 lab=_55157_/X }
C {devices/lab_pin.sym} 8980 -34720 0 0 {name=p8374 lab=_55172_/A }
C {devices/lab_pin.sym} 8980 -34680 0 0 {name=p8375 lab=_55769_/X }
C {devices/lab_pin.sym} 9140 -34740 0 1 {name=p8376 lab=_55771_/B }
C {sky130_stdcells/a211o_4.sym} 9060 -34740 0 0 {name=X_55770_ }
C {devices/lab_pin.sym} 9000 -34600 0 0 {name=p8377 lab=_67658_/X }
C {devices/lab_pin.sym} 9000 -34560 0 0 {name=p8378 lab=_67756_/B }
C {devices/lab_pin.sym} 9120 -34580 0 1 {name=p8379 lab=_67756_/X }
C {sky130_stdcells/and2_4.sym} 9060 -34580 0 0 {name=X_67756_ }
C {devices/lab_pin.sym} 8970 -34450 0 0 {name=p8380 lab=_86558_/CLK }
C {devices/lab_pin.sym} 8970 -34430 0 0 {name=p8381 lab=_86590_/D }
C {devices/lab_pin.sym} 9150 -34450 0 1 {name=p8382 lab=_73638_/B }
C {sky130_stdcells/dfxtp_4.sym} 9060 -34440 0 0 {name=X_86590_ }
C {devices/lab_pin.sym} 9000 -34340 0 0 {name=p8383 lab=_52997_/A }
C {devices/lab_pin.sym} 9000 -34300 0 0 {name=p8384 lab=_52982_/B }
C {devices/lab_pin.sym} 9000 -34260 0 0 {name=p8385 lab=_52997_/C }
C {devices/lab_pin.sym} 9000 -34220 0 0 {name=p8386 lab=_52982_/D }
C {devices/lab_pin.sym} 9120 -34280 0 1 {name=p8387 lab=_52982_/X }
C {sky130_stdcells/and4_4.sym} 9060 -34280 0 0 {name=X_52982_ }
C {devices/lab_pin.sym} 9020 -34130 0 0 {name=p8388 lab=_64967_/X }
C {devices/lab_pin.sym} 9100 -34130 0 1 {name=p8389 lab=_65196_/A }
C {sky130_stdcells/buf_2.sym} 9060 -34130 0 0 {name=X_64968_ }
C {devices/lab_pin.sym} 9000 -34040 0 0 {name=p8390 lab=_54699_/X }
C {devices/lab_pin.sym} 9000 -34000 0 0 {name=p8391 lab=_54734_/B }
C {devices/lab_pin.sym} 9000 -33960 0 0 {name=p8392 lab=_54721_/C }
C {devices/lab_pin.sym} 9000 -33920 0 0 {name=p8393 lab=_47407_/A }
C {devices/lab_pin.sym} 9120 -33980 0 1 {name=p8394 lab=_54721_/X }
C {sky130_stdcells/and4_4.sym} 9060 -33980 0 0 {name=X_54721_ }
C {devices/lab_pin.sym} 8980 -33850 0 0 {name=p8395 lab=_66702_/X }
C {devices/lab_pin.sym} 8980 -33810 0 0 {name=p8396 lab=_66705_/X }
C {devices/lab_pin.sym} 8980 -33770 0 0 {name=p8397 lab=_66706_/X }
C {devices/lab_pin.sym} 9140 -33810 0 1 {name=p8398 lab=_66707_/Y }
C {sky130_stdcells/a21oi_4.sym} 9060 -33810 0 0 {name=X_66707_ }
C {devices/lab_pin.sym} 8970 -33670 0 0 {name=p8399 lab=_86149_/CLK }
C {devices/lab_pin.sym} 8970 -33650 0 0 {name=p8400 lab=_85541_/D }
C {devices/lab_pin.sym} 9150 -33670 0 1 {name=p8401 lab=_85541_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -33660 0 0 {name=X_85541_ }
C {devices/lab_pin.sym} 8980 -33550 0 0 {name=p8402 lab=_73583_/B }
C {devices/lab_pin.sym} 8980 -33510 0 0 {name=p8403 lab=_51929_/X }
C {devices/lab_pin.sym} 8980 -33470 0 0 {name=p8404 lab=_51932_/Y }
C {devices/lab_pin.sym} 9140 -33510 0 1 {name=p8405 lab=_51933_/Y }
C {sky130_stdcells/o21ai_4.sym} 9060 -33510 0 0 {name=X_51933_ }
C {devices/lab_pin.sym} 9020 -33370 0 0 {name=p8406 lab=_60879_/B }
C {devices/lab_pin.sym} 9100 -33370 0 1 {name=p8407 lab=_63951_/C }
C {sky130_stdcells/buf_2.sym} 9060 -33370 0 0 {name=X_63919_ }
C {devices/lab_pin.sym} 8970 -33250 0 0 {name=p8408 lab=_82746_/CLK }
C {devices/lab_pin.sym} 8970 -33230 0 0 {name=p8409 lab=_66364_/C }
C {devices/lab_pin.sym} 9150 -33250 0 1 {name=p8410 lab=_82753_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -33240 0 0 {name=X_82753_ }
C {devices/lab_pin.sym} 8980 -33130 0 0 {name=p8411 lab=_84059_/Q }
C {devices/lab_pin.sym} 8980 -33090 0 0 {name=p8412 lab=_67568_/X }
C {devices/lab_pin.sym} 8980 -33050 0 0 {name=p8413 lab=_67686_/X }
C {devices/lab_pin.sym} 9140 -33090 0 1 {name=p8414 lab=_67687_/X }
C {sky130_stdcells/a21bo_4.sym} 9060 -33090 0 0 {name=X_67687_ }
C {devices/lab_pin.sym} 9000 -32960 0 0 {name=p8415 lab=_65319_/A }
C {devices/lab_pin.sym} 9000 -32920 0 0 {name=p8416 lab=_86422_/Q }
C {devices/lab_pin.sym} 9120 -32940 0 1 {name=p8417 lab=_64899_/X }
C {sky130_stdcells/and2_4.sym} 9060 -32940 0 0 {name=X_64899_ }
C {devices/lab_pin.sym} 8970 -32810 0 0 {name=p8418 lab=_81703_/CLK }
C {devices/lab_pin.sym} 8970 -32790 0 0 {name=p8419 lab=_81704_/D }
C {devices/lab_pin.sym} 9150 -32810 0 1 {name=p8420 lab=_81704_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -32800 0 0 {name=X_81704_ }
C {devices/lab_pin.sym} 9020 -32670 0 0 {name=p8421 lab=_57440_/A }
C {devices/lab_pin.sym} 9100 -32670 0 1 {name=p8422 lab=_57440_/X }
C {sky130_stdcells/buf_2.sym} 9060 -32670 0 0 {name=X_57440_ }
C {devices/lab_pin.sym} 8980 -32580 0 0 {name=p8423 lab=_88030_/Q }
C {devices/lab_pin.sym} 8980 -32540 0 0 {name=p8424 lab=_69424_/X }
C {devices/lab_pin.sym} 8980 -32500 0 0 {name=p8425 lab=_69202_/X }
C {devices/lab_pin.sym} 8980 -32460 0 0 {name=p8426 lab=_69425_/X }
C {devices/lab_pin.sym} 9140 -32520 0 1 {name=p8427 lab=_69426_/X }
C {sky130_stdcells/a211o_4.sym} 9060 -32520 0 0 {name=X_69426_ }
C {devices/lab_pin.sym} 8970 -32370 0 0 {name=p8428 lab=_88263_/CLK }
C {devices/lab_pin.sym} 8970 -32350 0 0 {name=p8429 lab=_88260_/D }
C {devices/lab_pin.sym} 9150 -32370 0 1 {name=p8430 lab=_68763_/B }
C {sky130_stdcells/dfxtp_4.sym} 9060 -32360 0 0 {name=X_88260_ }
C {devices/lab_pin.sym} 9000 -32260 0 0 {name=p8431 lab=_54667_/A }
C {devices/lab_pin.sym} 9000 -32220 0 0 {name=p8432 lab=_54645_/B }
C {devices/lab_pin.sym} 9000 -32180 0 0 {name=p8433 lab=_54644_/X }
C {devices/lab_pin.sym} 9000 -32140 0 0 {name=p8434 lab=_47283_/A }
C {devices/lab_pin.sym} 9120 -32200 0 1 {name=p8435 lab=_54652_/X }
C {sky130_stdcells/and4_4.sym} 9060 -32200 0 0 {name=X_54652_ }
C {devices/lab_pin.sym} 8980 -32070 0 0 {name=p8436 lab=_80927_/D }
C {devices/lab_pin.sym} 8980 -32030 0 0 {name=p8437 lab=_66614_/X }
C {devices/lab_pin.sym} 8980 -31990 0 0 {name=p8438 lab=_66637_/X }
C {devices/lab_pin.sym} 9140 -32030 0 1 {name=p8439 lab=_84103_/D }
C {sky130_stdcells/a21bo_4.sym} 9060 -32030 0 0 {name=X_66638_ }
C {devices/lab_pin.sym} 8970 -31890 0 0 {name=p8440 lab=_85471_/CLK }
C {devices/lab_pin.sym} 8970 -31870 0 0 {name=p8441 lab=_85472_/D }
C {devices/lab_pin.sym} 9150 -31890 0 1 {name=p8442 lab=_85472_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -31880 0 0 {name=X_85472_ }
C {devices/lab_pin.sym} 9020 -31750 0 0 {name=p8443 lab=_51781_/A }
C {devices/lab_pin.sym} 9100 -31750 0 1 {name=p8444 lab=_51870_/C }
C {sky130_stdcells/buf_2.sym} 9060 -31750 0 0 {name=X_51864_ }
C {devices/lab_pin.sym} 8970 -31630 0 0 {name=p8445 lab=_82933_/CLK }
C {devices/lab_pin.sym} 8970 -31610 0 0 {name=p8446 lab=_82684_/D }
C {devices/lab_pin.sym} 9150 -31630 0 1 {name=p8447 lab=_82684_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -31620 0 0 {name=X_82684_ }
C {devices/lab_pin.sym} 8970 -31490 0 0 {name=p8448 lab=_86934_/CLK }
C {devices/lab_pin.sym} 8970 -31470 0 0 {name=p8449 lab=_43894_/X }
C {devices/lab_pin.sym} 9150 -31490 0 1 {name=p8450 lab=_67527_/B }
C {sky130_stdcells/dfxtp_4.sym} 9060 -31480 0 0 {name=X_87211_ }
C {devices/lab_pin.sym} 9020 -31350 0 0 {name=p8451 lab=_53696_/A }
C {devices/lab_pin.sym} 9100 -31350 0 1 {name=p8452 lab=_53603_/X }
C {sky130_stdcells/buf_2.sym} 9060 -31350 0 0 {name=X_53603_ }
C {devices/lab_pin.sym} 8970 -31230 0 0 {name=p8453 lab=_84424_/CLK }
C {devices/lab_pin.sym} 8970 -31210 0 0 {name=p8454 lab=_62255_/Y }
C {devices/lab_pin.sym} 9150 -31230 0 1 {name=p8455 lab=_62254_/C }
C {sky130_stdcells/dfxtp_4.sym} 9060 -31220 0 0 {name=X_84423_ }
C {devices/lab_pin.sym} 8980 -31110 0 0 {name=p8456 lab=_86127_/Q }
C {devices/lab_pin.sym} 8980 -31070 0 0 {name=p8457 lab=_50804_/X }
C {devices/lab_pin.sym} 8980 -31030 0 0 {name=p8458 lab=_50814_/Y }
C {devices/lab_pin.sym} 9140 -31070 0 1 {name=p8459 lab=_50815_/Y }
C {sky130_stdcells/o21ai_4.sym} 9060 -31070 0 0 {name=X_50815_ }
C {devices/lab_pin.sym} 9020 -30930 0 0 {name=p8460 lab=clkbuf_4_7_1_CLK/X }
C {devices/lab_pin.sym} 9100 -30930 0 1 {name=p8461 lab=clkbuf_6_29_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 9060 -30930 0 0 {name=Xclkbuf_5_14_0_CLK }
C {devices/lab_pin.sym} 9020 -30810 0 0 {name=p8462 lab=_44308_/X }
C {devices/lab_pin.sym} 9100 -30810 0 1 {name=p8463 lab=_57440_/A }
C {sky130_stdcells/buf_2.sym} 9060 -30810 0 0 {name=X_57371_ }
C {devices/lab_pin.sym} 8970 -30690 0 0 {name=p8464 lab=_81794_/CLK }
C {devices/lab_pin.sym} 8970 -30670 0 0 {name=p8465 lab=_81667_/Q }
C {devices/lab_pin.sym} 9150 -30690 0 1 {name=p8466 lab=_81635_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -30680 0 0 {name=X_81635_ }
C {devices/lab_pin.sym} 9020 -30550 0 0 {name=p8467 lab=_69357_/A }
C {devices/lab_pin.sym} 9100 -30550 0 1 {name=p8468 lab=_69383_/A }
C {sky130_stdcells/buf_2.sym} 9060 -30550 0 0 {name=X_69357_ }
C {devices/lab_pin.sym} 8970 -30430 0 0 {name=p8469 lab=_87686_/CLK }
C {devices/lab_pin.sym} 8970 -30410 0 0 {name=p8470 lab=_41567_/Y }
C {devices/lab_pin.sym} 9150 -30430 0 1 {name=p8471 lab=_67052_/B }
C {sky130_stdcells/dfxtp_4.sym} 9060 -30420 0 0 {name=X_88191_ }
C {devices/lab_pin.sym} 8980 -30310 0 0 {name=p8472 lab=_85415_/Q }
C {devices/lab_pin.sym} 8980 -30270 0 0 {name=p8473 lab=_54567_/X }
C {devices/lab_pin.sym} 8980 -30230 0 0 {name=p8474 lab=_54582_/Y }
C {devices/lab_pin.sym} 9140 -30270 0 1 {name=p8475 lab=_54583_/Y }
C {sky130_stdcells/o21ai_4.sym} 9060 -30270 0 0 {name=X_54583_ }
C {devices/lab_pin.sym} 9020 -30130 0 0 {name=p8476 lab=_44146_/A }
C {devices/lab_pin.sym} 9100 -30130 0 1 {name=p8477 lab=_68392_/A }
C {sky130_stdcells/buf_2.sym} 9060 -30130 0 0 {name=X_66569_ }
C {devices/lab_pin.sym} 8980 -30030 0 0 {name=p8478 lab=_51792_/Y }
C {devices/lab_pin.sym} 8980 -29990 0 0 {name=p8479 lab=_51793_/X }
C {devices/lab_pin.sym} 8980 -29950 0 0 {name=p8480 lab=_51794_/X }
C {devices/lab_pin.sym} 9140 -29990 0 1 {name=p8481 lab=_51795_/Y }
C {sky130_stdcells/a21oi_4.sym} 9060 -29990 0 0 {name=X_51795_ }
C {devices/lab_pin.sym} 9000 -29860 0 0 {name=p8482 lab=_58941_/A }
C {devices/lab_pin.sym} 9000 -29820 0 0 {name=p8483 lab=_86360_/Q }
C {devices/lab_pin.sym} 9120 -29840 0 1 {name=p8484 lab=_59110_/Y }
C {sky130_stdcells/nor2_4.sym} 9060 -29840 0 0 {name=X_59110_ }
C {devices/lab_pin.sym} 9020 -29710 0 0 {name=p8485 lab=_56347_/A }
C {devices/lab_pin.sym} 9100 -29710 0 1 {name=p8486 lab=_56332_/A }
C {sky130_stdcells/buf_2.sym} 9060 -29710 0 0 {name=X_56322_ }
C {devices/lab_pin.sym} 9020 -29590 0 0 {name=p8487 lab=_68447_/A }
C {devices/lab_pin.sym} 9100 -29590 0 1 {name=p8488 lab=_68308_/X }
C {sky130_stdcells/buf_2.sym} 9060 -29590 0 0 {name=X_68308_ }
C {devices/lab_pin.sym} 8970 -29470 0 0 {name=p8489 lab=_87141_/CLK }
C {devices/lab_pin.sym} 8970 -29450 0 0 {name=p8490 lab=_44372_/Y }
C {devices/lab_pin.sym} 9150 -29470 0 1 {name=p8491 lab=_87142_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -29460 0 0 {name=X_87142_ }
C {devices/lab_pin.sym} 8980 -29350 0 0 {name=p8492 lab=_53532_/Y }
C {devices/lab_pin.sym} 8980 -29310 0 0 {name=p8493 lab=_53472_/X }
C {devices/lab_pin.sym} 8980 -29270 0 0 {name=p8494 lab=_53533_/X }
C {devices/lab_pin.sym} 9140 -29310 0 1 {name=p8495 lab=_53534_/Y }
C {sky130_stdcells/a21oi_4.sym} 9060 -29310 0 0 {name=X_53534_ }
C {devices/lab_pin.sym} 8970 -29170 0 0 {name=p8496 lab=_84321_/CLK }
C {devices/lab_pin.sym} 8970 -29150 0 0 {name=p8497 lab=_84354_/D }
C {devices/lab_pin.sym} 9150 -29170 0 1 {name=p8498 lab=_79436_/A }
C {sky130_stdcells/dfxtp_4.sym} 9060 -29160 0 0 {name=X_84354_ }
C {devices/lab_pin.sym} 9000 -29040 0 0 {name=p8499 lab=_50740_/A }
C {devices/lab_pin.sym} 9000 -29000 0 0 {name=p8500 lab=_53959_/B }
C {devices/lab_pin.sym} 9120 -29020 0 1 {name=p8501 lab=_50746_/Y }
C {sky130_stdcells/nand2_4.sym} 9060 -29020 0 0 {name=X_50746_ }
C {devices/lab_pin.sym} 8970 -28890 0 0 {name=p8502 lab=_81482_/CLK }
C {devices/lab_pin.sym} 8970 -28870 0 0 {name=p8503 lab=_81566_/D }
C {devices/lab_pin.sym} 9150 -28890 0 1 {name=p8504 lab=_81522_/D }
C {sky130_stdcells/dfxtp_4.sym} 9060 -28880 0 0 {name=X_81566_ }
C {devices/lab_pin.sym} 9000 -28760 0 0 {name=p8505 lab=_69288_/A }
C {devices/lab_pin.sym} 9000 -28720 0 0 {name=p8506 lab=_69288_/B }
C {devices/lab_pin.sym} 9120 -28740 0 1 {name=p8507 lab=_69288_/X }
C {sky130_stdcells/and2_4.sym} 9060 -28740 0 0 {name=X_69288_ }
C {devices/lab_pin.sym} 8970 -28610 0 0 {name=p8508 lab=_83305_/CLK }
C {devices/lab_pin.sym} 8970 -28590 0 0 {name=p8509 lab=_83305_/D }
C {devices/lab_pin.sym} 9150 -28610 0 1 {name=p8510 lab=_83305_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -28600 0 0 {name=X_83305_ }
C {devices/lab_pin.sym} 8980 -28500 0 0 {name=p8511 lab=_84774_/Q }
C {devices/lab_pin.sym} 8980 -28460 0 0 {name=p8512 lab=_58956_/X }
C {devices/lab_pin.sym} 8980 -28420 0 0 {name=p8513 lab=_59032_/X }
C {devices/lab_pin.sym} 8980 -28380 0 0 {name=p8514 lab=_59040_/X }
C {devices/lab_pin.sym} 9140 -28440 0 1 {name=p8515 lab=_84774_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 9060 -28440 0 0 {name=X_59041_ }
C {devices/lab_pin.sym} 9000 -28300 0 0 {name=p8516 lab=_80517_/A }
C {devices/lab_pin.sym} 9000 -28260 0 0 {name=p8517 lab=_63493_/C }
C {devices/lab_pin.sym} 9120 -28280 0 1 {name=p8518 lab=_80518_/B }
C {sky130_stdcells/xor2_4.sym} 9060 -28280 0 0 {name=X_80517_ }
C {devices/lab_pin.sym} 9000 -28170 0 0 {name=p8519 lab=_56263_/A }
C {devices/lab_pin.sym} 9000 -28130 0 0 {name=p8520 lab=_56253_/B }
C {devices/lab_pin.sym} 9000 -28090 0 0 {name=p8521 lab=_56253_/C }
C {devices/lab_pin.sym} 9120 -28130 0 1 {name=p8522 lab=_56253_/Y }
C {sky130_stdcells/nand3_4.sym} 9060 -28130 0 0 {name=X_56253_ }
C {devices/lab_pin.sym} 9020 -27990 0 0 {name=p8523 lab=_68208_/X }
C {devices/lab_pin.sym} 9100 -27990 0 1 {name=p8524 lab=_68239_/X }
C {sky130_stdcells/buf_2.sym} 9060 -27990 0 0 {name=X_68239_ }
C {devices/lab_pin.sym} 8970 -27870 0 0 {name=p8525 lab=_87073_/CLK }
C {devices/lab_pin.sym} 8970 -27850 0 0 {name=p8526 lab=_44509_/Y }
C {devices/lab_pin.sym} 9150 -27870 0 1 {name=p8527 lab=_87073_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -27860 0 0 {name=X_87073_ }
C {devices/lab_pin.sym} 9020 -27730 0 0 {name=p8528 lab=_53990_/A }
C {devices/lab_pin.sym} 9100 -27730 0 1 {name=p8529 lab=_53687_/A }
C {sky130_stdcells/buf_2.sym} 9060 -27730 0 0 {name=X_53465_ }
C {devices/lab_pin.sym} 8970 -27610 0 0 {name=p8530 lab=_84280_/CLK }
C {devices/lab_pin.sym} 8970 -27590 0 0 {name=p8531 lab=_84285_/D }
C {devices/lab_pin.sym} 9150 -27610 0 1 {name=p8532 lab=_63944_/C }
C {sky130_stdcells/dfxtp_4.sym} 9060 -27600 0 0 {name=X_84285_ }
C {devices/lab_pin.sym} 9000 -27490 0 0 {name=p8533 lab=_50677_/A }
C {devices/lab_pin.sym} 9000 -27450 0 0 {name=p8534 lab=_50651_/X }
C {devices/lab_pin.sym} 9000 -27410 0 0 {name=p8535 lab=_50668_/C }
C {devices/lab_pin.sym} 9120 -27450 0 1 {name=p8536 lab=_50677_/X }
C {sky130_stdcells/and3_4.sym} 9060 -27450 0 0 {name=X_50677_ }
C {devices/lab_pin.sym} 8970 -27310 0 0 {name=p8537 lab=_81749_/CLK }
C {devices/lab_pin.sym} 8970 -27290 0 0 {name=p8538 lab=_84065_/Q }
C {devices/lab_pin.sym} 9150 -27310 0 1 {name=p8539 lab=_81497_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -27300 0 0 {name=X_81497_ }
C {devices/lab_pin.sym} 9000 -27180 0 0 {name=p8540 lab=_55710_/B }
C {devices/lab_pin.sym} 9000 -27140 0 0 {name=p8541 lab=_45826_/Y }
C {devices/lab_pin.sym} 9120 -27160 0 1 {name=p8542 lab=_55204_/Y }
C {sky130_stdcells/nor2_4.sym} 9060 -27160 0 0 {name=X_55204_ }
C {devices/lab_pin.sym} 9020 -27030 0 0 {name=p8543 lab=clkbuf_4_14_1_CLK/X }
C {devices/lab_pin.sym} 9100 -27030 0 1 {name=p8544 lab=clkbuf_6_59_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 9060 -27030 0 0 {name=Xclkbuf_5_29_0_CLK }
C {devices/lab_pin.sym} 8970 -26910 0 0 {name=p8545 lab=_86121_/CLK }
C {devices/lab_pin.sym} 8970 -26890 0 0 {name=p8546 lab=_86024_/D }
C {devices/lab_pin.sym} 9150 -26910 0 1 {name=p8547 lab=_65260_/B }
C {sky130_stdcells/dfxtp_4.sym} 9060 -26900 0 0 {name=X_86024_ }
C {devices/lab_pin.sym} 9000 -26780 0 0 {name=p8548 lab=_40368_/X }
C {devices/lab_pin.sym} 9000 -26740 0 0 {name=p8549 lab=_40430_/B }
C {devices/lab_pin.sym} 9120 -26760 0 1 {name=p8550 lab=_40430_/X }
C {sky130_stdcells/or2_4.sym} 9060 -26760 0 0 {name=X_40430_ }
C {devices/lab_pin.sym} 9000 -26640 0 0 {name=p8551 lab=_52407_/A }
C {devices/lab_pin.sym} 9000 -26600 0 0 {name=p8552 lab=_49192_/A }
C {devices/lab_pin.sym} 9120 -26620 0 1 {name=p8553 lab=_52416_/X }
C {sky130_stdcells/and2_4.sym} 9060 -26620 0 0 {name=X_52416_ }
C {devices/lab_pin.sym} 9000 -26510 0 0 {name=p8554 lab=_71252_/A }
C {devices/lab_pin.sym} 9000 -26470 0 0 {name=p8555 lab=_71226_/B }
C {devices/lab_pin.sym} 9000 -26430 0 0 {name=p8556 lab=_71248_/C }
C {devices/lab_pin.sym} 9120 -26470 0 1 {name=p8557 lab=_71250_/Y }
C {sky130_stdcells/nand3_4.sym} 9060 -26470 0 0 {name=X_71250_ }
C {devices/lab_pin.sym} 8970 -26330 0 0 {name=p8558 lab=_83231_/CLK }
C {devices/lab_pin.sym} 8970 -26310 0 0 {name=p8559 lab=_72548_/Y }
C {devices/lab_pin.sym} 9150 -26330 0 1 {name=p8560 lab=_79456_/B }
C {sky130_stdcells/dfxtp_4.sym} 9060 -26320 0 0 {name=X_83236_ }
C {devices/lab_pin.sym} 9020 -26190 0 0 {name=p8561 lab=_74539_/A }
C {devices/lab_pin.sym} 9100 -26190 0 1 {name=p8562 lab=_56460_/B }
C {sky130_stdcells/buf_2.sym} 9060 -26190 0 0 {name=X_56184_ }
C {devices/lab_pin.sym} 9000 -26080 0 0 {name=p8563 lab=_80448_/A }
C {devices/lab_pin.sym} 9000 -26040 0 0 {name=p8564 lab=_80448_/B }
C {devices/lab_pin.sym} 9120 -26060 0 1 {name=p8565 lab=_80448_/X }
C {sky130_stdcells/and2_4.sym} 9060 -26060 0 0 {name=X_80448_ }
C {devices/lab_pin.sym} 8980 -25950 0 0 {name=p8566 lab=_85641_/Q }
C {devices/lab_pin.sym} 8980 -25910 0 0 {name=p8567 lab=_53378_/X }
C {devices/lab_pin.sym} 8980 -25870 0 0 {name=p8568 lab=_53395_/Y }
C {devices/lab_pin.sym} 9140 -25910 0 1 {name=p8569 lab=_53396_/Y }
C {sky130_stdcells/o21ai_4.sym} 9060 -25910 0 0 {name=X_53396_ }
C {devices/lab_pin.sym} 8980 -25790 0 0 {name=p8570 lab=_70195_/X }
C {devices/lab_pin.sym} 8980 -25750 0 0 {name=p8571 lab=_74789_/C }
C {devices/lab_pin.sym} 8980 -25710 0 0 {name=p8572 lab=_70200_/X }
C {devices/lab_pin.sym} 9140 -25750 0 1 {name=p8573 lab=_70201_/X }
C {sky130_stdcells/a21o_4.sym} 9060 -25750 0 0 {name=X_70201_ }
C {devices/lab_pin.sym} 9000 -25620 0 0 {name=p8574 lab=_55135_/A }
C {devices/lab_pin.sym} 9000 -25580 0 0 {name=p8575 lab=_57179_/B }
C {devices/lab_pin.sym} 9120 -25600 0 1 {name=p8576 lab=_55135_/X }
C {sky130_stdcells/and2_4.sym} 9060 -25600 0 0 {name=X_55135_ }
C {devices/lab_pin.sym} 9020 -25470 0 0 {name=p8577 lab=_52324_/A }
C {devices/lab_pin.sym} 9100 -25470 0 1 {name=p8578 lab=_52347_/X }
C {sky130_stdcells/buf_2.sym} 9060 -25470 0 0 {name=X_52347_ }
C {devices/lab_pin.sym} 9020 -25350 0 0 {name=p8579 lab=_40361_/A }
C {devices/lab_pin.sym} 9100 -25350 0 1 {name=p8580 lab=_42081_/A }
C {sky130_stdcells/inv_2.sym} 9060 -25350 0 0 {name=X_40361_ }
C {devices/lab_pin.sym} 9000 -25260 0 0 {name=p8581 lab=_71181_/A }
C {devices/lab_pin.sym} 9000 -25220 0 0 {name=p8582 lab=_71185_/B }
C {devices/lab_pin.sym} 9000 -25180 0 0 {name=p8583 lab=_71181_/C }
C {devices/lab_pin.sym} 9000 -25140 0 0 {name=p8584 lab=_74518_/D }
C {devices/lab_pin.sym} 9120 -25200 0 1 {name=p8585 lab=_71181_/Y }
C {sky130_stdcells/nand4_4.sym} 9060 -25200 0 0 {name=X_71181_ }
C {devices/lab_pin.sym} 8970 -25050 0 0 {name=p8586 lab=_83167_/CLK }
C {devices/lab_pin.sym} 8970 -25030 0 0 {name=p8587 lab=_83167_/D }
C {devices/lab_pin.sym} 9150 -25050 0 1 {name=p8588 lab=_83167_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -25040 0 0 {name=X_83167_ }
C {devices/lab_pin.sym} 9000 -24920 0 0 {name=p8589 lab=_80379_/A }
C {devices/lab_pin.sym} 9000 -24880 0 0 {name=p8590 lab=_80379_/B }
C {devices/lab_pin.sym} 9120 -24900 0 1 {name=p8591 lab=_80380_/B }
C {sky130_stdcells/xor2_4.sym} 9060 -24900 0 0 {name=X_80379_ }
C {devices/lab_pin.sym} 8980 -24810 0 0 {name=p8592 lab=_42099_/X }
C {devices/lab_pin.sym} 8980 -24770 0 0 {name=p8593 lab=_42094_/X }
C {devices/lab_pin.sym} 8980 -24730 0 0 {name=p8594 lab=_41021_/X }
C {devices/lab_pin.sym} 8980 -24690 0 0 {name=p8595 lab=_88036_/Q }
C {devices/lab_pin.sym} 8980 -24650 0 0 {name=p8596 lab=_42096_/X }
C {devices/lab_pin.sym} 9140 -24730 0 1 {name=p8597 lab=_42101_/A }
C {sky130_stdcells/o32ai_4.sym} 9060 -24730 0 0 {name=X_42100_ }
C {devices/lab_pin.sym} 9020 -24570 0 0 {name=p8598 lab=_83115_/Q }
C {devices/lab_pin.sym} 9100 -24570 0 1 {name=p8599 lab=_70134_/B }
C {sky130_stdcells/inv_2.sym} 9060 -24570 0 0 {name=X_70132_ }
C {devices/lab_pin.sym} 8970 -24450 0 0 {name=p8600 lab=_82145_/CLK }
C {devices/lab_pin.sym} 8970 -24430 0 0 {name=p8601 lab=_77768_/X }
C {devices/lab_pin.sym} 9150 -24450 0 1 {name=p8602 lab=_82118_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -24440 0 0 {name=X_82118_ }
C {devices/lab_pin.sym} 9020 -24310 0 0 {name=p8603 lab=_43121_/A }
C {devices/lab_pin.sym} 9100 -24310 0 1 {name=p8604 lab=_43080_/X }
C {sky130_stdcells/buf_2.sym} 9060 -24310 0 0 {name=X_43080_ }
C {devices/lab_pin.sym} 8980 -24210 0 0 {name=p8605 lab=_55064_/Y }
C {devices/lab_pin.sym} 8980 -24170 0 0 {name=p8606 lab=_55050_/X }
C {devices/lab_pin.sym} 8980 -24130 0 0 {name=p8607 lab=_55065_/X }
C {devices/lab_pin.sym} 9140 -24170 0 1 {name=p8608 lab=_85325_/D }
C {sky130_stdcells/a21oi_4.sym} 9060 -24170 0 0 {name=X_55066_ }
C {devices/lab_pin.sym} 9020 -24030 0 0 {name=p8609 lab=_59943_/A }
C {devices/lab_pin.sym} 9100 -24030 0 1 {name=p8610 lab=_59943_/X }
C {sky130_stdcells/buf_2.sym} 9060 -24030 0 0 {name=X_59943_ }
C {devices/lab_pin.sym} 8980 -23930 0 0 {name=p8611 lab=_85854_/Q }
C {devices/lab_pin.sym} 8980 -23890 0 0 {name=p8612 lab=_52269_/X }
C {devices/lab_pin.sym} 8980 -23850 0 0 {name=p8613 lab=_52277_/Y }
C {devices/lab_pin.sym} 9140 -23890 0 1 {name=p8614 lab=_52278_/Y }
C {sky130_stdcells/o21ai_4.sym} 9060 -23890 0 0 {name=X_52278_ }
C {devices/lab_pin.sym} 8970 -23750 0 0 {name=p8615 lab=_83846_/CLK }
C {devices/lab_pin.sym} 8970 -23730 0 0 {name=p8616 lab=_83098_/D }
C {devices/lab_pin.sym} 9150 -23750 0 1 {name=p8617 lab=_83098_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -23740 0 0 {name=X_83098_ }
C {devices/lab_pin.sym} 8970 -23610 0 0 {name=p8618 lab=_87149_/CLK }
C {devices/lab_pin.sym} 8970 -23590 0 0 {name=p8619 lab=_87975_/D }
C {devices/lab_pin.sym} 9150 -23610 0 1 {name=p8620 lab=_87975_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -23600 0 0 {name=X_87975_ }
C {devices/lab_pin.sym} 8980 -23510 0 0 {name=p8621 lab=_42028_/X }
C {devices/lab_pin.sym} 8980 -23470 0 0 {name=p8622 lab=_42024_/X }
C {devices/lab_pin.sym} 8980 -23430 0 0 {name=p8623 lab=_40866_/X }
C {devices/lab_pin.sym} 8980 -23390 0 0 {name=p8624 lab=_73247_/A }
C {devices/lab_pin.sym} 8980 -23350 0 0 {name=p8625 lab=_42025_/X }
C {devices/lab_pin.sym} 9140 -23430 0 1 {name=p8626 lab=_42031_/Y }
C {sky130_stdcells/o32ai_4.sym} 9060 -23430 0 0 {name=X_42031_ }
C {devices/lab_pin.sym} 8980 -23290 0 0 {name=p8627 lab=_54014_/Y }
C {devices/lab_pin.sym} 8980 -23250 0 0 {name=p8628 lab=_54015_/X }
C {devices/lab_pin.sym} 8980 -23210 0 0 {name=p8629 lab=_54016_/X }
C {devices/lab_pin.sym} 9140 -23250 0 1 {name=p8630 lab=_85522_/D }
C {sky130_stdcells/a21oi_4.sym} 9060 -23250 0 0 {name=X_54017_ }
C {devices/lab_pin.sym} 9020 -23110 0 0 {name=p8631 lab=_51147_/A }
C {devices/lab_pin.sym} 9100 -23110 0 1 {name=p8632 lab=_51229_/X }
C {sky130_stdcells/buf_2.sym} 9060 -23110 0 0 {name=X_51229_ }
C {devices/lab_pin.sym} 9000 -23000 0 0 {name=p8633 lab=_74940_/A }
C {devices/lab_pin.sym} 9000 -22960 0 0 {name=p8634 lab=_74940_/B }
C {devices/lab_pin.sym} 9120 -22980 0 1 {name=p8635 lab=_74940_/X }
C {sky130_stdcells/xor2_4.sym} 9060 -22980 0 0 {name=X_74940_ }
C {devices/lab_pin.sym} 8980 -22870 0 0 {name=p8636 lab=_68912_/X }
C {devices/lab_pin.sym} 8980 -22830 0 0 {name=p8637 lab=_68914_/X }
C {devices/lab_pin.sym} 8980 -22790 0 0 {name=p8638 lab=_69992_/X }
C {devices/lab_pin.sym} 9140 -22830 0 1 {name=p8639 lab=_70063_/X }
C {sky130_stdcells/a21o_4.sym} 9060 -22830 0 0 {name=X_70063_ }
C {devices/lab_pin.sym} 8970 -22690 0 0 {name=p8640 lab=_87652_/CLK }
C {devices/lab_pin.sym} 8970 -22670 0 0 {name=p8641 lab=_44841_/X }
C {devices/lab_pin.sym} 9150 -22690 0 1 {name=p8642 lab=_86926_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -22680 0 0 {name=X_86926_ }
C {devices/lab_pin.sym} 8970 -22550 0 0 {name=p8643 lab=_82575_/CLK }
C {devices/lab_pin.sym} 8970 -22530 0 0 {name=p8644 lab=_78033_/Y }
C {devices/lab_pin.sym} 9150 -22550 0 1 {name=p8645 lab=_82017_/D }
C {sky130_stdcells/dfxtp_4.sym} 9060 -22540 0 0 {name=X_82049_ }
C {devices/lab_pin.sym} 8980 -22450 0 0 {name=p8646 lab=_59727_/X }
C {devices/lab_pin.sym} 8980 -22410 0 0 {name=p8647 lab=_59745_/X }
C {devices/lab_pin.sym} 8980 -22370 0 0 {name=p8648 lab=_59651_/C }
C {devices/lab_pin.sym} 8980 -22330 0 0 {name=p8649 lab=_59859_/Y }
C {devices/lab_pin.sym} 8980 -22300 0 0 {name=p8650 lab=_59873_/Y }
C {devices/lab_pin.sym} 9140 -22370 0 1 {name=p8651 lab=_59874_/Y }
C {sky130_stdcells/a41oi_4.sym} 9060 -22370 0 0 {name=X_59874_ }
C {devices/lab_pin.sym} 8980 -22230 0 0 {name=p8652 lab=_58822_/Y }
C {devices/lab_pin.sym} 8980 -22190 0 0 {name=p8653 lab=_58824_/Y }
C {devices/lab_pin.sym} 8980 -22150 0 0 {name=p8654 lab=_58735_/X }
C {devices/lab_pin.sym} 9140 -22190 0 1 {name=p8655 lab=_58825_/X }
C {sky130_stdcells/a21o_4.sym} 9060 -22190 0 0 {name=X_58825_ }
C {devices/lab_pin.sym} 9000 -22060 0 0 {name=p8656 lab=_81125_/D }
C {devices/lab_pin.sym} 9000 -22020 0 0 {name=p8657 lab=_74870_/B }
C {devices/lab_pin.sym} 9120 -22040 0 1 {name=p8658 lab=_74871_/Y }
C {sky130_stdcells/nand2_4.sym} 9060 -22040 0 0 {name=X_74871_ }
C {devices/lab_pin.sym} 8970 -21910 0 0 {name=p8659 lab=_80664_/CLK }
C {devices/lab_pin.sym} 8970 -21890 0 0 {name=p8660 lab=_45751_/Y }
C {devices/lab_pin.sym} 9150 -21910 0 1 {name=p8661 lab=_63265_/B }
C {sky130_stdcells/dfxtp_4.sym} 9060 -21900 0 0 {name=X_86857_ }
C {devices/lab_pin.sym} 8980 -21790 0 0 {name=p8662 lab=_76611_/A }
C {devices/lab_pin.sym} 8980 -21750 0 0 {name=p8663 lab=_76609_/Y }
C {devices/lab_pin.sym} 8980 -21710 0 0 {name=p8664 lab=_81375_/Q }
C {devices/lab_pin.sym} 9140 -21750 0 1 {name=p8665 lab=_76613_/A }
C {sky130_stdcells/a21oi_4.sym} 9060 -21750 0 0 {name=X_76610_ }
C {devices/lab_pin.sym} 8970 -21610 0 0 {name=p8666 lab=_86030_/CLK }
C {devices/lab_pin.sym} 8970 -21590 0 0 {name=p8667 lab=_85808_/D }
C {devices/lab_pin.sym} 9150 -21610 0 1 {name=p8668 lab=_65049_/B }
C {sky130_stdcells/dfxtp_4.sym} 9060 -21600 0 0 {name=X_85808_ }
C {devices/lab_pin.sym} 9000 -21480 0 0 {name=p8669 lab=_73822_/A }
C {devices/lab_pin.sym} 9000 -21440 0 0 {name=p8670 lab=_74246_/B }
C {devices/lab_pin.sym} 9120 -21460 0 1 {name=p8671 lab=_73822_/Y }
C {sky130_stdcells/nor2_4.sym} 9060 -21460 0 0 {name=X_73822_ }
C {devices/lab_pin.sym} 9020 -21330 0 0 {name=p8672 lab=_52663_/B }
C {devices/lab_pin.sym} 9100 -21330 0 1 {name=p8673 lab=_50971_/B }
C {sky130_stdcells/buf_2.sym} 9060 -21330 0 0 {name=X_46770_ }
C {devices/lab_pin.sym} 9020 -21210 0 0 {name=p8674 lab=_58641_/A }
C {devices/lab_pin.sym} 9100 -21210 0 1 {name=p8675 lab=_58756_/X }
C {sky130_stdcells/buf_2.sym} 9060 -21210 0 0 {name=X_58756_ }
C {devices/lab_pin.sym} 9000 -21100 0 0 {name=p8676 lab=_77590_/A }
C {devices/lab_pin.sym} 9000 -21060 0 0 {name=p8677 lab=_77590_/B }
C {devices/lab_pin.sym} 9120 -21080 0 1 {name=p8678 lab=_77591_/A }
C {sky130_stdcells/and2_4.sym} 9060 -21080 0 0 {name=X_77590_ }
C {devices/lab_pin.sym} 9020 -20950 0 0 {name=p8679 lab=_59538_/C }
C {devices/lab_pin.sym} 9100 -20950 0 1 {name=p8680 lab=_60665_/C }
C {sky130_stdcells/buf_2.sym} 9060 -20950 0 0 {name=X_43982_ }
C {devices/lab_pin.sym} 8980 -20860 0 0 {name=p8681 lab=_56198_/C }
C {devices/lab_pin.sym} 8980 -20820 0 0 {name=p8682 lab=_55690_/A }
C {devices/lab_pin.sym} 8980 -20780 0 0 {name=p8683 lab=_44052_/X }
C {devices/lab_pin.sym} 8980 -20740 0 0 {name=p8684 lab=_55967_/X }
C {devices/lab_pin.sym} 9140 -20800 0 1 {name=p8685 lab=_55968_/X }
C {sky130_stdcells/a211o_4.sym} 9060 -20800 0 0 {name=X_55968_ }
C {devices/lab_pin.sym} 8970 -20650 0 0 {name=p8686 lab=_86814_/CLK }
C {devices/lab_pin.sym} 8970 -20630 0 0 {name=p8687 lab=_46060_/X }
C {devices/lab_pin.sym} 9150 -20650 0 1 {name=p8688 lab=_86788_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -20640 0 0 {name=X_86788_ }
C {devices/lab_pin.sym} 9000 -20520 0 0 {name=p8689 lab=_85068_/Q }
C {devices/lab_pin.sym} 9000 -20480 0 0 {name=p8690 lab=_45801_/A }
C {devices/lab_pin.sym} 9120 -20500 0 1 {name=p8691 lab=_45721_/Y }
C {sky130_stdcells/nor2_4.sym} 9060 -20500 0 0 {name=X_45721_ }
C {devices/lab_pin.sym} 8980 -20390 0 0 {name=p8692 lab=_46224_/X }
C {devices/lab_pin.sym} 8980 -20350 0 0 {name=p8693 lab=_85409_/Q }
C {devices/lab_pin.sym} 8980 -20310 0 0 {name=p8694 lab=_57706_/X }
C {devices/lab_pin.sym} 9140 -20350 0 1 {name=p8695 lab=_57707_/Y }
C {sky130_stdcells/o21ai_4.sym} 9060 -20350 0 0 {name=X_57707_ }
C {devices/lab_pin.sym} 9000 -20220 0 0 {name=p8696 lab=_76541_/A }
C {devices/lab_pin.sym} 9000 -20180 0 0 {name=p8697 lab=_76541_/B }
C {devices/lab_pin.sym} 9120 -20200 0 1 {name=p8698 lab=_76584_/C }
C {sky130_stdcells/and2_4.sym} 9060 -20200 0 0 {name=X_76541_ }
C {devices/lab_pin.sym} 8980 -20100 0 0 {name=p8699 lab=_41749_/X }
C {devices/lab_pin.sym} 8980 -20060 0 0 {name=p8700 lab=_42930_/X }
C {devices/lab_pin.sym} 8980 -20020 0 0 {name=p8701 lab=_87644_/Q }
C {devices/lab_pin.sym} 8980 -19980 0 0 {name=p8702 lab=_42931_/X }
C {devices/lab_pin.sym} 9140 -20040 0 1 {name=p8703 lab=_42933_/X }
C {sky130_stdcells/a2bb2o_4.sym} 9060 -20040 0 0 {name=X_42933_ }
C {devices/lab_pin.sym} 9020 -19890 0 0 {name=p8704 lab=_54919_/A }
C {devices/lab_pin.sym} 9100 -19890 0 1 {name=p8705 lab=_54919_/X }
C {sky130_stdcells/buf_2.sym} 9060 -19890 0 0 {name=X_54919_ }
C {devices/lab_pin.sym} 8980 -19800 0 0 {name=p8706 lab=_43048_/Y }
C {devices/lab_pin.sym} 8980 -19760 0 0 {name=p8707 lab=_73627_/X }
C {devices/lab_pin.sym} 8980 -19720 0 0 {name=p8708 lab=_73652_/X }
C {devices/lab_pin.sym} 8980 -19680 0 0 {name=p8709 lab=_73752_/Y }
C {devices/lab_pin.sym} 9140 -19740 0 1 {name=p8710 lab=_73753_/X }
C {sky130_stdcells/a211o_4.sym} 9060 -19740 0 0 {name=X_73753_ }
C {devices/lab_pin.sym} 8970 -19590 0 0 {name=p8711 lab=_85741_/CLK }
C {devices/lab_pin.sym} 8970 -19570 0 0 {name=p8712 lab=_52873_/Y }
C {devices/lab_pin.sym} 9150 -19590 0 1 {name=p8713 lab=_85739_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -19580 0 0 {name=X_85739_ }
C {devices/lab_pin.sym} 8980 -19470 0 0 {name=p8714 lab=_46356_/X }
C {devices/lab_pin.sym} 8980 -19430 0 0 {name=p8715 lab=_70961_/X }
C {devices/lab_pin.sym} 8980 -19390 0 0 {name=p8716 lab=_70964_/Y }
C {devices/lab_pin.sym} 9140 -19430 0 1 {name=p8717 lab=_70965_/Y }
C {sky130_stdcells/o21ai_4.sym} 9060 -19430 0 0 {name=X_70965_ }
C {devices/lab_pin.sym} 9000 -19300 0 0 {name=p8718 lab=_58687_/A }
C {devices/lab_pin.sym} 9000 -19260 0 0 {name=p8719 lab=_58687_/B }
C {devices/lab_pin.sym} 9120 -19280 0 1 {name=p8720 lab=_58687_/Y }
C {sky130_stdcells/nor2_4.sym} 9060 -19280 0 0 {name=X_58687_ }
C {devices/lab_pin.sym} 9020 -19150 0 0 {name=p8721 lab=_55908_/A }
C {devices/lab_pin.sym} 9100 -19150 0 1 {name=p8722 lab=_55949_/A }
C {sky130_stdcells/buf_2.sym} 9060 -19150 0 0 {name=X_55899_ }
C {devices/lab_pin.sym} 9020 -19030 0 0 {name=p8723 lab=_48440_/A }
C {devices/lab_pin.sym} 9100 -19030 0 1 {name=p8724 lab=_52135_/A }
C {sky130_stdcells/buf_2.sym} 9060 -19030 0 0 {name=X_48440_ }
C {devices/lab_pin.sym} 9020 -18910 0 0 {name=p8725 lab=_72704_/A }
C {devices/lab_pin.sym} 9100 -18910 0 1 {name=p8726 lab=_72714_/A }
C {sky130_stdcells/buf_2.sym} 9060 -18910 0 0 {name=X_72704_ }
C {devices/lab_pin.sym} 9000 -18800 0 0 {name=p8727 lab=_79258_/X }
C {devices/lab_pin.sym} 9000 -18760 0 0 {name=p8728 lab=_79260_/B }
C {devices/lab_pin.sym} 9120 -18780 0 1 {name=p8729 lab=_79270_/B }
C {sky130_stdcells/xor2_4.sym} 9060 -18780 0 0 {name=X_79260_ }
C {devices/lab_pin.sym} 8980 -18670 0 0 {name=p8730 lab=_85137_/Q }
C {devices/lab_pin.sym} 8980 -18630 0 0 {name=p8731 lab=_45556_/X }
C {devices/lab_pin.sym} 8980 -18590 0 0 {name=p8732 lab=_45651_/X }
C {devices/lab_pin.sym} 9140 -18630 0 1 {name=p8733 lab=_45652_/X }
C {sky130_stdcells/o21a_4.sym} 9060 -18630 0 0 {name=X_45652_ }
C {devices/lab_pin.sym} 8980 -18510 0 0 {name=p8734 lab=_84964_/Q }
C {devices/lab_pin.sym} 8980 -18470 0 0 {name=p8735 lab=_57635_/X }
C {devices/lab_pin.sym} 8980 -18430 0 0 {name=p8736 lab=_57637_/Y }
C {devices/lab_pin.sym} 9140 -18470 0 1 {name=p8737 lab=_57638_/Y }
C {sky130_stdcells/o21ai_4.sym} 9060 -18470 0 0 {name=X_57638_ }
C {devices/lab_pin.sym} 9000 -18340 0 0 {name=p8738 lab=_81272_/Q }
C {devices/lab_pin.sym} 9000 -18300 0 0 {name=p8739 lab=_81528_/D }
C {devices/lab_pin.sym} 9120 -18320 0 1 {name=p8740 lab=_76473_/A }
C {sky130_stdcells/nand2_4.sym} 9060 -18320 0 0 {name=X_76472_ }
C {devices/lab_pin.sym} 8980 -18230 0 0 {name=p8741 lab=_42847_/X }
C {devices/lab_pin.sym} 8980 -18190 0 0 {name=p8742 lab=_42849_/X }
C {devices/lab_pin.sym} 8980 -18150 0 0 {name=p8743 lab=_41565_/X }
C {devices/lab_pin.sym} 8980 -18110 0 0 {name=p8744 lab=_67047_/B }
C {devices/lab_pin.sym} 8980 -18070 0 0 {name=p8745 lab=_42858_/X }
C {devices/lab_pin.sym} 9140 -18150 0 1 {name=p8746 lab=_42865_/A }
C {sky130_stdcells/o32ai_4.sym} 9060 -18150 0 0 {name=X_42864_ }
C {devices/lab_pin.sym} 9000 -18000 0 0 {name=p8747 lab=_73607_/A }
C {devices/lab_pin.sym} 9000 -17960 0 0 {name=p8748 lab=_65972_/B }
C {devices/lab_pin.sym} 9120 -17980 0 1 {name=p8749 lab=_73684_/X }
C {sky130_stdcells/and2_4.sym} 9060 -17980 0 0 {name=X_73684_ }
C {devices/lab_pin.sym} 9020 -17850 0 0 {name=p8750 lab=_70925_/A }
C {devices/lab_pin.sym} 9100 -17850 0 1 {name=p8751 lab=_70899_/C }
C {sky130_stdcells/buf_2.sym} 9060 -17850 0 0 {name=X_70896_ }
C {devices/lab_pin.sym} 9000 -17740 0 0 {name=p8752 lab=_82676_/Q }
C {devices/lab_pin.sym} 9000 -17700 0 0 {name=p8753 lab=_78211_/B }
C {devices/lab_pin.sym} 9120 -17720 0 1 {name=p8754 lab=_78211_/X }
C {sky130_stdcells/xor2_4.sym} 9060 -17720 0 0 {name=X_78211_ }
C {devices/lab_pin.sym} 9020 -17590 0 0 {name=p8755 lab=_44603_/A }
C {devices/lab_pin.sym} 9100 -17590 0 1 {name=p8756 lab=_44603_/X }
C {sky130_stdcells/buf_2.sym} 9060 -17590 0 0 {name=X_44603_ }
C {devices/lab_pin.sym} 9020 -17470 0 0 {name=p8757 lab=_81082_/Q }
C {devices/lab_pin.sym} 9100 -17470 0 1 {name=p8758 lab=_75423_/Y }
C {sky130_stdcells/inv_2.sym} 9060 -17470 0 0 {name=X_75423_ }
C {devices/lab_pin.sym} 8970 -17350 0 0 {name=p8759 lab=_87922_/CLK }
C {devices/lab_pin.sym} 8970 -17330 0 0 {name=p8760 lab=_87409_/D }
C {devices/lab_pin.sym} 9150 -17350 0 1 {name=p8761 lab=_87409_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -17340 0 0 {name=X_87409_ }
C {devices/lab_pin.sym} 8980 -17240 0 0 {name=p8762 lab=_40408_/X }
C {devices/lab_pin.sym} 8980 -17200 0 0 {name=p8763 lab=_41813_/X }
C {devices/lab_pin.sym} 8980 -17160 0 0 {name=p8764 lab=_88139_/Q }
C {devices/lab_pin.sym} 8980 -17120 0 0 {name=p8765 lab=_41814_/X }
C {devices/lab_pin.sym} 9140 -17180 0 1 {name=p8766 lab=_88139_/D }
C {sky130_stdcells/a2bb2o_4.sym} 9060 -17180 0 0 {name=X_41815_ }
C {devices/lab_pin.sym} 9020 -17030 0 0 {name=p8767 lab=_40420_/A }
C {devices/lab_pin.sym} 9100 -17030 0 1 {name=p8768 lab=_48471_/A }
C {sky130_stdcells/buf_2.sym} 9060 -17030 0 0 {name=X_48371_ }
C {devices/lab_pin.sym} 9000 -16930 0 0 {name=p8769 lab=_72633_/X }
C {devices/lab_pin.sym} 9000 -16890 0 0 {name=p8770 lab=_72643_/B }
C {devices/lab_pin.sym} 9000 -16850 0 0 {name=p8771 lab=_56564_/D }
C {devices/lab_pin.sym} 9120 -16890 0 1 {name=p8772 lab=_72635_/Y }
C {sky130_stdcells/nand3_4.sym} 9060 -16890 0 0 {name=X_72635_ }
C {devices/lab_pin.sym} 9000 -16760 0 0 {name=p8773 lab=_79189_/B }
C {devices/lab_pin.sym} 9000 -16720 0 0 {name=p8774 lab=_79189_/A }
C {devices/lab_pin.sym} 9120 -16740 0 1 {name=p8775 lab=_79192_/B }
C {sky130_stdcells/nand2_4.sym} 9060 -16740 0 0 {name=X_79191_ }
C {devices/lab_pin.sym} 8980 -16640 0 0 {name=p8776 lab=_45581_/Y }
C {devices/lab_pin.sym} 8980 -16600 0 0 {name=p8777 lab=_45516_/X }
C {devices/lab_pin.sym} 8980 -16560 0 0 {name=p8778 lab=_45548_/X }
C {devices/lab_pin.sym} 8980 -16520 0 0 {name=p8779 lab=_45582_/Y }
C {devices/lab_pin.sym} 9140 -16580 0 1 {name=p8780 lab=_45583_/X }
C {sky130_stdcells/a211o_4.sym} 9060 -16580 0 0 {name=X_45583_ }
C {devices/lab_pin.sym} 9000 -16440 0 0 {name=p8781 lab=_57564_/X }
C {devices/lab_pin.sym} 9000 -16400 0 0 {name=p8782 lab=_53535_/B }
C {devices/lab_pin.sym} 9120 -16420 0 1 {name=p8783 lab=_57569_/Y }
C {sky130_stdcells/nand2_4.sym} 9060 -16420 0 0 {name=X_57569_ }
C {devices/lab_pin.sym} 8970 -16290 0 0 {name=p8784 lab=_88133_/CLK }
C {devices/lab_pin.sym} 8970 -16270 0 0 {name=p8785 lab=_40454_/Y }
C {devices/lab_pin.sym} 9150 -16290 0 1 {name=p8786 lab=_88389_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9060 -16280 0 0 {name=X_88389_ }
C {devices/lab_pin.sym} 9020 -16150 0 0 {name=p8787 lab=_42720_/X }
C {devices/lab_pin.sym} 9100 -16150 0 1 {name=p8788 lab=_42795_/X }
C {sky130_stdcells/buf_2.sym} 9060 -16150 0 0 {name=X_42795_ }
C {devices/lab_pin.sym} 8980 -16050 0 0 {name=p8789 lab=_47316_/Y }
C {devices/lab_pin.sym} 8980 -16010 0 0 {name=p8790 lab=_47317_/X }
C {devices/lab_pin.sym} 8980 -15970 0 0 {name=p8791 lab=_47321_/X }
C {devices/lab_pin.sym} 9140 -16010 0 1 {name=p8792 lab=_86647_/D }
C {sky130_stdcells/a21oi_4.sym} 9060 -16010 0 0 {name=X_47322_ }
C {devices/lab_pin.sym} 9020 -15870 0 0 {name=p8793 lab=_72255_/A }
C {devices/lab_pin.sym} 9100 -15870 0 1 {name=p8794 lab=_59308_/X }
C {sky130_stdcells/buf_2.sym} 9060 -15870 0 0 {name=X_59308_ }
C {devices/lab_pin.sym} 8980 -15770 0 0 {name=p8795 lab=_78137_/Y }
C {devices/lab_pin.sym} 8980 -15730 0 0 {name=p8796 lab=_78129_/X }
C {devices/lab_pin.sym} 8980 -15690 0 0 {name=p8797 lab=_78141_/Y }
C {devices/lab_pin.sym} 9140 -15730 0 1 {name=p8798 lab=_78143_/B }
C {sky130_stdcells/a21boi_4.sym} 9060 -15730 0 0 {name=X_78142_ }
C {devices/lab_pin.sym} 8980 -15630 0 0 {name=p8799 lab=_44529_/X }
C {devices/lab_pin.sym} 8980 -15590 0 0 {name=p8800 lab=_44530_/X }
C {devices/lab_pin.sym} 8980 -15550 0 0 {name=p8801 lab=_40798_/A }
C {devices/lab_pin.sym} 8980 -15510 0 0 {name=p8802 lab=_44531_/Y }
C {devices/lab_pin.sym} 8980 -15470 0 0 {name=p8803 lab=_44533_/X }
C {devices/lab_pin.sym} 9140 -15550 0 1 {name=p8804 lab=_87065_/D }
C {sky130_stdcells/o32ai_4.sym} 9060 -15550 0 0 {name=X_44534_ }
C {devices/lab_pin.sym} 9000 -15400 0 0 {name=p8805 lab=_75354_/A }
C {devices/lab_pin.sym} 9000 -15360 0 0 {name=p8806 lab=_75353_/Y }
C {devices/lab_pin.sym} 9120 -15380 0 1 {name=p8807 lab=_75354_/X }
C {sky130_stdcells/and2_4.sym} 9060 -15380 0 0 {name=X_75354_ }
C {devices/lab_pin.sym} 8980 -15280 0 0 {name=p8808 lab=_41745_/X }
C {devices/lab_pin.sym} 8980 -15240 0 0 {name=p8809 lab=_41722_/X }
C {devices/lab_pin.sym} 8980 -15200 0 0 {name=p8810 lab=_67873_/B }
C {devices/lab_pin.sym} 8980 -15160 0 0 {name=p8811 lab=_41723_/X }
C {devices/lab_pin.sym} 9140 -15220 0 1 {name=p8812 lab=_88157_/D }
C {sky130_stdcells/a2bb2o_4.sym} 9060 -15220 0 0 {name=X_41746_ }
C {devices/lab_pin.sym} 9020 -15070 0 0 {name=p8813 lab=_60525_/A }
C {devices/lab_pin.sym} 9100 -15070 0 1 {name=p8814 lab=_60612_/B }
C {sky130_stdcells/buf_2.sym} 9060 -15070 0 0 {name=X_60580_ }
C {devices/lab_pin.sym} 8980 -14990 0 0 {name=p8815 lab=_60356_/Y }
C {devices/lab_pin.sym} 8980 -14950 0 0 {name=p8816 lab=_72522_/Y }
C {devices/lab_pin.sym} 8980 -14910 0 0 {name=p8817 lab=_72562_/Y }
C {devices/lab_pin.sym} 8980 -14870 0 0 {name=p8818 lab=_72570_/C }
C {devices/lab_pin.sym} 8980 -14840 0 0 {name=p8819 lab=_72565_/Y }
C {devices/lab_pin.sym} 9140 -14910 0 1 {name=p8820 lab=_72566_/Y }
C {sky130_stdcells/a41oi_4.sym} 9060 -14910 0 0 {name=X_72566_ }
C {devices/lab_pin.sym} 8980 -14770 0 0 {name=p8821 lab=_83106_/Q }
C {devices/lab_pin.sym} 8980 -14730 0 0 {name=p8822 lab=_74301_/X }
C {devices/lab_pin.sym} 8980 -14690 0 0 {name=p8823 lab=_74304_/Y }
C {devices/lab_pin.sym} 9140 -14730 0 1 {name=p8824 lab=_83106_/D }
C {sky130_stdcells/a21bo_4.sym} 9060 -14730 0 0 {name=X_74305_ }
C {devices/lab_pin.sym} 9000 -14600 0 0 {name=p8825 lab=_47241_/X }
C {devices/lab_pin.sym} 9000 -14560 0 0 {name=p8826 lab=_52940_/B }
C {devices/lab_pin.sym} 9120 -14580 0 1 {name=p8827 lab=_47253_/Y }
C {sky130_stdcells/nand2_4.sym} 9060 -14580 0 0 {name=X_47253_ }
C {devices/lab_pin.sym} 9000 -14460 0 0 {name=p8828 lab=_59238_/X }
C {devices/lab_pin.sym} 9000 -14420 0 0 {name=p8829 lab=_86350_/Q }
C {devices/lab_pin.sym} 9120 -14440 0 1 {name=p8830 lab=_59239_/Y }
C {sky130_stdcells/nor2_4.sym} 9060 -14440 0 0 {name=X_59239_ }
C {devices/lab_pin.sym} 9000 -14320 0 0 {name=p8831 lab=_71521_/A }
C {devices/lab_pin.sym} 9000 -14280 0 0 {name=p8832 lab=_70717_/A }
C {devices/lab_pin.sym} 9120 -14300 0 1 {name=p8833 lab=_71517_/Y }
C {sky130_stdcells/nand2_4.sym} 9060 -14300 0 0 {name=X_71517_ }
C {devices/lab_pin.sym} 9000 -14180 0 0 {name=p8834 lab=_84578_/Q }
C {devices/lab_pin.sym} 9000 -14140 0 0 {name=p8835 lab=_78073_/B }
C {devices/lab_pin.sym} 9120 -14160 0 1 {name=p8836 lab=_81882_/D }
C {sky130_stdcells/xor2_4.sym} 9060 -14160 0 0 {name=X_78073_ }
C {devices/lab_pin.sym} 9020 -14030 0 0 {name=p8837 lab=_40353_/Y }
C {devices/lab_pin.sym} 9100 -14030 0 1 {name=p8838 lab=_44603_/A }
C {sky130_stdcells/buf_2.sym} 9060 -14030 0 0 {name=X_44465_ }
C {devices/lab_pin.sym} 9000 -13920 0 0 {name=p8839 lab=_80784_/Q }
C {devices/lab_pin.sym} 9000 -13880 0 0 {name=p8840 lab=_75284_/X }
C {devices/lab_pin.sym} 9120 -13900 0 1 {name=p8841 lab=_75285_/X }
C {sky130_stdcells/xor2_4.sym} 9060 -13900 0 0 {name=X_75285_ }
C {devices/lab_pin.sym} 8980 -13810 0 0 {name=p8842 lab=_41672_/X }
C {devices/lab_pin.sym} 8980 -13770 0 0 {name=p8843 lab=_41673_/X }
C {devices/lab_pin.sym} 8980 -13730 0 0 {name=p8844 lab=_41676_/X }
C {devices/lab_pin.sym} 8980 -13690 0 0 {name=p8845 lab=_88171_/Q }
C {devices/lab_pin.sym} 8980 -13650 0 0 {name=p8846 lab=_41668_/X }
C {devices/lab_pin.sym} 9140 -13730 0 1 {name=p8847 lab=_41678_/A }
C {sky130_stdcells/o32ai_4.sym} 9060 -13730 0 0 {name=X_41677_ }
C {devices/lab_pin.sym} 8980 -13590 0 0 {name=p8848 lab=_46150_/B }
C {devices/lab_pin.sym} 8980 -13550 0 0 {name=p8849 lab=_83380_/Q }
C {devices/lab_pin.sym} 8980 -13510 0 0 {name=p8850 lab=_72496_/Y }
C {devices/lab_pin.sym} 9140 -13550 0 1 {name=p8851 lab=_72497_/X }
C {sky130_stdcells/o21a_4.sym} 9060 -13550 0 0 {name=X_72497_ }
C {devices/lab_pin.sym} 9000 -13440 0 0 {name=p8852 lab=_58160_/B }
C {devices/lab_pin.sym} 9000 -13400 0 0 {name=p8853 lab=_46204_/B }
C {devices/lab_pin.sym} 9000 -13360 0 0 {name=p8854 lab=_46204_/C }
C {devices/lab_pin.sym} 9000 -13320 0 0 {name=p8855 lab=_46204_/D }
C {devices/lab_pin.sym} 9120 -13380 0 1 {name=p8856 lab=_46204_/Y }
C {sky130_stdcells/nand4_4.sym} 9060 -13380 0 0 {name=X_46204_ }
C {sky130_stdcells/decap_3.sym} 9060 -13200 0 0 {name=XPHY_160 }
C {devices/lab_pin.sym} 9000 -13060 0 0 {name=p8857 lab=_77018_/A }
C {devices/lab_pin.sym} 9000 -13020 0 0 {name=p8858 lab=_82277_/D }
C {devices/lab_pin.sym} 9120 -13040 0 1 {name=p8859 lab=_77024_/Y }
C {sky130_stdcells/nor2_4.sym} 9060 -13040 0 0 {name=X_77024_ }
C {devices/lab_pin.sym} 9020 -12910 0 0 {name=p8860 lab=_43416_/A }
C {devices/lab_pin.sym} 9100 -12910 0 1 {name=p8861 lab=_43416_/Y }
C {sky130_stdcells/inv_2.sym} 9060 -12910 0 0 {name=X_43416_ }
C {devices/lab_pin.sym} 9000 -12820 0 0 {name=p8862 lab=_61356_/X }
C {devices/lab_pin.sym} 9000 -12780 0 0 {name=p8863 lab=_62560_/B }
C {devices/lab_pin.sym} 9000 -12740 0 0 {name=p8864 lab=_62560_/C }
C {devices/lab_pin.sym} 9000 -12700 0 0 {name=p8865 lab=_62211_/D }
C {devices/lab_pin.sym} 9120 -12760 0 1 {name=p8866 lab=_62251_/D }
C {sky130_stdcells/nand4_4.sym} 9060 -12760 0 0 {name=X_62250_ }
C {devices/lab_pin.sym} 8980 -12630 0 0 {name=p8867 lab=_74233_/X }
C {devices/lab_pin.sym} 8980 -12590 0 0 {name=p8868 lab=_74235_/X }
C {devices/lab_pin.sym} 8980 -12550 0 0 {name=p8869 lab=_56547_/X }
C {devices/lab_pin.sym} 9140 -12590 0 1 {name=p8870 lab=_74239_/A }
C {sky130_stdcells/a21o_4.sym} 9060 -12590 0 0 {name=X_74236_ }
C {sky130_stdcells/decap_3.sym} 9060 -12420 0 0 {name=XPHY_171 }
C {devices/lab_pin.sym} 9020 -12270 0 0 {name=p8871 lab=_40623_/X }
C {devices/lab_pin.sym} 9100 -12270 0 1 {name=p8872 lab=_40628_/X }
C {sky130_stdcells/buf_2.sym} 9060 -12270 0 0 {name=X_40628_ }
C {devices/lab_pin.sym} 9020 -12150 0 0 {name=p8873 lab=_47184_/A }
C {devices/lab_pin.sym} 9100 -12150 0 1 {name=p8874 lab=_47184_/X }
C {sky130_stdcells/buf_2.sym} 9060 -12150 0 0 {name=X_47184_ }
C {devices/lab_pin.sym} 9000 -12050 0 0 {name=p8875 lab=_70673_/A }
C {devices/lab_pin.sym} 9000 -12010 0 0 {name=p8876 lab=_71626_/C }
C {devices/lab_pin.sym} 9000 -11970 0 0 {name=p8877 lab=_71450_/C }
C {devices/lab_pin.sym} 9120 -12010 0 1 {name=p8878 lab=_71448_/Y }
C {sky130_stdcells/nor3_4.sym} 9060 -12010 0 0 {name=X_71448_ }
C {devices/lab_pin.sym} 8980 -11900 0 0 {name=p8879 lab=_41485_/X }
C {devices/lab_pin.sym} 8980 -11860 0 0 {name=p8880 lab=_44394_/X }
C {devices/lab_pin.sym} 8980 -11820 0 0 {name=p8881 lab=_87130_/Q }
C {devices/lab_pin.sym} 8980 -11780 0 0 {name=p8882 lab=_44395_/X }
C {devices/lab_pin.sym} 9140 -11840 0 1 {name=p8883 lab=_87130_/D }
C {sky130_stdcells/a2bb2o_4.sym} 9060 -11840 0 0 {name=X_44396_ }
C {sky130_stdcells/decap_3.sym} 9060 -11660 0 0 {name=XPHY_182 }
C {sky130_stdcells/decap_3.sym} 9060 -11480 0 0 {name=XPHY_193 }
C {devices/lab_pin.sym} 9020 -11330 0 0 {name=p8884 lab=clkbuf_6_56_0_CLK/X }
C {devices/lab_pin.sym} 9100 -11330 0 1 {name=p8885 lab=clkbuf_8_225_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 9060 -11330 0 0 {name=Xclkbuf_7_112_0_CLK }
C {devices/lab_pin.sym} 8980 -11250 0 0 {name=p8886 lab=_61194_/X }
C {devices/lab_pin.sym} 8980 -11210 0 0 {name=p8887 lab=_61198_/X }
C {devices/lab_pin.sym} 8980 -11170 0 0 {name=p8888 lab=_61135_/X }
C {devices/lab_pin.sym} 8980 -11130 0 0 {name=p8889 lab=_61188_/Y }
C {devices/lab_pin.sym} 8980 -11090 0 0 {name=p8890 lab=_61200_/X }
C {devices/lab_pin.sym} 9140 -11170 0 1 {name=p8891 lab=_61201_/X }
C {sky130_stdcells/o41a_4.sym} 9060 -11170 0 0 {name=X_61201_ }
C {devices/lab_pin.sym} 9000 -11020 0 0 {name=p8892 lab=_46135_/A }
C {devices/lab_pin.sym} 9000 -10980 0 0 {name=p8893 lab=_46204_/C }
C {devices/lab_pin.sym} 9120 -11000 0 1 {name=p8894 lab=_46135_/Y }
C {sky130_stdcells/nand2_4.sym} 9060 -11000 0 0 {name=X_46135_ }
C {devices/lab_pin.sym} 9020 -10870 0 0 {name=p8895 lab=_43296_/A }
C {devices/lab_pin.sym} 9100 -10870 0 1 {name=p8896 lab=_43347_/X }
C {sky130_stdcells/buf_2.sym} 9060 -10870 0 0 {name=X_43347_ }
C {devices/lab_pin.sym} 9000 -10770 0 0 {name=p8897 lab=_62181_/A }
C {devices/lab_pin.sym} 9000 -10730 0 0 {name=p8898 lab=_62181_/B }
C {devices/lab_pin.sym} 9000 -10690 0 0 {name=p8899 lab=_78050_/B }
C {devices/lab_pin.sym} 9120 -10730 0 1 {name=p8900 lab=_62181_/Y }
C {sky130_stdcells/nor3_4.sym} 9060 -10730 0 0 {name=X_62181_ }
C {devices/lab_pin.sym} 8980 -10620 0 0 {name=p8901 lab=_43096_/Y }
C {devices/lab_pin.sym} 8980 -10580 0 0 {name=p8902 lab=_56273_/X }
C {devices/lab_pin.sym} 8980 -10540 0 0 {name=p8903 lab=_73035_/X }
C {devices/lab_pin.sym} 8980 -10500 0 0 {name=p8904 lab=_74166_/Y }
C {devices/lab_pin.sym} 9140 -10560 0 1 {name=p8905 lab=_74167_/X }
C {sky130_stdcells/a211o_4.sym} 9060 -10560 0 0 {name=X_74167_ }
C {devices/lab_pin.sym} 8980 -10430 0 0 {name=p8906 lab=_40380_/X }
C {devices/lab_pin.sym} 8980 -10390 0 0 {name=p8907 lab=_82881_/Q }
C {devices/lab_pin.sym} 8980 -10350 0 0 {name=p8908 lab=_40558_/X }
C {devices/lab_pin.sym} 9140 -10390 0 1 {name=p8909 lab=_40559_/X }
C {sky130_stdcells/o21a_4.sym} 9060 -10390 0 0 {name=X_40559_ }
C {devices/lab_pin.sym} 9000 -10270 0 0 {name=p8910 lab=_70673_/A }
C {devices/lab_pin.sym} 9000 -10230 0 0 {name=p8911 lab=_71377_/B }
C {devices/lab_pin.sym} 9000 -10190 0 0 {name=p8912 lab=_71377_/C }
C {devices/lab_pin.sym} 9120 -10230 0 1 {name=p8913 lab=_71379_/Y }
C {sky130_stdcells/nor3_4.sym} 9060 -10230 0 0 {name=X_71379_ }
C {devices/lab_pin.sym} 9020 -10090 0 0 {name=p8914 lab=clkbuf_9_41_0_CLK/X }
C {devices/lab_pin.sym} 9100 -10090 0 1 {name=p8915 lab=_86770_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9060 -10090 0 0 {name=Xclkbuf_10_82_0_CLK }
C {devices/lab_pin.sym} 9000 -9990 0 0 {name=p8916 lab=_60946_/X }
C {devices/lab_pin.sym} 9000 -9950 0 0 {name=p8917 lab=_61138_/B }
C {devices/lab_pin.sym} 9000 -9910 0 0 {name=p8918 lab=_61132_/C }
C {devices/lab_pin.sym} 9120 -9950 0 1 {name=p8919 lab=_61132_/Y }
C {sky130_stdcells/nor3_4.sym} 9060 -9950 0 0 {name=X_61132_ }
C {devices/lab_pin.sym} 8980 -9840 0 0 {name=p8920 lab=_72978_/X }
C {devices/lab_pin.sym} 8980 -9800 0 0 {name=p8921 lab=_83068_/Q }
C {devices/lab_pin.sym} 8980 -9760 0 0 {name=p8922 lab=_72992_/X }
C {devices/lab_pin.sym} 8980 -9720 0 0 {name=p8923 lab=_73117_/X }
C {devices/lab_pin.sym} 9140 -9780 0 1 {name=p8924 lab=_73118_/X }
C {sky130_stdcells/a211o_4.sym} 9060 -9780 0 0 {name=X_73118_ }
C {devices/lab_pin.sym} 8980 -9660 0 0 {name=p8925 lab=_41569_/Y }
C {devices/lab_pin.sym} 8980 -9620 0 0 {name=p8926 lab=_46061_/X }
C {devices/lab_pin.sym} 8980 -9580 0 0 {name=p8927 lab=_86785_/Q }
C {devices/lab_pin.sym} 8980 -9540 0 0 {name=p8928 lab=_46062_/X }
C {devices/lab_pin.sym} 9140 -9600 0 1 {name=p8929 lab=_86785_/D }
C {sky130_stdcells/a2bb2o_4.sym} 9060 -9600 0 0 {name=X_46066_ }
C {devices/lab_pin.sym} 9020 -9450 0 0 {name=p8930 lab=_43218_/A }
C {devices/lab_pin.sym} 9100 -9450 0 1 {name=p8931 lab=_43278_/X }
C {sky130_stdcells/buf_2.sym} 9060 -9450 0 0 {name=X_43278_ }
C {devices/lab_pin.sym} 8980 -9360 0 0 {name=p8932 lab=_43089_/Y }
C {devices/lab_pin.sym} 8980 -9320 0 0 {name=p8933 lab=_72895_/X }
C {devices/lab_pin.sym} 8980 -9280 0 0 {name=p8934 lab=_73486_/X }
C {devices/lab_pin.sym} 8980 -9240 0 0 {name=p8935 lab=_74097_/Y }
C {devices/lab_pin.sym} 9140 -9300 0 1 {name=p8936 lab=_74098_/X }
C {sky130_stdcells/a211o_4.sym} 9060 -9300 0 0 {name=X_74098_ }
C {devices/lab_pin.sym} 9000 -9160 0 0 {name=p8937 lab=_78975_/A }
C {devices/lab_pin.sym} 9000 -9120 0 0 {name=p8938 lab=_78975_/B }
C {devices/lab_pin.sym} 9120 -9140 0 1 {name=p8939 lab=_78975_/X }
C {sky130_stdcells/xor2_4.sym} 9060 -9140 0 0 {name=X_78975_ }
C {devices/lab_pin.sym} 8980 -9030 0 0 {name=p8940 lab=_45014_/Y }
C {devices/lab_pin.sym} 8980 -8990 0 0 {name=p8941 lab=_45016_/Y }
C {devices/lab_pin.sym} 8980 -8950 0 0 {name=p8942 lab=_44986_/X }
C {devices/lab_pin.sym} 9140 -8990 0 1 {name=p8943 lab=_45017_/X }
C {sky130_stdcells/a21o_4.sym} 9060 -8990 0 0 {name=X_45017_ }
C {devices/lab_pin.sym} 8980 -8890 0 0 {name=p8944 lab=_42205_/X }
C {devices/lab_pin.sym} 8980 -8850 0 0 {name=p8945 lab=_42226_/X }
C {devices/lab_pin.sym} 8980 -8810 0 0 {name=p8946 lab=_41376_/X }
C {devices/lab_pin.sym} 8980 -8770 0 0 {name=p8947 lab=_87970_/Q }
C {devices/lab_pin.sym} 8980 -8730 0 0 {name=p8948 lab=_42228_/X }
C {devices/lab_pin.sym} 9140 -8810 0 1 {name=p8949 lab=_42230_/A }
C {sky130_stdcells/o32ai_4.sym} 9060 -8810 0 0 {name=X_42229_ }
C {devices/lab_pin.sym} 8980 -8680 0 0 {name=p8950 lab=_65924_/X }
C {devices/lab_pin.sym} 8980 -8640 0 0 {name=p8951 lab=_84991_/Q }
C {devices/lab_pin.sym} 8980 -8600 0 0 {name=p8952 lab=_65865_/X }
C {devices/lab_pin.sym} 8980 -8560 0 0 {name=p8953 lab=_65939_/X }
C {devices/lab_pin.sym} 9140 -8620 0 1 {name=p8954 lab=_65940_/X }
C {sky130_stdcells/a211o_4.sym} 9060 -8620 0 0 {name=X_65940_ }
C {devices/lab_pin.sym} 9020 -8470 0 0 {name=p8955 lab=_60846_/Y }
C {devices/lab_pin.sym} 9100 -8470 0 1 {name=p8956 lab=_61063_/Y }
C {sky130_stdcells/inv_2.sym} 9060 -8470 0 0 {name=X_61063_ }
C {devices/lab_pin.sym} 9000 -8360 0 0 {name=p8957 lab=_73039_/Y }
C {devices/lab_pin.sym} 9000 -8320 0 0 {name=p8958 lab=_73048_/X }
C {devices/lab_pin.sym} 9120 -8340 0 1 {name=p8959 lab=_73049_/Y }
C {sky130_stdcells/xnor2_4.sym} 9060 -8340 0 0 {name=X_73049_ }
C {devices/lab_pin.sym} 9000 -8220 0 0 {name=p8960 lab=_82248_/Q }
C {devices/lab_pin.sym} 9000 -8180 0 0 {name=p8961 lab=_81960_/Q }
C {devices/lab_pin.sym} 9120 -8200 0 1 {name=p8962 lab=_77927_/B }
C {sky130_stdcells/xnor2_4.sym} 9060 -8200 0 0 {name=X_77926_ }
C {devices/lab_pin.sym} 9020 -8070 0 0 {name=p8963 lab=clkbuf_6_63_0_CLK/X }
C {devices/lab_pin.sym} 9100 -8070 0 1 {name=p8964 lab=clkbuf_8_255_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 9060 -8070 0 0 {name=Xclkbuf_7_127_0_CLK }
C {devices/lab_pin.sym} 9020 -7950 0 0 {name=p8965 lab=_60109_/A }
C {devices/lab_pin.sym} 9100 -7950 0 1 {name=p8966 lab=_60014_/X }
C {sky130_stdcells/buf_2.sym} 9060 -7950 0 0 {name=X_60014_ }
C {devices/lab_pin.sym} 9020 -7830 0 0 {name=p8967 lab=_49825_/A }
C {devices/lab_pin.sym} 9100 -7830 0 1 {name=p8968 lab=_49825_/X }
C {sky130_stdcells/buf_2.sym} 9060 -7830 0 0 {name=X_49825_ }
C {devices/lab_pin.sym} 9020 -7710 0 0 {name=p8969 lab=_84172_/Q }
C {devices/lab_pin.sym} 9100 -7710 0 1 {name=p8970 lab=_65872_/C }
C {sky130_stdcells/inv_2.sym} 9060 -7710 0 0 {name=X_65871_ }
C {devices/lab_pin.sym} 9020 -7590 0 0 {name=p8971 lab=_77833_/Y }
C {devices/lab_pin.sym} 9100 -7590 0 1 {name=p8972 lab=_81934_/D }
C {sky130_stdcells/inv_2.sym} 9060 -7590 0 0 {name=X_77857_ }
C {devices/lab_pin.sym} 9020 -7470 0 0 {name=p8973 lab=clkbuf_9_48_0_CLK/X }
C {devices/lab_pin.sym} 9100 -7470 0 1 {name=p8974 lab=_82987_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9060 -7470 0 0 {name=Xclkbuf_10_97_0_CLK }
C {devices/lab_pin.sym} 8980 -7370 0 0 {name=p8975 lab=_67607_/X }
C {devices/lab_pin.sym} 8980 -7330 0 0 {name=p8976 lab=_67609_/X }
C {devices/lab_pin.sym} 8980 -7290 0 0 {name=p8977 lab=_67423_/X }
C {devices/lab_pin.sym} 9140 -7330 0 1 {name=p8978 lab=_67610_/Y }
C {sky130_stdcells/a21oi_4.sym} 9060 -7330 0 0 {name=X_67610_ }
C {devices/lab_pin.sym} 8980 -7210 0 0 {name=p8979 lab=_64819_/X }
C {devices/lab_pin.sym} 8980 -7170 0 0 {name=p8980 lab=_64821_/X }
C {devices/lab_pin.sym} 8980 -7130 0 0 {name=p8981 lab=_64807_/X }
C {devices/lab_pin.sym} 9140 -7170 0 1 {name=p8982 lab=_64822_/X }
C {sky130_stdcells/a21o_4.sym} 9060 -7170 0 0 {name=X_64822_ }
C {devices/lab_pin.sym} 9000 -7040 0 0 {name=p8983 lab=_76808_/A }
C {devices/lab_pin.sym} 9000 -7000 0 0 {name=p8984 lab=_76807_/Y }
C {devices/lab_pin.sym} 9120 -7020 0 1 {name=p8985 lab=_76809_/B }
C {sky130_stdcells/xnor2_4.sym} 9060 -7020 0 0 {name=X_76808_ }
C {devices/lab_pin.sym} 8980 -6910 0 0 {name=p8986 lab=_49754_/Y }
C {devices/lab_pin.sym} 8980 -6870 0 0 {name=p8987 lab=_49732_/X }
C {devices/lab_pin.sym} 8980 -6830 0 0 {name=p8988 lab=_49755_/X }
C {devices/lab_pin.sym} 9140 -6870 0 1 {name=p8989 lab=_86329_/D }
C {sky130_stdcells/a21oi_4.sym} 9060 -6870 0 0 {name=X_49756_ }
C {devices/lab_pin.sym} 8980 -6760 0 0 {name=p8990 lab=_88106_/Q }
C {devices/lab_pin.sym} 8980 -6720 0 0 {name=p8991 lab=_68066_/X }
C {devices/lab_pin.sym} 8980 -6680 0 0 {name=p8992 lab=_67997_/X }
C {devices/lab_pin.sym} 8980 -6640 0 0 {name=p8993 lab=_68589_/Y }
C {devices/lab_pin.sym} 9140 -6700 0 1 {name=p8994 lab=_68590_/X }
C {sky130_stdcells/a211o_4.sym} 9060 -6700 0 0 {name=X_68590_ }
C {devices/lab_pin.sym} 9020 -6550 0 0 {name=p8995 lab=_54469_/B }
C {devices/lab_pin.sym} 9100 -6550 0 1 {name=p8996 lab=_52777_/B }
C {sky130_stdcells/buf_2.sym} 9060 -6550 0 0 {name=X_46968_ }
C {devices/lab_pin.sym} 9000 -6440 0 0 {name=p8997 lab=_81928_/D }
C {devices/lab_pin.sym} 9000 -6400 0 0 {name=p8998 lab=_77776_/A }
C {devices/lab_pin.sym} 9120 -6420 0 1 {name=p8999 lab=_77788_/X }
C {sky130_stdcells/and2_4.sym} 9060 -6420 0 0 {name=X_77788_ }
C {devices/lab_pin.sym} 9020 -6290 0 0 {name=p9000 lab=clkbuf_8_243_0_CLK/A }
C {devices/lab_pin.sym} 9100 -6290 0 1 {name=p9001 lab=clkbuf_9_486_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 9060 -6290 0 0 {name=Xclkbuf_8_243_0_CLK }
C {devices/lab_pin.sym} 8980 -6190 0 0 {name=p9002 lab=_86498_/Q }
C {devices/lab_pin.sym} 8980 -6150 0 0 {name=p9003 lab=_48548_/X }
C {devices/lab_pin.sym} 8980 -6110 0 0 {name=p9004 lab=_48706_/Y }
C {devices/lab_pin.sym} 9140 -6150 0 1 {name=p9005 lab=_48707_/Y }
C {sky130_stdcells/o21ai_4.sym} 9060 -6150 0 0 {name=X_48707_ }
C {devices/lab_pin.sym} 8980 -6040 0 0 {name=p9006 lab=_87159_/Q }
C {devices/lab_pin.sym} 8980 -6000 0 0 {name=p9007 lab=_67467_/X }
C {devices/lab_pin.sym} 8980 -5960 0 0 {name=p9008 lab=_67516_/X }
C {devices/lab_pin.sym} 8980 -5920 0 0 {name=p9009 lab=_67540_/X }
C {devices/lab_pin.sym} 9140 -5980 0 1 {name=p9010 lab=_67541_/X }
C {sky130_stdcells/a211o_4.sym} 9060 -5980 0 0 {name=X_67541_ }
C {devices/lab_pin.sym} 9000 -5840 0 0 {name=p9011 lab=_79526_/Y }
C {devices/lab_pin.sym} 9000 -5800 0 0 {name=p9012 lab=_60374_/C }
C {devices/lab_pin.sym} 9120 -5820 0 1 {name=p9013 lab=_79527_/Y }
C {sky130_stdcells/nand2_4.sym} 9060 -5820 0 0 {name=X_79527_ }
C {devices/lab_pin.sym} 9000 -5710 0 0 {name=p9014 lab=_44005_/X }
C {devices/lab_pin.sym} 9000 -5670 0 0 {name=p9015 lab=_44024_/A }
C {devices/lab_pin.sym} 9000 -5630 0 0 {name=p9016 lab=_45918_/Y }
C {devices/lab_pin.sym} 9120 -5670 0 1 {name=p9017 lab=_45919_/Y }
C {sky130_stdcells/nand3_4.sym} 9060 -5670 0 0 {name=X_45919_ }
C {devices/lab_pin.sym} 9000 -5540 0 0 {name=p9018 lab=_64826_/A }
C {devices/lab_pin.sym} 9000 -5500 0 0 {name=p9019 lab=_64753_/B }
C {devices/lab_pin.sym} 9120 -5520 0 1 {name=p9020 lab=_64753_/X }
C {sky130_stdcells/and2_4.sym} 9060 -5520 0 0 {name=X_64753_ }
C {devices/lab_pin.sym} 9020 -5390 0 0 {name=p9021 lab=_76728_/Y }
C {devices/lab_pin.sym} 9100 -5390 0 1 {name=p9022 lab=_81355_/D }
C {sky130_stdcells/inv_2.sym} 9060 -5390 0 0 {name=X_76739_ }
C {devices/lab_pin.sym} 9020 -5270 0 0 {name=p9023 lab=_49632_/A }
C {devices/lab_pin.sym} 9100 -5270 0 1 {name=p9024 lab=_49687_/X }
C {sky130_stdcells/buf_2.sym} 9060 -5270 0 0 {name=X_49687_ }
C {devices/lab_pin.sym} 8980 -5190 0 0 {name=p9025 lab=_57683_/X }
C {devices/lab_pin.sym} 8980 -5150 0 0 {name=p9026 lab=_61902_/X }
C {devices/lab_pin.sym} 8980 -5110 0 0 {name=p9027 lab=_61916_/X }
C {devices/lab_pin.sym} 8980 -5070 0 0 {name=p9028 lab=_61948_/X }
C {devices/lab_pin.sym} 8980 -5040 0 0 {name=p9029 lab=_61964_/X }
C {devices/lab_pin.sym} 9140 -5110 0 1 {name=p9030 lab=_61965_/X }
C {sky130_stdcells/a41o_4.sym} 9060 -5110 0 0 {name=X_61965_ }
C {devices/lab_pin.sym} 9020 -4950 0 0 {name=p9031 lab=_52739_/B }
C {devices/lab_pin.sym} 9100 -4950 0 1 {name=p9032 lab=_46899_/X }
C {sky130_stdcells/buf_2.sym} 9060 -4950 0 0 {name=X_46899_ }
C {devices/lab_pin.sym} 9020 -4830 0 0 {name=p9033 lab=clkbuf_9_10_0_CLK/X }
C {devices/lab_pin.sym} 9100 -4830 0 1 {name=p9034 lab=_85257_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9060 -4830 0 0 {name=Xclkbuf_10_20_0_CLK }
C {devices/lab_pin.sym} 8980 -4740 0 0 {name=p9035 lab=_59445_/A }
C {devices/lab_pin.sym} 8980 -4700 0 0 {name=p9036 lab=_63370_/A }
C {devices/lab_pin.sym} 8980 -4660 0 0 {name=p9037 lab=_61685_/A }
C {devices/lab_pin.sym} 8980 -4620 0 0 {name=p9038 lab=_60780_/X }
C {devices/lab_pin.sym} 9140 -4680 0 1 {name=p9039 lab=_63704_/X }
C {sky130_stdcells/a2bb2o_4.sym} 9060 -4680 0 0 {name=X_63704_ }
C {devices/lab_pin.sym} 9020 -4530 0 0 {name=p9040 lab=_48638_/A }
C {devices/lab_pin.sym} 9100 -4530 0 1 {name=p9041 lab=_48639_/A }
C {sky130_stdcells/inv_2.sym} 9060 -4530 0 0 {name=X_48638_ }
C {devices/lab_pin.sym} 9020 -4410 0 0 {name=p9042 lab=_60915_/X }
C {devices/lab_pin.sym} 9100 -4410 0 1 {name=p9043 lab=_64189_/C }
C {sky130_stdcells/buf_2.sym} 9060 -4410 0 0 {name=X_60916_ }
C {devices/lab_pin.sym} 8980 -4310 0 0 {name=p9044 lab=_81500_/D }
C {devices/lab_pin.sym} 8980 -4270 0 0 {name=p9045 lab=_67449_/X }
C {devices/lab_pin.sym} 8980 -4230 0 0 {name=p9046 lab=_67471_/X }
C {devices/lab_pin.sym} 9140 -4270 0 1 {name=p9047 lab=_84068_/D }
C {sky130_stdcells/a21bo_4.sym} 9060 -4270 0 0 {name=X_67472_ }
C {devices/lab_pin.sym} 9000 -4140 0 0 {name=p9048 lab=_79470_/A }
C {devices/lab_pin.sym} 9000 -4100 0 0 {name=p9049 lab=_79470_/B }
C {devices/lab_pin.sym} 9120 -4120 0 1 {name=p9050 lab=_79481_/A }
C {sky130_stdcells/xnor2_4.sym} 9060 -4120 0 0 {name=X_79458_ }
C {devices/lab_pin.sym} 9000 -4000 0 0 {name=p9051 lab=_64684_/A }
C {devices/lab_pin.sym} 9000 -3960 0 0 {name=p9052 lab=_64684_/B }
C {devices/lab_pin.sym} 9120 -3980 0 1 {name=p9053 lab=_64684_/X }
C {sky130_stdcells/and2_4.sym} 9060 -3980 0 0 {name=X_64684_ }
C {devices/lab_pin.sym} 8980 -3890 0 0 {name=p9054 lab=_61885_/X }
C {devices/lab_pin.sym} 8980 -3850 0 0 {name=p9055 lab=_61887_/X }
C {devices/lab_pin.sym} 8980 -3810 0 0 {name=p9056 lab=_61894_/Y }
C {devices/lab_pin.sym} 8980 -3770 0 0 {name=p9057 lab=_84743_/Q }
C {devices/lab_pin.sym} 8980 -3730 0 0 {name=p9058 lab=_61895_/X }
C {devices/lab_pin.sym} 9140 -3810 0 1 {name=p9059 lab=_61896_/Y }
C {sky130_stdcells/o32ai_4.sym} 9060 -3810 0 0 {name=X_61896_ }
C {devices/lab_pin.sym} 8980 -3670 0 0 {name=p9060 lab=_69208_/X }
C {devices/lab_pin.sym} 8980 -3630 0 0 {name=p9061 lab=_69210_/X }
C {devices/lab_pin.sym} 8980 -3590 0 0 {name=p9062 lab=_69171_/X }
C {devices/lab_pin.sym} 9140 -3630 0 1 {name=p9063 lab=_69211_/Y }
C {sky130_stdcells/a21oi_4.sym} 9060 -3630 0 0 {name=X_69211_ }
C {devices/lab_pin.sym} 9000 -3510 0 0 {name=p9064 lab=_64897_/X }
C {devices/lab_pin.sym} 9000 -3470 0 0 {name=p9065 lab=_66423_/B }
C {devices/lab_pin.sym} 9000 -3430 0 0 {name=p9066 lab=_64900_/X }
C {devices/lab_pin.sym} 9120 -3470 0 1 {name=p9067 lab=_66423_/Y }
C {sky130_stdcells/nand3_4.sym} 9060 -3470 0 0 {name=X_66423_ }
C {devices/lab_pin.sym} 8980 -3350 0 0 {name=p9068 lab=_78387_/Y }
C {devices/lab_pin.sym} 8980 -3310 0 0 {name=p9069 lab=_78384_/Y }
C {devices/lab_pin.sym} 8980 -3270 0 0 {name=p9070 lab=_78385_/Y }
C {devices/lab_pin.sym} 9140 -3310 0 1 {name=p9071 lab=_78409_/Y }
C {sky130_stdcells/o21ai_4.sym} 9060 -3310 0 0 {name=X_78409_ }
C {devices/lab_pin.sym} 9020 -3170 0 0 {name=p9072 lab=_63578_/A }
C {devices/lab_pin.sym} 9100 -3170 0 1 {name=p9073 lab=_63635_/X }
C {sky130_stdcells/buf_2.sym} 9060 -3170 0 0 {name=X_63635_ }
C {devices/lab_pin.sym} 9000 -3070 0 0 {name=p9074 lab=_52194_/A }
C {devices/lab_pin.sym} 9000 -3030 0 0 {name=p9075 lab=_48624_/B }
C {devices/lab_pin.sym} 9000 -2990 0 0 {name=p9076 lab=_48610_/C }
C {devices/lab_pin.sym} 9120 -3030 0 1 {name=p9077 lab=_48569_/X }
C {sky130_stdcells/and3_4.sym} 9060 -3030 0 0 {name=X_48569_ }
C {devices/lab_pin.sym} 9000 -2900 0 0 {name=p9078 lab=_60386_/A }
C {devices/lab_pin.sym} 9000 -2860 0 0 {name=p9079 lab=_60846_/Y }
C {devices/lab_pin.sym} 9120 -2880 0 1 {name=p9080 lab=_60848_/A }
C {sky130_stdcells/and2_4.sym} 9060 -2880 0 0 {name=X_60847_ }
C {devices/lab_pin.sym} 8980 -2770 0 0 {name=p9081 lab=_79375_/Y }
C {devices/lab_pin.sym} 8980 -2730 0 0 {name=p9082 lab=_79381_/B }
C {devices/lab_pin.sym} 8980 -2690 0 0 {name=p9083 lab=_79388_/X }
C {devices/lab_pin.sym} 9140 -2730 0 1 {name=p9084 lab=_79390_/B }
C {sky130_stdcells/o21ai_4.sym} 9060 -2730 0 0 {name=X_79389_ }
C {devices/lab_pin.sym} 9020 -2590 0 0 {name=p9085 lab=clkbuf_9_126_0_CLK/X }
C {devices/lab_pin.sym} 9100 -2590 0 1 {name=p9086 lab=_82436_/CLK }
