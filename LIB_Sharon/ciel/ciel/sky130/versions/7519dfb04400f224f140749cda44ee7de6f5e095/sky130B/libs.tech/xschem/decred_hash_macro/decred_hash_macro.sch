C {devices/lab_pin.sym} 98380 -26510 0 1 {name=p97526 lab=_86980_/D }
C {sky130_stdcells/o32ai_4.sym} 98300 -26510 0 0 {name=X_44739_ }
C {devices/lab_pin.sym} 98240 -26360 0 0 {name=p97527 lab=_80961_/D }
C {devices/lab_pin.sym} 98240 -26320 0 0 {name=p97528 lab=_75559_/B }
C {devices/lab_pin.sym} 98360 -26340 0 1 {name=p97529 lab=_75559_/X }
C {sky130_stdcells/xor2_4.sym} 98300 -26340 0 0 {name=X_75559_ }
C {devices/lab_pin.sym} 98240 -26230 0 0 {name=p97530 lab=_63573_/A }
C {devices/lab_pin.sym} 98240 -26190 0 0 {name=p97531 lab=_60712_/B }
C {devices/lab_pin.sym} 98240 -26150 0 0 {name=p97532 lab=_63630_/C }
C {devices/lab_pin.sym} 98360 -26190 0 1 {name=p97533 lab=_63573_/Y }
C {sky130_stdcells/nor3_4.sym} 98300 -26190 0 0 {name=X_63573_ }
C {devices/lab_pin.sym} 98240 -26080 0 0 {name=p97534 lab=_63384_/C }
C {devices/lab_pin.sym} 98240 -26040 0 0 {name=p97535 lab=_63384_/D }
C {devices/lab_pin.sym} 98240 -26000 0 0 {name=p97536 lab=_60694_/C }
C {devices/lab_pin.sym} 98240 -25960 0 0 {name=p97537 lab=_60660_/A }
C {devices/lab_pin.sym} 98360 -26020 0 1 {name=p97538 lab=_60785_/Y }
C {sky130_stdcells/nand4_4.sym} 98300 -26020 0 0 {name=X_60785_ }
C {devices/lab_pin.sym} 98220 -25890 0 0 {name=p97539 lab=_82079_/D }
C {devices/lab_pin.sym} 98220 -25850 0 0 {name=p97540 lab=_68040_/X }
C {devices/lab_pin.sym} 98220 -25810 0 0 {name=p97541 lab=_68099_/X }
C {devices/lab_pin.sym} 98380 -25850 0 1 {name=p97542 lab=_84039_/D }
C {sky130_stdcells/a21bo_4.sym} 98300 -25850 0 0 {name=X_68100_ }
C {devices/lab_pin.sym} 98240 -25730 0 0 {name=p97543 lab=_65305_/X }
C {devices/lab_pin.sym} 98240 -25690 0 0 {name=p97544 lab=_65833_/B }
C {devices/lab_pin.sym} 98240 -25650 0 0 {name=p97545 lab=_65311_/X }
C {devices/lab_pin.sym} 98360 -25690 0 1 {name=p97546 lab=_65312_/Y }
C {sky130_stdcells/nand3_4.sym} 98300 -25690 0 0 {name=X_65312_ }
C {devices/lab_pin.sym} 98240 -25580 0 0 {name=p97547 lab=_62623_/A }
C {devices/lab_pin.sym} 98240 -25540 0 0 {name=p97548 lab=_84892_/Q }
C {devices/lab_pin.sym} 98240 -25500 0 0 {name=p97549 lab=_62623_/C }
C {devices/lab_pin.sym} 98240 -25460 0 0 {name=p97550 lab=_62623_/D }
C {devices/lab_pin.sym} 98360 -25520 0 1 {name=p97551 lab=_62524_/X }
C {sky130_stdcells/and4_4.sym} 98300 -25520 0 0 {name=X_62524_ }
C {devices/lab_pin.sym} 98220 -25390 0 0 {name=p97552 lab=_69077_/X }
C {devices/lab_pin.sym} 98220 -25350 0 0 {name=p97553 lab=_69079_/X }
C {devices/lab_pin.sym} 98220 -25310 0 0 {name=p97554 lab=_69035_/X }
C {devices/lab_pin.sym} 98380 -25350 0 1 {name=p97555 lab=_69080_/X }
C {sky130_stdcells/a21o_4.sym} 98300 -25350 0 0 {name=X_69080_ }
C {devices/lab_pin.sym} 98260 -25210 0 0 {name=p97556 lab=_47458_/A }
C {devices/lab_pin.sym} 98340 -25210 0 1 {name=p97557 lab=_47459_/A }
C {sky130_stdcells/inv_2.sym} 98300 -25210 0 0 {name=X_47458_ }
C {devices/lab_pin.sym} 98240 -25110 0 0 {name=p97558 lab=_66231_/X }
C {devices/lab_pin.sym} 98240 -25070 0 0 {name=p97559 lab=_66319_/B }
C {devices/lab_pin.sym} 98240 -25030 0 0 {name=p97560 lab=_84143_/Q }
C {devices/lab_pin.sym} 98360 -25070 0 1 {name=p97561 lab=_66292_/X }
C {sky130_stdcells/and3_4.sym} 98300 -25070 0 0 {name=X_66292_ }
C {devices/lab_pin.sym} 98240 -24940 0 0 {name=p97562 lab=_78278_/A }
C {devices/lab_pin.sym} 98240 -24900 0 0 {name=p97563 lab=_78278_/B }
C {devices/lab_pin.sym} 98360 -24920 0 1 {name=p97564 lab=_78278_/X }
C {sky130_stdcells/xor2_4.sym} 98300 -24920 0 0 {name=X_78278_ }
C {devices/lab_pin.sym} 98240 -24800 0 0 {name=p97565 lab=_68405_/A }
C {devices/lab_pin.sym} 98240 -24760 0 0 {name=p97566 lab=_87190_/Q }
C {devices/lab_pin.sym} 98360 -24780 0 1 {name=p97567 lab=_68031_/X }
C {sky130_stdcells/and2_4.sym} 98300 -24780 0 0 {name=X_68031_ }
C {devices/lab_pin.sym} 98220 -24670 0 0 {name=p97568 lab=_46397_/Y }
C {devices/lab_pin.sym} 98220 -24630 0 0 {name=p97569 lab=_46399_/X }
C {devices/lab_pin.sym} 98220 -24590 0 0 {name=p97570 lab=_46408_/Y }
C {devices/lab_pin.sym} 98380 -24630 0 1 {name=p97571 lab=_46409_/Y }
C {sky130_stdcells/a21boi_4.sym} 98300 -24630 0 0 {name=X_46409_ }
C {devices/lab_pin.sym} 98220 -24510 0 0 {name=p97572 lab=_65198_/X }
C {devices/lab_pin.sym} 98220 -24470 0 0 {name=p97573 lab=_65233_/Y }
C {devices/lab_pin.sym} 98220 -24430 0 0 {name=p97574 lab=_65242_/Y }
C {devices/lab_pin.sym} 98380 -24470 0 1 {name=p97575 lab=_65243_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -24470 0 0 {name=X_65243_ }
C {devices/lab_pin.sym} 98220 -24350 0 0 {name=p97576 lab=_77230_/A }
C {devices/lab_pin.sym} 98220 -24310 0 0 {name=p97577 lab=_77230_/C }
C {devices/lab_pin.sym} 98220 -24270 0 0 {name=p97578 lab=_77230_/B }
C {devices/lab_pin.sym} 98380 -24310 0 1 {name=p97579 lab=_77229_/Y }
C {sky130_stdcells/a21oi_4.sym} 98300 -24310 0 0 {name=X_77229_ }
C {devices/lab_pin.sym} 98240 -24190 0 0 {name=p97580 lab=_62411_/X }
C {devices/lab_pin.sym} 98240 -24150 0 0 {name=p97581 lab=_62412_/X }
C {devices/lab_pin.sym} 98240 -24110 0 0 {name=p97582 lab=_76985_/B }
C {devices/lab_pin.sym} 98360 -24150 0 1 {name=p97583 lab=_62455_/Y }
C {sky130_stdcells/nor3_4.sym} 98300 -24150 0 0 {name=X_62455_ }
C {devices/lab_pin.sym} 98260 -24010 0 0 {name=p97584 lab=_47198_/X }
C {devices/lab_pin.sym} 98340 -24010 0 1 {name=p97585 lab=_47418_/A }
C {sky130_stdcells/buf_2.sym} 98300 -24010 0 0 {name=X_47389_ }
C {devices/lab_pin.sym} 98240 -23920 0 0 {name=p97586 lab=_61406_/A }
C {devices/lab_pin.sym} 98240 -23880 0 0 {name=p97587 lab=_61404_/X }
C {devices/lab_pin.sym} 98240 -23840 0 0 {name=p97588 lab=_61406_/C }
C {devices/lab_pin.sym} 98240 -23800 0 0 {name=p97589 lab=_61390_/D }
C {devices/lab_pin.sym} 98360 -23860 0 1 {name=p97590 lab=_61406_/Y }
C {sky130_stdcells/nand4_4.sym} 98300 -23860 0 0 {name=X_61406_ }
C {devices/lab_pin.sym} 98260 -23710 0 0 {name=p97591 lab=_48946_/A }
C {devices/lab_pin.sym} 98340 -23710 0 1 {name=p97592 lab=_49128_/X }
C {sky130_stdcells/buf_2.sym} 98300 -23710 0 0 {name=X_49128_ }
C {devices/lab_pin.sym} 98240 -23600 0 0 {name=p97593 lab=_84952_/Q }
C {devices/lab_pin.sym} 98240 -23560 0 0 {name=p97594 lab=_65449_/C }
C {devices/lab_pin.sym} 98360 -23580 0 1 {name=p97595 lab=_80242_/A }
C {sky130_stdcells/xor2_4.sym} 98300 -23580 0 0 {name=X_80240_ }
C {devices/lab_pin.sym} 98220 -23480 0 0 {name=p97596 lab=_65172_/X }
C {devices/lab_pin.sym} 98220 -23440 0 0 {name=p97597 lab=_86123_/Q }
C {devices/lab_pin.sym} 98220 -23400 0 0 {name=p97598 lab=_65127_/X }
C {devices/lab_pin.sym} 98220 -23360 0 0 {name=p97599 lab=_65173_/X }
C {devices/lab_pin.sym} 98380 -23420 0 1 {name=p97600 lab=_65174_/X }
C {sky130_stdcells/a211o_4.sym} 98300 -23420 0 0 {name=X_65174_ }
C {devices/lab_pin.sym} 98240 -23300 0 0 {name=p97601 lab=_61483_/A }
C {devices/lab_pin.sym} 98240 -23260 0 0 {name=p97602 lab=_62332_/B }
C {devices/lab_pin.sym} 98240 -23220 0 0 {name=p97603 lab=_62386_/C }
C {devices/lab_pin.sym} 98240 -23180 0 0 {name=p97604 lab=_62332_/D }
C {devices/lab_pin.sym} 98360 -23240 0 1 {name=p97605 lab=_62389_/B }
C {sky130_stdcells/nand4_4.sym} 98300 -23240 0 0 {name=X_62386_ }
C {devices/lab_pin.sym} 98240 -23120 0 0 {name=p97606 lab=_62113_/X }
C {devices/lab_pin.sym} 98240 -23080 0 0 {name=p97607 lab=_64095_/B }
C {devices/lab_pin.sym} 98240 -23040 0 0 {name=p97608 lab=_64095_/C }
C {devices/lab_pin.sym} 98240 -23000 0 0 {name=p97609 lab=_64095_/D }
C {devices/lab_pin.sym} 98360 -23060 0 1 {name=p97610 lab=_64125_/Y }
C {sky130_stdcells/nand4_4.sym} 98300 -23060 0 0 {name=X_64125_ }
C {devices/lab_pin.sym} 98220 -22930 0 0 {name=p97611 lab=_48881_/X }
C {devices/lab_pin.sym} 98220 -22890 0 0 {name=p97612 lab=_81776_/Q }
C {devices/lab_pin.sym} 98220 -22850 0 0 {name=p97613 lab=_49058_/Y }
C {devices/lab_pin.sym} 98380 -22890 0 1 {name=p97614 lab=_49060_/A }
C {sky130_stdcells/o21ai_4.sym} 98300 -22890 0 0 {name=X_49059_ }
C {devices/lab_pin.sym} 98260 -22750 0 0 {name=p97615 lab=_72550_/C }
C {devices/lab_pin.sym} 98340 -22750 0 1 {name=p97616 lab=_61367_/D }
C {sky130_stdcells/buf_2.sym} 98300 -22750 0 0 {name=X_61337_ }
C {devices/lab_pin.sym} 98240 -22640 0 0 {name=p97617 lab=_80178_/B }
C {devices/lab_pin.sym} 98240 -22600 0 0 {name=p97618 lab=_80171_/B }
C {devices/lab_pin.sym} 98360 -22620 0 1 {name=p97619 lab=_80171_/X }
C {sky130_stdcells/xor2_4.sym} 98300 -22620 0 0 {name=X_80171_ }
C {devices/lab_pin.sym} 98220 -22520 0 0 {name=p97620 lab=_69588_/Y }
C {devices/lab_pin.sym} 98220 -22480 0 0 {name=p97621 lab=_69916_/X }
C {devices/lab_pin.sym} 98220 -22440 0 0 {name=p97622 lab=_69938_/X }
C {devices/lab_pin.sym} 98220 -22400 0 0 {name=p97623 lab=_69981_/Y }
C {devices/lab_pin.sym} 98380 -22460 0 1 {name=p97624 lab=_69982_/X }
C {sky130_stdcells/a211o_4.sym} 98300 -22460 0 0 {name=X_69982_ }
C {devices/lab_pin.sym} 98260 -22310 0 0 {name=p97625 lab=clkbuf_6_36_0_CLK/X }
C {devices/lab_pin.sym} 98340 -22310 0 1 {name=p97626 lab=clkbuf_7_72_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 98300 -22310 0 0 {name=Xclkbuf_7_72_0_CLK }
C {devices/lab_pin.sym} 98240 -22200 0 0 {name=p97627 lab=_52070_/A }
C {devices/lab_pin.sym} 98240 -22160 0 0 {name=p97628 lab=_50370_/B }
C {devices/lab_pin.sym} 98360 -22180 0 1 {name=p97629 lab=_52070_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -22180 0 0 {name=X_52070_ }
C {devices/lab_pin.sym} 98220 -22070 0 0 {name=p97630 lab=_64054_/X }
C {devices/lab_pin.sym} 98220 -22030 0 0 {name=p97631 lab=_63994_/X }
C {devices/lab_pin.sym} 98220 -21990 0 0 {name=p97632 lab=_64055_/Y }
C {devices/lab_pin.sym} 98380 -22030 0 1 {name=p97633 lab=_64056_/Y }
C {sky130_stdcells/a21oi_4.sym} 98300 -22030 0 0 {name=X_64056_ }
C {devices/lab_pin.sym} 98260 -21890 0 0 {name=p97634 lab=_69567_/A }
C {devices/lab_pin.sym} 98340 -21890 0 1 {name=p97635 lab=_68933_/X }
C {sky130_stdcells/buf_2.sym} 98300 -21890 0 0 {name=X_68933_ }
C {devices/lab_pin.sym} 98240 -21790 0 0 {name=p97636 lab=_61262_/A }
C {devices/lab_pin.sym} 98240 -21750 0 0 {name=p97637 lab=_72544_/B }
C {devices/lab_pin.sym} 98240 -21710 0 0 {name=p97638 lab=_84493_/Q }
C {devices/lab_pin.sym} 98360 -21750 0 1 {name=p97639 lab=_61268_/Y }
C {sky130_stdcells/nor3_4.sym} 98300 -21750 0 0 {name=X_61268_ }
C {devices/lab_pin.sym} 98260 -21610 0 0 {name=p97640 lab=_51021_/A }
C {devices/lab_pin.sym} 98340 -21610 0 1 {name=p97641 lab=_51022_/A }
C {sky130_stdcells/buf_2.sym} 98300 -21610 0 0 {name=X_51021_ }
C {devices/lab_pin.sym} 98220 -21510 0 0 {name=p97642 lab=_63005_/Y }
C {devices/lab_pin.sym} 98220 -21470 0 0 {name=p97643 lab=_62987_/X }
C {devices/lab_pin.sym} 98220 -21430 0 0 {name=p97644 lab=_63006_/Y }
C {devices/lab_pin.sym} 98380 -21470 0 1 {name=p97645 lab=_84361_/D }
C {sky130_stdcells/a21oi_4.sym} 98300 -21470 0 0 {name=X_63007_ }
C {devices/lab_pin.sym} 98260 -21330 0 0 {name=p97646 lab=_60288_/C }
C {devices/lab_pin.sym} 98340 -21330 0 1 {name=p97647 lab=_60220_/A }
C {sky130_stdcells/buf_2.sym} 98300 -21330 0 0 {name=X_60219_ }
C {devices/lab_pin.sym} 98210 -21210 0 0 {name=p97648 lab=_83932_/CLK }
C {devices/lab_pin.sym} 98210 -21190 0 0 {name=p97649 lab=_69353_/X }
C {devices/lab_pin.sym} 98390 -21210 0 1 {name=p97650 lab=_83930_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -21200 0 0 {name=X_83930_ }
C {devices/lab_pin.sym} 98260 -21070 0 0 {name=p97651 lab=_68394_/A }
C {devices/lab_pin.sym} 98340 -21070 0 1 {name=p97652 lab=_68864_/X }
C {sky130_stdcells/buf_2.sym} 98300 -21070 0 0 {name=X_68864_ }
C {devices/lab_pin.sym} 98260 -20950 0 0 {name=p97653 lab=_72296_/A }
C {devices/lab_pin.sym} 98340 -20950 0 1 {name=p97654 lab=_66518_/B }
C {sky130_stdcells/buf_2.sym} 98300 -20950 0 0 {name=X_61199_ }
C {devices/lab_pin.sym} 98240 -20840 0 0 {name=p97655 lab=_67812_/X }
C {devices/lab_pin.sym} 98240 -20800 0 0 {name=p97656 lab=_67814_/X }
C {devices/lab_pin.sym} 98360 -20820 0 1 {name=p97657 lab=_67815_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -20820 0 0 {name=X_67815_ }
C {devices/lab_pin.sym} 98210 -20690 0 0 {name=p97658 lab=_82541_/CLK }
C {devices/lab_pin.sym} 98210 -20670 0 0 {name=p97659 lab=_70059_/X }
C {devices/lab_pin.sym} 98390 -20690 0 1 {name=p97660 lab=_82541_/D }
C {sky130_stdcells/dfxtp_4.sym} 98300 -20680 0 0 {name=X_83861_ }
C {devices/lab_pin.sym} 98260 -20550 0 0 {name=p97661 lab=clkbuf_7_87_0_CLK/A }
C {devices/lab_pin.sym} 98340 -20550 0 1 {name=p97662 lab=clkbuf_7_87_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 98300 -20550 0 0 {name=Xclkbuf_7_87_0_CLK }
C {devices/lab_pin.sym} 98220 -20450 0 0 {name=p97663 lab=_68791_/X }
C {devices/lab_pin.sym} 98220 -20410 0 0 {name=p97664 lab=_68794_/X }
C {devices/lab_pin.sym} 98220 -20370 0 0 {name=p97665 lab=_68773_/X }
C {devices/lab_pin.sym} 98380 -20410 0 1 {name=p97666 lab=_68795_/X }
C {sky130_stdcells/a21o_4.sym} 98300 -20410 0 0 {name=X_68795_ }
C {devices/lab_pin.sym} 98210 -20270 0 0 {name=p97667 lab=_85601_/CLK }
C {devices/lab_pin.sym} 98210 -20250 0 0 {name=p97668 lab=_53625_/Y }
C {devices/lab_pin.sym} 98390 -20270 0 1 {name=p97669 lab=_85600_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -20260 0 0 {name=X_85600_ }
C {devices/lab_pin.sym} 98210 -20130 0 0 {name=p97670 lab=_84115_/CLK }
C {devices/lab_pin.sym} 98210 -20110 0 0 {name=p97671 lab=_82844_/Q }
C {devices/lab_pin.sym} 98390 -20130 0 1 {name=p97672 lab=_78689_/A }
C {sky130_stdcells/dfxtp_4.sym} 98300 -20120 0 0 {name=X_82812_ }
C {devices/lab_pin.sym} 98240 -20000 0 0 {name=p97673 lab=_55757_/X }
C {devices/lab_pin.sym} 98240 -19960 0 0 {name=p97674 lab=_55759_/X }
C {devices/lab_pin.sym} 98360 -19980 0 1 {name=p97675 lab=_55760_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -19980 0 0 {name=X_55760_ }
C {devices/lab_pin.sym} 98210 -19850 0 0 {name=p97676 lab=_86578_/CLK }
C {devices/lab_pin.sym} 98210 -19830 0 0 {name=p97677 lab=_47976_/Y }
C {devices/lab_pin.sym} 98390 -19850 0 1 {name=p97678 lab=_66097_/B }
C {sky130_stdcells/dfxtp_4.sym} 98300 -19840 0 0 {name=X_86580_ }
C {devices/lab_pin.sym} 98240 -19720 0 0 {name=p97679 lab=_67743_/X }
C {devices/lab_pin.sym} 98240 -19680 0 0 {name=p97680 lab=_67745_/X }
C {devices/lab_pin.sym} 98360 -19700 0 1 {name=p97681 lab=_67746_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -19700 0 0 {name=X_67746_ }
C {devices/lab_pin.sym} 98220 -19590 0 0 {name=p97682 lab=_52970_/Y }
C {devices/lab_pin.sym} 98220 -19550 0 0 {name=p97683 lab=_52946_/X }
C {devices/lab_pin.sym} 98220 -19510 0 0 {name=p97684 lab=_52971_/X }
C {devices/lab_pin.sym} 98380 -19550 0 1 {name=p97685 lab=_52972_/Y }
C {sky130_stdcells/a21oi_4.sym} 98300 -19550 0 0 {name=X_52972_ }
C {devices/lab_pin.sym} 98220 -19440 0 0 {name=p97686 lab=_64858_/X }
C {devices/lab_pin.sym} 98220 -19400 0 0 {name=p97687 lab=_85524_/Q }
C {devices/lab_pin.sym} 98220 -19360 0 0 {name=p97688 lab=_64859_/X }
C {devices/lab_pin.sym} 98220 -19320 0 0 {name=p97689 lab=_64957_/X }
C {devices/lab_pin.sym} 98380 -19380 0 1 {name=p97690 lab=_64958_/X }
C {sky130_stdcells/a211o_4.sym} 98300 -19380 0 0 {name=X_64958_ }
C {devices/lab_pin.sym} 98210 -19230 0 0 {name=p97691 lab=_81631_/CLK }
C {devices/lab_pin.sym} 98210 -19210 0 0 {name=p97692 lab=_83792_/D }
C {devices/lab_pin.sym} 98390 -19230 0 1 {name=p97693 lab=_74795_/A }
C {sky130_stdcells/dfxtp_4.sym} 98300 -19220 0 0 {name=X_83792_ }
C {devices/lab_pin.sym} 98260 -19090 0 0 {name=p97694 lab=_54656_/X }
C {devices/lab_pin.sym} 98340 -19090 0 1 {name=p97695 lab=_54734_/B }
C {sky130_stdcells/buf_2.sym} 98300 -19090 0 0 {name=X_54711_ }
C {devices/lab_pin.sym} 98210 -18970 0 0 {name=p97696 lab=_85822_/CLK }
C {devices/lab_pin.sym} 98210 -18950 0 0 {name=p97697 lab=_85531_/D }
C {devices/lab_pin.sym} 98390 -18970 0 1 {name=p97698 lab=_85531_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -18960 0 0 {name=X_85531_ }
C {devices/lab_pin.sym} 98240 -18850 0 0 {name=p97699 lab=_52021_/A }
C {devices/lab_pin.sym} 98240 -18810 0 0 {name=p97700 lab=_47830_/Y }
C {devices/lab_pin.sym} 98240 -18770 0 0 {name=p97701 lab=_51922_/X }
C {devices/lab_pin.sym} 98360 -18810 0 1 {name=p97702 lab=_51923_/Y }
C {sky130_stdcells/nand3_4.sym} 98300 -18810 0 0 {name=X_51923_ }
C {devices/lab_pin.sym} 98260 -18670 0 0 {name=p97703 lab=_64184_/A }
C {devices/lab_pin.sym} 98340 -18670 0 1 {name=p97704 lab=_63942_/A }
C {sky130_stdcells/buf_2.sym} 98300 -18670 0 0 {name=X_63909_ }
C {devices/lab_pin.sym} 98210 -18550 0 0 {name=p97705 lab=_82743_/CLK }
C {devices/lab_pin.sym} 98210 -18530 0 0 {name=p97706 lab=_66420_/C }
C {devices/lab_pin.sym} 98390 -18550 0 1 {name=p97707 lab=_79001_/A }
C {sky130_stdcells/dfxtp_4.sym} 98300 -18540 0 0 {name=X_82743_ }
C {devices/lab_pin.sym} 98260 -18410 0 0 {name=p97708 lab=_55691_/A }
C {devices/lab_pin.sym} 98340 -18410 0 1 {name=p97709 lab=_55698_/A }
C {sky130_stdcells/buf_2.sym} 98300 -18410 0 0 {name=X_55691_ }
C {devices/lab_pin.sym} 98260 -18290 0 0 {name=p97710 lab=_44020_/A }
C {devices/lab_pin.sym} 98340 -18290 0 1 {name=p97711 lab=_68451_/A }
C {sky130_stdcells/buf_2.sym} 98300 -18290 0 0 {name=X_67677_ }
C {devices/lab_pin.sym} 98240 -18180 0 0 {name=p97712 lab=_64880_/Y }
C {devices/lab_pin.sym} 98240 -18140 0 0 {name=p97713 lab=_64888_/Y }
C {devices/lab_pin.sym} 98360 -18160 0 1 {name=p97714 lab=_64889_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -18160 0 0 {name=X_64889_ }
C {devices/lab_pin.sym} 98260 -18030 0 0 {name=p97715 lab=clkbuf_6_5_0_CLK/X }
C {devices/lab_pin.sym} 98340 -18030 0 1 {name=p97716 lab=clkbuf_8_21_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 98300 -18030 0 0 {name=Xclkbuf_7_10_0_CLK }
C {devices/lab_pin.sym} 98240 -17920 0 0 {name=p97717 lab=_57430_/A }
C {devices/lab_pin.sym} 98240 -17880 0 0 {name=p97718 lab=_57413_/X }
C {devices/lab_pin.sym} 98360 -17900 0 1 {name=p97719 lab=_57430_/X }
C {sky130_stdcells/or2_4.sym} 98300 -17900 0 0 {name=X_57430_ }
C {devices/lab_pin.sym} 98220 -17800 0 0 {name=p97720 lab=_87019_/Q }
C {devices/lab_pin.sym} 98220 -17760 0 0 {name=p97721 lab=_69414_/X }
C {devices/lab_pin.sym} 98220 -17720 0 0 {name=p97722 lab=_69168_/X }
C {devices/lab_pin.sym} 98220 -17680 0 0 {name=p97723 lab=_69415_/X }
C {devices/lab_pin.sym} 98380 -17740 0 1 {name=p97724 lab=_69416_/X }
C {sky130_stdcells/a211o_4.sym} 98300 -17740 0 0 {name=X_69416_ }
C {devices/lab_pin.sym} 98210 -17590 0 0 {name=p97725 lab=_88247_/CLK }
C {devices/lab_pin.sym} 98210 -17570 0 0 {name=p97726 lab=_88250_/D }
C {devices/lab_pin.sym} 98390 -17590 0 1 {name=p97727 lab=_68984_/B }
C {sky130_stdcells/dfxtp_4.sym} 98300 -17580 0 0 {name=X_88250_ }
C {devices/lab_pin.sym} 98220 -17470 0 0 {name=p97728 lab=_85404_/Q }
C {devices/lab_pin.sym} 98220 -17430 0 0 {name=p97729 lab=_54621_/X }
C {devices/lab_pin.sym} 98220 -17390 0 0 {name=p97730 lab=_54641_/Y }
C {devices/lab_pin.sym} 98380 -17430 0 1 {name=p97731 lab=_54642_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -17430 0 0 {name=X_54642_ }
C {devices/lab_pin.sym} 98260 -17290 0 0 {name=p97732 lab=_66572_/X }
C {devices/lab_pin.sym} 98340 -17290 0 1 {name=p97733 lab=_66628_/X }
C {sky130_stdcells/buf_2.sym} 98300 -17290 0 0 {name=X_66628_ }
C {devices/lab_pin.sym} 98210 -17170 0 0 {name=p97734 lab=_82769_/CLK }
C {devices/lab_pin.sym} 98210 -17150 0 0 {name=p97735 lab=_85462_/D }
C {devices/lab_pin.sym} 98390 -17170 0 1 {name=p97736 lab=_85462_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -17160 0 0 {name=X_85462_ }
C {devices/lab_pin.sym} 98260 -17030 0 0 {name=p97737 lab=clkbuf_7_75_0_CLK/X }
C {devices/lab_pin.sym} 98340 -17030 0 1 {name=p97738 lab=clkbuf_8_150_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 98300 -17030 0 0 {name=Xclkbuf_8_150_0_CLK }
C {devices/lab_pin.sym} 98220 -16930 0 0 {name=p97739 lab=_85934_/Q }
C {devices/lab_pin.sym} 98220 -16890 0 0 {name=p97740 lab=_51846_/X }
C {devices/lab_pin.sym} 98220 -16850 0 0 {name=p97741 lab=_51853_/Y }
C {devices/lab_pin.sym} 98380 -16890 0 1 {name=p97742 lab=_51854_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -16890 0 0 {name=X_51854_ }
C {devices/lab_pin.sym} 98210 -16750 0 0 {name=p97743 lab=_81190_/CLK }
C {devices/lab_pin.sym} 98210 -16730 0 0 {name=p97744 lab=_82674_/D }
C {devices/lab_pin.sym} 98390 -16750 0 1 {name=p97745 lab=_78197_/A }
C {sky130_stdcells/dfxtp_4.sym} 98300 -16740 0 0 {name=X_82674_ }
C {devices/lab_pin.sym} 98210 -16610 0 0 {name=p97746 lab=_87720_/CLK }
C {devices/lab_pin.sym} 98210 -16590 0 0 {name=p97747 lab=_43915_/Y }
C {devices/lab_pin.sym} 98390 -16610 0 1 {name=p97748 lab=_87201_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -16600 0 0 {name=X_87201_ }
C {devices/lab_pin.sym} 98210 -16470 0 0 {name=p97749 lab=_84421_/CLK }
C {devices/lab_pin.sym} 98210 -16450 0 0 {name=p97750 lab=_84413_/D }
C {devices/lab_pin.sym} 98390 -16470 0 1 {name=p97751 lab=_62397_/C }
C {sky130_stdcells/dfxtp_4.sym} 98300 -16460 0 0 {name=X_84413_ }
C {devices/lab_pin.sym} 98260 -16330 0 0 {name=p97752 lab=_50505_/A }
C {devices/lab_pin.sym} 98340 -16330 0 1 {name=p97753 lab=_50806_/A }
C {sky130_stdcells/buf_2.sym} 98300 -16330 0 0 {name=X_50805_ }
C {devices/lab_pin.sym} 98240 -16220 0 0 {name=p97754 lab=_44231_/A }
C {devices/lab_pin.sym} 98240 -16180 0 0 {name=p97755 lab=_85028_/Q }
C {devices/lab_pin.sym} 98360 -16200 0 1 {name=p97756 lab=_57361_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -16200 0 0 {name=X_57361_ }
C {devices/lab_pin.sym} 98210 -16070 0 0 {name=p97757 lab=_81689_/CLK }
C {devices/lab_pin.sym} 98210 -16050 0 0 {name=p97758 lab=_76499_/X }
C {devices/lab_pin.sym} 98390 -16070 0 1 {name=p97759 lab=_81625_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -16060 0 0 {name=X_81625_ }
C {devices/lab_pin.sym} 98220 -15950 0 0 {name=p97760 lab=_69342_/X }
C {devices/lab_pin.sym} 98220 -15910 0 0 {name=p97761 lab=_69345_/X }
C {devices/lab_pin.sym} 98220 -15870 0 0 {name=p97762 lab=_69346_/X }
C {devices/lab_pin.sym} 98380 -15910 0 1 {name=p97763 lab=_69347_/X }
C {sky130_stdcells/a21o_4.sym} 98300 -15910 0 0 {name=X_69347_ }
C {devices/lab_pin.sym} 98210 -15770 0 0 {name=p97764 lab=_87926_/CLK }
C {devices/lab_pin.sym} 98210 -15750 0 0 {name=p97765 lab=_41623_/Y }
C {devices/lab_pin.sym} 98390 -15770 0 1 {name=p97766 lab=_88181_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -15760 0 0 {name=X_88181_ }
C {devices/lab_pin.sym} 98240 -15640 0 0 {name=p97767 lab=_54578_/A }
C {devices/lab_pin.sym} 98240 -15600 0 0 {name=p97768 lab=_53395_/B }
C {devices/lab_pin.sym} 98360 -15620 0 1 {name=p97769 lab=_54573_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -15620 0 0 {name=X_54573_ }
C {devices/lab_pin.sym} 98240 -15500 0 0 {name=p97770 lab=_66548_/X }
C {devices/lab_pin.sym} 98240 -15460 0 0 {name=p97771 lab=_66559_/B }
C {devices/lab_pin.sym} 98360 -15480 0 1 {name=p97772 lab=_66559_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -15480 0 0 {name=X_66559_ }
C {devices/lab_pin.sym} 98210 -15350 0 0 {name=p97773 lab=_85489_/CLK }
C {devices/lab_pin.sym} 98210 -15330 0 0 {name=p97774 lab=_54708_/Y }
C {devices/lab_pin.sym} 98390 -15350 0 1 {name=p97775 lab=_85393_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -15340 0 0 {name=X_85393_ }
C {devices/lab_pin.sym} 98220 -15230 0 0 {name=p97776 lab=_85946_/Q }
C {devices/lab_pin.sym} 98220 -15190 0 0 {name=p97777 lab=_51763_/X }
C {devices/lab_pin.sym} 98220 -15150 0 0 {name=p97778 lab=_51784_/Y }
C {devices/lab_pin.sym} 98380 -15190 0 1 {name=p97779 lab=_51785_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -15190 0 0 {name=X_51785_ }
C {devices/lab_pin.sym} 98220 -15070 0 0 {name=p97780 lab=_59097_/Y }
C {devices/lab_pin.sym} 98220 -15030 0 0 {name=p97781 lab=_59099_/Y }
C {devices/lab_pin.sym} 98220 -14990 0 0 {name=p97782 lab=_59053_/X }
C {devices/lab_pin.sym} 98380 -15030 0 1 {name=p97783 lab=_59100_/X }
C {sky130_stdcells/a21o_4.sym} 98300 -15030 0 0 {name=X_59100_ }
C {devices/lab_pin.sym} 98260 -14890 0 0 {name=p97784 lab=_56351_/A }
C {devices/lab_pin.sym} 98340 -14890 0 1 {name=p97785 lab=_56312_/X }
C {sky130_stdcells/buf_2.sym} 98300 -14890 0 0 {name=X_56312_ }
C {devices/lab_pin.sym} 98210 -14770 0 0 {name=p97786 lab=_88215_/CLK }
C {devices/lab_pin.sym} 98210 -14750 0 0 {name=p97787 lab=_87132_/D }
C {devices/lab_pin.sym} 98390 -14770 0 1 {name=p97788 lab=_87132_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -14760 0 0 {name=X_87132_ }
C {devices/lab_pin.sym} 98260 -14630 0 0 {name=p97789 lab=_53696_/A }
C {devices/lab_pin.sym} 98340 -14630 0 1 {name=p97790 lab=_53524_/X }
C {sky130_stdcells/buf_2.sym} 98300 -14630 0 0 {name=X_53524_ }
C {devices/lab_pin.sym} 98210 -14510 0 0 {name=p97791 lab=_84344_/CLK }
C {devices/lab_pin.sym} 98210 -14490 0 0 {name=p97792 lab=_63211_/X }
C {devices/lab_pin.sym} 98390 -14510 0 1 {name=p97793 lab=_79330_/A }
C {sky130_stdcells/dfxtp_4.sym} 98300 -14500 0 0 {name=X_84344_ }
C {devices/lab_pin.sym} 98240 -14380 0 0 {name=p97794 lab=_50740_/A }
C {devices/lab_pin.sym} 98240 -14340 0 0 {name=p97795 lab=_53949_/B }
C {devices/lab_pin.sym} 98360 -14360 0 1 {name=p97796 lab=_50736_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -14360 0 0 {name=X_50736_ }
C {devices/lab_pin.sym} 98220 -14250 0 0 {name=p97797 lab=_56727_/X }
C {devices/lab_pin.sym} 98220 -14210 0 0 {name=p97798 lab=_57290_/X }
C {devices/lab_pin.sym} 98220 -14170 0 0 {name=p97799 lab=_57291_/Y }
C {devices/lab_pin.sym} 98380 -14210 0 1 {name=p97800 lab=_57292_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -14210 0 0 {name=X_57292_ }
C {devices/lab_pin.sym} 98210 -14070 0 0 {name=p97801 lab=_84087_/CLK }
C {devices/lab_pin.sym} 98210 -14050 0 0 {name=p97802 lab=_76819_/X }
C {devices/lab_pin.sym} 98390 -14070 0 1 {name=p97803 lab=_81512_/D }
C {sky130_stdcells/dfxtp_4.sym} 98300 -14060 0 0 {name=X_81556_ }
C {devices/lab_pin.sym} 98260 -13930 0 0 {name=p97804 lab=_69183_/A }
C {devices/lab_pin.sym} 98340 -13930 0 1 {name=p97805 lab=_69278_/X }
C {sky130_stdcells/buf_2.sym} 98300 -13930 0 0 {name=X_69278_ }
C {devices/lab_pin.sym} 98260 -13810 0 0 {name=p97806 lab=clkbuf_6_12_0_CLK/X }
C {devices/lab_pin.sym} 98340 -13810 0 1 {name=p97807 lab=clkbuf_8_51_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 98300 -13810 0 0 {name=Xclkbuf_7_25_0_CLK }
C {devices/lab_pin.sym} 98260 -13690 0 0 {name=p97808 lab=_58923_/A }
C {devices/lab_pin.sym} 98340 -13690 0 1 {name=p97809 lab=_59031_/X }
C {sky130_stdcells/buf_2.sym} 98300 -13690 0 0 {name=X_59031_ }
C {devices/lab_pin.sym} 98260 -13570 0 0 {name=p97810 lab=clkbuf_7_82_0_CLK/X }
C {devices/lab_pin.sym} 98340 -13570 0 1 {name=p97811 lab=clkbuf_9_331_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 98300 -13570 0 0 {name=Xclkbuf_8_165_0_CLK }
C {devices/lab_pin.sym} 98240 -13470 0 0 {name=p97812 lab=_56250_/A }
C {devices/lab_pin.sym} 98240 -13430 0 0 {name=p97813 lab=_56243_/B }
C {devices/lab_pin.sym} 98240 -13390 0 0 {name=p97814 lab=_56243_/C }
C {devices/lab_pin.sym} 98360 -13430 0 1 {name=p97815 lab=_56243_/Y }
C {sky130_stdcells/nand3_4.sym} 98300 -13430 0 0 {name=X_56243_ }
C {devices/lab_pin.sym} 98240 -13300 0 0 {name=p97816 lab=_80505_/X }
C {devices/lab_pin.sym} 98240 -13260 0 0 {name=p97817 lab=_80506_/X }
C {devices/lab_pin.sym} 98360 -13280 0 1 {name=p97818 lab=_80520_/B }
C {sky130_stdcells/xnor2_4.sym} 98300 -13280 0 0 {name=X_80507_ }
C {devices/lab_pin.sym} 98220 -13170 0 0 {name=p97819 lab=_67419_/X }
C {devices/lab_pin.sym} 98220 -13130 0 0 {name=p97820 lab=_67422_/X }
C {devices/lab_pin.sym} 98220 -13090 0 0 {name=p97821 lab=_68216_/X }
C {devices/lab_pin.sym} 98380 -13130 0 1 {name=p97822 lab=_68229_/Y }
C {sky130_stdcells/a21oi_4.sym} 98300 -13130 0 0 {name=X_68229_ }
C {devices/lab_pin.sym} 98210 -12990 0 0 {name=p97823 lab=_87063_/CLK }
C {devices/lab_pin.sym} 98210 -12970 0 0 {name=p97824 lab=_44538_/Y }
C {devices/lab_pin.sym} 98390 -12990 0 1 {name=p97825 lab=_72973_/A }
C {sky130_stdcells/dfxtp_4.sym} 98300 -12980 0 0 {name=X_87063_ }
C {devices/lab_pin.sym} 98260 -12850 0 0 {name=p97826 lab=_53455_/A }
C {devices/lab_pin.sym} 98340 -12850 0 1 {name=p97827 lab=_53455_/X }
C {sky130_stdcells/buf_2.sym} 98300 -12850 0 0 {name=X_53455_ }
C {devices/lab_pin.sym} 98260 -12730 0 0 {name=p97828 lab=clkbuf_9_80_0_CLK/X }
C {devices/lab_pin.sym} 98340 -12730 0 1 {name=p97829 lab=_81801_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 98300 -12730 0 0 {name=Xclkbuf_10_160_0_CLK }
C {devices/lab_pin.sym} 98210 -12610 0 0 {name=p97830 lab=_84273_/CLK }
C {devices/lab_pin.sym} 98210 -12590 0 0 {name=p97831 lab=_64101_/Y }
C {devices/lab_pin.sym} 98390 -12610 0 1 {name=p97832 lab=_64100_/C }
C {sky130_stdcells/dfxtp_4.sym} 98300 -12600 0 0 {name=X_84275_ }
C {devices/lab_pin.sym} 98220 -12490 0 0 {name=p97833 lab=_86157_/Q }
C {devices/lab_pin.sym} 98220 -12450 0 0 {name=p97834 lab=_50654_/X }
C {devices/lab_pin.sym} 98220 -12410 0 0 {name=p97835 lab=_50666_/Y }
C {devices/lab_pin.sym} 98380 -12450 0 1 {name=p97836 lab=_50667_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -12450 0 0 {name=X_50667_ }
C {devices/lab_pin.sym} 98210 -12310 0 0 {name=p97837 lab=_81333_/CLK }
C {devices/lab_pin.sym} 98210 -12290 0 0 {name=p97838 lab=_84055_/Q }
C {devices/lab_pin.sym} 98390 -12310 0 1 {name=p97839 lab=_81487_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -12300 0 0 {name=X_81487_ }
C {devices/lab_pin.sym} 98210 -12170 0 0 {name=p97840 lab=_85727_/CLK }
C {devices/lab_pin.sym} 98210 -12150 0 0 {name=p97841 lab=_86014_/D }
C {devices/lab_pin.sym} 98390 -12170 0 1 {name=p97842 lab=_86014_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -12160 0 0 {name=X_86014_ }
C {devices/lab_pin.sym} 98260 -12030 0 0 {name=p97843 lab=clkbuf_9_395_0_CLK/X }
C {devices/lab_pin.sym} 98340 -12030 0 1 {name=p97844 lab=_82147_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 98300 -12030 0 0 {name=Xclkbuf_10_790_0_CLK }
C {devices/lab_pin.sym} 98260 -11910 0 0 {name=p97845 lab=_40420_/A }
C {devices/lab_pin.sym} 98340 -11910 0 1 {name=p97846 lab=_47867_/A }
C {sky130_stdcells/buf_2.sym} 98300 -11910 0 0 {name=X_40420_ }
C {devices/lab_pin.sym} 98220 -11810 0 0 {name=p97847 lab=_65324_/B }
C {devices/lab_pin.sym} 98220 -11770 0 0 {name=p97848 lab=_52397_/X }
C {devices/lab_pin.sym} 98220 -11730 0 0 {name=p97849 lab=_52405_/Y }
C {devices/lab_pin.sym} 98380 -11770 0 1 {name=p97850 lab=_52406_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -11770 0 0 {name=X_52406_ }
C {devices/lab_pin.sym} 98260 -11630 0 0 {name=p97851 lab=_71238_/B }
C {devices/lab_pin.sym} 98340 -11630 0 1 {name=p97852 lab=_71241_/A }
C {sky130_stdcells/inv_2.sym} 98300 -11630 0 0 {name=X_71240_ }
C {devices/lab_pin.sym} 98210 -11510 0 0 {name=p97853 lab=_83227_/CLK }
C {devices/lab_pin.sym} 98210 -11490 0 0 {name=p97854 lab=_83226_/D }
C {devices/lab_pin.sym} 98390 -11510 0 1 {name=p97855 lab=_79352_/B }
C {sky130_stdcells/dfxtp_4.sym} 98300 -11500 0 0 {name=X_83226_ }
C {devices/lab_pin.sym} 98260 -11370 0 0 {name=p97856 lab=_56173_/Y }
C {devices/lab_pin.sym} 98340 -11370 0 1 {name=p97857 lab=_56174_/X }
C {sky130_stdcells/buf_2.sym} 98300 -11370 0 0 {name=X_56174_ }
C {devices/lab_pin.sym} 98240 -11260 0 0 {name=p97858 lab=_80435_/X }
C {devices/lab_pin.sym} 98240 -11220 0 0 {name=p97859 lab=_80437_/Y }
C {devices/lab_pin.sym} 98360 -11240 0 1 {name=p97860 lab=_80438_/Y }
C {sky130_stdcells/xnor2_4.sym} 98300 -11240 0 0 {name=X_80438_ }
C {devices/lab_pin.sym} 98240 -11120 0 0 {name=p97861 lab=_53386_/A }
C {devices/lab_pin.sym} 98240 -11080 0 0 {name=p97862 lab=_53386_/B }
C {devices/lab_pin.sym} 98360 -11100 0 1 {name=p97863 lab=_53386_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -11100 0 0 {name=X_53386_ }
C {devices/lab_pin.sym} 98220 -10990 0 0 {name=p97864 lab=_86170_/Q }
C {devices/lab_pin.sym} 98220 -10950 0 0 {name=p97865 lab=_50594_/X }
C {devices/lab_pin.sym} 98220 -10910 0 0 {name=p97866 lab=_50597_/Y }
C {devices/lab_pin.sym} 98380 -10950 0 1 {name=p97867 lab=_50598_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -10950 0 0 {name=X_50598_ }
C {devices/lab_pin.sym} 98260 -10810 0 0 {name=p97868 lab=_55125_/A }
C {devices/lab_pin.sym} 98340 -10810 0 1 {name=p97869 lab=_55126_/A }
C {sky130_stdcells/buf_2.sym} 98300 -10810 0 0 {name=X_55125_ }
C {devices/lab_pin.sym} 98260 -10690 0 0 {name=p97870 lab=clkbuf_9_281_0_CLK/A }
C {devices/lab_pin.sym} 98340 -10690 0 1 {name=p97871 lab=clkbuf_9_281_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 98300 -10690 0 0 {name=Xclkbuf_9_281_0_CLK }
C {devices/lab_pin.sym} 98240 -10590 0 0 {name=p97872 lab=_42447_/C }
C {devices/lab_pin.sym} 98240 -10550 0 0 {name=p97873 lab=_42447_/A }
C {devices/lab_pin.sym} 98240 -10510 0 0 {name=p97874 lab=_41869_/C }
C {devices/lab_pin.sym} 98360 -10550 0 1 {name=p97875 lab=_40351_/Y }
C {sky130_stdcells/nor3_4.sym} 98300 -10550 0 0 {name=X_40351_ }
C {devices/lab_pin.sym} 98220 -10430 0 0 {name=p97876 lab=_52335_/Y }
C {devices/lab_pin.sym} 98220 -10390 0 0 {name=p97877 lab=_52314_/X }
C {devices/lab_pin.sym} 98220 -10350 0 0 {name=p97878 lab=_52336_/X }
C {devices/lab_pin.sym} 98380 -10390 0 1 {name=p97879 lab=_52337_/Y }
C {sky130_stdcells/a21oi_4.sym} 98300 -10390 0 0 {name=X_52337_ }
C {devices/lab_pin.sym} 98240 -10280 0 0 {name=p97880 lab=_71171_/A }
C {devices/lab_pin.sym} 98240 -10240 0 0 {name=p97881 lab=_71173_/B }
C {devices/lab_pin.sym} 98240 -10200 0 0 {name=p97882 lab=_71181_/C }
C {devices/lab_pin.sym} 98240 -10160 0 0 {name=p97883 lab=_71178_/D }
C {devices/lab_pin.sym} 98360 -10220 0 1 {name=p97884 lab=_71171_/Y }
C {sky130_stdcells/nand4_4.sym} 98300 -10220 0 0 {name=X_71171_ }
C {devices/lab_pin.sym} 98210 -10070 0 0 {name=p97885 lab=_85895_/CLK }
C {devices/lab_pin.sym} 98210 -10050 0 0 {name=p97886 lab=_73295_/X }
C {devices/lab_pin.sym} 98390 -10070 0 1 {name=p97887 lab=_83157_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -10060 0 0 {name=X_83157_ }
C {devices/lab_pin.sym} 98260 -9930 0 0 {name=p97888 lab=_80368_/Y }
C {devices/lab_pin.sym} 98340 -9930 0 1 {name=p97889 lab=_80383_/B }
C {sky130_stdcells/inv_2.sym} 98300 -9930 0 0 {name=X_80369_ }
C {devices/lab_pin.sym} 98260 -9810 0 0 {name=p97890 lab=_83142_/Q }
C {devices/lab_pin.sym} 98340 -9810 0 1 {name=p97891 lab=_70122_/Y }
C {sky130_stdcells/inv_2.sym} 98300 -9810 0 0 {name=X_70122_ }
C {devices/lab_pin.sym} 98260 -9690 0 0 {name=p97892 lab=clkbuf_9_87_0_CLK/X }
C {devices/lab_pin.sym} 98340 -9690 0 1 {name=p97893 lab=_80784_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 98300 -9690 0 0 {name=Xclkbuf_10_175_0_CLK }
C {devices/lab_pin.sym} 98210 -9570 0 0 {name=p97894 lab=_82015_/CLK }
C {devices/lab_pin.sym} 98210 -9550 0 0 {name=p97895 lab=_82108_/D }
C {devices/lab_pin.sym} 98390 -9570 0 1 {name=p97896 lab=_82108_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -9560 0 0 {name=X_82108_ }
C {devices/lab_pin.sym} 98260 -9430 0 0 {name=p97897 lab=_43070_/A }
C {devices/lab_pin.sym} 98340 -9430 0 1 {name=p97898 lab=_43070_/Y }
C {sky130_stdcells/inv_2.sym} 98300 -9430 0 0 {name=X_43070_ }
C {devices/lab_pin.sym} 98260 -9310 0 0 {name=p97899 lab=_47918_/A }
C {devices/lab_pin.sym} 98340 -9310 0 1 {name=p97900 lab=_55056_/X }
C {sky130_stdcells/buf_2.sym} 98300 -9310 0 0 {name=X_55056_ }
C {devices/lab_pin.sym} 98260 -9190 0 0 {name=p97901 lab=_59927_/A }
C {devices/lab_pin.sym} 98340 -9190 0 1 {name=p97902 lab=_59973_/A }
C {sky130_stdcells/buf_2.sym} 98300 -9190 0 0 {name=X_59933_ }
C {devices/lab_pin.sym} 98220 -9090 0 0 {name=p97903 lab=_52266_/Y }
C {devices/lab_pin.sym} 98220 -9050 0 0 {name=p97904 lab=_52262_/X }
C {devices/lab_pin.sym} 98220 -9010 0 0 {name=p97905 lab=_52267_/X }
C {devices/lab_pin.sym} 98380 -9050 0 1 {name=p97906 lab=_52268_/Y }
C {sky130_stdcells/a21oi_4.sym} 98300 -9050 0 0 {name=X_52268_ }
C {devices/lab_pin.sym} 98210 -8910 0 0 {name=p97907 lab=_87644_/CLK }
C {devices/lab_pin.sym} 98210 -8890 0 0 {name=p97908 lab=_87965_/D }
C {devices/lab_pin.sym} 98390 -8910 0 1 {name=p97909 lab=_87965_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -8900 0 0 {name=X_87965_ }
C {devices/lab_pin.sym} 98210 -8770 0 0 {name=p97910 lab=_83187_/CLK }
C {devices/lab_pin.sym} 98210 -8750 0 0 {name=p97911 lab=_74350_/X }
C {devices/lab_pin.sym} 98390 -8770 0 1 {name=p97912 lab=_83088_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -8760 0 0 {name=X_83088_ }
C {devices/lab_pin.sym} 98220 -8670 0 0 {name=p97913 lab=_41998_/X }
C {devices/lab_pin.sym} 98220 -8630 0 0 {name=p97914 lab=_42010_/X }
C {devices/lab_pin.sym} 98220 -8590 0 0 {name=p97915 lab=_40845_/X }
C {devices/lab_pin.sym} 98220 -8550 0 0 {name=p97916 lab=_42020_/Y }
C {devices/lab_pin.sym} 98220 -8510 0 0 {name=p97917 lab=_42000_/X }
C {devices/lab_pin.sym} 98380 -8590 0 1 {name=p97918 lab=_42021_/Y }
C {sky130_stdcells/o32ai_4.sym} 98300 -8590 0 0 {name=X_42021_ }
C {devices/lab_pin.sym} 98240 -8440 0 0 {name=p97919 lab=_53998_/A }
C {devices/lab_pin.sym} 98240 -8400 0 0 {name=p97920 lab=_46407_/X }
C {devices/lab_pin.sym} 98360 -8420 0 1 {name=p97921 lab=_54007_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -8420 0 0 {name=X_54007_ }
C {devices/lab_pin.sym} 98260 -8290 0 0 {name=p97922 lab=_51218_/X }
C {devices/lab_pin.sym} 98340 -8290 0 1 {name=p97923 lab=_51220_/A }
C {sky130_stdcells/buf_2.sym} 98300 -8290 0 0 {name=X_51219_ }
C {devices/lab_pin.sym} 98240 -8180 0 0 {name=p97924 lab=_74930_/A }
C {devices/lab_pin.sym} 98240 -8140 0 0 {name=p97925 lab=_74929_/X }
C {devices/lab_pin.sym} 98360 -8160 0 1 {name=p97926 lab=_74930_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -8160 0 0 {name=X_74930_ }
C {devices/lab_pin.sym} 98220 -8050 0 0 {name=p97927 lab=_69825_/X }
C {devices/lab_pin.sym} 98220 -8010 0 0 {name=p97928 lab=_69827_/X }
C {devices/lab_pin.sym} 98220 -7970 0 0 {name=p97929 lab=_69994_/X }
C {devices/lab_pin.sym} 98380 -8010 0 1 {name=p97930 lab=_70053_/X }
C {sky130_stdcells/a21o_4.sym} 98300 -8010 0 0 {name=X_70053_ }
C {devices/lab_pin.sym} 98210 -7870 0 0 {name=p97931 lab=_88215_/CLK }
C {devices/lab_pin.sym} 98210 -7850 0 0 {name=p97932 lab=_86916_/D }
C {devices/lab_pin.sym} 98390 -7870 0 1 {name=p97933 lab=_67988_/B }
C {sky130_stdcells/dfxtp_4.sym} 98300 -7860 0 0 {name=X_86916_ }
C {devices/lab_pin.sym} 98210 -7730 0 0 {name=p97934 lab=_82008_/CLK }
C {devices/lab_pin.sym} 98210 -7710 0 0 {name=p97935 lab=_82039_/D }
C {devices/lab_pin.sym} 98390 -7730 0 1 {name=p97936 lab=_82007_/D }
C {sky130_stdcells/dfxtp_4.sym} 98300 -7720 0 0 {name=X_82039_ }
C {devices/lab_pin.sym} 98240 -7610 0 0 {name=p97937 lab=_59873_/A }
C {devices/lab_pin.sym} 98240 -7570 0 0 {name=p97938 lab=_59855_/B }
C {devices/lab_pin.sym} 98240 -7530 0 0 {name=p97939 lab=_80308_/B }
C {devices/lab_pin.sym} 98360 -7570 0 1 {name=p97940 lab=_59864_/Y }
C {sky130_stdcells/nor3_4.sym} 98300 -7570 0 0 {name=X_59864_ }
C {devices/lab_pin.sym} 98240 -7450 0 0 {name=p97941 lab=_52199_/A }
C {devices/lab_pin.sym} 98240 -7410 0 0 {name=p97942 lab=_52198_/X }
C {devices/lab_pin.sym} 98240 -7370 0 0 {name=p97943 lab=_52218_/C }
C {devices/lab_pin.sym} 98360 -7410 0 1 {name=p97944 lab=_52199_/X }
C {sky130_stdcells/and3_4.sym} 98300 -7410 0 0 {name=X_52199_ }
C {devices/lab_pin.sym} 98210 -7270 0 0 {name=p97945 lab=_86914_/CLK }
C {devices/lab_pin.sym} 98210 -7250 0 0 {name=p97946 lab=_87896_/D }
C {devices/lab_pin.sym} 98390 -7270 0 1 {name=p97947 lab=_87896_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -7260 0 0 {name=X_87896_ }
C {devices/lab_pin.sym} 98260 -7130 0 0 {name=p97948 lab=clkbuf_9_296_0_CLK/A }
C {devices/lab_pin.sym} 98340 -7130 0 1 {name=p97949 lab=clkbuf_9_296_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 98300 -7130 0 0 {name=Xclkbuf_9_296_0_CLK }
C {devices/lab_pin.sym} 98220 -7030 0 0 {name=p97950 lab=_58787_/X }
C {devices/lab_pin.sym} 98220 -6990 0 0 {name=p97951 lab=_86094_/Q }
C {devices/lab_pin.sym} 98220 -6950 0 0 {name=p97952 lab=_58814_/X }
C {devices/lab_pin.sym} 98380 -6990 0 1 {name=p97953 lab=_58815_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -6990 0 0 {name=X_58815_ }
C {devices/lab_pin.sym} 98260 -6850 0 0 {name=p97954 lab=clkbuf_7_51_0_CLK/X }
C {devices/lab_pin.sym} 98340 -6850 0 1 {name=p97955 lab=clkbuf_9_206_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 98300 -6850 0 0 {name=Xclkbuf_8_103_0_CLK }
C {devices/lab_pin.sym} 98240 -6740 0 0 {name=p97956 lab=_74857_/Y }
C {devices/lab_pin.sym} 98240 -6700 0 0 {name=p97957 lab=_74860_/Y }
C {devices/lab_pin.sym} 98360 -6720 0 1 {name=p97958 lab=_74863_/B }
C {sky130_stdcells/xnor2_4.sym} 98300 -6720 0 0 {name=X_74861_ }
C {devices/lab_pin.sym} 98210 -6590 0 0 {name=p97959 lab=_81117_/CLK }
C {devices/lab_pin.sym} 98210 -6570 0 0 {name=p97960 lab=_86847_/D }
C {devices/lab_pin.sym} 98390 -6590 0 1 {name=p97961 lab=_41869_/A }
C {sky130_stdcells/dfxtp_4.sym} 98300 -6580 0 0 {name=X_86847_ }
C {devices/lab_pin.sym} 98240 -6470 0 0 {name=p97962 lab=_59737_/A }
C {devices/lab_pin.sym} 98240 -6430 0 0 {name=p97963 lab=_59848_/B }
C {devices/lab_pin.sym} 98240 -6390 0 0 {name=p97964 lab=_80475_/A }
C {devices/lab_pin.sym} 98360 -6430 0 1 {name=p97965 lab=_59795_/Y }
C {sky130_stdcells/nor3_4.sym} 98300 -6430 0 0 {name=X_59795_ }
C {devices/lab_pin.sym} 98260 -6290 0 0 {name=p97966 lab=_76599_/X }
C {devices/lab_pin.sym} 98340 -6290 0 1 {name=p97967 lab=_76602_/B }
C {sky130_stdcells/inv_2.sym} 98300 -6290 0 0 {name=X_76600_ }
C {devices/lab_pin.sym} 98240 -6180 0 0 {name=p97968 lab=_73812_/A }
C {devices/lab_pin.sym} 98240 -6140 0 0 {name=p97969 lab=_73812_/B }
C {devices/lab_pin.sym} 98360 -6160 0 1 {name=p97970 lab=_73813_/B }
C {sky130_stdcells/nand2_4.sym} 98300 -6160 0 0 {name=X_73812_ }
C {devices/lab_pin.sym} 98220 -6050 0 0 {name=p97971 lab=_86706_/Q }
C {devices/lab_pin.sym} 98220 -6010 0 0 {name=p97972 lab=_46719_/X }
C {devices/lab_pin.sym} 98220 -5970 0 0 {name=p97973 lab=_46759_/Y }
C {devices/lab_pin.sym} 98380 -6010 0 1 {name=p97974 lab=_46760_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -6010 0 0 {name=X_46760_ }
C {devices/lab_pin.sym} 98260 -5870 0 0 {name=p97975 lab=_44170_/A }
C {devices/lab_pin.sym} 98340 -5870 0 1 {name=p97976 lab=_64600_/A }
C {sky130_stdcells/buf_2.sym} 98300 -5870 0 0 {name=X_58746_ }
C {devices/lab_pin.sym} 98260 -5750 0 0 {name=p97977 lab=_77580_/A }
C {devices/lab_pin.sym} 98340 -5750 0 1 {name=p97978 lab=_77584_/A }
C {sky130_stdcells/inv_2.sym} 98300 -5750 0 0 {name=X_77580_ }
C {devices/lab_pin.sym} 98240 -5640 0 0 {name=p97979 lab=_80667_/Q }
C {devices/lab_pin.sym} 98240 -5600 0 0 {name=p97980 lab=_43972_/B }
C {devices/lab_pin.sym} 98360 -5620 0 1 {name=p97981 lab=_43972_/Y }
C {sky130_stdcells/nor2_4.sym} 98300 -5620 0 0 {name=X_43972_ }
C {devices/lab_pin.sym} 98240 -5500 0 0 {name=p97982 lab=_55695_/A }
C {devices/lab_pin.sym} 98240 -5460 0 0 {name=p97983 lab=_55958_/B }
C {devices/lab_pin.sym} 98360 -5480 0 1 {name=p97984 lab=_55958_/X }
C {sky130_stdcells/and2_4.sym} 98300 -5480 0 0 {name=X_55958_ }
C {devices/lab_pin.sym} 98220 -5390 0 0 {name=p97985 lab=_74734_/Y }
C {devices/lab_pin.sym} 98220 -5350 0 0 {name=p97986 lab=_83847_/Q }
C {devices/lab_pin.sym} 98220 -5310 0 0 {name=p97987 lab=_74789_/X }
C {devices/lab_pin.sym} 98220 -5270 0 0 {name=p97988 lab=_74790_/X }
C {devices/lab_pin.sym} 98220 -5230 0 0 {name=p97989 lab=_74791_/X }
C {devices/lab_pin.sym} 98380 -5310 0 1 {name=p97990 lab=_74792_/X }
C {sky130_stdcells/a2111o_4.sym} 98300 -5310 0 0 {name=X_74792_ }
C {devices/lab_pin.sym} 98210 -5150 0 0 {name=p97991 lab=_86814_/CLK }
C {devices/lab_pin.sym} 98210 -5130 0 0 {name=p97992 lab=_46078_/Y }
C {devices/lab_pin.sym} 98390 -5150 0 1 {name=p97993 lab=_86778_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -5140 0 0 {name=X_86778_ }
C {devices/lab_pin.sym} 98260 -5010 0 0 {name=p97994 lab=_82989_/Q }
C {devices/lab_pin.sym} 98340 -5010 0 1 {name=p97995 lab=_45713_/A }
C {sky130_stdcells/inv_2.sym} 98300 -5010 0 0 {name=X_45711_ }
C {devices/lab_pin.sym} 98260 -4890 0 0 {name=p97996 lab=_81660_/Q }
C {devices/lab_pin.sym} 98340 -4890 0 1 {name=p97997 lab=_76531_/Y }
C {sky130_stdcells/inv_2.sym} 98300 -4890 0 0 {name=X_76531_ }
C {devices/lab_pin.sym} 98220 -4800 0 0 {name=p97998 lab=_41715_/X }
C {devices/lab_pin.sym} 98220 -4760 0 0 {name=p97999 lab=_42920_/X }
C {devices/lab_pin.sym} 98220 -4720 0 0 {name=p98000 lab=_67714_/B }
C {devices/lab_pin.sym} 98220 -4680 0 0 {name=p98001 lab=_42922_/X }
C {devices/lab_pin.sym} 98380 -4740 0 1 {name=p98002 lab=_87651_/D }
C {sky130_stdcells/a2bb2o_4.sym} 98300 -4740 0 0 {name=X_42923_ }
C {devices/lab_pin.sym} 98260 -4590 0 0 {name=p98003 lab=_54882_/A }
C {devices/lab_pin.sym} 98340 -4590 0 1 {name=p98004 lab=_54909_/X }
C {sky130_stdcells/buf_2.sym} 98300 -4590 0 0 {name=X_54909_ }
C {devices/lab_pin.sym} 98220 -4500 0 0 {name=p98005 lab=_73665_/X }
C {devices/lab_pin.sym} 98220 -4460 0 0 {name=p98006 lab=_84986_/Q }
C {devices/lab_pin.sym} 98220 -4420 0 0 {name=p98007 lab=_73740_/X }
C {devices/lab_pin.sym} 98220 -4380 0 0 {name=p98008 lab=_73742_/X }
C {devices/lab_pin.sym} 98380 -4440 0 1 {name=p98009 lab=_73743_/X }
C {sky130_stdcells/a211o_4.sym} 98300 -4440 0 0 {name=X_73743_ }
C {devices/lab_pin.sym} 98210 -4290 0 0 {name=p98010 lab=_83690_/CLK }
C {devices/lab_pin.sym} 98210 -4270 0 0 {name=p98011 lab=_85729_/D }
C {devices/lab_pin.sym} 98390 -4290 0 1 {name=p98012 lab=_85729_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -4280 0 0 {name=X_85729_ }
C {devices/lab_pin.sym} 98220 -4170 0 0 {name=p98013 lab=_50757_/B }
C {devices/lab_pin.sym} 98220 -4130 0 0 {name=p98014 lab=_70936_/X }
C {devices/lab_pin.sym} 98220 -4090 0 0 {name=p98015 lab=_70954_/Y }
C {devices/lab_pin.sym} 98380 -4130 0 1 {name=p98016 lab=_70955_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -4130 0 0 {name=X_70955_ }
C {devices/lab_pin.sym} 98240 -4000 0 0 {name=p98017 lab=_58677_/A }
C {devices/lab_pin.sym} 98240 -3960 0 0 {name=p98018 lab=_58688_/B }
C {devices/lab_pin.sym} 98360 -3980 0 1 {name=p98019 lab=_58677_/Y }
C {sky130_stdcells/nor2_4.sym} 98300 -3980 0 0 {name=X_58677_ }
C {devices/lab_pin.sym} 98220 -3870 0 0 {name=p98020 lab=_46687_/Y }
C {devices/lab_pin.sym} 98220 -3830 0 0 {name=p98021 lab=_46654_/X }
C {devices/lab_pin.sym} 98220 -3790 0 0 {name=p98022 lab=_46690_/X }
C {devices/lab_pin.sym} 98380 -3830 0 1 {name=p98023 lab=_86714_/D }
C {sky130_stdcells/a21oi_4.sym} 98300 -3830 0 0 {name=X_46691_ }
C {devices/lab_pin.sym} 98240 -3700 0 0 {name=p98024 lab=_55903_/A }
C {devices/lab_pin.sym} 98240 -3660 0 0 {name=p98025 lab=_55889_/B }
C {devices/lab_pin.sym} 98360 -3680 0 1 {name=p98026 lab=_55889_/X }
C {sky130_stdcells/and2_4.sym} 98300 -3680 0 0 {name=X_55889_ }
C {devices/lab_pin.sym} 98260 -3550 0 0 {name=p98027 lab=clkbuf_7_59_0_CLK/X }
C {devices/lab_pin.sym} 98340 -3550 0 1 {name=p98028 lab=clkbuf_8_118_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 98300 -3550 0 0 {name=Xclkbuf_8_118_0_CLK }
C {devices/lab_pin.sym} 98260 -3430 0 0 {name=p98029 lab=_48545_/A }
C {devices/lab_pin.sym} 98340 -3430 0 1 {name=p98030 lab=_48476_/C }
C {sky130_stdcells/buf_2.sym} 98300 -3430 0 0 {name=X_48430_ }
C {devices/lab_pin.sym} 98260 -3310 0 0 {name=p98031 lab=_79250_/A }
C {devices/lab_pin.sym} 98340 -3310 0 1 {name=p98032 lab=_79250_/Y }
C {sky130_stdcells/inv_2.sym} 98300 -3310 0 0 {name=X_79250_ }
C {devices/lab_pin.sym} 98260 -3190 0 0 {name=p98033 lab=clkbuf_9_56_0_CLK/X }
C {devices/lab_pin.sym} 98340 -3190 0 1 {name=p98034 lab=_83242_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 98300 -3190 0 0 {name=Xclkbuf_10_113_0_CLK }
C {devices/lab_pin.sym} 98240 -3080 0 0 {name=p98035 lab=_57608_/X }
C {devices/lab_pin.sym} 98240 -3040 0 0 {name=p98036 lab=_50372_/B }
C {devices/lab_pin.sym} 98360 -3060 0 1 {name=p98037 lab=_57628_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -3060 0 0 {name=X_57628_ }
C {devices/lab_pin.sym} 98220 -2950 0 0 {name=p98038 lab=_45635_/X }
C {devices/lab_pin.sym} 98220 -2910 0 0 {name=p98039 lab=_45639_/Y }
C {devices/lab_pin.sym} 98220 -2870 0 0 {name=p98040 lab=_45641_/Y }
C {devices/lab_pin.sym} 98380 -2910 0 1 {name=p98041 lab=_45642_/Y }
C {sky130_stdcells/a21oi_4.sym} 98300 -2910 0 0 {name=X_45642_ }
C {devices/lab_pin.sym} 98260 -2770 0 0 {name=p98042 lab=_76461_/X }
C {devices/lab_pin.sym} 98340 -2770 0 1 {name=p98043 lab=_76482_/B }
C {sky130_stdcells/inv_2.sym} 98300 -2770 0 0 {name=X_76462_ }
C {devices/lab_pin.sym} 98220 -2680 0 0 {name=p98044 lab=_41525_/X }
C {devices/lab_pin.sym} 98220 -2640 0 0 {name=p98045 lab=_42852_/X }
C {devices/lab_pin.sym} 98220 -2600 0 0 {name=p98046 lab=_66876_/B }
C {devices/lab_pin.sym} 98220 -2560 0 0 {name=p98047 lab=_42853_/X }
C {devices/lab_pin.sym} 98380 -2620 0 1 {name=p98048 lab=_87686_/D }
C {sky130_stdcells/a2bb2o_4.sym} 98300 -2620 0 0 {name=X_42854_ }
C {devices/lab_pin.sym} 98260 -2470 0 0 {name=p98049 lab=_73250_/A }
C {devices/lab_pin.sym} 98340 -2470 0 1 {name=p98050 lab=_73674_/X }
C {sky130_stdcells/buf_2.sym} 98300 -2470 0 0 {name=X_73674_ }
C {devices/lab_pin.sym} 98240 -2360 0 0 {name=p98051 lab=_70886_/A }
C {devices/lab_pin.sym} 98240 -2320 0 0 {name=p98052 lab=_70882_/Y }
C {devices/lab_pin.sym} 98360 -2340 0 1 {name=p98053 lab=_70905_/D }
C {sky130_stdcells/nor2_4.sym} 98300 -2340 0 0 {name=X_70886_ }
C {devices/lab_pin.sym} 98260 -2210 0 0 {name=p98054 lab=clkbuf_9_371_0_CLK/X }
C {devices/lab_pin.sym} 98340 -2210 0 1 {name=p98055 lab=_87235_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 98300 -2210 0 0 {name=Xclkbuf_10_743_0_CLK }
C {devices/lab_pin.sym} 98240 -2100 0 0 {name=p98056 lab=_78204_/B }
C {devices/lab_pin.sym} 98240 -2060 0 0 {name=p98057 lab=_78200_/Y }
C {devices/lab_pin.sym} 98360 -2080 0 1 {name=p98058 lab=_78202_/B }
C {sky130_stdcells/xnor2_4.sym} 98300 -2080 0 0 {name=X_78201_ }
C {devices/lab_pin.sym} 98240 -1970 0 0 {name=p98059 lab=_75413_/A }
C {devices/lab_pin.sym} 98240 -1930 0 0 {name=p98060 lab=_75413_/B }
C {devices/lab_pin.sym} 98240 -1890 0 0 {name=p98061 lab=_75413_/C }
C {devices/lab_pin.sym} 98360 -1930 0 1 {name=p98062 lab=_75413_/X }
C {sky130_stdcells/or3_4.sym} 98300 -1930 0 0 {name=X_75413_ }
C {devices/lab_pin.sym} 98260 -1790 0 0 {name=p98063 lab=_41805_/A }
C {devices/lab_pin.sym} 98340 -1790 0 1 {name=p98064 lab=_41805_/Y }
C {sky130_stdcells/inv_2.sym} 98300 -1790 0 0 {name=X_41805_ }
C {devices/lab_pin.sym} 98240 -1680 0 0 {name=p98065 lab=_48044_/A }
C {devices/lab_pin.sym} 98240 -1640 0 0 {name=p98066 lab=_48361_/B }
C {devices/lab_pin.sym} 98360 -1660 0 1 {name=p98067 lab=_48361_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -1660 0 0 {name=X_48361_ }
C {devices/lab_pin.sym} 98240 -1540 0 0 {name=p98068 lab=_72625_/A }
C {devices/lab_pin.sym} 98240 -1500 0 0 {name=p98069 lab=_72625_/B }
C {devices/lab_pin.sym} 98360 -1520 0 1 {name=p98070 lab=_72625_/X }
C {sky130_stdcells/and2_4.sym} 98300 -1520 0 0 {name=X_72625_ }
C {devices/lab_pin.sym} 98240 -1400 0 0 {name=p98071 lab=_84788_/Q }
C {devices/lab_pin.sym} 98240 -1360 0 0 {name=p98072 lab=_84108_/Q }
C {devices/lab_pin.sym} 98360 -1380 0 1 {name=p98073 lab=_79181_/Y }
C {sky130_stdcells/nand2_4.sym} 98300 -1380 0 0 {name=X_79181_ }
C {devices/lab_pin.sym} 98220 -1280 0 0 {name=p98074 lab=_55508_/B }
C {devices/lab_pin.sym} 98220 -1240 0 0 {name=p98075 lab=_45570_/X }
C {devices/lab_pin.sym} 98220 -1200 0 0 {name=p98076 lab=_45571_/X }
C {devices/lab_pin.sym} 98220 -1160 0 0 {name=p98077 lab=_45572_/Y }
C {devices/lab_pin.sym} 98380 -1220 0 1 {name=p98078 lab=_45573_/X }
C {sky130_stdcells/a211o_4.sym} 98300 -1220 0 0 {name=X_45573_ }
C {devices/lab_pin.sym} 98220 -1090 0 0 {name=p98079 lab=_84979_/Q }
C {devices/lab_pin.sym} 98220 -1050 0 0 {name=p98080 lab=_57550_/X }
C {devices/lab_pin.sym} 98220 -1010 0 0 {name=p98081 lab=_57558_/Y }
C {devices/lab_pin.sym} 98380 -1050 0 1 {name=p98082 lab=_57559_/Y }
C {sky130_stdcells/o21ai_4.sym} 98300 -1050 0 0 {name=X_57559_ }
C {devices/lab_pin.sym} 98240 -920 0 0 {name=p98083 lab=_76393_/A }
C {devices/lab_pin.sym} 98240 -880 0 0 {name=p98084 lab=_81567_/Q }
C {devices/lab_pin.sym} 98360 -900 0 1 {name=p98085 lab=_76394_/A }
C {sky130_stdcells/nand2_4.sym} 98300 -900 0 0 {name=X_76393_ }
C {devices/lab_pin.sym} 98210 -770 0 0 {name=p98086 lab=_87417_/CLK }
C {devices/lab_pin.sym} 98210 -750 0 0 {name=p98087 lab=_88379_/D }
C {devices/lab_pin.sym} 98390 -770 0 1 {name=p98088 lab=_88379_/Q }
C {sky130_stdcells/dfxtp_4.sym} 98300 -760 0 0 {name=X_88379_ }
C {devices/lab_pin.sym} 99180 -42150 0 0 {name=p98089 lab=_42785_/A }
C {devices/lab_pin.sym} 99260 -42150 0 1 {name=p98090 lab=_87720_/D }
C {sky130_stdcells/inv_2.sym} 99220 -42150 0 0 {name=X_42785_ }
C {devices/lab_pin.sym} 99140 -42050 0 0 {name=p98091 lab=_47308_/Y }
C {devices/lab_pin.sym} 99140 -42010 0 0 {name=p98092 lab=_47271_/X }
C {devices/lab_pin.sym} 99140 -41970 0 0 {name=p98093 lab=_47311_/X }
C {devices/lab_pin.sym} 99300 -42010 0 1 {name=p98094 lab=_86648_/D }
C {sky130_stdcells/a21oi_4.sym} 99220 -42010 0 0 {name=X_47312_ }
C {devices/lab_pin.sym} 99180 -41870 0 0 {name=p98095 lab=clkbuf_9_235_0_CLK/A }
C {devices/lab_pin.sym} 99260 -41870 0 1 {name=p98096 lab=clkbuf_9_234_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 99220 -41870 0 0 {name=Xclkbuf_9_234_0_CLK }
C {devices/lab_pin.sym} 99160 -41760 0 0 {name=p98097 lab=_78130_/C }
C {devices/lab_pin.sym} 99160 -41720 0 0 {name=p98098 lab=_78130_/D }
C {devices/lab_pin.sym} 99280 -41740 0 1 {name=p98099 lab=_78132_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -41740 0 0 {name=X_78132_ }
C {devices/lab_pin.sym} 99140 -41650 0 0 {name=p98100 lab=_44496_/X }
C {devices/lab_pin.sym} 99140 -41610 0 0 {name=p98101 lab=_44497_/X }
C {devices/lab_pin.sym} 99140 -41570 0 0 {name=p98102 lab=_40787_/X }
C {devices/lab_pin.sym} 99140 -41530 0 0 {name=p98103 lab=_87067_/Q }
C {devices/lab_pin.sym} 99140 -41490 0 0 {name=p98104 lab=_44498_/X }
C {devices/lab_pin.sym} 99300 -41570 0 1 {name=p98105 lab=_44524_/Y }
C {sky130_stdcells/o32ai_4.sym} 99220 -41570 0 0 {name=X_44524_ }
C {devices/lab_pin.sym} 99140 -41430 0 0 {name=p98106 lab=_75308_/Y }
C {devices/lab_pin.sym} 99140 -41390 0 0 {name=p98107 lab=_75342_/X }
C {devices/lab_pin.sym} 99140 -41350 0 0 {name=p98108 lab=_75343_/Y }
C {devices/lab_pin.sym} 99300 -41390 0 1 {name=p98109 lab=_75345_/B }
C {sky130_stdcells/a21oi_4.sym} 99220 -41390 0 0 {name=X_75344_ }
C {devices/lab_pin.sym} 99180 -41250 0 0 {name=p98110 lab=_41607_/X }
C {devices/lab_pin.sym} 99260 -41250 0 1 {name=p98111 lab=_41736_/X }
C {sky130_stdcells/buf_2.sym} 99220 -41250 0 0 {name=X_41736_ }
C {devices/lab_pin.sym} 99160 -41150 0 0 {name=p98112 lab=_60570_/A }
C {devices/lab_pin.sym} 99160 -41110 0 0 {name=p98113 lab=_60570_/B }
C {devices/lab_pin.sym} 99160 -41070 0 0 {name=p98114 lab=_60570_/C }
C {devices/lab_pin.sym} 99280 -41110 0 1 {name=p98115 lab=_60570_/X }
C {sky130_stdcells/and3_4.sym} 99220 -41110 0 0 {name=X_60570_ }
C {devices/lab_pin.sym} 99140 -40990 0 0 {name=p98116 lab=_48290_/Y }
C {devices/lab_pin.sym} 99140 -40950 0 0 {name=p98117 lab=_48233_/X }
C {devices/lab_pin.sym} 99140 -40910 0 0 {name=p98118 lab=_48291_/X }
C {devices/lab_pin.sym} 99300 -40950 0 1 {name=p98119 lab=_86541_/D }
C {sky130_stdcells/a21oi_4.sym} 99220 -40950 0 0 {name=X_48292_ }
C {devices/lab_pin.sym} 99180 -40810 0 0 {name=p98120 lab=_72572_/A }
C {devices/lab_pin.sym} 99260 -40810 0 1 {name=p98121 lab=_72556_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -40810 0 0 {name=X_72556_ }
C {devices/lab_pin.sym} 99180 -40690 0 0 {name=p98122 lab=clkbuf_9_64_0_CLK/X }
C {devices/lab_pin.sym} 99260 -40690 0 1 {name=p98123 lab=_81807_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 99220 -40690 0 0 {name=Xclkbuf_10_128_0_CLK }
C {devices/lab_pin.sym} 99180 -40570 0 0 {name=p98124 lab=_54102_/B }
C {devices/lab_pin.sym} 99260 -40570 0 1 {name=p98125 lab=_52936_/B }
C {sky130_stdcells/buf_2.sym} 99220 -40570 0 0 {name=X_47243_ }
C {devices/lab_pin.sym} 99160 -40460 0 0 {name=p98126 lab=_71507_/A }
C {devices/lab_pin.sym} 99160 -40420 0 0 {name=p98127 lab=_71507_/B }
C {devices/lab_pin.sym} 99280 -40440 0 1 {name=p98128 lab=_71525_/A }
C {sky130_stdcells/nor2_4.sym} 99220 -40440 0 0 {name=X_71507_ }
C {devices/lab_pin.sym} 99180 -40310 0 0 {name=p98129 lab=_59229_/A }
C {devices/lab_pin.sym} 99260 -40310 0 1 {name=p98130 lab=_59229_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -40310 0 0 {name=X_59229_ }
C {devices/lab_pin.sym} 99160 -40200 0 0 {name=p98131 lab=_84568_/Q }
C {devices/lab_pin.sym} 99160 -40160 0 0 {name=p98132 lab=_78063_/B }
C {devices/lab_pin.sym} 99280 -40180 0 1 {name=p98133 lab=_78063_/X }
C {sky130_stdcells/xor2_4.sym} 99220 -40180 0 0 {name=X_78063_ }
C {devices/lab_pin.sym} 99140 -40080 0 0 {name=p98134 lab=_41121_/A }
C {devices/lab_pin.sym} 99140 -40040 0 0 {name=p98135 lab=_44453_/X }
C {devices/lab_pin.sym} 99140 -40000 0 0 {name=p98136 lab=_87102_/Q }
C {devices/lab_pin.sym} 99140 -39960 0 0 {name=p98137 lab=_44454_/X }
C {devices/lab_pin.sym} 99300 -40020 0 1 {name=p98138 lab=_44455_/X }
C {sky130_stdcells/a2bb2o_4.sym} 99220 -40020 0 0 {name=X_44455_ }
C {devices/lab_pin.sym} 99140 -39890 0 0 {name=p98139 lab=_75271_/X }
C {devices/lab_pin.sym} 99140 -39850 0 0 {name=p98140 lab=_75272_/Y }
C {devices/lab_pin.sym} 99140 -39810 0 0 {name=p98141 lab=_75274_/Y }
C {devices/lab_pin.sym} 99300 -39850 0 1 {name=p98142 lab=_75277_/A }
C {sky130_stdcells/a21o_4.sym} 99220 -39850 0 0 {name=X_75275_ }
C {devices/lab_pin.sym} 99180 -39710 0 0 {name=p98143 lab=_41666_/X }
C {devices/lab_pin.sym} 99260 -39710 0 1 {name=p98144 lab=_41667_/X }
C {sky130_stdcells/buf_2.sym} 99220 -39710 0 0 {name=X_41667_ }
C {devices/lab_pin.sym} 99140 -39610 0 0 {name=p98145 lab=_72484_/X }
C {devices/lab_pin.sym} 99140 -39570 0 0 {name=p98146 lab=_83385_/Q }
C {devices/lab_pin.sym} 99140 -39530 0 0 {name=p98147 lab=_72486_/Y }
C {devices/lab_pin.sym} 99300 -39570 0 1 {name=p98148 lab=_83249_/D }
C {sky130_stdcells/o21a_4.sym} 99220 -39570 0 0 {name=X_72487_ }
C {devices/lab_pin.sym} 99180 -39430 0 0 {name=p98149 lab=clkbuf_9_379_0_CLK/X }
C {devices/lab_pin.sym} 99260 -39430 0 1 {name=p98150 lab=_87533_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 99220 -39430 0 0 {name=Xclkbuf_10_758_0_CLK }
C {devices/lab_pin.sym} 99140 -39330 0 0 {name=p98151 lab=_77004_/Y }
C {devices/lab_pin.sym} 99140 -39290 0 0 {name=p98152 lab=_77012_/Y }
C {devices/lab_pin.sym} 99140 -39250 0 0 {name=p98153 lab=_77013_/Y }
C {devices/lab_pin.sym} 99300 -39290 0 1 {name=p98154 lab=_77014_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -39290 0 0 {name=X_77014_ }
C {devices/lab_pin.sym} 99180 -39150 0 0 {name=p98155 lab=_43405_/Y }
C {devices/lab_pin.sym} 99260 -39150 0 1 {name=p98156 lab=_43406_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -39150 0 0 {name=X_43406_ }
C {devices/lab_pin.sym} 99140 -39070 0 0 {name=p98157 lab=_62220_/X }
C {devices/lab_pin.sym} 99140 -39030 0 0 {name=p98158 lab=_62234_/Y }
C {devices/lab_pin.sym} 99140 -38990 0 0 {name=p98159 lab=_62239_/X }
C {devices/lab_pin.sym} 99140 -38950 0 0 {name=p98160 lab=_58149_/A }
C {devices/lab_pin.sym} 99140 -38910 0 0 {name=p98161 lab=_62214_/X }
C {devices/lab_pin.sym} 99300 -38990 0 1 {name=p98162 lab=_62240_/Y }
C {sky130_stdcells/o32ai_4.sym} 99220 -38990 0 0 {name=X_62240_ }
C {devices/lab_pin.sym} 99160 -38840 0 0 {name=p98163 lab=_74226_/A }
C {devices/lab_pin.sym} 99160 -38800 0 0 {name=p98164 lab=_74073_/X }
C {devices/lab_pin.sym} 99280 -38820 0 1 {name=p98165 lab=_74226_/Y }
C {sky130_stdcells/nor2_4.sym} 99220 -38820 0 0 {name=X_74226_ }
C {devices/lab_pin.sym} 99140 -38720 0 0 {name=p98166 lab=_40617_/X }
C {devices/lab_pin.sym} 99140 -38680 0 0 {name=p98167 lab=_40596_/X }
C {devices/lab_pin.sym} 99140 -38640 0 0 {name=p98168 lab=_88365_/Q }
C {devices/lab_pin.sym} 99140 -38600 0 0 {name=p98169 lab=_40599_/X }
C {devices/lab_pin.sym} 99300 -38660 0 1 {name=p98170 lab=_40618_/X }
C {sky130_stdcells/a2bb2o_4.sym} 99220 -38660 0 0 {name=X_40618_ }
C {devices/lab_pin.sym} 99180 -38510 0 0 {name=p98171 lab=_54587_/B }
C {devices/lab_pin.sym} 99260 -38510 0 1 {name=p98172 lab=_47174_/X }
C {sky130_stdcells/buf_2.sym} 99220 -38510 0 0 {name=X_47174_ }
C {devices/lab_pin.sym} 99140 -38410 0 0 {name=p98173 lab=_71419_/Y }
C {devices/lab_pin.sym} 99140 -38370 0 0 {name=p98174 lab=_83499_/Q }
C {devices/lab_pin.sym} 99140 -38330 0 0 {name=p98175 lab=_71437_/X }
C {devices/lab_pin.sym} 99300 -38370 0 1 {name=p98176 lab=_71438_/X }
C {sky130_stdcells/a21o_4.sym} 99220 -38370 0 0 {name=X_71438_ }
C {devices/lab_pin.sym} 99140 -38270 0 0 {name=p98177 lab=_44381_/X }
C {devices/lab_pin.sym} 99140 -38230 0 0 {name=p98178 lab=_44382_/X }
C {devices/lab_pin.sym} 99140 -38190 0 0 {name=p98179 lab=_41791_/X }
C {devices/lab_pin.sym} 99140 -38150 0 0 {name=p98180 lab=_87136_/Q }
C {devices/lab_pin.sym} 99140 -38110 0 0 {name=p98181 lab=_44383_/X }
C {devices/lab_pin.sym} 99300 -38190 0 1 {name=p98182 lab=_44387_/A }
C {sky130_stdcells/o32ai_4.sym} 99220 -38190 0 0 {name=X_44386_ }
C {devices/lab_pin.sym} 99180 -38030 0 0 {name=p98183 lab=_41597_/Y }
C {devices/lab_pin.sym} 99260 -38030 0 1 {name=p98184 lab=_88185_/D }
C {sky130_stdcells/inv_2.sym} 99220 -38030 0 0 {name=X_41598_ }
C {devices/lab_pin.sym} 99180 -37910 0 0 {name=p98185 lab=clkbuf_8_124_0_CLK/X }
C {devices/lab_pin.sym} 99260 -37910 0 1 {name=p98186 lab=clkbuf_9_249_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 99220 -37910 0 0 {name=Xclkbuf_9_249_0_CLK }
C {devices/lab_pin.sym} 99180 -37790 0 0 {name=p98187 lab=_46125_/A }
C {devices/lab_pin.sym} 99260 -37790 0 1 {name=p98188 lab=_46195_/A }
C {sky130_stdcells/buf_2.sym} 99220 -37790 0 0 {name=X_46125_ }
C {devices/lab_pin.sym} 99180 -37670 0 0 {name=p98189 lab=_43302_/A }
C {devices/lab_pin.sym} 99260 -37670 0 1 {name=p98190 lab=_43337_/X }
C {sky130_stdcells/buf_2.sym} 99220 -37670 0 0 {name=X_43337_ }
C {devices/lab_pin.sym} 99140 -37590 0 0 {name=p98191 lab=_58210_/X }
C {devices/lab_pin.sym} 99140 -37550 0 0 {name=p98192 lab=_62105_/X }
C {devices/lab_pin.sym} 99140 -37510 0 0 {name=p98193 lab=_62065_/D }
C {devices/lab_pin.sym} 99140 -37470 0 0 {name=p98194 lab=_62055_/A }
C {devices/lab_pin.sym} 99140 -37440 0 0 {name=p98195 lab=_62170_/X }
C {devices/lab_pin.sym} 99300 -37510 0 1 {name=p98196 lab=_62171_/X }
C {sky130_stdcells/a41o_4.sym} 99220 -37510 0 0 {name=X_62171_ }
C {devices/lab_pin.sym} 99160 -37360 0 0 {name=p98197 lab=_74237_/A }
C {devices/lab_pin.sym} 99160 -37320 0 0 {name=p98198 lab=_86536_/Q }
C {devices/lab_pin.sym} 99280 -37340 0 1 {name=p98199 lab=_74157_/X }
C {sky130_stdcells/and2_4.sym} 99220 -37340 0 0 {name=X_74157_ }
C {devices/lab_pin.sym} 99140 -37240 0 0 {name=p98200 lab=_40548_/X }
C {devices/lab_pin.sym} 99140 -37200 0 0 {name=p98201 lab=_40543_/X }
C {devices/lab_pin.sym} 99140 -37160 0 0 {name=p98202 lab=_88372_/Q }
C {devices/lab_pin.sym} 99140 -37120 0 0 {name=p98203 lab=_40544_/X }
C {devices/lab_pin.sym} 99300 -37180 0 1 {name=p98204 lab=_40549_/X }
C {sky130_stdcells/a2bb2o_4.sym} 99220 -37180 0 0 {name=X_40549_ }
C {devices/lab_pin.sym} 99160 -37060 0 0 {name=p98205 lab=_71366_/A }
C {devices/lab_pin.sym} 99160 -37020 0 0 {name=p98206 lab=_70939_/A }
C {devices/lab_pin.sym} 99160 -36980 0 0 {name=p98207 lab=_71439_/C }
C {devices/lab_pin.sym} 99160 -36940 0 0 {name=p98208 lab=_71365_/X }
C {devices/lab_pin.sym} 99280 -37000 0 1 {name=p98209 lab=_71369_/X }
C {sky130_stdcells/and4_4.sym} 99220 -37000 0 0 {name=X_71369_ }
C {devices/lab_pin.sym} 99160 -36870 0 0 {name=p98210 lab=_61122_/A }
C {devices/lab_pin.sym} 99160 -36830 0 0 {name=p98211 lab=_61122_/B }
C {devices/lab_pin.sym} 99160 -36790 0 0 {name=p98212 lab=_61122_/C }
C {devices/lab_pin.sym} 99280 -36830 0 1 {name=p98213 lab=_64421_/A }
C {sky130_stdcells/and3_4.sym} 99220 -36830 0 0 {name=X_61122_ }
C {devices/lab_pin.sym} 99160 -36700 0 0 {name=p98214 lab=_73108_/A }
C {devices/lab_pin.sym} 99160 -36660 0 0 {name=p98215 lab=_44127_/X }
C {devices/lab_pin.sym} 99280 -36680 0 1 {name=p98216 lab=_73108_/Y }
C {sky130_stdcells/nor2_4.sym} 99220 -36680 0 0 {name=X_73108_ }
C {devices/lab_pin.sym} 99180 -36550 0 0 {name=p98217 lab=_46055_/Y }
C {devices/lab_pin.sym} 99260 -36550 0 1 {name=p98218 lab=_86791_/D }
C {sky130_stdcells/inv_2.sym} 99220 -36550 0 0 {name=X_46056_ }
C {devices/lab_pin.sym} 99140 -36460 0 0 {name=p98219 lab=_41108_/X }
C {devices/lab_pin.sym} 99140 -36420 0 0 {name=p98220 lab=_43264_/X }
C {devices/lab_pin.sym} 99140 -36380 0 0 {name=p98221 lab=_87508_/Q }
C {devices/lab_pin.sym} 99140 -36340 0 0 {name=p98222 lab=_43265_/X }
C {devices/lab_pin.sym} 99300 -36400 0 1 {name=p98223 lab=_43268_/X }
C {sky130_stdcells/a2bb2o_4.sym} 99220 -36400 0 0 {name=X_43268_ }
C {devices/lab_pin.sym} 99160 -36260 0 0 {name=p98224 lab=_73588_/A }
C {devices/lab_pin.sym} 99160 -36220 0 0 {name=p98225 lab=_86539_/Q }
C {devices/lab_pin.sym} 99280 -36240 0 1 {name=p98226 lab=_74088_/X }
C {sky130_stdcells/and2_4.sym} 99220 -36240 0 0 {name=X_74088_ }
C {devices/lab_pin.sym} 99160 -36120 0 0 {name=p98227 lab=_78965_/A }
C {devices/lab_pin.sym} 99160 -36080 0 0 {name=p98228 lab=_78965_/B }
C {devices/lab_pin.sym} 99280 -36100 0 1 {name=p98229 lab=_78965_/X }
C {sky130_stdcells/xor2_4.sym} 99220 -36100 0 0 {name=X_78965_ }
C {devices/lab_pin.sym} 99160 -35980 0 0 {name=p98230 lab=_45007_/A }
C {devices/lab_pin.sym} 99160 -35940 0 0 {name=p98231 lab=_45033_/B }
C {devices/lab_pin.sym} 99280 -35960 0 1 {name=p98232 lab=_45007_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -35960 0 0 {name=X_45007_ }
C {devices/lab_pin.sym} 99140 -35860 0 0 {name=p98233 lab=_41356_/X }
C {devices/lab_pin.sym} 99140 -35820 0 0 {name=p98234 lab=_42209_/X }
C {devices/lab_pin.sym} 99140 -35780 0 0 {name=p98235 lab=_87974_/Q }
C {devices/lab_pin.sym} 99140 -35740 0 0 {name=p98236 lab=_42210_/X }
C {devices/lab_pin.sym} 99300 -35800 0 1 {name=p98237 lab=_87974_/D }
C {sky130_stdcells/a2bb2o_4.sym} 99220 -35800 0 0 {name=X_42219_ }
C {devices/lab_pin.sym} 99160 -35670 0 0 {name=p98238 lab=_65916_/A }
C {devices/lab_pin.sym} 99160 -35630 0 0 {name=p98239 lab=_65970_/B }
C {devices/lab_pin.sym} 99160 -35590 0 0 {name=p98240 lab=_84168_/Q }
C {devices/lab_pin.sym} 99280 -35630 0 1 {name=p98241 lab=_65930_/X }
C {sky130_stdcells/and3_4.sym} 99220 -35630 0 0 {name=X_65930_ }
C {devices/lab_pin.sym} 99160 -35510 0 0 {name=p98242 lab=_60946_/X }
C {devices/lab_pin.sym} 99160 -35470 0 0 {name=p98243 lab=_61138_/B }
C {devices/lab_pin.sym} 99160 -35430 0 0 {name=p98244 lab=_76975_/A }
C {devices/lab_pin.sym} 99280 -35470 0 1 {name=p98245 lab=_61053_/Y }
C {sky130_stdcells/nor3_4.sym} 99220 -35470 0 0 {name=X_61053_ }
C {devices/lab_pin.sym} 99160 -35340 0 0 {name=p98246 lab=_77916_/A }
C {devices/lab_pin.sym} 99160 -35300 0 0 {name=p98247 lab=_77916_/B }
C {devices/lab_pin.sym} 99280 -35320 0 1 {name=p98248 lab=_82038_/D }
C {sky130_stdcells/xor2_4.sym} 99220 -35320 0 0 {name=X_77916_ }
C {devices/lab_pin.sym} 99140 -35210 0 0 {name=p98249 lab=_73024_/Y }
C {devices/lab_pin.sym} 99140 -35170 0 0 {name=p98250 lab=_73029_/Y }
C {devices/lab_pin.sym} 99140 -35130 0 0 {name=p98251 lab=_73038_/X }
C {devices/lab_pin.sym} 99300 -35170 0 1 {name=p98252 lab=_73039_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -35170 0 0 {name=X_73039_ }
C {devices/lab_pin.sym} 99180 -35030 0 0 {name=p98253 lab=_43199_/A }
C {devices/lab_pin.sym} 99260 -35030 0 1 {name=p98254 lab=_43199_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -35030 0 0 {name=X_43199_ }
C {devices/lab_pin.sym} 99180 -34910 0 0 {name=p98255 lab=_78896_/A }
C {devices/lab_pin.sym} 99260 -34910 0 1 {name=p98256 lab=_82506_/D }
C {sky130_stdcells/inv_2.sym} 99220 -34910 0 0 {name=X_78896_ }
C {devices/lab_pin.sym} 99180 -34790 0 0 {name=p98257 lab=_63055_/A }
C {devices/lab_pin.sym} 99260 -34790 0 1 {name=p98258 lab=_65842_/A }
C {sky130_stdcells/buf_2.sym} 99220 -34790 0 0 {name=X_60004_ }
C {devices/lab_pin.sym} 99180 -34670 0 0 {name=p98259 lab=_49787_/A }
C {devices/lab_pin.sym} 99260 -34670 0 1 {name=p98260 lab=_49815_/X }
C {sky130_stdcells/buf_2.sym} 99220 -34670 0 0 {name=X_49815_ }
C {devices/lab_pin.sym} 99160 -34560 0 0 {name=p98261 lab=_65807_/A }
C {devices/lab_pin.sym} 99160 -34520 0 0 {name=p98262 lab=_86468_/Q }
C {devices/lab_pin.sym} 99280 -34540 0 1 {name=p98263 lab=_65861_/X }
C {sky130_stdcells/and2_4.sym} 99220 -34540 0 0 {name=X_65861_ }
C {devices/lab_pin.sym} 99160 -34420 0 0 {name=p98264 lab=_77847_/A }
C {devices/lab_pin.sym} 99160 -34380 0 0 {name=p98265 lab=_77833_/Y }
C {devices/lab_pin.sym} 99280 -34400 0 1 {name=p98266 lab=_77847_/Y }
C {sky130_stdcells/nor2_4.sym} 99220 -34400 0 0 {name=X_77847_ }
C {devices/lab_pin.sym} 99160 -34280 0 0 {name=p98267 lab=_67696_/A }
C {devices/lab_pin.sym} 99160 -34240 0 0 {name=p98268 lab=_67600_/B }
C {devices/lab_pin.sym} 99280 -34260 0 1 {name=p98269 lab=_67600_/X }
C {sky130_stdcells/and2_4.sym} 99220 -34260 0 0 {name=X_67600_ }
C {devices/lab_pin.sym} 99160 -34150 0 0 {name=p98270 lab=_64808_/X }
C {devices/lab_pin.sym} 99160 -34110 0 0 {name=p98271 lab=_64937_/B }
C {devices/lab_pin.sym} 99160 -34070 0 0 {name=p98272 lab=_64811_/X }
C {devices/lab_pin.sym} 99280 -34110 0 1 {name=p98273 lab=_64812_/Y }
C {sky130_stdcells/nand3_4.sym} 99220 -34110 0 0 {name=X_64812_ }
C {devices/lab_pin.sym} 99160 -34000 0 0 {name=p98274 lab=_49751_/A }
C {devices/lab_pin.sym} 99160 -33960 0 0 {name=p98275 lab=_49724_/B }
C {devices/lab_pin.sym} 99160 -33920 0 0 {name=p98276 lab=_49761_/C }
C {devices/lab_pin.sym} 99160 -33880 0 0 {name=p98277 lab=_52963_/D }
C {devices/lab_pin.sym} 99280 -33940 0 1 {name=p98278 lab=_49746_/X }
C {sky130_stdcells/and4_4.sym} 99220 -33940 0 0 {name=X_49746_ }
C {devices/lab_pin.sym} 99180 -33790 0 0 {name=p98279 lab=_68059_/A }
C {devices/lab_pin.sym} 99260 -33790 0 1 {name=p98280 lab=_68580_/X }
C {sky130_stdcells/buf_2.sym} 99220 -33790 0 0 {name=X_68580_ }
C {devices/lab_pin.sym} 99180 -33670 0 0 {name=p98281 lab=_54464_/B }
C {devices/lab_pin.sym} 99260 -33670 0 1 {name=p98282 lab=_52773_/B }
C {sky130_stdcells/buf_2.sym} 99220 -33670 0 0 {name=X_46958_ }
C {devices/lab_pin.sym} 99160 -33560 0 0 {name=p98283 lab=_65804_/A }
C {devices/lab_pin.sym} 99160 -33520 0 0 {name=p98284 lab=_85865_/Q }
C {devices/lab_pin.sym} 99280 -33540 0 1 {name=p98285 lab=_65792_/X }
C {sky130_stdcells/and2_4.sym} 99220 -33540 0 0 {name=X_65792_ }
C {devices/lab_pin.sym} 99160 -33420 0 0 {name=p98286 lab=_77780_/B }
C {devices/lab_pin.sym} 99160 -33380 0 0 {name=p98287 lab=_81927_/D }
C {devices/lab_pin.sym} 99280 -33400 0 1 {name=p98288 lab=_77778_/X }
C {sky130_stdcells/or2_4.sym} 99220 -33400 0 0 {name=X_77778_ }
C {devices/lab_pin.sym} 99140 -33300 0 0 {name=p98289 lab=_86967_/Q }
C {devices/lab_pin.sym} 99140 -33260 0 0 {name=p98290 lab=_67432_/X }
C {devices/lab_pin.sym} 99140 -33220 0 0 {name=p98291 lab=_67433_/X }
C {devices/lab_pin.sym} 99140 -33180 0 0 {name=p98292 lab=_67530_/X }
C {devices/lab_pin.sym} 99300 -33240 0 1 {name=p98293 lab=_67531_/X }
C {sky130_stdcells/a211o_4.sym} 99220 -33240 0 0 {name=X_67531_ }
C {devices/lab_pin.sym} 99160 -33100 0 0 {name=p98294 lab=_79517_/A }
C {devices/lab_pin.sym} 99160 -33060 0 0 {name=p98295 lab=_79517_/B }
C {devices/lab_pin.sym} 99280 -33080 0 1 {name=p98296 lab=_79518_/B }
C {sky130_stdcells/xor2_4.sym} 99220 -33080 0 0 {name=X_79517_ }
C {devices/lab_pin.sym} 99180 -32950 0 0 {name=p98297 lab=_45909_/A }
C {devices/lab_pin.sym} 99260 -32950 0 1 {name=p98298 lab=_45909_/X }
C {sky130_stdcells/buf_2.sym} 99220 -32950 0 0 {name=X_45909_ }
C {devices/lab_pin.sym} 99160 -32840 0 0 {name=p98299 lab=_64676_/A }
C {devices/lab_pin.sym} 99160 -32800 0 0 {name=p98300 lab=_64743_/B }
C {devices/lab_pin.sym} 99280 -32820 0 1 {name=p98301 lab=_64743_/X }
C {sky130_stdcells/and2_4.sym} 99220 -32820 0 0 {name=X_64743_ }
C {devices/lab_pin.sym} 99160 -32700 0 0 {name=p98302 lab=_76727_/Y }
C {devices/lab_pin.sym} 99160 -32660 0 0 {name=p98303 lab=_76728_/Y }
C {devices/lab_pin.sym} 99280 -32680 0 1 {name=p98304 lab=_76732_/A }
C {sky130_stdcells/xor2_4.sym} 99220 -32680 0 0 {name=X_76729_ }
C {devices/lab_pin.sym} 99180 -32550 0 0 {name=p98305 lab=_61777_/A }
C {devices/lab_pin.sym} 99260 -32550 0 1 {name=p98306 lab=_61971_/C }
C {sky130_stdcells/buf_2.sym} 99220 -32550 0 0 {name=X_61955_ }
C {devices/lab_pin.sym} 99180 -32430 0 0 {name=p98307 lab=_49570_/A }
C {devices/lab_pin.sym} 99260 -32430 0 1 {name=p98308 lab=_49677_/X }
C {sky130_stdcells/buf_2.sym} 99220 -32430 0 0 {name=X_49677_ }
C {devices/lab_pin.sym} 99140 -32330 0 0 {name=p98309 lab=_58942_/A }
C {devices/lab_pin.sym} 99140 -32290 0 0 {name=p98310 lab=_46859_/X }
C {devices/lab_pin.sym} 99140 -32250 0 0 {name=p98311 lab=_46888_/Y }
C {devices/lab_pin.sym} 99300 -32290 0 1 {name=p98312 lab=_46889_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -32290 0 0 {name=X_46889_ }
C {devices/lab_pin.sym} 99180 -32150 0 0 {name=p98313 lab=_60892_/Y }
C {devices/lab_pin.sym} 99260 -32150 0 1 {name=p98314 lab=_60906_/X }
C {sky130_stdcells/buf_2.sym} 99220 -32150 0 0 {name=X_60906_ }
C {devices/lab_pin.sym} 99160 -32040 0 0 {name=p98315 lab=_48661_/A }
C {devices/lab_pin.sym} 99160 -32000 0 0 {name=p98316 lab=_48628_/B }
C {devices/lab_pin.sym} 99280 -32020 0 1 {name=p98317 lab=_48628_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -32020 0 0 {name=X_48628_ }
C {devices/lab_pin.sym} 99160 -31900 0 0 {name=p98318 lab=_79446_/X }
C {devices/lab_pin.sym} 99160 -31860 0 0 {name=p98319 lab=_79453_/B }
C {devices/lab_pin.sym} 99280 -31880 0 1 {name=p98320 lab=_79448_/Y }
C {sky130_stdcells/xnor2_4.sym} 99220 -31880 0 0 {name=X_79448_ }
C {devices/lab_pin.sym} 99180 -31750 0 0 {name=p98321 lab=_67226_/A }
C {devices/lab_pin.sym} 99260 -31750 0 1 {name=p98322 lab=_67462_/X }
C {sky130_stdcells/buf_2.sym} 99220 -31750 0 0 {name=X_67462_ }
C {devices/lab_pin.sym} 99140 -31660 0 0 {name=p98323 lab=_64577_/X }
C {devices/lab_pin.sym} 99140 -31620 0 0 {name=p98324 lab=_86750_/Q }
C {devices/lab_pin.sym} 99140 -31580 0 0 {name=p98325 lab=_64579_/X }
C {devices/lab_pin.sym} 99140 -31540 0 0 {name=p98326 lab=_64673_/X }
C {devices/lab_pin.sym} 99300 -31600 0 1 {name=p98327 lab=_64674_/X }
C {sky130_stdcells/a211o_4.sym} 99220 -31600 0 0 {name=X_64674_ }
C {devices/lab_pin.sym} 99160 -31480 0 0 {name=p98328 lab=_61871_/A }
C {devices/lab_pin.sym} 99160 -31440 0 0 {name=p98329 lab=_61839_/B }
C {devices/lab_pin.sym} 99160 -31400 0 0 {name=p98330 lab=_61839_/C }
C {devices/lab_pin.sym} 99160 -31360 0 0 {name=p98331 lab=_63124_/B }
C {devices/lab_pin.sym} 99280 -31420 0 1 {name=p98332 lab=_61886_/X }
C {sky130_stdcells/and4_4.sym} 99220 -31420 0 0 {name=X_61886_ }
C {devices/lab_pin.sym} 99140 -31290 0 0 {name=p98333 lab=_81405_/D }
C {devices/lab_pin.sym} 99140 -31250 0 0 {name=p98334 lab=_69161_/X }
C {devices/lab_pin.sym} 99140 -31210 0 0 {name=p98335 lab=_69200_/X }
C {devices/lab_pin.sym} 99300 -31250 0 1 {name=p98336 lab=_83941_/D }
C {sky130_stdcells/a21bo_4.sym} 99220 -31250 0 0 {name=X_69201_ }
C {devices/lab_pin.sym} 99140 -31130 0 0 {name=p98337 lab=_66411_/X }
C {devices/lab_pin.sym} 99140 -31090 0 0 {name=p98338 lab=_66043_/Y }
C {devices/lab_pin.sym} 99140 -31050 0 0 {name=p98339 lab=_66412_/Y }
C {devices/lab_pin.sym} 99300 -31090 0 1 {name=p98340 lab=_66413_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -31090 0 0 {name=X_66413_ }
C {devices/lab_pin.sym} 99160 -30980 0 0 {name=p98341 lab=_63655_/A }
C {devices/lab_pin.sym} 99160 -30940 0 0 {name=p98342 lab=_58495_/A }
C {devices/lab_pin.sym} 99160 -30900 0 0 {name=p98343 lab=_63581_/X }
C {devices/lab_pin.sym} 99160 -30860 0 0 {name=p98344 lab=_63595_/D }
C {devices/lab_pin.sym} 99280 -30920 0 1 {name=p98345 lab=_63625_/X }
C {sky130_stdcells/and4_4.sym} 99220 -30920 0 0 {name=X_63625_ }
C {devices/lab_pin.sym} 99180 -30770 0 0 {name=p98346 lab=_48559_/A }
C {devices/lab_pin.sym} 99260 -30770 0 1 {name=p98347 lab=_48559_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -30770 0 0 {name=X_48559_ }
C {devices/lab_pin.sym} 99140 -30690 0 0 {name=p98348 lab=_60376_/X }
C {devices/lab_pin.sym} 99140 -30650 0 0 {name=p98349 lab=_60834_/X }
C {devices/lab_pin.sym} 99140 -30610 0 0 {name=p98350 lab=_60804_/Y }
C {devices/lab_pin.sym} 99140 -30570 0 0 {name=p98351 lab=_60799_/X }
C {devices/lab_pin.sym} 99140 -30530 0 0 {name=p98352 lab=_60836_/X }
C {devices/lab_pin.sym} 99300 -30610 0 1 {name=p98353 lab=_84555_/D }
C {sky130_stdcells/o41a_4.sym} 99220 -30610 0 0 {name=X_60837_ }
C {devices/lab_pin.sym} 99140 -30480 0 0 {name=p98354 lab=_87985_/Q }
C {devices/lab_pin.sym} 99140 -30440 0 0 {name=p98355 lab=_67293_/X }
C {devices/lab_pin.sym} 99140 -30400 0 0 {name=p98356 lab=_67391_/X }
C {devices/lab_pin.sym} 99140 -30360 0 0 {name=p98357 lab=_67392_/X }
C {devices/lab_pin.sym} 99300 -30420 0 1 {name=p98358 lab=_67393_/X }
C {sky130_stdcells/a211o_4.sym} 99220 -30420 0 0 {name=X_67393_ }
C {devices/lab_pin.sym} 99140 -30290 0 0 {name=p98359 lab=_79366_/X }
C {devices/lab_pin.sym} 99140 -30250 0 0 {name=p98360 lab=_79377_/X }
C {devices/lab_pin.sym} 99140 -30210 0 0 {name=p98361 lab=_79378_/X }
C {devices/lab_pin.sym} 99300 -30250 0 1 {name=p98362 lab=_79379_/Y }
C {sky130_stdcells/a21oi_4.sym} 99220 -30250 0 0 {name=X_79379_ }
C {devices/lab_pin.sym} 99130 -30110 0 0 {name=p98363 lab=_84079_/CLK }
C {devices/lab_pin.sym} 99130 -30090 0 0 {name=p98364 lab=_81442_/Q }
C {devices/lab_pin.sym} 99310 -30110 0 1 {name=p98365 lab=_75924_/B }
C {sky130_stdcells/dfxtp_4.sym} 99220 -30100 0 0 {name=X_81410_ }
C {devices/lab_pin.sym} 99140 -30000 0 0 {name=p98366 lab=_68907_/X }
C {devices/lab_pin.sym} 99140 -29960 0 0 {name=p98367 lab=_69109_/X }
C {devices/lab_pin.sym} 99140 -29920 0 0 {name=p98368 lab=_69120_/Y }
C {devices/lab_pin.sym} 99140 -29880 0 0 {name=p98369 lab=_69131_/Y }
C {devices/lab_pin.sym} 99300 -29940 0 1 {name=p98370 lab=_69132_/X }
C {sky130_stdcells/a211o_4.sym} 99220 -29940 0 0 {name=X_69132_ }
C {devices/lab_pin.sym} 99180 -29790 0 0 {name=p98371 lab=_84139_/Q }
C {devices/lab_pin.sym} 99260 -29790 0 1 {name=p98372 lab=_66345_/C }
C {sky130_stdcells/inv_2.sym} 99220 -29790 0 0 {name=X_66344_ }
C {devices/lab_pin.sym} 99160 -29700 0 0 {name=p98373 lab=_51553_/A }
C {devices/lab_pin.sym} 99160 -29660 0 0 {name=p98374 lab=_51580_/B }
C {devices/lab_pin.sym} 99160 -29620 0 0 {name=p98375 lab=_51553_/C }
C {devices/lab_pin.sym} 99160 -29580 0 0 {name=p98376 lab=_53099_/D }
C {devices/lab_pin.sym} 99280 -29640 0 1 {name=p98377 lab=_51570_/X }
C {sky130_stdcells/and4_4.sym} 99220 -29640 0 0 {name=X_51570_ }
C {devices/lab_pin.sym} 99180 -29490 0 0 {name=p98378 lab=_63368_/A }
C {devices/lab_pin.sym} 99260 -29490 0 1 {name=p98379 lab=_63556_/X }
C {sky130_stdcells/buf_2.sym} 99220 -29490 0 0 {name=X_63556_ }
C {devices/lab_pin.sym} 99130 -29370 0 0 {name=p98380 lab=_82390_/CLK }
C {devices/lab_pin.sym} 99130 -29350 0 0 {name=p98381 lab=_82390_/D }
C {devices/lab_pin.sym} 99310 -29370 0 1 {name=p98382 lab=_82390_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -29360 0 0 {name=X_82390_ }
C {devices/lab_pin.sym} 99160 -29250 0 0 {name=p98383 lab=_60610_/A }
C {devices/lab_pin.sym} 99160 -29210 0 0 {name=p98384 lab=_60513_/B }
C {devices/lab_pin.sym} 99160 -29170 0 0 {name=p98385 lab=_78066_/A }
C {devices/lab_pin.sym} 99280 -29210 0 1 {name=p98386 lab=_60768_/X }
C {sky130_stdcells/or3_4.sym} 99220 -29210 0 0 {name=X_60768_ }
C {devices/lab_pin.sym} 99160 -29080 0 0 {name=p98387 lab=_50513_/A }
C {devices/lab_pin.sym} 99160 -29040 0 0 {name=p98388 lab=_48843_/B }
C {devices/lab_pin.sym} 99280 -29060 0 1 {name=p98389 lab=_50521_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -29060 0 0 {name=X_50521_ }
C {devices/lab_pin.sym} 99130 -28930 0 0 {name=p98390 lab=_81330_/CLK }
C {devices/lab_pin.sym} 99130 -28910 0 0 {name=p98391 lab=_81341_/D }
C {devices/lab_pin.sym} 99310 -28930 0 1 {name=p98392 lab=_81717_/D }
C {sky130_stdcells/dfxtp_4.sym} 99220 -28920 0 0 {name=X_81341_ }
C {devices/lab_pin.sym} 99180 -28790 0 0 {name=p98393 lab=_59950_/C }
C {devices/lab_pin.sym} 99260 -28790 0 1 {name=p98394 lab=_62507_/X }
C {sky130_stdcells/buf_2.sym} 99220 -28790 0 0 {name=X_62507_ }
C {devices/lab_pin.sym} 99140 -28700 0 0 {name=p98395 lab=_69050_/Y }
C {devices/lab_pin.sym} 99140 -28660 0 0 {name=p98396 lab=_68823_/X }
C {devices/lab_pin.sym} 99140 -28620 0 0 {name=p98397 lab=_68824_/X }
C {devices/lab_pin.sym} 99140 -28580 0 0 {name=p98398 lab=_69062_/Y }
C {devices/lab_pin.sym} 99300 -28640 0 1 {name=p98399 lab=_69063_/X }
C {sky130_stdcells/a211o_4.sym} 99220 -28640 0 0 {name=X_69063_ }
C {devices/lab_pin.sym} 99160 -28500 0 0 {name=p98400 lab=_66272_/X }
C {devices/lab_pin.sym} 99160 -28460 0 0 {name=p98401 lab=_66274_/X }
C {devices/lab_pin.sym} 99280 -28480 0 1 {name=p98402 lab=_66275_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -28480 0 0 {name=X_66275_ }
C {devices/lab_pin.sym} 99180 -28350 0 0 {name=p98403 lab=_63487_/A }
C {devices/lab_pin.sym} 99260 -28350 0 1 {name=p98404 lab=_63487_/X }
C {sky130_stdcells/buf_2.sym} 99220 -28350 0 0 {name=X_63487_ }
C {devices/lab_pin.sym} 99180 -28230 0 0 {name=p98405 lab=_60558_/X }
C {devices/lab_pin.sym} 99260 -28230 0 1 {name=p98406 lab=_60700_/A }
C {sky130_stdcells/buf_2.sym} 99220 -28230 0 0 {name=X_60699_ }
C {devices/lab_pin.sym} 99140 -28140 0 0 {name=p98407 lab=_87139_/Q }
C {devices/lab_pin.sym} 99140 -28100 0 0 {name=p98408 lab=_67942_/X }
C {devices/lab_pin.sym} 99140 -28060 0 0 {name=p98409 lab=_67991_/X }
C {devices/lab_pin.sym} 99140 -28020 0 0 {name=p98410 lab=_68013_/X }
C {devices/lab_pin.sym} 99300 -28080 0 1 {name=p98411 lab=_68014_/X }
C {sky130_stdcells/a211o_4.sym} 99220 -28080 0 0 {name=X_68014_ }
C {devices/lab_pin.sym} 99160 -27940 0 0 {name=p98412 lab=_53246_/A }
C {devices/lab_pin.sym} 99160 -27900 0 0 {name=p98413 lab=_53240_/B }
C {devices/lab_pin.sym} 99280 -27920 0 1 {name=p98414 lab=_53240_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -27920 0 0 {name=X_53240_ }
C {devices/lab_pin.sym} 99140 -27820 0 0 {name=p98415 lab=_65199_/X }
C {devices/lab_pin.sym} 99140 -27780 0 0 {name=p98416 lab=_86153_/Q }
C {devices/lab_pin.sym} 99140 -27740 0 0 {name=p98417 lab=_65224_/X }
C {devices/lab_pin.sym} 99140 -27700 0 0 {name=p98418 lab=_65225_/X }
C {devices/lab_pin.sym} 99300 -27760 0 1 {name=p98419 lab=_65226_/X }
C {sky130_stdcells/a211o_4.sym} 99220 -27760 0 0 {name=X_65226_ }
C {devices/lab_pin.sym} 99130 -27610 0 0 {name=p98420 lab=_81749_/CLK }
C {devices/lab_pin.sym} 99130 -27590 0 0 {name=p98421 lab=_67663_/X }
C {devices/lab_pin.sym} 99310 -27610 0 1 {name=p98422 lab=_81492_/D }
C {sky130_stdcells/dfxtp_4.sym} 99220 -27600 0 0 {name=X_84060_ }
C {devices/lab_pin.sym} 99140 -27490 0 0 {name=p98423 lab=_50450_/Y }
C {devices/lab_pin.sym} 99140 -27450 0 0 {name=p98424 lab=_50429_/X }
C {devices/lab_pin.sym} 99140 -27410 0 0 {name=p98425 lab=_50451_/X }
C {devices/lab_pin.sym} 99300 -27450 0 1 {name=p98426 lab=_50452_/Y }
C {sky130_stdcells/a21oi_4.sym} 99220 -27450 0 0 {name=X_50452_ }
C {devices/lab_pin.sym} 99160 -27340 0 0 {name=p98427 lab=_62479_/A }
C {devices/lab_pin.sym} 99160 -27300 0 0 {name=p98428 lab=_61969_/X }
C {devices/lab_pin.sym} 99160 -27260 0 0 {name=p98429 lab=_62479_/C }
C {devices/lab_pin.sym} 99160 -27220 0 0 {name=p98430 lab=_62392_/D }
C {devices/lab_pin.sym} 99280 -27280 0 1 {name=p98431 lab=_62438_/X }
C {sky130_stdcells/and4_4.sym} 99220 -27280 0 0 {name=X_62438_ }
C {devices/lab_pin.sym} 99130 -27130 0 0 {name=p98432 lab=_81697_/CLK }
C {devices/lab_pin.sym} 99130 -27110 0 0 {name=p98433 lab=_81304_/Q }
C {devices/lab_pin.sym} 99310 -27130 0 1 {name=p98434 lab=_81272_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -27120 0 0 {name=X_81272_ }
C {devices/lab_pin.sym} 99130 -26990 0 0 {name=p98435 lab=_83012_/CLK }
C {devices/lab_pin.sym} 99130 -26970 0 0 {name=p98436 lab=_74624_/Y }
C {devices/lab_pin.sym} 99310 -26990 0 1 {name=p98437 lab=_83011_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -26980 0 0 {name=X_83011_ }
C {devices/lab_pin.sym} 99160 -26860 0 0 {name=p98438 lab=_80204_/Y }
C {devices/lab_pin.sym} 99160 -26820 0 0 {name=p98439 lab=_80207_/Y }
C {devices/lab_pin.sym} 99280 -26840 0 1 {name=p98440 lab=_80225_/B }
C {sky130_stdcells/or2_4.sym} 99220 -26840 0 0 {name=X_80223_ }
C {devices/lab_pin.sym} 99140 -26730 0 0 {name=p98441 lab=_53168_/Y }
C {devices/lab_pin.sym} 99140 -26690 0 0 {name=p98442 lab=_53163_/X }
C {devices/lab_pin.sym} 99140 -26650 0 0 {name=p98443 lab=_53170_/X }
C {devices/lab_pin.sym} 99300 -26690 0 1 {name=p98444 lab=_85684_/D }
C {sky130_stdcells/a21oi_4.sym} 99220 -26690 0 0 {name=X_53171_ }
C {devices/lab_pin.sym} 99180 -26550 0 0 {name=p98445 lab=_64717_/A }
C {devices/lab_pin.sym} 99260 -26550 0 1 {name=p98446 lab=_65158_/A }
C {sky130_stdcells/buf_2.sym} 99220 -26550 0 0 {name=X_65157_ }
C {devices/lab_pin.sym} 99160 -26440 0 0 {name=p98447 lab=_50383_/A }
C {devices/lab_pin.sym} 99160 -26400 0 0 {name=p98448 lab=_50383_/B }
C {devices/lab_pin.sym} 99280 -26420 0 1 {name=p98449 lab=_50383_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -26420 0 0 {name=X_50383_ }
C {devices/lab_pin.sym} 99160 -26310 0 0 {name=p98450 lab=_62342_/A }
C {devices/lab_pin.sym} 99160 -26270 0 0 {name=p98451 lab=_62341_/X }
C {devices/lab_pin.sym} 99160 -26230 0 0 {name=p98452 lab=_84415_/Q }
C {devices/lab_pin.sym} 99280 -26270 0 1 {name=p98453 lab=_62369_/Y }
C {sky130_stdcells/nor3_4.sym} 99220 -26270 0 0 {name=X_62369_ }
C {devices/lab_pin.sym} 99140 -26150 0 0 {name=p98454 lab=_65501_/B }
C {devices/lab_pin.sym} 99140 -26110 0 0 {name=p98455 lab=_52075_/X }
C {devices/lab_pin.sym} 99140 -26070 0 0 {name=p98456 lab=_52121_/Y }
C {devices/lab_pin.sym} 99300 -26110 0 1 {name=p98457 lab=_52122_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -26110 0 0 {name=X_52122_ }
C {devices/lab_pin.sym} 99160 -25990 0 0 {name=p98458 lab=_64116_/A }
C {devices/lab_pin.sym} 99160 -25950 0 0 {name=p98459 lab=_64087_/X }
C {devices/lab_pin.sym} 99160 -25910 0 0 {name=p98460 lab=_64108_/C }
C {devices/lab_pin.sym} 99280 -25950 0 1 {name=p98461 lab=_64108_/Y }
C {sky130_stdcells/nor3_4.sym} 99220 -25950 0 0 {name=X_64108_ }
C {devices/lab_pin.sym} 99160 -25820 0 0 {name=p98462 lab=_80154_/A }
C {devices/lab_pin.sym} 99160 -25780 0 0 {name=p98463 lab=_80153_/X }
C {devices/lab_pin.sym} 99280 -25800 0 1 {name=p98464 lab=_80169_/B }
C {sky130_stdcells/xnor2_4.sym} 99220 -25800 0 0 {name=X_80154_ }
C {devices/lab_pin.sym} 99140 -25700 0 0 {name=p98465 lab=_65065_/X }
C {devices/lab_pin.sym} 99140 -25660 0 0 {name=p98466 lab=_83295_/Q }
C {devices/lab_pin.sym} 99140 -25620 0 0 {name=p98467 lab=_64991_/X }
C {devices/lab_pin.sym} 99140 -25580 0 0 {name=p98468 lab=_65087_/X }
C {devices/lab_pin.sym} 99300 -25640 0 1 {name=p98469 lab=_65088_/X }
C {sky130_stdcells/a211o_4.sym} 99220 -25640 0 0 {name=X_65088_ }
C {devices/lab_pin.sym} 99140 -25520 0 0 {name=p98470 lab=_69943_/X }
C {devices/lab_pin.sym} 99140 -25480 0 0 {name=p98471 lab=_46199_/X }
C {devices/lab_pin.sym} 99140 -25440 0 0 {name=p98472 lab=_69963_/Y }
C {devices/lab_pin.sym} 99140 -25400 0 0 {name=p98473 lab=_69964_/Y }
C {devices/lab_pin.sym} 99300 -25460 0 1 {name=p98474 lab=_69965_/X }
C {sky130_stdcells/a211o_4.sym} 99220 -25460 0 0 {name=X_69965_ }
C {devices/lab_pin.sym} 99140 -25330 0 0 {name=p98475 lab=_74104_/B }
C {devices/lab_pin.sym} 99140 -25290 0 0 {name=p98476 lab=_52041_/X }
C {devices/lab_pin.sym} 99140 -25250 0 0 {name=p98477 lab=_52052_/Y }
C {devices/lab_pin.sym} 99300 -25290 0 1 {name=p98478 lab=_52053_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -25290 0 0 {name=X_52053_ }
C {devices/lab_pin.sym} 99180 -25150 0 0 {name=p98479 lab=_56953_/A }
C {devices/lab_pin.sym} 99260 -25150 0 1 {name=p98480 lab=_56930_/X }
C {sky130_stdcells/buf_2.sym} 99220 -25150 0 0 {name=X_56930_ }
C {devices/lab_pin.sym} 99180 -25030 0 0 {name=p98481 lab=_69478_/A }
C {devices/lab_pin.sym} 99260 -25030 0 1 {name=p98482 lab=_68916_/X }
C {sky130_stdcells/buf_2.sym} 99220 -25030 0 0 {name=X_68916_ }
C {devices/lab_pin.sym} 99180 -24910 0 0 {name=p98483 lab=_63751_/X }
C {devices/lab_pin.sym} 99260 -24910 0 1 {name=p98484 lab=_64142_/D }
C {sky130_stdcells/buf_2.sym} 99220 -24910 0 0 {name=X_64039_ }
C {devices/lab_pin.sym} 99130 -24790 0 0 {name=p98485 lab=_88006_/CLK }
C {devices/lab_pin.sym} 99130 -24770 0 0 {name=p98486 lab=_87750_/D }
C {devices/lab_pin.sym} 99310 -24790 0 1 {name=p98487 lab=_87750_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -24780 0 0 {name=X_87750_ }
C {devices/lab_pin.sym} 99130 -24650 0 0 {name=p98488 lab=_86210_/CLK }
C {devices/lab_pin.sym} 99130 -24630 0 0 {name=p98489 lab=_84962_/D }
C {devices/lab_pin.sym} 99310 -24650 0 1 {name=p98490 lab=_84962_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -24640 0 0 {name=X_84962_ }
C {devices/lab_pin.sym} 99160 -24520 0 0 {name=p98491 lab=_80071_/A }
C {devices/lab_pin.sym} 99160 -24480 0 0 {name=p98492 lab=_80070_/Y }
C {devices/lab_pin.sym} 99280 -24500 0 1 {name=p98493 lab=_80085_/X }
C {sky130_stdcells/or2_4.sym} 99220 -24500 0 0 {name=X_80085_ }
C {devices/lab_pin.sym} 99140 -24400 0 0 {name=p98494 lab=_43190_/A }
C {devices/lab_pin.sym} 99140 -24360 0 0 {name=p98495 lab=_69833_/X }
C {devices/lab_pin.sym} 99140 -24320 0 0 {name=p98496 lab=_68348_/X }
C {devices/lab_pin.sym} 99140 -24280 0 0 {name=p98497 lab=_69895_/X }
C {devices/lab_pin.sym} 99300 -24340 0 1 {name=p98498 lab=_69896_/X }
C {sky130_stdcells/a211o_4.sym} 99220 -24340 0 0 {name=X_69896_ }
C {devices/lab_pin.sym} 99140 -24210 0 0 {name=p98499 lab=_86091_/Q }
C {devices/lab_pin.sym} 99140 -24170 0 0 {name=p98500 lab=_50992_/X }
C {devices/lab_pin.sym} 99140 -24130 0 0 {name=p98501 lab=_51003_/Y }
C {devices/lab_pin.sym} 99300 -24170 0 1 {name=p98502 lab=_51004_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -24170 0 0 {name=X_51004_ }
C {devices/lab_pin.sym} 99130 -24030 0 0 {name=p98503 lab=_86701_/CLK }
C {devices/lab_pin.sym} 99130 -24010 0 0 {name=p98504 lab=_86701_/D }
C {devices/lab_pin.sym} 99310 -24030 0 1 {name=p98505 lab=_86701_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -24020 0 0 {name=X_86701_ }
C {devices/lab_pin.sym} 99130 -23890 0 0 {name=p98506 lab=_81985_/CLK }
C {devices/lab_pin.sym} 99130 -23870 0 0 {name=p98507 lab=_83913_/D }
C {devices/lab_pin.sym} 99310 -23890 0 1 {name=p98508 lab=_81985_/D }
C {sky130_stdcells/dfxtp_4.sym} 99220 -23880 0 0 {name=X_83913_ }
C {devices/lab_pin.sym} 99180 -23750 0 0 {name=p98509 lab=_56675_/X }
C {devices/lab_pin.sym} 99260 -23750 0 1 {name=p98510 lab=_56893_/B }
C {sky130_stdcells/buf_2.sym} 99220 -23750 0 0 {name=X_56861_ }
C {devices/lab_pin.sym} 99140 -23650 0 0 {name=p98511 lab=_68843_/X }
C {devices/lab_pin.sym} 99140 -23610 0 0 {name=p98512 lab=_68845_/X }
C {devices/lab_pin.sym} 99140 -23570 0 0 {name=p98513 lab=_68846_/X }
C {devices/lab_pin.sym} 99300 -23610 0 1 {name=p98514 lab=_68847_/Y }
C {sky130_stdcells/a21oi_4.sym} 99220 -23610 0 0 {name=X_68847_ }
C {devices/lab_pin.sym} 99130 -23470 0 0 {name=p98515 lab=_82888_/CLK }
C {devices/lab_pin.sym} 99130 -23450 0 0 {name=p98516 lab=_42862_/X }
C {devices/lab_pin.sym} 99310 -23470 0 1 {name=p98517 lab=_87681_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -23460 0 0 {name=X_87681_ }
C {devices/lab_pin.sym} 99130 -23330 0 0 {name=p98518 lab=_84250_/CLK }
C {devices/lab_pin.sym} 99130 -23310 0 0 {name=p98519 lab=_84893_/D }
C {devices/lab_pin.sym} 99310 -23330 0 1 {name=p98520 lab=_58264_/A }
C {sky130_stdcells/dfxtp_4.sym} 99220 -23320 0 0 {name=X_84893_ }
C {devices/lab_pin.sym} 99160 -23200 0 0 {name=p98521 lab=_58687_/A }
C {devices/lab_pin.sym} 99160 -23160 0 0 {name=p98522 lab=_86398_/Q }
C {devices/lab_pin.sym} 99280 -23180 0 1 {name=p98523 lab=_58600_/Y }
C {sky130_stdcells/nor2_4.sym} 99220 -23180 0 0 {name=X_58600_ }
C {devices/lab_pin.sym} 99160 -23060 0 0 {name=p98524 lab=_44077_/X }
C {devices/lab_pin.sym} 99160 -23020 0 0 {name=p98525 lab=_56339_/C }
C {devices/lab_pin.sym} 99280 -23040 0 1 {name=p98526 lab=_55812_/X }
C {sky130_stdcells/and2_4.sym} 99220 -23040 0 0 {name=X_55812_ }
C {devices/lab_pin.sym} 99130 -22910 0 0 {name=p98527 lab=_85993_/CLK }
C {devices/lab_pin.sym} 99130 -22890 0 0 {name=p98528 lab=_47467_/Y }
C {devices/lab_pin.sym} 99310 -22910 0 1 {name=p98529 lab=_86632_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -22900 0 0 {name=X_86632_ }
C {devices/lab_pin.sym} 99160 -22790 0 0 {name=p98530 lab=_59557_/A }
C {devices/lab_pin.sym} 99160 -22750 0 0 {name=p98531 lab=_59516_/A }
C {devices/lab_pin.sym} 99160 -22710 0 0 {name=p98532 lab=_59581_/C }
C {devices/lab_pin.sym} 99280 -22750 0 1 {name=p98533 lab=_59582_/A }
C {sky130_stdcells/nand3_4.sym} 99220 -22750 0 0 {name=X_59580_ }
C {devices/lab_pin.sym} 99130 -22610 0 0 {name=p98534 lab=_83835_/CLK }
C {devices/lab_pin.sym} 99130 -22590 0 0 {name=p98535 lab=_83844_/D }
C {devices/lab_pin.sym} 99310 -22610 0 1 {name=p98536 lab=_83844_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -22600 0 0 {name=X_83844_ }
C {devices/lab_pin.sym} 99140 -22490 0 0 {name=p98537 lab=_46159_/A }
C {devices/lab_pin.sym} 99140 -22450 0 0 {name=p98538 lab=_55176_/Y }
C {devices/lab_pin.sym} 99140 -22410 0 0 {name=p98539 lab=_56791_/Y }
C {devices/lab_pin.sym} 99300 -22450 0 1 {name=p98540 lab=_56792_/X }
C {sky130_stdcells/o21a_4.sym} 99220 -22450 0 0 {name=X_56792_ }
C {devices/lab_pin.sym} 99180 -22310 0 0 {name=p98541 lab=_69007_/A }
C {devices/lab_pin.sym} 99260 -22310 0 1 {name=p98542 lab=_68778_/X }
C {sky130_stdcells/buf_2.sym} 99220 -22310 0 0 {name=X_68778_ }
C {devices/lab_pin.sym} 99180 -22190 0 0 {name=p98543 lab=_84826_/Q }
C {devices/lab_pin.sym} 99260 -22190 0 1 {name=p98544 lab=_58533_/A }
C {sky130_stdcells/buf_2.sym} 99220 -22190 0 0 {name=X_58531_ }
C {devices/lab_pin.sym} 99180 -22070 0 0 {name=p98545 lab=clkbuf_9_500_0_CLK/X }
C {devices/lab_pin.sym} 99260 -22070 0 1 {name=p98546 lab=_85888_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 99220 -22070 0 0 {name=Xclkbuf_10_1000_0_CLK }
C {devices/lab_pin.sym} 99180 -21950 0 0 {name=p98547 lab=_55742_/X }
C {devices/lab_pin.sym} 99260 -21950 0 1 {name=p98548 lab=_55743_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -21950 0 0 {name=X_55743_ }
C {devices/lab_pin.sym} 99160 -21840 0 0 {name=p98549 lab=_67678_/X }
C {devices/lab_pin.sym} 99160 -21800 0 0 {name=p98550 lab=_67729_/B }
C {devices/lab_pin.sym} 99280 -21820 0 1 {name=p98551 lab=_67729_/X }
C {sky130_stdcells/and2_4.sym} 99220 -21820 0 0 {name=X_67729_ }
C {devices/lab_pin.sym} 99130 -21690 0 0 {name=p98552 lab=_85888_/CLK }
C {devices/lab_pin.sym} 99130 -21670 0 0 {name=p98553 lab=_86563_/D }
C {devices/lab_pin.sym} 99310 -21690 0 1 {name=p98554 lab=_86563_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -21680 0 0 {name=X_86563_ }
C {devices/lab_pin.sym} 99140 -21570 0 0 {name=p98555 lab=_52951_/Y }
C {devices/lab_pin.sym} 99140 -21530 0 0 {name=p98556 lab=_52946_/X }
C {devices/lab_pin.sym} 99140 -21490 0 0 {name=p98557 lab=_52954_/X }
C {devices/lab_pin.sym} 99300 -21530 0 1 {name=p98558 lab=_85724_/D }
C {sky130_stdcells/a21oi_4.sym} 99220 -21530 0 0 {name=X_52955_ }
C {devices/lab_pin.sym} 99130 -21390 0 0 {name=p98559 lab=_86553_/CLK }
C {devices/lab_pin.sym} 99130 -21370 0 0 {name=p98560 lab=_83775_/D }
C {devices/lab_pin.sym} 99310 -21390 0 1 {name=p98561 lab=_83775_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -21380 0 0 {name=X_83775_ }
C {devices/lab_pin.sym} 99130 -21250 0 0 {name=p98562 lab=_80818_/CLK }
C {devices/lab_pin.sym} 99130 -21230 0 0 {name=p98563 lab=_80987_/D }
C {devices/lab_pin.sym} 99310 -21250 0 1 {name=p98564 lab=_80943_/D }
C {sky130_stdcells/dfxtp_4.sym} 99220 -21240 0 0 {name=X_80987_ }
C {devices/lab_pin.sym} 99130 -21110 0 0 {name=p98565 lab=_86989_/CLK }
C {devices/lab_pin.sym} 99130 -21090 0 0 {name=p98566 lab=_88302_/D }
C {devices/lab_pin.sym} 99310 -21110 0 1 {name=p98567 lab=_69209_/B }
C {sky130_stdcells/dfxtp_4.sym} 99220 -21100 0 0 {name=X_88302_ }
C {devices/lab_pin.sym} 99130 -20970 0 0 {name=p98568 lab=_85514_/CLK }
C {devices/lab_pin.sym} 99130 -20950 0 0 {name=p98569 lab=_85514_/D }
C {devices/lab_pin.sym} 99310 -20970 0 1 {name=p98570 lab=_85514_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -20960 0 0 {name=X_85514_ }
C {devices/lab_pin.sym} 99140 -20850 0 0 {name=p98571 lab=_51903_/Y }
C {devices/lab_pin.sym} 99140 -20810 0 0 {name=p98572 lab=_51904_/X }
C {devices/lab_pin.sym} 99140 -20770 0 0 {name=p98573 lab=_51905_/X }
C {devices/lab_pin.sym} 99300 -20810 0 1 {name=p98574 lab=_51906_/Y }
C {sky130_stdcells/a21oi_4.sym} 99220 -20810 0 0 {name=X_51906_ }
C {devices/lab_pin.sym} 99160 -20680 0 0 {name=p98575 lab=_70740_/A }
C {devices/lab_pin.sym} 99160 -20640 0 0 {name=p98576 lab=_70585_/X }
C {devices/lab_pin.sym} 99280 -20660 0 1 {name=p98577 lab=_70740_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -20660 0 0 {name=X_70740_ }
C {devices/lab_pin.sym} 99140 -20550 0 0 {name=p98578 lab=_58448_/X }
C {devices/lab_pin.sym} 99140 -20510 0 0 {name=p98579 lab=_83475_/Q }
C {devices/lab_pin.sym} 99140 -20470 0 0 {name=p98580 lab=_58461_/Y }
C {devices/lab_pin.sym} 99300 -20510 0 1 {name=p98581 lab=_84843_/D }
C {sky130_stdcells/o21a_4.sym} 99220 -20510 0 0 {name=X_58462_ }
C {devices/lab_pin.sym} 99130 -20370 0 0 {name=p98582 lab=_81190_/CLK }
C {devices/lab_pin.sym} 99130 -20350 0 0 {name=p98583 lab=_84110_/Q }
C {devices/lab_pin.sym} 99310 -20370 0 1 {name=p98584 lab=_82726_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -20360 0 0 {name=X_82726_ }
C {devices/lab_pin.sym} 99160 -20240 0 0 {name=p98585 lab=_55674_/A }
C {devices/lab_pin.sym} 99160 -20200 0 0 {name=p98586 lab=_55674_/B }
C {devices/lab_pin.sym} 99280 -20220 0 1 {name=p98587 lab=_55675_/B }
C {sky130_stdcells/nand2_4.sym} 99220 -20220 0 0 {name=X_55674_ }
C {devices/lab_pin.sym} 99130 -20090 0 0 {name=p98588 lab=_86203_/CLK }
C {devices/lab_pin.sym} 99130 -20070 0 0 {name=p98589 lab=_86494_/D }
C {devices/lab_pin.sym} 99310 -20090 0 1 {name=p98590 lab=_72840_/B }
C {sky130_stdcells/dfxtp_4.sym} 99220 -20080 0 0 {name=X_86494_ }
C {devices/lab_pin.sym} 99140 -19970 0 0 {name=p98591 lab=_85736_/Q }
C {devices/lab_pin.sym} 99140 -19930 0 0 {name=p98592 lab=_52874_/X }
C {devices/lab_pin.sym} 99140 -19890 0 0 {name=p98593 lab=_52885_/Y }
C {devices/lab_pin.sym} 99300 -19930 0 1 {name=p98594 lab=_52886_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -19930 0 0 {name=X_52886_ }
C {devices/lab_pin.sym} 99180 -19790 0 0 {name=p98595 lab=_44037_/X }
C {devices/lab_pin.sym} 99260 -19790 0 1 {name=p98596 lab=_57413_/X }
C {sky130_stdcells/buf_2.sym} 99220 -19790 0 0 {name=X_57413_ }
C {devices/lab_pin.sym} 99130 -19670 0 0 {name=p98597 lab=_88224_/CLK }
C {devices/lab_pin.sym} 99130 -19650 0 0 {name=p98598 lab=_41343_/Y }
C {devices/lab_pin.sym} 99310 -19670 0 1 {name=p98599 lab=_88233_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -19660 0 0 {name=X_88233_ }
C {devices/lab_pin.sym} 99160 -19560 0 0 {name=p98600 lab=_54625_/A }
C {devices/lab_pin.sym} 99160 -19520 0 0 {name=p98601 lab=_54607_/B }
C {devices/lab_pin.sym} 99160 -19480 0 0 {name=p98602 lab=_54618_/X }
C {devices/lab_pin.sym} 99160 -19440 0 0 {name=p98603 lab=_47236_/A }
C {devices/lab_pin.sym} 99280 -19500 0 1 {name=p98604 lab=_54625_/X }
C {sky130_stdcells/and4_4.sym} 99220 -19500 0 0 {name=X_54625_ }
C {devices/lab_pin.sym} 99130 -19350 0 0 {name=p98605 lab=_85767_/CLK }
C {devices/lab_pin.sym} 99130 -19330 0 0 {name=p98606 lab=_54424_/Y }
C {devices/lab_pin.sym} 99310 -19350 0 1 {name=p98607 lab=_85445_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -19340 0 0 {name=X_85445_ }
C {devices/lab_pin.sym} 99180 -19210 0 0 {name=p98608 lab=_51781_/A }
C {devices/lab_pin.sym} 99260 -19210 0 1 {name=p98609 lab=_51851_/C }
C {sky130_stdcells/buf_2.sym} 99220 -19210 0 0 {name=X_51837_ }
C {devices/lab_pin.sym} 99140 -19110 0 0 {name=p98610 lab=_70664_/X }
C {devices/lab_pin.sym} 99140 -19070 0 0 {name=p98611 lab=_83729_/Q }
C {devices/lab_pin.sym} 99140 -19030 0 0 {name=p98612 lab=_70670_/Y }
C {devices/lab_pin.sym} 99300 -19070 0 1 {name=p98613 lab=_70671_/X }
C {sky130_stdcells/a21o_4.sym} 99220 -19070 0 0 {name=X_70671_ }
C {devices/lab_pin.sym} 99180 -18930 0 0 {name=p98614 lab=_84860_/Q }
C {devices/lab_pin.sym} 99260 -18930 0 1 {name=p98615 lab=_58393_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -18930 0 0 {name=X_58393_ }
C {devices/lab_pin.sym} 99130 -18810 0 0 {name=p98616 lab=_84014_/CLK }
C {devices/lab_pin.sym} 99130 -18790 0 0 {name=p98617 lab=_82657_/D }
C {devices/lab_pin.sym} 99310 -18810 0 1 {name=p98618 lab=_82657_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -18800 0 0 {name=X_82657_ }
C {devices/lab_pin.sym} 99180 -18670 0 0 {name=p98619 lab=clkbuf_9_507_0_CLK/X }
C {devices/lab_pin.sym} 99260 -18670 0 1 {name=p98620 lab=_85571_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 99220 -18670 0 0 {name=Xclkbuf_10_1015_0_CLK }
C {devices/lab_pin.sym} 99140 -18570 0 0 {name=p98621 lab=_72352_/X }
C {devices/lab_pin.sym} 99140 -18530 0 0 {name=p98622 lab=_85961_/Q }
C {devices/lab_pin.sym} 99140 -18490 0 0 {name=p98623 lab=_72409_/X }
C {devices/lab_pin.sym} 99300 -18530 0 1 {name=p98624 lab=_72410_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -18530 0 0 {name=X_72410_ }
C {devices/lab_pin.sym} 99180 -18390 0 0 {name=p98625 lab=_57344_/A }
C {devices/lab_pin.sym} 99260 -18390 0 1 {name=p98626 lab=_57344_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -18390 0 0 {name=X_57344_ }
C {devices/lab_pin.sym} 99130 -18270 0 0 {name=p98627 lab=_81582_/CLK }
C {devices/lab_pin.sym} 99130 -18250 0 0 {name=p98628 lab=_81608_/D }
C {devices/lab_pin.sym} 99310 -18270 0 1 {name=p98629 lab=_81800_/D }
C {sky130_stdcells/dfxtp_4.sym} 99220 -18260 0 0 {name=X_81608_ }
C {devices/lab_pin.sym} 99130 -18130 0 0 {name=p98630 lab=_88164_/CLK }
C {devices/lab_pin.sym} 99130 -18110 0 0 {name=p98631 lab=_41712_/Y }
C {devices/lab_pin.sym} 99310 -18130 0 1 {name=p98632 lab=_88164_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -18120 0 0 {name=X_88164_ }
C {devices/lab_pin.sym} 99180 -17990 0 0 {name=p98633 lab=_87816_/Q }
C {devices/lab_pin.sym} 99260 -17990 0 1 {name=p98634 lab=_69710_/B }
C {sky130_stdcells/inv_2.sym} 99220 -17990 0 0 {name=X_42570_ }
C {devices/lab_pin.sym} 99140 -17890 0 0 {name=p98635 lab=_85420_/Q }
C {devices/lab_pin.sym} 99140 -17850 0 0 {name=p98636 lab=_54540_/X }
C {devices/lab_pin.sym} 99140 -17810 0 0 {name=p98637 lab=_54555_/Y }
C {devices/lab_pin.sym} 99300 -17850 0 1 {name=p98638 lab=_54556_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -17850 0 0 {name=X_54556_ }
C {devices/lab_pin.sym} 99130 -17710 0 0 {name=p98639 lab=_83711_/CLK }
C {devices/lab_pin.sym} 99130 -17690 0 0 {name=p98640 lab=_54799_/Y }
C {devices/lab_pin.sym} 99310 -17710 0 1 {name=p98641 lab=_85376_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -17700 0 0 {name=X_85376_ }
C {devices/lab_pin.sym} 99160 -17580 0 0 {name=p98642 lab=_73377_/Y }
C {devices/lab_pin.sym} 99160 -17540 0 0 {name=p98643 lab=_73389_/X }
C {devices/lab_pin.sym} 99280 -17560 0 1 {name=p98644 lab=_73391_/B }
C {sky130_stdcells/xnor2_4.sym} 99220 -17560 0 0 {name=X_73390_ }
C {devices/lab_pin.sym} 99160 -17460 0 0 {name=p98645 lab=_51768_/A }
C {devices/lab_pin.sym} 99160 -17420 0 0 {name=p98646 lab=_51782_/B }
C {devices/lab_pin.sym} 99160 -17380 0 0 {name=p98647 lab=_51755_/X }
C {devices/lab_pin.sym} 99160 -17340 0 0 {name=p98648 lab=_51768_/D }
C {devices/lab_pin.sym} 99280 -17400 0 1 {name=p98649 lab=_51768_/X }
C {sky130_stdcells/and4_4.sym} 99220 -17400 0 0 {name=X_51768_ }
C {devices/lab_pin.sym} 99130 -17250 0 0 {name=p98650 lab=_82589_/CLK }
C {devices/lab_pin.sym} 99130 -17230 0 0 {name=p98651 lab=_82620_/Q }
C {devices/lab_pin.sym} 99310 -17250 0 1 {name=p98652 lab=_78262_/A }
C {sky130_stdcells/dfxtp_4.sym} 99220 -17240 0 0 {name=X_82588_ }
C {devices/lab_pin.sym} 99130 -17110 0 0 {name=p98653 lab=_87684_/CLK }
C {devices/lab_pin.sym} 99130 -17090 0 0 {name=p98654 lab=_87115_/D }
C {devices/lab_pin.sym} 99310 -17110 0 1 {name=p98655 lab=_87115_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -17100 0 0 {name=X_87115_ }
C {devices/lab_pin.sym} 99140 -17010 0 0 {name=p98656 lab=_41489_/X }
C {devices/lab_pin.sym} 99140 -16970 0 0 {name=p98657 lab=_41490_/X }
C {devices/lab_pin.sym} 99140 -16930 0 0 {name=p98658 lab=_41520_/X }
C {devices/lab_pin.sym} 99140 -16890 0 0 {name=p98659 lab=_66857_/B }
C {devices/lab_pin.sym} 99140 -16850 0 0 {name=p98660 lab=_41474_/X }
C {devices/lab_pin.sym} 99300 -16930 0 1 {name=p98661 lab=_41522_/A }
C {sky130_stdcells/o32ai_4.sym} 99220 -16930 0 0 {name=X_41521_ }
C {devices/lab_pin.sym} 99180 -16770 0 0 {name=p98662 lab=_53817_/A }
C {devices/lab_pin.sym} 99260 -16770 0 1 {name=p98663 lab=_53723_/A }
C {sky130_stdcells/buf_2.sym} 99220 -16770 0 0 {name=X_53507_ }
C {devices/lab_pin.sym} 99140 -16670 0 0 {name=p98664 lab=_72305_/X }
C {devices/lab_pin.sym} 99140 -16630 0 0 {name=p98665 lab=_85359_/Q }
C {devices/lab_pin.sym} 99140 -16590 0 0 {name=p98666 lab=_72340_/X }
C {devices/lab_pin.sym} 99300 -16630 0 1 {name=p98667 lab=_72341_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -16630 0 0 {name=X_72341_ }
C {devices/lab_pin.sym} 99130 -16490 0 0 {name=p98668 lab=_84355_/CLK }
C {devices/lab_pin.sym} 99130 -16470 0 0 {name=p98669 lab=_63393_/Y }
C {devices/lab_pin.sym} 99310 -16490 0 1 {name=p98670 lab=_63392_/C }
C {sky130_stdcells/dfxtp_4.sym} 99220 -16480 0 0 {name=X_84327_ }
C {devices/lab_pin.sym} 99160 -16360 0 0 {name=p98671 lab=_50740_/A }
C {devices/lab_pin.sym} 99160 -16320 0 0 {name=p98672 lab=_50719_/B }
C {devices/lab_pin.sym} 99280 -16340 0 1 {name=p98673 lab=_50719_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -16340 0 0 {name=X_50719_ }
C {devices/lab_pin.sym} 99180 -16210 0 0 {name=p98674 lab=_44207_/A }
C {devices/lab_pin.sym} 99260 -16210 0 1 {name=p98675 lab=_57275_/X }
C {sky130_stdcells/buf_2.sym} 99220 -16210 0 0 {name=X_57275_ }
C {devices/lab_pin.sym} 99130 -16090 0 0 {name=p98676 lab=_81351_/CLK }
C {devices/lab_pin.sym} 99130 -16070 0 0 {name=p98677 lab=_81539_/D }
C {devices/lab_pin.sym} 99310 -16090 0 1 {name=p98678 lab=_81539_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -16080 0 0 {name=X_81539_ }
C {devices/lab_pin.sym} 99130 -15950 0 0 {name=p98679 lab=_88111_/CLK }
C {devices/lab_pin.sym} 99130 -15930 0 0 {name=p98680 lab=_41950_/Y }
C {devices/lab_pin.sym} 99310 -15950 0 1 {name=p98681 lab=_74031_/A }
C {sky130_stdcells/dfxtp_4.sym} 99220 -15940 0 0 {name=X_88095_ }
C {devices/lab_pin.sym} 99160 -15820 0 0 {name=p98682 lab=_54486_/X }
C {devices/lab_pin.sym} 99160 -15780 0 0 {name=p98683 lab=_53309_/B }
C {devices/lab_pin.sym} 99280 -15800 0 1 {name=p98684 lab=_54487_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -15800 0 0 {name=X_54487_ }
C {devices/lab_pin.sym} 99160 -15700 0 0 {name=p98685 lab=_51695_/A }
C {devices/lab_pin.sym} 99160 -15660 0 0 {name=p98686 lab=_51715_/B }
C {devices/lab_pin.sym} 99160 -15620 0 0 {name=p98687 lab=_51695_/C }
C {devices/lab_pin.sym} 99160 -15580 0 0 {name=p98688 lab=_53223_/D }
C {devices/lab_pin.sym} 99280 -15640 0 1 {name=p98689 lab=_51699_/X }
C {sky130_stdcells/and4_4.sym} 99220 -15640 0 0 {name=X_51699_ }
C {devices/lab_pin.sym} 99140 -15510 0 0 {name=p98690 lab=_59013_/X }
C {devices/lab_pin.sym} 99140 -15470 0 0 {name=p98691 lab=_85760_/Q }
C {devices/lab_pin.sym} 99140 -15430 0 0 {name=p98692 lab=_58928_/X }
C {devices/lab_pin.sym} 99300 -15470 0 1 {name=p98693 lab=_59014_/X }
C {sky130_stdcells/o21a_4.sym} 99220 -15470 0 0 {name=X_59014_ }
C {devices/lab_pin.sym} 99140 -15350 0 0 {name=p98694 lab=_44226_/Y }
C {devices/lab_pin.sym} 99140 -15310 0 0 {name=p98695 lab=_44232_/Y }
C {devices/lab_pin.sym} 99140 -15270 0 0 {name=p98696 lab=_44256_/A }
C {devices/lab_pin.sym} 99300 -15310 0 1 {name=p98697 lab=_87179_/D }
C {sky130_stdcells/a21oi_4.sym} 99220 -15310 0 0 {name=X_44240_ }
C {devices/lab_pin.sym} 99180 -15170 0 0 {name=p98698 lab=_56252_/A }
C {devices/lab_pin.sym} 99260 -15170 0 1 {name=p98699 lab=_56233_/A }
C {sky130_stdcells/buf_2.sym} 99220 -15170 0 0 {name=X_56226_ }
C {devices/lab_pin.sym} 99160 -15060 0 0 {name=p98700 lab=_80959_/Q }
C {devices/lab_pin.sym} 99160 -15020 0 0 {name=p98701 lab=_75059_/X }
C {devices/lab_pin.sym} 99280 -15040 0 1 {name=p98702 lab=_75060_/X }
C {sky130_stdcells/xor2_4.sym} 99220 -15040 0 0 {name=X_75060_ }
C {devices/lab_pin.sym} 99160 -14920 0 0 {name=p98703 lab=_41452_/A }
C {devices/lab_pin.sym} 99160 -14880 0 0 {name=p98704 lab=_41459_/B }
C {devices/lab_pin.sym} 99280 -14900 0 1 {name=p98705 lab=_41452_/X }
C {sky130_stdcells/or2_4.sym} 99220 -14900 0 0 {name=X_41452_ }
C {devices/lab_pin.sym} 99130 -14770 0 0 {name=p98706 lab=_87285_/CLK }
C {devices/lab_pin.sym} 99130 -14750 0 0 {name=p98707 lab=_87046_/D }
C {devices/lab_pin.sym} 99310 -14770 0 1 {name=p98708 lab=_87046_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -14760 0 0 {name=X_87046_ }
C {devices/lab_pin.sym} 99180 -14630 0 0 {name=p98709 lab=_53357_/A }
C {devices/lab_pin.sym} 99260 -14630 0 1 {name=p98710 lab=_54111_/C }
C {sky130_stdcells/buf_2.sym} 99220 -14630 0 0 {name=X_53438_ }
C {devices/lab_pin.sym} 99160 -14520 0 0 {name=p98711 lab=_72366_/A }
C {devices/lab_pin.sym} 99160 -14480 0 0 {name=p98712 lab=_86293_/Q }
C {devices/lab_pin.sym} 99280 -14500 0 1 {name=p98713 lab=_72272_/Y }
C {sky130_stdcells/nor2_4.sym} 99220 -14500 0 0 {name=X_72272_ }
C {devices/lab_pin.sym} 99130 -14370 0 0 {name=p98714 lab=_83402_/CLK }
C {devices/lab_pin.sym} 99130 -14350 0 0 {name=p98715 lab=_84258_/D }
C {devices/lab_pin.sym} 99310 -14370 0 1 {name=p98716 lab=_79806_/B }
C {sky130_stdcells/dfxtp_4.sym} 99220 -14360 0 0 {name=X_84258_ }
C {devices/lab_pin.sym} 99140 -14250 0 0 {name=p98717 lab=_44719_/Y }
C {devices/lab_pin.sym} 99140 -14210 0 0 {name=p98718 lab=_56183_/X }
C {devices/lab_pin.sym} 99140 -14170 0 0 {name=p98719 lab=_74010_/Y }
C {devices/lab_pin.sym} 99300 -14210 0 1 {name=p98720 lab=_74028_/C }
C {sky130_stdcells/a21o_4.sym} 99220 -14210 0 0 {name=X_74011_ }
C {devices/lab_pin.sym} 99140 -14090 0 0 {name=p98721 lab=_40325_/X }
C {devices/lab_pin.sym} 99140 -14050 0 0 {name=p98722 lab=_82330_/Q }
C {devices/lab_pin.sym} 99140 -14010 0 0 {name=p98723 lab=_40402_/X }
C {devices/lab_pin.sym} 99300 -14050 0 1 {name=p98724 lab=_40403_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -14050 0 0 {name=X_40403_ }
C {devices/lab_pin.sym} 99160 -13930 0 0 {name=p98725 lab=_71232_/A }
C {devices/lab_pin.sym} 99160 -13890 0 0 {name=p98726 lab=_71223_/B }
C {devices/lab_pin.sym} 99160 -13850 0 0 {name=p98727 lab=_71219_/C }
C {devices/lab_pin.sym} 99280 -13890 0 1 {name=p98728 lab=_71223_/Y }
C {sky130_stdcells/nand3_4.sym} 99220 -13890 0 0 {name=X_71223_ }
C {devices/lab_pin.sym} 99130 -13750 0 0 {name=p98729 lab=_83095_/CLK }
C {devices/lab_pin.sym} 99130 -13730 0 0 {name=p98730 lab=_72636_/X }
C {devices/lab_pin.sym} 99310 -13750 0 1 {name=p98731 lab=_70165_/A }
C {sky130_stdcells/dfxtp_4.sym} 99220 -13740 0 0 {name=X_83209_ }
C {devices/lab_pin.sym} 99180 -13610 0 0 {name=p98732 lab=_65768_/A }
C {devices/lab_pin.sym} 99260 -13610 0 1 {name=p98733 lab=_44171_/X }
C {sky130_stdcells/buf_2.sym} 99220 -13610 0 0 {name=X_44171_ }
C {devices/lab_pin.sym} 99160 -13510 0 0 {name=p98734 lab=_56163_/A }
C {devices/lab_pin.sym} 99160 -13470 0 0 {name=p98735 lab=_56167_/B }
C {devices/lab_pin.sym} 99160 -13430 0 0 {name=p98736 lab=_56167_/A }
C {devices/lab_pin.sym} 99280 -13470 0 1 {name=p98737 lab=_56157_/Y }
C {sky130_stdcells/nand3_4.sym} 99220 -13470 0 0 {name=X_56157_ }
C {devices/lab_pin.sym} 99140 -13370 0 0 {name=p98738 lab=_41337_/X }
C {devices/lab_pin.sym} 99140 -13330 0 0 {name=p98739 lab=_41338_/X }
C {devices/lab_pin.sym} 99140 -13290 0 0 {name=p98740 lab=_41382_/X }
C {devices/lab_pin.sym} 99140 -13250 0 0 {name=p98741 lab=_67767_/B }
C {devices/lab_pin.sym} 99140 -13210 0 0 {name=p98742 lab=_41333_/X }
C {devices/lab_pin.sym} 99300 -13290 0 1 {name=p98743 lab=_41383_/Y }
C {sky130_stdcells/o32ai_4.sym} 99220 -13290 0 0 {name=X_41383_ }
C {devices/lab_pin.sym} 99160 -13140 0 0 {name=p98744 lab=_53353_/A }
C {devices/lab_pin.sym} 99160 -13100 0 0 {name=p98745 lab=_53369_/B }
C {devices/lab_pin.sym} 99280 -13120 0 1 {name=p98746 lab=_53369_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -13120 0 0 {name=X_53369_ }
C {devices/lab_pin.sym} 99130 -12990 0 0 {name=p98747 lab=_84192_/CLK }
C {devices/lab_pin.sym} 99130 -12970 0 0 {name=p98748 lab=_84189_/D }
C {devices/lab_pin.sym} 99310 -12990 0 1 {name=p98749 lab=_84189_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -12980 0 0 {name=X_84189_ }
C {devices/lab_pin.sym} 99140 -12890 0 0 {name=p98750 lab=_43100_/X }
C {devices/lab_pin.sym} 99140 -12850 0 0 {name=p98751 lab=_43110_/X }
C {devices/lab_pin.sym} 99140 -12810 0 0 {name=p98752 lab=_40787_/X }
C {devices/lab_pin.sym} 99140 -12770 0 0 {name=p98753 lab=_72859_/A }
C {devices/lab_pin.sym} 99140 -12730 0 0 {name=p98754 lab=_43121_/X }
C {devices/lab_pin.sym} 99300 -12810 0 1 {name=p98755 lab=_43123_/A }
C {sky130_stdcells/o32ai_4.sym} 99220 -12810 0 0 {name=X_43122_ }
C {devices/lab_pin.sym} 99160 -12680 0 0 {name=p98756 lab=_55112_/A }
C {devices/lab_pin.sym} 99160 -12640 0 0 {name=p98757 lab=_47877_/A }
C {devices/lab_pin.sym} 99160 -12600 0 0 {name=p98758 lab=_55120_/C }
C {devices/lab_pin.sym} 99160 -12560 0 0 {name=p98759 lab=_47794_/A }
C {devices/lab_pin.sym} 99280 -12620 0 1 {name=p98760 lab=_55108_/X }
C {sky130_stdcells/and4_4.sym} 99220 -12620 0 0 {name=X_55108_ }
C {devices/lab_pin.sym} 99180 -12470 0 0 {name=p98761 lab=_86757_/Q }
C {devices/lab_pin.sym} 99260 -12470 0 1 {name=p98762 lab=_40335_/B }
C {sky130_stdcells/inv_2.sym} 99220 -12470 0 0 {name=X_40334_ }
C {devices/lab_pin.sym} 99180 -12350 0 0 {name=p98763 lab=_70716_/A }
C {devices/lab_pin.sym} 99260 -12350 0 1 {name=p98764 lab=_71160_/C }
C {sky130_stdcells/buf_2.sym} 99220 -12350 0 0 {name=X_71154_ }
C {devices/lab_pin.sym} 99160 -12240 0 0 {name=p98765 lab=_56088_/A }
C {devices/lab_pin.sym} 99160 -12200 0 0 {name=p98766 lab=_55842_/X }
C {devices/lab_pin.sym} 99280 -12220 0 1 {name=p98767 lab=_56088_/X }
C {sky130_stdcells/and2_4.sym} 99220 -12220 0 0 {name=X_56088_ }
C {devices/lab_pin.sym} 99180 -12090 0 0 {name=p98768 lab=_83137_/Q }
C {devices/lab_pin.sym} 99260 -12090 0 1 {name=p98769 lab=_70107_/C }
C {sky130_stdcells/inv_2.sym} 99220 -12090 0 0 {name=X_70105_ }
C {devices/lab_pin.sym} 99180 -11970 0 0 {name=p98770 lab=_83776_/Q }
C {devices/lab_pin.sym} 99260 -11970 0 1 {name=p98771 lab=_53501_/B }
C {sky130_stdcells/inv_2.sym} 99220 -11970 0 0 {name=X_47930_ }
C {devices/lab_pin.sym} 99160 -11880 0 0 {name=p98772 lab=_55017_/X }
C {devices/lab_pin.sym} 99160 -11840 0 0 {name=p98773 lab=_55030_/X }
C {devices/lab_pin.sym} 99160 -11800 0 0 {name=p98774 lab=_55026_/C }
C {devices/lab_pin.sym} 99160 -11760 0 0 {name=p98775 lab=_47675_/A }
C {devices/lab_pin.sym} 99280 -11820 0 1 {name=p98776 lab=_55039_/X }
C {sky130_stdcells/and4_4.sym} 99220 -11820 0 0 {name=X_55039_ }
C {devices/lab_pin.sym} 99160 -11700 0 0 {name=p98777 lab=_59660_/C }
C {devices/lab_pin.sym} 99160 -11660 0 0 {name=p98778 lab=_60620_/C }
C {devices/lab_pin.sym} 99160 -11620 0 0 {name=p98779 lab=_59660_/D }
C {devices/lab_pin.sym} 99160 -11580 0 0 {name=p98780 lab=_60620_/B }
C {devices/lab_pin.sym} 99280 -11640 0 1 {name=p98781 lab=_60155_/C }
C {sky130_stdcells/and4_4.sym} 99220 -11640 0 0 {name=X_59916_ }
C {devices/lab_pin.sym} 99180 -11490 0 0 {name=p98782 lab=_43129_/A }
C {devices/lab_pin.sym} 99260 -11490 0 1 {name=p98783 lab=_43053_/X }
C {sky130_stdcells/buf_2.sym} 99220 -11490 0 0 {name=X_43053_ }
C {devices/lab_pin.sym} 99160 -11380 0 0 {name=p98784 lab=_78750_/A }
C {devices/lab_pin.sym} 99160 -11340 0 0 {name=p98785 lab=_82687_/D }
C {devices/lab_pin.sym} 99280 -11360 0 1 {name=p98786 lab=_78753_/B }
C {sky130_stdcells/nor2_4.sym} 99220 -11360 0 0 {name=X_78750_ }
C {devices/lab_pin.sym} 99180 -11230 0 0 {name=p98787 lab=_70819_/A }
C {devices/lab_pin.sym} 99260 -11230 0 1 {name=p98788 lab=_71230_/B }
C {sky130_stdcells/buf_2.sym} 99220 -11230 0 0 {name=X_71085_ }
C {devices/lab_pin.sym} 99140 -11130 0 0 {name=p98789 lab=_75956_/Y }
C {devices/lab_pin.sym} 99140 -11090 0 0 {name=p98790 lab=_75963_/C }
C {devices/lab_pin.sym} 99140 -11050 0 0 {name=p98791 lab=_75961_/Y }
C {devices/lab_pin.sym} 99300 -11090 0 1 {name=p98792 lab=_75964_/A }
C {sky130_stdcells/a21o_4.sym} 99220 -11090 0 0 {name=X_75962_ }
C {devices/lab_pin.sym} 99130 -10950 0 0 {name=p98793 lab=_87952_/CLK }
C {devices/lab_pin.sym} 99130 -10930 0 0 {name=p98794 lab=_42269_/Y }
C {devices/lab_pin.sym} 99310 -10950 0 1 {name=p98795 lab=_87948_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -10940 0 0 {name=X_87948_ }
C {devices/lab_pin.sym} 99180 -10810 0 0 {name=p98796 lab=_88074_/Q }
C {devices/lab_pin.sym} 99260 -10810 0 1 {name=p98797 lab=_42004_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -10810 0 0 {name=X_42004_ }
C {devices/lab_pin.sym} 99160 -10700 0 0 {name=p98798 lab=_77701_/A }
C {devices/lab_pin.sym} 99160 -10660 0 0 {name=p98799 lab=_77700_/X }
C {devices/lab_pin.sym} 99280 -10680 0 1 {name=p98800 lab=_77702_/A }
C {sky130_stdcells/xor2_4.sym} 99220 -10680 0 0 {name=X_77701_ }
C {devices/lab_pin.sym} 99160 -10560 0 0 {name=p98801 lab=_74905_/A }
C {devices/lab_pin.sym} 99160 -10520 0 0 {name=p98802 lab=_74910_/A }
C {devices/lab_pin.sym} 99280 -10540 0 1 {name=p98803 lab=_74914_/B }
C {sky130_stdcells/and2_4.sym} 99220 -10540 0 0 {name=X_74913_ }
C {devices/lab_pin.sym} 99140 -10430 0 0 {name=p98804 lab=_82547_/D }
C {devices/lab_pin.sym} 99140 -10390 0 0 {name=p98805 lab=_70029_/X }
C {devices/lab_pin.sym} 99140 -10350 0 0 {name=p98806 lab=_70035_/X }
C {devices/lab_pin.sym} 99300 -10390 0 1 {name=p98807 lab=_70036_/X }
C {sky130_stdcells/a21bo_4.sym} 99220 -10390 0 0 {name=X_70036_ }
C {devices/lab_pin.sym} 99160 -10260 0 0 {name=p98808 lab=_47887_/A }
C {devices/lab_pin.sym} 99160 -10220 0 0 {name=p98809 lab=_47861_/B }
C {devices/lab_pin.sym} 99280 -10240 0 1 {name=p98810 lab=_47861_/X }
C {sky130_stdcells/and2_4.sym} 99220 -10240 0 0 {name=X_47861_ }
C {devices/lab_pin.sym} 99140 -10150 0 0 {name=p98811 lab=_43969_/A }
C {devices/lab_pin.sym} 99140 -10110 0 0 {name=p98812 lab=_59741_/A }
C {devices/lab_pin.sym} 99140 -10070 0 0 {name=p98813 lab=_59581_/C }
C {devices/lab_pin.sym} 99140 -10030 0 0 {name=p98814 lab=_43969_/B }
C {devices/lab_pin.sym} 99140 -10000 0 0 {name=p98815 lab=_59846_/X }
C {devices/lab_pin.sym} 99300 -10070 0 1 {name=p98816 lab=_59847_/Y }
C {sky130_stdcells/a41oi_4.sym} 99220 -10070 0 0 {name=X_59847_ }
C {devices/lab_pin.sym} 99180 -9910 0 0 {name=p98817 lab=_78680_/Y }
C {devices/lab_pin.sym} 99260 -9910 0 1 {name=p98818 lab=_78682_/C }
C {sky130_stdcells/inv_2.sym} 99220 -9910 0 0 {name=X_78681_ }
C {devices/lab_pin.sym} 99160 -9800 0 0 {name=p98819 lab=_84491_/Q }
C {devices/lab_pin.sym} 99160 -9760 0 0 {name=p98820 lab=_62988_/C }
C {devices/lab_pin.sym} 99280 -9780 0 1 {name=p98821 lab=_75893_/X }
C {sky130_stdcells/xor2_4.sym} 99220 -9780 0 0 {name=X_75893_ }
C {devices/lab_pin.sym} 99130 -9650 0 0 {name=p98822 lab=_87883_/CLK }
C {devices/lab_pin.sym} 99130 -9630 0 0 {name=p98823 lab=_42405_/Y }
C {devices/lab_pin.sym} 99310 -9650 0 1 {name=p98824 lab=_87879_/Q }
C {sky130_stdcells/dfxtp_4.sym} 99220 -9640 0 0 {name=X_87879_ }
C {devices/lab_pin.sym} 99160 -9520 0 0 {name=p98825 lab=_49580_/X }
C {devices/lab_pin.sym} 99160 -9480 0 0 {name=p98826 lab=_52813_/B }
C {devices/lab_pin.sym} 99280 -9500 0 1 {name=p98827 lab=_49600_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -9500 0 0 {name=X_49600_ }
C {devices/lab_pin.sym} 99140 -9390 0 0 {name=p98828 lab=_46807_/Y }
C {devices/lab_pin.sym} 99140 -9350 0 0 {name=p98829 lab=_46798_/X }
C {devices/lab_pin.sym} 99140 -9310 0 0 {name=p98830 lab=_46811_/X }
C {devices/lab_pin.sym} 99300 -9350 0 1 {name=p98831 lab=_86701_/D }
C {sky130_stdcells/a21oi_4.sym} 99220 -9350 0 0 {name=X_46812_ }
C {devices/lab_pin.sym} 99180 -9210 0 0 {name=p98832 lab=_77632_/A }
C {devices/lab_pin.sym} 99260 -9210 0 1 {name=p98833 lab=_77632_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -9210 0 0 {name=X_77632_ }
C {devices/lab_pin.sym} 99160 -9100 0 0 {name=p98834 lab=_74844_/A }
C {devices/lab_pin.sym} 99160 -9060 0 0 {name=p98835 lab=_46099_/X }
C {devices/lab_pin.sym} 99280 -9080 0 1 {name=p98836 lab=_74844_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -9080 0 0 {name=X_74844_ }
C {devices/lab_pin.sym} 99180 -8950 0 0 {name=p98837 lab=_47792_/A }
C {devices/lab_pin.sym} 99260 -8950 0 1 {name=p98838 lab=_49364_/B }
C {sky130_stdcells/buf_2.sym} 99220 -8950 0 0 {name=X_47792_ }
C {devices/lab_pin.sym} 99160 -8850 0 0 {name=p98839 lab=_59772_/A }
C {devices/lab_pin.sym} 99160 -8810 0 0 {name=p98840 lab=_59837_/B }
C {devices/lab_pin.sym} 99160 -8770 0 0 {name=p98841 lab=_80506_/A }
C {devices/lab_pin.sym} 99280 -8810 0 1 {name=p98842 lab=_59778_/Y }
C {sky130_stdcells/nor3_4.sym} 99220 -8810 0 0 {name=X_59778_ }
C {devices/lab_pin.sym} 99140 -8690 0 0 {name=p98843 lab=_58957_/B }
C {devices/lab_pin.sym} 99140 -8650 0 0 {name=p98844 lab=_49524_/X }
C {devices/lab_pin.sym} 99140 -8610 0 0 {name=p98845 lab=_49530_/Y }
C {devices/lab_pin.sym} 99300 -8650 0 1 {name=p98846 lab=_49531_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -8650 0 0 {name=X_49531_ }
C {devices/lab_pin.sym} 99180 -8510 0 0 {name=p98847 lab=_82964_/Q }
C {devices/lab_pin.sym} 99260 -8510 0 1 {name=p98848 lab=_46743_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -8510 0 0 {name=X_46743_ }
C {devices/lab_pin.sym} 99140 -8430 0 0 {name=p98849 lab=_58696_/X }
C {devices/lab_pin.sym} 99140 -8390 0 0 {name=p98850 lab=_58726_/Y }
C {devices/lab_pin.sym} 99140 -8350 0 0 {name=p98851 lab=_58727_/Y }
C {devices/lab_pin.sym} 99140 -8310 0 0 {name=p98852 lab=_58728_/X }
C {devices/lab_pin.sym} 99140 -8270 0 0 {name=p98853 lab=_58701_/X }
C {devices/lab_pin.sym} 99300 -8350 0 1 {name=p98854 lab=_58729_/X }
C {sky130_stdcells/o32a_4.sym} 99220 -8350 0 0 {name=X_58729_ }
C {devices/lab_pin.sym} 99140 -8210 0 0 {name=p98855 lab=_77526_/Y }
C {devices/lab_pin.sym} 99140 -8170 0 0 {name=p98856 lab=_77561_/X }
C {devices/lab_pin.sym} 99140 -8130 0 0 {name=p98857 lab=_77562_/Y }
C {devices/lab_pin.sym} 99300 -8170 0 1 {name=p98858 lab=_77564_/B }
C {sky130_stdcells/a21oi_4.sym} 99220 -8170 0 0 {name=X_77563_ }
C {devices/lab_pin.sym} 99180 -8030 0 0 {name=p98859 lab=_80669_/Q }
C {devices/lab_pin.sym} 99260 -8030 0 1 {name=p98860 lab=_43955_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -8030 0 0 {name=X_43955_ }
C {devices/lab_pin.sym} 99160 -7940 0 0 {name=p98861 lab=_74775_/A }
C {devices/lab_pin.sym} 99160 -7900 0 0 {name=p98862 lab=_74775_/B }
C {devices/lab_pin.sym} 99160 -7860 0 0 {name=p98863 lab=_71846_/A }
C {devices/lab_pin.sym} 99160 -7820 0 0 {name=p98864 lab=_70500_/B }
C {devices/lab_pin.sym} 99280 -7880 0 1 {name=p98865 lab=_74775_/X }
C {sky130_stdcells/and4_4.sym} 99220 -7880 0 0 {name=X_74775_ }
C {devices/lab_pin.sym} 99160 -7740 0 0 {name=p98866 lab=_72007_/A }
C {devices/lab_pin.sym} 99160 -7700 0 0 {name=p98867 lab=_71987_/B }
C {devices/lab_pin.sym} 99280 -7720 0 1 {name=p98868 lab=_71987_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -7720 0 0 {name=X_71987_ }
C {devices/lab_pin.sym} 99160 -7600 0 0 {name=p98869 lab=_79302_/A }
C {devices/lab_pin.sym} 99160 -7560 0 0 {name=p98870 lab=_79301_/X }
C {devices/lab_pin.sym} 99280 -7580 0 1 {name=p98871 lab=_79302_/Y }
C {sky130_stdcells/xnor2_4.sym} 99220 -7580 0 0 {name=X_79302_ }
C {devices/lab_pin.sym} 99180 -7450 0 0 {name=p98872 lab=clkbuf_9_341_0_CLK/X }
C {devices/lab_pin.sym} 99260 -7450 0 1 {name=p98873 lab=_87720_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 99220 -7450 0 0 {name=Xclkbuf_10_682_0_CLK }
C {devices/lab_pin.sym} 99180 -7330 0 0 {name=p98874 lab=_76514_/A }
C {devices/lab_pin.sym} 99260 -7330 0 1 {name=p98875 lab=_76514_/Y }
C {sky130_stdcells/inv_2.sym} 99220 -7330 0 0 {name=X_76514_ }
C {devices/lab_pin.sym} 99140 -7250 0 0 {name=p98876 lab=_42895_/X }
C {devices/lab_pin.sym} 99140 -7210 0 0 {name=p98877 lab=_42896_/X }
C {devices/lab_pin.sym} 99140 -7170 0 0 {name=p98878 lab=_41676_/X }
C {devices/lab_pin.sym} 99140 -7130 0 0 {name=p98879 lab=_87659_/Q }
C {devices/lab_pin.sym} 99140 -7090 0 0 {name=p98880 lab=_42905_/X }
C {devices/lab_pin.sym} 99300 -7170 0 1 {name=p98881 lab=_42907_/A }
C {sky130_stdcells/o32ai_4.sym} 99220 -7170 0 0 {name=X_42906_ }
C {devices/lab_pin.sym} 99160 -7040 0 0 {name=p98882 lab=_49467_/A }
C {devices/lab_pin.sym} 99160 -7000 0 0 {name=p98883 lab=_49456_/B }
C {devices/lab_pin.sym} 99160 -6960 0 0 {name=p98884 lab=_49447_/C }
C {devices/lab_pin.sym} 99160 -6920 0 0 {name=p98885 lab=_46791_/X }
C {devices/lab_pin.sym} 99280 -6980 0 1 {name=p98886 lab=_49462_/X }
C {sky130_stdcells/and4_4.sym} 99220 -6980 0 0 {name=X_49462_ }
C {devices/lab_pin.sym} 99180 -6830 0 0 {name=p98887 lab=_59664_/C }
C {devices/lab_pin.sym} 99260 -6830 0 1 {name=p98888 lab=_61777_/A }
C {sky130_stdcells/buf_2.sym} 99220 -6830 0 0 {name=X_61740_ }
C {devices/lab_pin.sym} 99140 -6740 0 0 {name=p98889 lab=_43043_/Y }
C {devices/lab_pin.sym} 99140 -6700 0 0 {name=p98890 lab=_73627_/X }
C {devices/lab_pin.sym} 99140 -6660 0 0 {name=p98891 lab=_73652_/X }
C {devices/lab_pin.sym} 99140 -6620 0 0 {name=p98892 lab=_73725_/Y }
C {devices/lab_pin.sym} 99300 -6680 0 1 {name=p98893 lab=_73726_/X }
C {sky130_stdcells/a211o_4.sym} 99220 -6680 0 0 {name=X_73726_ }
C {devices/lab_pin.sym} 99180 -6530 0 0 {name=p98894 lab=_46720_/A }
C {devices/lab_pin.sym} 99260 -6530 0 1 {name=p98895 lab=_46712_/A }
C {sky130_stdcells/buf_2.sym} 99220 -6530 0 0 {name=X_46674_ }
C {devices/lab_pin.sym} 99180 -6410 0 0 {name=p98896 lab=_70935_/A }
C {devices/lab_pin.sym} 99260 -6410 0 1 {name=p98897 lab=_70939_/A }
C {sky130_stdcells/buf_2.sym} 99220 -6410 0 0 {name=X_70938_ }
C {devices/lab_pin.sym} 99140 -6310 0 0 {name=p98898 lab=_77495_/A }
C {devices/lab_pin.sym} 99140 -6270 0 0 {name=p98899 lab=_77491_/Y }
C {devices/lab_pin.sym} 99140 -6230 0 0 {name=p98900 lab=_77493_/Y }
C {devices/lab_pin.sym} 99300 -6270 0 1 {name=p98901 lab=_77496_/A }
C {sky130_stdcells/a21o_4.sym} 99220 -6270 0 0 {name=X_77494_ }
C {devices/lab_pin.sym} 99180 -6130 0 0 {name=p98902 lab=_43842_/A }
C {devices/lab_pin.sym} 99260 -6130 0 1 {name=p98903 lab=_43886_/X }
C {sky130_stdcells/buf_2.sym} 99220 -6130 0 0 {name=X_43886_ }
C {devices/lab_pin.sym} 99140 -6030 0 0 {name=p98904 lab=_86524_/Q }
C {devices/lab_pin.sym} 99140 -5990 0 0 {name=p98905 lab=_48333_/X }
C {devices/lab_pin.sym} 99140 -5950 0 0 {name=p98906 lab=_48412_/Y }
C {devices/lab_pin.sym} 99300 -5990 0 1 {name=p98907 lab=_48413_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -5990 0 0 {name=X_48413_ }
C {devices/lab_pin.sym} 99180 -5850 0 0 {name=p98908 lab=_79233_/A }
C {devices/lab_pin.sym} 99260 -5850 0 1 {name=p98909 lab=_79248_/C }
C {sky130_stdcells/buf_2.sym} 99220 -5850 0 0 {name=X_79233_ }
C {devices/lab_pin.sym} 99140 -5750 0 0 {name=p98910 lab=_45619_/X }
C {devices/lab_pin.sym} 99140 -5710 0 0 {name=p98911 lab=_45622_/X }
C {devices/lab_pin.sym} 99140 -5670 0 0 {name=p98912 lab=_45624_/Y }
C {devices/lab_pin.sym} 99300 -5710 0 1 {name=p98913 lab=_86865_/D }
C {sky130_stdcells/a21oi_4.sym} 99220 -5710 0 0 {name=X_45625_ }
C {devices/lab_pin.sym} 99180 -5570 0 0 {name=p98914 lab=clkbuf_8_86_0_CLK/X }
C {devices/lab_pin.sym} 99260 -5570 0 1 {name=p98915 lab=clkbuf_9_173_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 99220 -5570 0 0 {name=Xclkbuf_9_173_0_CLK }
C {devices/lab_pin.sym} 99140 -5470 0 0 {name=p98916 lab=_76425_/X }
C {devices/lab_pin.sym} 99140 -5430 0 0 {name=p98917 lab=_76444_/Y }
C {devices/lab_pin.sym} 99140 -5390 0 0 {name=p98918 lab=_76417_/Y }
C {devices/lab_pin.sym} 99300 -5430 0 1 {name=p98919 lab=_76445_/Y }
C {sky130_stdcells/o21ai_4.sym} 99220 -5430 0 0 {name=X_76445_ }
C {devices/lab_pin.sym} 99140 -5330 0 0 {name=p98920 lab=_42816_/X }
C {devices/lab_pin.sym} 99140 -5290 0 0 {name=p98921 lab=_42817_/X }
C {devices/lab_pin.sym} 99140 -5250 0 0 {name=p98922 lab=_41493_/X }
C {devices/lab_pin.sym} 99140 -5210 0 0 {name=p98923 lab=_66710_/B }
C {devices/lab_pin.sym} 99140 -5170 0 0 {name=p98924 lab=_42836_/X }
C {devices/lab_pin.sym} 99300 -5250 0 1 {name=p98925 lab=_42837_/Y }
C {sky130_stdcells/o32ai_4.sym} 99220 -5250 0 0 {name=X_42837_ }
C {devices/lab_pin.sym} 99160 -5110 0 0 {name=p98926 lab=_61690_/A }
C {devices/lab_pin.sym} 99160 -5070 0 0 {name=p98927 lab=_61690_/B }
C {devices/lab_pin.sym} 99160 -5030 0 0 {name=p98928 lab=_79129_/B }
C {devices/lab_pin.sym} 99280 -5070 0 1 {name=p98929 lab=_61671_/Y }
C {sky130_stdcells/nor3_4.sym} 99220 -5070 0 0 {name=X_61671_ }
C {devices/lab_pin.sym} 99140 -4950 0 0 {name=p98930 lab=_49391_/Y }
C {devices/lab_pin.sym} 99140 -4910 0 0 {name=p98931 lab=_49378_/X }
C {devices/lab_pin.sym} 99140 -4870 0 0 {name=p98932 lab=_49392_/X }
C {devices/lab_pin.sym} 99300 -4910 0 1 {name=p98933 lab=_86396_/D }
C {sky130_stdcells/a21oi_4.sym} 99220 -4910 0 0 {name=X_49393_ }
C {devices/lab_pin.sym} 99140 -4790 0 0 {name=p98934 lab=_88367_/Q }
C {devices/lab_pin.sym} 99140 -4750 0 0 {name=p98935 lab=_73279_/X }
C {devices/lab_pin.sym} 99140 -4710 0 0 {name=p98936 lab=_73656_/X }
C {devices/lab_pin.sym} 99300 -4750 0 1 {name=p98937 lab=_73657_/X }
C {sky130_stdcells/o21a_4.sym} 99220 -4750 0 0 {name=X_73657_ }
C {devices/lab_pin.sym} 99160 -4640 0 0 {name=p98938 lab=_70869_/A }
C {devices/lab_pin.sym} 99160 -4600 0 0 {name=p98939 lab=_70869_/B }
C {devices/lab_pin.sym} 99160 -4560 0 0 {name=p98940 lab=_70869_/C }
C {devices/lab_pin.sym} 99160 -4520 0 0 {name=p98941 lab=_70869_/D }
C {devices/lab_pin.sym} 99280 -4580 0 1 {name=p98942 lab=_70869_/Y }
C {sky130_stdcells/nand4_4.sym} 99220 -4580 0 0 {name=X_70869_ }
C {devices/lab_pin.sym} 99160 -4460 0 0 {name=p98943 lab=_63410_/A }
C {devices/lab_pin.sym} 99160 -4420 0 0 {name=p98944 lab=_63410_/B }
C {devices/lab_pin.sym} 99160 -4380 0 0 {name=p98945 lab=_63410_/C }
C {devices/lab_pin.sym} 99160 -4340 0 0 {name=p98946 lab=_63410_/D }
C {devices/lab_pin.sym} 99280 -4400 0 1 {name=p98947 lab=_63410_/X }
C {sky130_stdcells/and4_4.sym} 99220 -4400 0 0 {name=X_63410_ }
C {devices/lab_pin.sym} 99140 -4270 0 0 {name=p98948 lab=_48341_/Y }
C {devices/lab_pin.sym} 99140 -4230 0 0 {name=p98949 lab=_48322_/X }
C {devices/lab_pin.sym} 99140 -4190 0 0 {name=p98950 lab=_48343_/Y }
C {devices/lab_pin.sym} 99300 -4230 0 1 {name=p98951 lab=_86532_/D }
C {sky130_stdcells/a21boi_4.sym} 99220 -4230 0 0 {name=X_48344_ }
C {devices/lab_pin.sym} 99160 -4120 0 0 {name=p98952 lab=_60622_/A }
C {devices/lab_pin.sym} 99160 -4080 0 0 {name=p98953 lab=_60616_/Y }
C {devices/lab_pin.sym} 99160 -4040 0 0 {name=p98954 lab=_60622_/C }
C {devices/lab_pin.sym} 99160 -4000 0 0 {name=p98955 lab=_60622_/D }
C {devices/lab_pin.sym} 99280 -4060 0 1 {name=p98956 lab=_60655_/A }
C {sky130_stdcells/and4_4.sym} 99220 -4060 0 0 {name=X_60622_ }
C {devices/lab_pin.sym} 99160 -3930 0 0 {name=p98957 lab=_72607_/Y }
C {devices/lab_pin.sym} 99160 -3890 0 0 {name=p98958 lab=_72572_/A }
C {devices/lab_pin.sym} 99160 -3850 0 0 {name=p98959 lab=_72572_/B }
C {devices/lab_pin.sym} 99280 -3890 0 1 {name=p98960 lab=_72608_/Y }
C {sky130_stdcells/nand3_4.sym} 99220 -3890 0 0 {name=X_72608_ }
C {devices/lab_pin.sym} 99140 -3770 0 0 {name=p98961 lab=_79161_/Y }
C {devices/lab_pin.sym} 99140 -3730 0 0 {name=p98962 lab=_79524_/A }
C {devices/lab_pin.sym} 99140 -3690 0 0 {name=p98963 lab=_79163_/Y }
C {devices/lab_pin.sym} 99300 -3730 0 1 {name=p98964 lab=_79164_/Y }
C {sky130_stdcells/a21boi_4.sym} 99220 -3730 0 0 {name=X_79164_ }
C {devices/lab_pin.sym} 99180 -3590 0 0 {name=p98965 lab=_45709_/A }
C {devices/lab_pin.sym} 99260 -3590 0 1 {name=p98966 lab=_45556_/X }
C {sky130_stdcells/buf_2.sym} 99220 -3590 0 0 {name=X_45556_ }
C {devices/lab_pin.sym} 99160 -3500 0 0 {name=p98967 lab=_64363_/A }
C {devices/lab_pin.sym} 99160 -3460 0 0 {name=p98968 lab=_64363_/B }
C {devices/lab_pin.sym} 99160 -3420 0 0 {name=p98969 lab=_84954_/Q }
C {devices/lab_pin.sym} 99160 -3380 0 0 {name=p98970 lab=_61145_/X }
C {devices/lab_pin.sym} 99280 -3440 0 1 {name=p98971 lab=_64390_/X }
C {sky130_stdcells/and4_4.sym} 99220 -3440 0 0 {name=X_64390_ }
C {devices/lab_pin.sym} 99140 -3310 0 0 {name=p98972 lab=_76369_/A }
C {devices/lab_pin.sym} 99140 -3270 0 0 {name=p98973 lab=_76369_/B }
C {devices/lab_pin.sym} 99140 -3230 0 0 {name=p98974 lab=_76368_/A }
C {devices/lab_pin.sym} 99300 -3270 0 1 {name=p98975 lab=_76376_/X }
C {sky130_stdcells/o21a_4.sym} 99220 -3270 0 0 {name=X_76376_ }
C {devices/lab_pin.sym} 99180 -3130 0 0 {name=p98976 lab=_42822_/A }
C {devices/lab_pin.sym} 99260 -3130 0 1 {name=p98977 lab=_42768_/X }
C {sky130_stdcells/buf_2.sym} 99220 -3130 0 0 {name=X_42768_ }
C {devices/lab_pin.sym} 99160 -3020 0 0 {name=p98978 lab=_73588_/A }
C {devices/lab_pin.sym} 99160 -2980 0 0 {name=p98979 lab=_73588_/B }
C {devices/lab_pin.sym} 99280 -3000 0 1 {name=p98980 lab=_73588_/X }
C {sky130_stdcells/and2_4.sym} 99220 -3000 0 0 {name=X_73588_ }
C {devices/lab_pin.sym} 99180 -2870 0 0 {name=p98981 lab=clkbuf_9_348_0_CLK/X }
C {devices/lab_pin.sym} 99260 -2870 0 1 {name=p98982 lab=_87382_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 99220 -2870 0 0 {name=Xclkbuf_10_697_0_CLK }
C {devices/lab_pin.sym} 99160 -2760 0 0 {name=p98983 lab=_82567_/Q }
C {devices/lab_pin.sym} 99160 -2720 0 0 {name=p98984 lab=_78108_/B }
C {devices/lab_pin.sym} 99280 -2740 0 1 {name=p98985 lab=_78115_/Y }
C {sky130_stdcells/nor2_4.sym} 99220 -2740 0 0 {name=X_78115_ }
C {devices/lab_pin.sym} 99140 -2640 0 0 {name=p98986 lab=_41271_/Y }
C {devices/lab_pin.sym} 99140 -2600 0 0 {name=p98987 lab=_44502_/X }
C {devices/lab_pin.sym} 99140 -2560 0 0 {name=p98988 lab=_87074_/Q }
C {devices/lab_pin.sym} 99140 -2520 0 0 {name=p98989 lab=_44503_/X }
C {devices/lab_pin.sym} 99300 -2580 0 1 {name=p98990 lab=_87074_/D }
C {sky130_stdcells/a2bb2o_4.sym} 99220 -2580 0 0 {name=X_44507_ }
C {devices/lab_pin.sym} 99160 -2460 0 0 {name=p98991 lab=_63289_/X }
C {devices/lab_pin.sym} 99160 -2420 0 0 {name=p98992 lab=_64546_/C }
C {devices/lab_pin.sym} 99160 -2380 0 0 {name=p98993 lab=_63341_/C }
C {devices/lab_pin.sym} 99160 -2340 0 0 {name=p98994 lab=_60383_/A }
C {devices/lab_pin.sym} 99280 -2400 0 1 {name=p98995 lab=_63341_/X }
C {sky130_stdcells/and4_4.sym} 99220 -2400 0 0 {name=X_63341_ }
C {devices/lab_pin.sym} 99140 -2270 0 0 {name=p98996 lab=_75308_/Y }
C {devices/lab_pin.sym} 99140 -2230 0 0 {name=p98997 lab=_75309_/A }
C {devices/lab_pin.sym} 99140 -2190 0 0 {name=p98998 lab=_75326_/X }
C {devices/lab_pin.sym} 99300 -2230 0 1 {name=p98999 lab=_75328_/B }
C {sky130_stdcells/a21boi_4.sym} 99220 -2230 0 0 {name=X_75327_ }
C {devices/lab_pin.sym} 99160 -2100 0 0 {name=p99000 lab=_41719_/A }
C {devices/lab_pin.sym} 99160 -2060 0 0 {name=p99001 lab=_41718_/X }
C {devices/lab_pin.sym} 99280 -2080 0 1 {name=p99002 lab=_41719_/X }
C {sky130_stdcells/or2_4.sym} 99220 -2080 0 0 {name=X_41719_ }
C {devices/lab_pin.sym} 99180 -1950 0 0 {name=p99003 lab=_49215_/A }
C {devices/lab_pin.sym} 99260 -1950 0 1 {name=p99004 lab=_48275_/X }
C {sky130_stdcells/buf_2.sym} 99220 -1950 0 0 {name=X_48275_ }
C {devices/lab_pin.sym} 99180 -1830 0 0 {name=p99005 lab=_60459_/B }
C {devices/lab_pin.sym} 99260 -1830 0 1 {name=p99006 lab=_60607_/A }
C {sky130_stdcells/buf_2.sym} 99220 -1830 0 0 {name=X_60553_ }
C {devices/lab_pin.sym} 99160 -1720 0 0 {name=p99007 lab=_72535_/Y }
C {devices/lab_pin.sym} 99160 -1680 0 0 {name=p99008 lab=_72539_/B }
C {devices/lab_pin.sym} 99280 -1700 0 1 {name=p99009 lab=_72539_/Y }
C {sky130_stdcells/nand2_4.sym} 99220 -1700 0 0 {name=X_72539_ }
C {devices/lab_pin.sym} 99160 -1580 0 0 {name=p99010 lab=_79095_/A }
C {devices/lab_pin.sym} 99160 -1540 0 0 {name=p99011 lab=_79095_/B }
C {devices/lab_pin.sym} 99280 -1560 0 1 {name=p99012 lab=_79095_/X }
C {sky130_stdcells/or2_4.sym} 99220 -1560 0 0 {name=X_79095_ }
C {devices/lab_pin.sym} 99140 -1460 0 0 {name=p99013 lab=_45485_/Y }
C {devices/lab_pin.sym} 99140 -1420 0 0 {name=p99014 lab=_45439_/X }
C {devices/lab_pin.sym} 99140 -1380 0 0 {name=p99015 lab=_45471_/X }
C {devices/lab_pin.sym} 99140 -1340 0 0 {name=p99016 lab=_45486_/Y }
C {devices/lab_pin.sym} 99300 -1400 0 1 {name=p99017 lab=_45487_/X }
C {sky130_stdcells/a211o_4.sym} 99220 -1400 0 0 {name=X_45487_ }
C {devices/lab_pin.sym} 99180 -1250 0 0 {name=p99018 lab=_42579_/A }
C {devices/lab_pin.sym} 99260 -1250 0 1 {name=p99019 lab=_42700_/A }
C {sky130_stdcells/buf_2.sym} 99220 -1250 0 0 {name=X_42699_ }
C {devices/lab_pin.sym} 99180 -1130 0 0 {name=p99020 lab=clkbuf_8_94_0_CLK/X }
C {devices/lab_pin.sym} 99260 -1130 0 1 {name=p99021 lab=clkbuf_9_188_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 99220 -1130 0 0 {name=Xclkbuf_9_188_0_CLK }
C {devices/lab_pin.sym} 99180 -1010 0 0 {name=p99022 lab=_47226_/A }
C {devices/lab_pin.sym} 99260 -1010 0 1 {name=p99023 lab=_47227_/A }
C {sky130_stdcells/inv_2.sym} 99220 -1010 0 0 {name=X_47226_ }
C {devices/lab_pin.sym} 99140 -920 0 0 {name=p99024 lab=_66040_/X }
C {devices/lab_pin.sym} 99140 -880 0 0 {name=p99025 lab=_84983_/Q }
C {devices/lab_pin.sym} 99140 -840 0 0 {name=p99026 lab=_66027_/X }
C {devices/lab_pin.sym} 99140 -800 0 0 {name=p99027 lab=_66059_/X }
C {devices/lab_pin.sym} 99300 -860 0 1 {name=p99028 lab=_66061_/B }
C {sky130_stdcells/a211o_4.sym} 99220 -860 0 0 {name=X_66060_ }
C {devices/lab_pin.sym} 99160 -720 0 0 {name=p99029 lab=_82260_/Q }
C {devices/lab_pin.sym} 99160 -680 0 0 {name=p99030 lab=_81972_/Q }
C {devices/lab_pin.sym} 99280 -700 0 1 {name=p99031 lab=_78046_/Y }
C {sky130_stdcells/xnor2_4.sym} 99220 -700 0 0 {name=X_78046_ }
C {devices/lab_pin.sym} 100060 -42180 0 0 {name=p99032 lab=_41601_/X }
C {devices/lab_pin.sym} 100060 -42140 0 0 {name=p99033 lab=_44431_/X }
C {devices/lab_pin.sym} 100060 -42100 0 0 {name=p99034 lab=_87108_/Q }
C {devices/lab_pin.sym} 100060 -42060 0 0 {name=p99035 lab=_44432_/X }
C {devices/lab_pin.sym} 100220 -42120 0 1 {name=p99036 lab=_87108_/D }
C {sky130_stdcells/a2bb2o_4.sym} 100140 -42120 0 0 {name=X_44438_ }
C {devices/lab_pin.sym} 100080 -41990 0 0 {name=p99037 lab=_63272_/A }
C {devices/lab_pin.sym} 100080 -41950 0 0 {name=p99038 lab=_61611_/A }
C {devices/lab_pin.sym} 100080 -41910 0 0 {name=p99039 lab=_60488_/C }
C {devices/lab_pin.sym} 100200 -41950 0 1 {name=p99040 lab=_63272_/Y }
C {sky130_stdcells/nand3_4.sym} 100140 -41950 0 0 {name=X_63272_ }
C {devices/lab_pin.sym} 100080 -41830 0 0 {name=p99041 lab=_75254_/Y }
C {devices/lab_pin.sym} 100080 -41790 0 0 {name=p99042 lab=_75258_/B }
C {devices/lab_pin.sym} 100080 -41750 0 0 {name=p99043 lab=_75258_/C }
C {devices/lab_pin.sym} 100200 -41790 0 1 {name=p99044 lab=_75258_/X }
C {sky130_stdcells/or3_4.sym} 100140 -41790 0 0 {name=X_75258_ }
C {devices/lab_pin.sym} 100100 -41650 0 0 {name=p99045 lab=_60484_/A }
C {devices/lab_pin.sym} 100180 -41650 0 1 {name=p99046 lab=_63280_/C }
C {sky130_stdcells/buf_2.sym} 100140 -41650 0 0 {name=X_60484_ }
C {devices/lab_pin.sym} 100060 -41560 0 0 {name=p99047 lab=_65009_/X }
C {devices/lab_pin.sym} 100060 -41520 0 0 {name=p99048 lab=_86162_/Q }
C {devices/lab_pin.sym} 100060 -41480 0 0 {name=p99049 lab=_64902_/X }
C {devices/lab_pin.sym} 100060 -41440 0 0 {name=p99050 lab=_65010_/X }
C {devices/lab_pin.sym} 100220 -41500 0 1 {name=p99051 lab=_65011_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -41500 0 0 {name=X_65011_ }
C {devices/lab_pin.sym} 100100 -41350 0 0 {name=p99052 lab=_62236_/A }
C {devices/lab_pin.sym} 100180 -41350 0 1 {name=p99053 lab=_62631_/B }
C {sky130_stdcells/buf_2.sym} 100140 -41350 0 0 {name=X_62223_ }
C {devices/lab_pin.sym} 100060 -41250 0 0 {name=p99054 lab=_88343_/Q }
C {devices/lab_pin.sym} 100060 -41210 0 0 {name=p99055 lab=_72769_/B }
C {devices/lab_pin.sym} 100060 -41170 0 0 {name=p99056 lab=_73007_/A }
C {devices/lab_pin.sym} 100220 -41210 0 1 {name=p99057 lab=_74209_/X }
C {sky130_stdcells/o21a_4.sym} 100140 -41210 0 0 {name=X_74209_ }
C {devices/lab_pin.sym} 100100 -41070 0 0 {name=p99058 lab=clkbuf_9_310_0_CLK/X }
C {devices/lab_pin.sym} 100180 -41070 0 1 {name=p99059 lab=_81195_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 100140 -41070 0 0 {name=Xclkbuf_10_620_0_CLK }
C {devices/lab_pin.sym} 100100 -40950 0 0 {name=p99060 lab=_47157_/A }
C {devices/lab_pin.sym} 100180 -40950 0 1 {name=p99061 lab=_54578_/B }
C {sky130_stdcells/inv_2.sym} 100140 -40950 0 0 {name=X_47157_ }
C {devices/lab_pin.sym} 100060 -40870 0 0 {name=p99062 lab=_44350_/X }
C {devices/lab_pin.sym} 100060 -40830 0 0 {name=p99063 lab=_44351_/X }
C {devices/lab_pin.sym} 100060 -40790 0 0 {name=p99064 lab=_41757_/X }
C {devices/lab_pin.sym} 100060 -40750 0 0 {name=p99065 lab=_87143_/Q }
C {devices/lab_pin.sym} 100060 -40710 0 0 {name=p99066 lab=_44353_/X }
C {devices/lab_pin.sym} 100220 -40790 0 1 {name=p99067 lab=_44370_/A }
C {sky130_stdcells/o32ai_4.sym} 100140 -40790 0 0 {name=X_44369_ }
C {devices/lab_pin.sym} 100060 -40650 0 0 {name=p99068 lab=_75190_/A }
C {devices/lab_pin.sym} 100060 -40610 0 0 {name=p99069 lab=_75190_/C }
C {devices/lab_pin.sym} 100060 -40570 0 0 {name=p99070 lab=_75190_/B }
C {devices/lab_pin.sym} 100220 -40610 0 1 {name=p99071 lab=_75189_/X }
C {sky130_stdcells/a21o_4.sym} 100140 -40610 0 0 {name=X_75189_ }
C {devices/lab_pin.sym} 100080 -40500 0 0 {name=p99072 lab=_46214_/D }
C {devices/lab_pin.sym} 100080 -40460 0 0 {name=p99073 lab=_72484_/A }
C {devices/lab_pin.sym} 100080 -40420 0 0 {name=p99074 lab=_46214_/C }
C {devices/lab_pin.sym} 100080 -40380 0 0 {name=p99075 lab=_46108_/D }
C {devices/lab_pin.sym} 100200 -40440 0 1 {name=p99076 lab=_46108_/X }
C {sky130_stdcells/and4_4.sym} 100140 -40440 0 0 {name=X_46108_ }
C {devices/lab_pin.sym} 100060 -40330 0 0 {name=p99077 lab=_62146_/X }
C {devices/lab_pin.sym} 100060 -40290 0 0 {name=p99078 lab=_62148_/X }
C {devices/lab_pin.sym} 100060 -40250 0 0 {name=p99079 lab=_62153_/Y }
C {devices/lab_pin.sym} 100060 -40210 0 0 {name=p99080 lab=_84869_/Q }
C {devices/lab_pin.sym} 100060 -40170 0 0 {name=p99081 lab=_62117_/X }
C {devices/lab_pin.sym} 100220 -40250 0 1 {name=p99082 lab=_62154_/Y }
C {sky130_stdcells/o32ai_4.sym} 100140 -40250 0 0 {name=X_62154_ }
C {devices/lab_pin.sym} 100100 -40090 0 0 {name=p99083 lab=clkbuf_8_55_0_CLK/X }
C {devices/lab_pin.sym} 100180 -40090 0 1 {name=p99084 lab=clkbuf_9_111_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 100140 -40090 0 0 {name=Xclkbuf_9_111_0_CLK }
C {devices/lab_pin.sym} 100100 -39970 0 0 {name=p99085 lab=_53364_/B }
C {devices/lab_pin.sym} 100180 -39970 0 1 {name=p99086 lab=_52850_/B }
C {sky130_stdcells/buf_2.sym} 100140 -39970 0 0 {name=X_47088_ }
C {devices/lab_pin.sym} 100080 -39860 0 0 {name=p99087 lab=_84929_/Q }
C {devices/lab_pin.sym} 100080 -39820 0 0 {name=p99088 lab=_84177_/Q }
C {devices/lab_pin.sym} 100200 -39840 0 1 {name=p99089 lab=_79997_/X }
C {sky130_stdcells/xor2_4.sym} 100140 -39840 0 0 {name=X_79997_ }
C {devices/lab_pin.sym} 100060 -39740 0 0 {name=p99090 lab=_61172_/A }
C {devices/lab_pin.sym} 100060 -39700 0 0 {name=p99091 lab=_61082_/X }
C {devices/lab_pin.sym} 100060 -39660 0 0 {name=p99092 lab=_61096_/X }
C {devices/lab_pin.sym} 100060 -39620 0 0 {name=p99093 lab=_61153_/A }
C {devices/lab_pin.sym} 100220 -39680 0 1 {name=p99094 lab=_61105_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -39680 0 0 {name=X_61105_ }
C {devices/lab_pin.sym} 100060 -39570 0 0 {name=p99095 lab=_46013_/X }
C {devices/lab_pin.sym} 100060 -39530 0 0 {name=p99096 lab=_46032_/X }
C {devices/lab_pin.sym} 100060 -39490 0 0 {name=p99097 lab=_41497_/X }
C {devices/lab_pin.sym} 100060 -39450 0 0 {name=p99098 lab=_86799_/Q }
C {devices/lab_pin.sym} 100060 -39410 0 0 {name=p99099 lab=_46014_/X }
C {devices/lab_pin.sym} 100220 -39490 0 1 {name=p99100 lab=_46039_/Y }
C {sky130_stdcells/o32ai_4.sym} 100140 -39490 0 0 {name=X_46039_ }
C {devices/lab_pin.sym} 100060 -39360 0 0 {name=p99101 lab=_73124_/A }
C {devices/lab_pin.sym} 100060 -39320 0 0 {name=p99102 lab=_69747_/X }
C {devices/lab_pin.sym} 100060 -39280 0 0 {name=p99103 lab=_68691_/X }
C {devices/lab_pin.sym} 100060 -39240 0 0 {name=p99104 lab=_69749_/Y }
C {devices/lab_pin.sym} 100220 -39300 0 1 {name=p99105 lab=_69750_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -39300 0 0 {name=X_69750_ }
C {devices/lab_pin.sym} 100080 -39160 0 0 {name=p99106 lab=_66961_/X }
C {devices/lab_pin.sym} 100080 -39120 0 0 {name=p99107 lab=_66962_/B }
C {devices/lab_pin.sym} 100200 -39140 0 1 {name=p99108 lab=_66962_/X }
C {sky130_stdcells/and2_4.sym} 100140 -39140 0 0 {name=X_66962_ }
C {devices/lab_pin.sym} 100100 -39010 0 0 {name=p99109 lab=_61708_/X }
C {devices/lab_pin.sym} 100180 -39010 0 1 {name=p99110 lab=_62128_/C }
C {sky130_stdcells/buf_2.sym} 100140 -39010 0 0 {name=X_62085_ }
C {devices/lab_pin.sym} 100100 -38890 0 0 {name=p99111 lab=_78948_/A }
C {devices/lab_pin.sym} 100180 -38890 0 1 {name=p99112 lab=_78948_/Y }
C {sky130_stdcells/inv_2.sym} 100140 -38890 0 0 {name=X_78948_ }
C {devices/lab_pin.sym} 100100 -38770 0 0 {name=p99113 lab=clkbuf_9_317_0_CLK/X }
C {devices/lab_pin.sym} 100180 -38770 0 1 {name=p99114 lab=_82284_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 100140 -38770 0 0 {name=Xclkbuf_10_635_0_CLK }
C {devices/lab_pin.sym} 100080 -38660 0 0 {name=p99115 lab=_68698_/X }
C {devices/lab_pin.sym} 100080 -38620 0 0 {name=p99116 lab=_68700_/X }
C {devices/lab_pin.sym} 100200 -38640 0 1 {name=p99117 lab=_68701_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -38640 0 0 {name=X_68701_ }
C {devices/lab_pin.sym} 100080 -38530 0 0 {name=p99118 lab=_65910_/X }
C {devices/lab_pin.sym} 100080 -38490 0 0 {name=p99119 lab=_65868_/B }
C {devices/lab_pin.sym} 100080 -38450 0 0 {name=p99120 lab=_65912_/X }
C {devices/lab_pin.sym} 100200 -38490 0 1 {name=p99121 lab=_65913_/Y }
C {sky130_stdcells/nand3_4.sym} 100140 -38490 0 0 {name=X_65913_ }
C {devices/lab_pin.sym} 100080 -38370 0 0 {name=p99122 lab=_61028_/X }
C {devices/lab_pin.sym} 100080 -38330 0 0 {name=p99123 lab=_61018_/Y }
C {devices/lab_pin.sym} 100080 -38290 0 0 {name=p99124 lab=_61036_/C }
C {devices/lab_pin.sym} 100200 -38330 0 1 {name=p99125 lab=_61037_/A }
C {sky130_stdcells/nor3_4.sym} 100140 -38330 0 0 {name=X_61036_ }
C {devices/lab_pin.sym} 100060 -38220 0 0 {name=p99126 lab=_72973_/A }
C {devices/lab_pin.sym} 100060 -38180 0 0 {name=p99127 lab=_69485_/X }
C {devices/lab_pin.sym} 100060 -38140 0 0 {name=p99128 lab=_69611_/X }
C {devices/lab_pin.sym} 100060 -38100 0 0 {name=p99129 lab=_69680_/X }
C {devices/lab_pin.sym} 100220 -38160 0 1 {name=p99130 lab=_69681_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -38160 0 0 {name=X_69681_ }
C {devices/lab_pin.sym} 100060 -38040 0 0 {name=p99131 lab=_88390_/Q }
C {devices/lab_pin.sym} 100060 -38000 0 0 {name=p99132 lab=_66868_/X }
C {devices/lab_pin.sym} 100060 -37960 0 0 {name=p99133 lab=_66801_/X }
C {devices/lab_pin.sym} 100060 -37920 0 0 {name=p99134 lab=_66892_/X }
C {devices/lab_pin.sym} 100220 -37980 0 1 {name=p99135 lab=_66893_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -37980 0 0 {name=X_66893_ }
C {devices/lab_pin.sym} 100060 -37850 0 0 {name=p99136 lab=_78859_/Y }
C {devices/lab_pin.sym} 100060 -37810 0 0 {name=p99137 lab=_78873_/Y }
C {devices/lab_pin.sym} 100060 -37770 0 0 {name=p99138 lab=_78878_/X }
C {devices/lab_pin.sym} 100220 -37810 0 1 {name=p99139 lab=_78879_/Y }
C {sky130_stdcells/a21oi_4.sym} 100140 -37810 0 0 {name=X_78879_ }
C {devices/lab_pin.sym} 100100 -37670 0 0 {name=p99140 lab=clkbuf_8_63_0_CLK/X }
C {devices/lab_pin.sym} 100180 -37670 0 1 {name=p99141 lab=clkbuf_9_126_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 100140 -37670 0 0 {name=Xclkbuf_9_126_0_CLK }
C {devices/lab_pin.sym} 100050 -37550 0 0 {name=p99142 lab=_83918_/CLK }
C {devices/lab_pin.sym} 100050 -37530 0 0 {name=p99143 lab=_80910_/D }
C {devices/lab_pin.sym} 100230 -37550 0 1 {name=p99144 lab=_80910_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -37540 0 0 {name=X_80910_ }
C {devices/lab_pin.sym} 100060 -37440 0 0 {name=p99145 lab=_87093_/Q }
C {devices/lab_pin.sym} 100060 -37400 0 0 {name=p99146 lab=_68580_/X }
C {devices/lab_pin.sym} 100060 -37360 0 0 {name=p99147 lab=_68630_/X }
C {devices/lab_pin.sym} 100060 -37320 0 0 {name=p99148 lab=_68631_/X }
C {devices/lab_pin.sym} 100220 -37380 0 1 {name=p99149 lab=_68632_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -37380 0 0 {name=X_68632_ }
C {devices/lab_pin.sym} 100060 -37250 0 0 {name=p99150 lab=_84174_/Q }
C {devices/lab_pin.sym} 100060 -37210 0 0 {name=p99151 lab=_65296_/X }
C {devices/lab_pin.sym} 100060 -37170 0 0 {name=p99152 lab=_65843_/Y }
C {devices/lab_pin.sym} 100220 -37210 0 1 {name=p99153 lab=_84174_/D }
C {sky130_stdcells/a21o_4.sym} 100140 -37210 0 0 {name=X_65844_ }
C {devices/lab_pin.sym} 100100 -37070 0 0 {name=p99154 lab=clkbuf_9_53_0_CLK/A }
C {devices/lab_pin.sym} 100180 -37070 0 1 {name=p99155 lab=clkbuf_9_53_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 100140 -37070 0 0 {name=Xclkbuf_9_53_0_CLK }
C {devices/lab_pin.sym} 100050 -36950 0 0 {name=p99156 lab=_82015_/CLK }
C {devices/lab_pin.sym} 100050 -36930 0 0 {name=p99157 lab=_77235_/X }
C {devices/lab_pin.sym} 100230 -36950 0 1 {name=p99158 lab=_77170_/B }
C {sky130_stdcells/dfxtp_4.sym} 100140 -36940 0 0 {name=X_81890_ }
C {devices/lab_pin.sym} 100060 -36830 0 0 {name=p99159 lab=_49727_/Y }
C {devices/lab_pin.sym} 100060 -36790 0 0 {name=p99160 lab=_49706_/X }
C {devices/lab_pin.sym} 100060 -36750 0 0 {name=p99161 lab=_49728_/X }
C {devices/lab_pin.sym} 100220 -36790 0 1 {name=p99162 lab=_86334_/D }
C {sky130_stdcells/a21oi_4.sym} 100140 -36790 0 0 {name=X_49729_ }
C {devices/lab_pin.sym} 100050 -36650 0 0 {name=p99163 lab=_80746_/CLK }
C {devices/lab_pin.sym} 100050 -36630 0 0 {name=p99164 lab=_80873_/Q }
C {devices/lab_pin.sym} 100230 -36650 0 1 {name=p99165 lab=_74891_/B }
C {sky130_stdcells/dfxtp_4.sym} 100140 -36640 0 0 {name=X_80841_ }
C {devices/lab_pin.sym} 100060 -36540 0 0 {name=p99166 lab=_68551_/Y }
C {devices/lab_pin.sym} 100060 -36500 0 0 {name=p99167 lab=_68358_/X }
C {devices/lab_pin.sym} 100060 -36460 0 0 {name=p99168 lab=_68447_/X }
C {devices/lab_pin.sym} 100060 -36420 0 0 {name=p99169 lab=_68562_/Y }
C {devices/lab_pin.sym} 100220 -36480 0 1 {name=p99170 lab=_68563_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -36480 0 0 {name=X_68563_ }
C {devices/lab_pin.sym} 100080 -36350 0 0 {name=p99171 lab=_65855_/A }
C {devices/lab_pin.sym} 100080 -36310 0 0 {name=p99172 lab=_65775_/B }
C {devices/lab_pin.sym} 100080 -36270 0 0 {name=p99173 lab=_84179_/Q }
C {devices/lab_pin.sym} 100200 -36310 0 1 {name=p99174 lab=_65775_/X }
C {sky130_stdcells/and3_4.sym} 100140 -36310 0 0 {name=X_65775_ }
C {devices/lab_pin.sym} 100100 -36170 0 0 {name=p99175 lab=_63516_/A }
C {devices/lab_pin.sym} 100180 -36170 0 1 {name=p99176 lab=_62987_/X }
C {sky130_stdcells/buf_2.sym} 100140 -36170 0 0 {name=X_62987_ }
C {devices/lab_pin.sym} 100060 -36080 0 0 {name=p99177 lab=_87468_/Q }
C {devices/lab_pin.sym} 100060 -36040 0 0 {name=p99178 lab=_67512_/X }
C {devices/lab_pin.sym} 100060 -36000 0 0 {name=p99179 lab=_67462_/X }
C {devices/lab_pin.sym} 100060 -35960 0 0 {name=p99180 lab=_67513_/X }
C {devices/lab_pin.sym} 100220 -36020 0 1 {name=p99181 lab=_67514_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -36020 0 0 {name=X_67514_ }
C {devices/lab_pin.sym} 100060 -35890 0 0 {name=p99182 lab=_85763_/Q }
C {devices/lab_pin.sym} 100060 -35850 0 0 {name=p99183 lab=_52737_/X }
C {devices/lab_pin.sym} 100060 -35810 0 0 {name=p99184 lab=_52739_/Y }
C {devices/lab_pin.sym} 100220 -35850 0 1 {name=p99185 lab=_52740_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -35850 0 0 {name=X_52740_ }
C {devices/lab_pin.sym} 100080 -35720 0 0 {name=p99186 lab=_64883_/A }
C {devices/lab_pin.sym} 100080 -35680 0 0 {name=p99187 lab=_86269_/Q }
C {devices/lab_pin.sym} 100200 -35700 0 1 {name=p99188 lab=_64726_/X }
C {sky130_stdcells/and2_4.sym} 100140 -35700 0 0 {name=X_64726_ }
C {devices/lab_pin.sym} 100050 -35570 0 0 {name=p99189 lab=_86592_/CLK }
C {devices/lab_pin.sym} 100050 -35550 0 0 {name=p99190 lab=_71247_/Y }
C {devices/lab_pin.sym} 100230 -35570 0 1 {name=p99191 lab=_47842_/A }
C {sky130_stdcells/dfxtp_4.sym} 100140 -35560 0 0 {name=X_83560_ }
C {devices/lab_pin.sym} 100080 -35460 0 0 {name=p99192 lab=_61489_/B }
C {devices/lab_pin.sym} 100080 -35420 0 0 {name=p99193 lab=_61953_/B }
C {devices/lab_pin.sym} 100080 -35380 0 0 {name=p99194 lab=_61953_/C }
C {devices/lab_pin.sym} 100080 -35340 0 0 {name=p99195 lab=_61937_/X }
C {devices/lab_pin.sym} 100200 -35400 0 1 {name=p99196 lab=_61938_/Y }
C {sky130_stdcells/nand4_4.sym} 100140 -35400 0 0 {name=X_61938_ }
C {devices/lab_pin.sym} 100050 -35250 0 0 {name=p99197 lab=_83967_/CLK }
C {devices/lab_pin.sym} 100050 -35230 0 0 {name=p99198 lab=_75890_/Y }
C {devices/lab_pin.sym} 100230 -35250 0 1 {name=p99199 lab=_75108_/A }
C {sky130_stdcells/dfxtp_4.sym} 100140 -35240 0 0 {name=X_80772_ }
C {devices/lab_pin.sym} 100100 -35110 0 0 {name=p99200 lab=_68385_/A }
C {devices/lab_pin.sym} 100180 -35110 0 1 {name=p99201 lab=_68494_/X }
C {sky130_stdcells/buf_2.sym} 100140 -35110 0 0 {name=X_68494_ }
C {devices/lab_pin.sym} 100050 -34990 0 0 {name=p99202 lab=_82711_/CLK }
C {devices/lab_pin.sym} 100050 -34970 0 0 {name=p99203 lab=_82511_/D }
C {devices/lab_pin.sym} 100230 -34990 0 1 {name=p99204 lab=_82511_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -34980 0 0 {name=X_82511_ }
C {devices/lab_pin.sym} 100060 -34880 0 0 {name=p99205 lab=_86971_/Q }
C {devices/lab_pin.sym} 100060 -34840 0 0 {name=p99206 lab=_67348_/X }
C {devices/lab_pin.sym} 100060 -34800 0 0 {name=p99207 lab=_67398_/X }
C {devices/lab_pin.sym} 100060 -34760 0 0 {name=p99208 lab=_67444_/X }
C {devices/lab_pin.sym} 100220 -34820 0 1 {name=p99209 lab=_67445_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -34820 0 0 {name=X_67445_ }
C {devices/lab_pin.sym} 100100 -34670 0 0 {name=p99210 lab=clkbuf_9_69_0_CLK/A }
C {devices/lab_pin.sym} 100180 -34670 0 1 {name=p99211 lab=clkbuf_9_68_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 100140 -34670 0 0 {name=Xclkbuf_9_68_0_CLK }
C {devices/lab_pin.sym} 100080 -34560 0 0 {name=p99212 lab=_52657_/X }
C {devices/lab_pin.sym} 100080 -34520 0 0 {name=p99213 lab=_54364_/B }
C {devices/lab_pin.sym} 100200 -34540 0 1 {name=p99214 lab=_52671_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -34540 0 0 {name=X_52671_ }
C {devices/lab_pin.sym} 100100 -34410 0 0 {name=p99215 lab=_64809_/A }
C {devices/lab_pin.sym} 100180 -34410 0 1 {name=p99216 lab=_64657_/X }
C {sky130_stdcells/buf_2.sym} 100140 -34410 0 0 {name=X_64657_ }
C {devices/lab_pin.sym} 100050 -34290 0 0 {name=p99217 lab=_83491_/CLK }
C {devices/lab_pin.sym} 100050 -34270 0 0 {name=p99218 lab=_71459_/X }
C {devices/lab_pin.sym} 100230 -34290 0 1 {name=p99219 lab=_83491_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -34280 0 0 {name=X_83491_ }
C {devices/lab_pin.sym} 100080 -34180 0 0 {name=p99220 lab=_61823_/A }
C {devices/lab_pin.sym} 100080 -34140 0 0 {name=p99221 lab=_61915_/B }
C {devices/lab_pin.sym} 100080 -34100 0 0 {name=p99222 lab=_58506_/A }
C {devices/lab_pin.sym} 100080 -34060 0 0 {name=p99223 lab=_61915_/D }
C {devices/lab_pin.sym} 100200 -34120 0 1 {name=p99224 lab=_61869_/X }
C {sky130_stdcells/and4_4.sym} 100140 -34120 0 0 {name=X_61869_ }
C {devices/lab_pin.sym} 100080 -33980 0 0 {name=p99225 lab=_54425_/A }
C {devices/lab_pin.sym} 100080 -33940 0 0 {name=p99226 lab=_52718_/B }
C {devices/lab_pin.sym} 100200 -33960 0 1 {name=p99227 lab=_54410_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -33960 0 0 {name=X_54410_ }
C {devices/lab_pin.sym} 100050 -33830 0 0 {name=p99228 lab=_85257_/CLK }
C {devices/lab_pin.sym} 100050 -33810 0 0 {name=p99229 lab=_85230_/D }
C {devices/lab_pin.sym} 100230 -33830 0 1 {name=p99230 lab=_56339_/C }
C {sky130_stdcells/dfxtp_4.sym} 100140 -33820 0 0 {name=X_85230_ }
C {devices/lab_pin.sym} 100100 -33690 0 0 {name=p99231 lab=_51622_/A }
C {devices/lab_pin.sym} 100180 -33690 0 1 {name=p99232 lab=_51627_/A }
C {sky130_stdcells/buf_2.sym} 100140 -33690 0 0 {name=X_51622_ }
C {devices/lab_pin.sym} 100060 -33600 0 0 {name=p99233 lab=_58391_/A }
C {devices/lab_pin.sym} 100060 -33560 0 0 {name=p99234 lab=_63558_/X }
C {devices/lab_pin.sym} 100060 -33520 0 0 {name=p99235 lab=_61572_/A }
C {devices/lab_pin.sym} 100060 -33480 0 0 {name=p99236 lab=_63559_/X }
C {devices/lab_pin.sym} 100220 -33540 0 1 {name=p99237 lab=_63608_/X }
C {sky130_stdcells/a2bb2o_4.sym} 100140 -33540 0 0 {name=X_63608_ }
C {devices/lab_pin.sym} 100050 -33390 0 0 {name=p99238 lab=_82443_/CLK }
C {devices/lab_pin.sym} 100050 -33370 0 0 {name=p99239 lab=_79134_/X }
C {devices/lab_pin.sym} 100230 -33390 0 1 {name=p99240 lab=_82410_/D }
C {sky130_stdcells/dfxtp_4.sym} 100140 -33380 0 0 {name=X_82442_ }
C {devices/lab_pin.sym} 100080 -33270 0 0 {name=p99241 lab=_56719_/A }
C {devices/lab_pin.sym} 100080 -33230 0 0 {name=p99242 lab=_56719_/B }
C {devices/lab_pin.sym} 100080 -33190 0 0 {name=p99243 lab=_55388_/Y }
C {devices/lab_pin.sym} 100200 -33230 0 1 {name=p99244 lab=_55441_/C }
C {sky130_stdcells/nand3_4.sym} 100140 -33230 0 0 {name=X_55390_ }
C {devices/lab_pin.sym} 100060 -33120 0 0 {name=p99245 lab=_67305_/X }
C {devices/lab_pin.sym} 100060 -33080 0 0 {name=p99246 lab=_67367_/Y }
C {devices/lab_pin.sym} 100060 -33040 0 0 {name=p99247 lab=_67269_/X }
C {devices/lab_pin.sym} 100060 -33000 0 0 {name=p99248 lab=_67375_/Y }
C {devices/lab_pin.sym} 100220 -33060 0 1 {name=p99249 lab=_67376_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -33060 0 0 {name=X_67376_ }
C {devices/lab_pin.sym} 100060 -32940 0 0 {name=p99250 lab=_59345_/X }
C {devices/lab_pin.sym} 100060 -32900 0 0 {name=p99251 lab=_86177_/Q }
C {devices/lab_pin.sym} 100060 -32860 0 0 {name=p99252 lab=_64583_/X }
C {devices/lab_pin.sym} 100060 -32820 0 0 {name=p99253 lab=_64587_/X }
C {devices/lab_pin.sym} 100220 -32880 0 1 {name=p99254 lab=_64588_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -32880 0 0 {name=X_64588_ }
C {devices/lab_pin.sym} 100060 -32760 0 0 {name=p99255 lab=_74266_/A }
C {devices/lab_pin.sym} 100060 -32720 0 0 {name=p99256 lab=_68958_/X }
C {devices/lab_pin.sym} 100060 -32680 0 0 {name=p99257 lab=_69113_/X }
C {devices/lab_pin.sym} 100060 -32640 0 0 {name=p99258 lab=_69114_/Y }
C {devices/lab_pin.sym} 100220 -32700 0 1 {name=p99259 lab=_69115_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -32700 0 0 {name=X_69115_ }
C {devices/lab_pin.sym} 100080 -32560 0 0 {name=p99260 lab=_54332_/A }
C {devices/lab_pin.sym} 100080 -32520 0 0 {name=p99261 lab=_52651_/B }
C {devices/lab_pin.sym} 100200 -32540 0 1 {name=p99262 lab=_54341_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -32540 0 0 {name=X_54341_ }
C {devices/lab_pin.sym} 100060 -32440 0 0 {name=p99263 lab=_66117_/X }
C {devices/lab_pin.sym} 100060 -32400 0 0 {name=p99264 lab=_84964_/Q }
C {devices/lab_pin.sym} 100060 -32360 0 0 {name=p99265 lab=_66118_/X }
C {devices/lab_pin.sym} 100060 -32320 0 0 {name=p99266 lab=_66326_/X }
C {devices/lab_pin.sym} 100220 -32380 0 1 {name=p99267 lab=_66328_/B }
C {sky130_stdcells/a211o_4.sym} 100140 -32380 0 0 {name=X_66327_ }
C {devices/lab_pin.sym} 100050 -32230 0 0 {name=p99268 lab=_83016_/CLK }
C {devices/lab_pin.sym} 100050 -32210 0 0 {name=p99269 lab=_85161_/D }
C {devices/lab_pin.sym} 100230 -32230 0 1 {name=p99270 lab=_85161_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -32220 0 0 {name=X_85161_ }
C {devices/lab_pin.sym} 100080 -32120 0 0 {name=p99271 lab=_51553_/A }
C {devices/lab_pin.sym} 100080 -32080 0 0 {name=p99272 lab=_51553_/B }
C {devices/lab_pin.sym} 100080 -32040 0 0 {name=p99273 lab=_51553_/C }
C {devices/lab_pin.sym} 100080 -32000 0 0 {name=p99274 lab=_53078_/D }
C {devices/lab_pin.sym} 100200 -32060 0 1 {name=p99275 lab=_51553_/X }
C {sky130_stdcells/and4_4.sym} 100140 -32060 0 0 {name=X_51553_ }
C {devices/lab_pin.sym} 100100 -31910 0 0 {name=p99276 lab=_63478_/A }
C {devices/lab_pin.sym} 100180 -31910 0 1 {name=p99277 lab=_63541_/B }
C {sky130_stdcells/buf_2.sym} 100140 -31910 0 0 {name=X_63539_ }
C {devices/lab_pin.sym} 100050 -31790 0 0 {name=p99278 lab=_83690_/CLK }
C {devices/lab_pin.sym} 100050 -31770 0 0 {name=p99279 lab=_82181_/Q }
C {devices/lab_pin.sym} 100230 -31790 0 1 {name=p99280 lab=_82373_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -31780 0 0 {name=X_82373_ }
C {devices/lab_pin.sym} 100050 -31650 0 0 {name=p99281 lab=_84161_/CLK }
C {devices/lab_pin.sym} 100050 -31630 0 0 {name=p99282 lab=_84112_/D }
C {devices/lab_pin.sym} 100230 -31650 0 1 {name=p99283 lab=_66495_/C }
C {sky130_stdcells/dfxtp_4.sym} 100140 -31640 0 0 {name=X_84112_ }
C {devices/lab_pin.sym} 100060 -31530 0 0 {name=p99284 lab=_50502_/Y }
C {devices/lab_pin.sym} 100060 -31490 0 0 {name=p99285 lab=_50474_/X }
C {devices/lab_pin.sym} 100060 -31450 0 0 {name=p99286 lab=_50503_/Y }
C {devices/lab_pin.sym} 100220 -31490 0 1 {name=p99287 lab=_86188_/D }
C {sky130_stdcells/a21boi_4.sym} 100140 -31490 0 0 {name=X_50504_ }
C {devices/lab_pin.sym} 100050 -31350 0 0 {name=p99288 lab=_84049_/CLK }
C {devices/lab_pin.sym} 100050 -31330 0 0 {name=p99289 lab=_76297_/X }
C {devices/lab_pin.sym} 100230 -31350 0 1 {name=p99290 lab=_81700_/D }
C {sky130_stdcells/dfxtp_4.sym} 100140 -31340 0 0 {name=X_81324_ }
C {devices/lab_pin.sym} 100060 -31230 0 0 {name=p99291 lab=_56873_/X }
C {devices/lab_pin.sym} 100060 -31190 0 0 {name=p99292 lab=_44220_/B }
C {devices/lab_pin.sym} 100060 -31150 0 0 {name=p99293 lab=_57059_/Y }
C {devices/lab_pin.sym} 100220 -31190 0 1 {name=p99294 lab=_57060_/X }
C {sky130_stdcells/a21o_4.sym} 100140 -31190 0 0 {name=X_57060_ }
C {devices/lab_pin.sym} 100060 -31080 0 0 {name=p99295 lab=_87479_/Q }
C {devices/lab_pin.sym} 100060 -31040 0 0 {name=p99296 lab=_69044_/X }
C {devices/lab_pin.sym} 100060 -31000 0 0 {name=p99297 lab=_68979_/X }
C {devices/lab_pin.sym} 100060 -30960 0 0 {name=p99298 lab=_69045_/X }
C {devices/lab_pin.sym} 100220 -31020 0 1 {name=p99299 lab=_69046_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -31020 0 0 {name=X_69046_ }
C {devices/lab_pin.sym} 100080 -30880 0 0 {name=p99300 lab=_54288_/A }
C {devices/lab_pin.sym} 100080 -30840 0 0 {name=p99301 lab=_46624_/Y }
C {devices/lab_pin.sym} 100200 -30860 0 1 {name=p99302 lab=_54272_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -30860 0 0 {name=X_54272_ }
C {devices/lab_pin.sym} 100080 -30740 0 0 {name=p99303 lab=_66254_/X }
C {devices/lab_pin.sym} 100080 -30700 0 0 {name=p99304 lab=_66257_/X }
C {devices/lab_pin.sym} 100200 -30720 0 1 {name=p99305 lab=_66258_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -30720 0 0 {name=X_66258_ }
C {devices/lab_pin.sym} 100050 -30590 0 0 {name=p99306 lab=_85041_/CLK }
C {devices/lab_pin.sym} 100050 -30570 0 0 {name=p99307 lab=_85092_/D }
C {devices/lab_pin.sym} 100230 -30590 0 1 {name=p99308 lab=_85092_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -30580 0 0 {name=X_85092_ }
C {devices/lab_pin.sym} 100060 -30470 0 0 {name=p99309 lab=_51482_/Y }
C {devices/lab_pin.sym} 100060 -30430 0 0 {name=p99310 lab=_51477_/X }
C {devices/lab_pin.sym} 100060 -30390 0 0 {name=p99311 lab=_51483_/X }
C {devices/lab_pin.sym} 100220 -30430 0 1 {name=p99312 lab=_86002_/D }
C {sky130_stdcells/a21oi_4.sym} 100140 -30430 0 0 {name=X_51484_ }
C {devices/lab_pin.sym} 100100 -30290 0 0 {name=p99313 lab=_56010_/X }
C {devices/lab_pin.sym} 100180 -30290 0 1 {name=p99314 lab=_56054_/B }
C {sky130_stdcells/buf_2.sym} 100140 -30290 0 0 {name=X_56011_ }
C {devices/lab_pin.sym} 100080 -30200 0 0 {name=p99315 lab=_53217_/A }
C {devices/lab_pin.sym} 100080 -30160 0 0 {name=p99316 lab=_53211_/B }
C {devices/lab_pin.sym} 100080 -30120 0 0 {name=p99317 lab=_53222_/X }
C {devices/lab_pin.sym} 100080 -30080 0 0 {name=p99318 lab=_53223_/D }
C {devices/lab_pin.sym} 100200 -30140 0 1 {name=p99319 lab=_53223_/X }
C {sky130_stdcells/and4_4.sym} 100140 -30140 0 0 {name=X_53223_ }
C {devices/lab_pin.sym} 100080 -30000 0 0 {name=p99320 lab=_65155_/A }
C {devices/lab_pin.sym} 100080 -29960 0 0 {name=p99321 lab=_65209_/B }
C {devices/lab_pin.sym} 100200 -29980 0 1 {name=p99322 lab=_65209_/X }
C {sky130_stdcells/and2_4.sym} 100140 -29980 0 0 {name=X_65209_ }
C {devices/lab_pin.sym} 100050 -29850 0 0 {name=p99323 lab=_81475_/CLK }
C {devices/lab_pin.sym} 100050 -29830 0 0 {name=p99324 lab=_68065_/X }
C {devices/lab_pin.sym} 100230 -29850 0 1 {name=p99325 lab=_81475_/D }
C {sky130_stdcells/dfxtp_4.sym} 100140 -29840 0 0 {name=X_84043_ }
C {devices/lab_pin.sym} 100080 -29730 0 0 {name=p99326 lab=_48752_/A }
C {devices/lab_pin.sym} 100080 -29690 0 0 {name=p99327 lab=_50456_/B }
C {devices/lab_pin.sym} 100080 -29650 0 0 {name=p99328 lab=_50435_/C }
C {devices/lab_pin.sym} 100200 -29690 0 1 {name=p99329 lab=_50435_/X }
C {sky130_stdcells/and3_4.sym} 100140 -29690 0 0 {name=X_50435_ }
C {devices/lab_pin.sym} 100050 -29550 0 0 {name=p99330 lab=_81671_/CLK }
C {devices/lab_pin.sym} 100050 -29530 0 0 {name=p99331 lab=_81255_/D }
C {devices/lab_pin.sym} 100230 -29550 0 1 {name=p99332 lab=_81255_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -29540 0 0 {name=X_81255_ }
C {devices/lab_pin.sym} 100080 -29420 0 0 {name=p99333 lab=_66185_/X }
C {devices/lab_pin.sym} 100080 -29380 0 0 {name=p99334 lab=_66188_/X }
C {devices/lab_pin.sym} 100200 -29400 0 1 {name=p99335 lab=_66189_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -29400 0 0 {name=X_66189_ }
C {devices/lab_pin.sym} 100080 -29280 0 0 {name=p99336 lab=_59992_/C }
C {devices/lab_pin.sym} 100080 -29240 0 0 {name=p99337 lab=_80206_/B }
C {devices/lab_pin.sym} 100200 -29260 0 1 {name=p99338 lab=_80207_/B }
C {sky130_stdcells/xor2_4.sym} 100140 -29260 0 0 {name=X_80206_ }
C {devices/lab_pin.sym} 100060 -29150 0 0 {name=p99339 lab=_85687_/Q }
C {devices/lab_pin.sym} 100060 -29110 0 0 {name=p99340 lab=_53146_/X }
C {devices/lab_pin.sym} 100060 -29070 0 0 {name=p99341 lab=_53153_/Y }
C {devices/lab_pin.sym} 100220 -29110 0 1 {name=p99342 lab=_53154_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -29110 0 0 {name=X_53154_ }
C {devices/lab_pin.sym} 100060 -28990 0 0 {name=p99343 lab=_86215_/Q }
C {devices/lab_pin.sym} 100060 -28950 0 0 {name=p99344 lab=_50363_/X }
C {devices/lab_pin.sym} 100060 -28910 0 0 {name=p99345 lab=_50365_/Y }
C {devices/lab_pin.sym} 100220 -28950 0 1 {name=p99346 lab=_50366_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -28950 0 0 {name=X_50366_ }
C {devices/lab_pin.sym} 100050 -28810 0 0 {name=p99347 lab=_81211_/CLK }
C {devices/lab_pin.sym} 100050 -28790 0 0 {name=p99348 lab=_81186_/D }
C {devices/lab_pin.sym} 100230 -28810 0 1 {name=p99349 lab=_81186_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -28800 0 0 {name=X_81186_ }
C {devices/lab_pin.sym} 100080 -28680 0 0 {name=p99350 lab=_52100_/A }
C {devices/lab_pin.sym} 100080 -28640 0 0 {name=p99351 lab=_48380_/X }
C {devices/lab_pin.sym} 100200 -28660 0 1 {name=p99352 lab=_52105_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -28660 0 0 {name=X_52105_ }
C {devices/lab_pin.sym} 100050 -28530 0 0 {name=p99353 lab=_88062_/CLK }
C {devices/lab_pin.sym} 100050 -28510 0 0 {name=p99354 lab=_87802_/D }
C {devices/lab_pin.sym} 100230 -28530 0 1 {name=p99355 lab=_73394_/A }
C {sky130_stdcells/dfxtp_4.sym} 100140 -28520 0 0 {name=X_87802_ }
C {devices/lab_pin.sym} 100060 -28420 0 0 {name=p99356 lab=_80109_/X }
C {devices/lab_pin.sym} 100060 -28380 0 0 {name=p99357 lab=_80112_/Y }
C {devices/lab_pin.sym} 100060 -28340 0 0 {name=p99358 lab=_80122_/X }
C {devices/lab_pin.sym} 100060 -28300 0 0 {name=p99359 lab=_80125_/Y }
C {devices/lab_pin.sym} 100220 -28360 0 1 {name=p99360 lab=_80137_/X }
C {sky130_stdcells/o22a_4.sym} 100140 -28360 0 0 {name=X_80137_ }
C {devices/lab_pin.sym} 100060 -28230 0 0 {name=p99361 lab=_53081_/Y }
C {devices/lab_pin.sym} 100060 -28190 0 0 {name=p99362 lab=_53082_/X }
C {devices/lab_pin.sym} 100060 -28150 0 0 {name=p99363 lab=_53084_/X }
C {devices/lab_pin.sym} 100220 -28190 0 1 {name=p99364 lab=_85700_/D }
C {sky130_stdcells/a21oi_4.sym} 100140 -28190 0 0 {name=X_53085_ }
C {devices/lab_pin.sym} 100100 -28050 0 0 {name=p99365 lab=_58679_/A }
C {devices/lab_pin.sym} 100180 -28050 0 1 {name=p99366 lab=_57962_/X }
C {sky130_stdcells/buf_2.sym} 100140 -28050 0 0 {name=X_57962_ }
C {devices/lab_pin.sym} 100060 -27950 0 0 {name=p99367 lab=_69945_/X }
C {devices/lab_pin.sym} 100060 -27910 0 0 {name=p99368 lab=_69947_/X }
C {devices/lab_pin.sym} 100060 -27870 0 0 {name=p99369 lab=_69624_/X }
C {devices/lab_pin.sym} 100220 -27910 0 1 {name=p99370 lab=_69948_/X }
C {sky130_stdcells/a21o_4.sym} 100140 -27910 0 0 {name=X_69948_ }
C {devices/lab_pin.sym} 100080 -27780 0 0 {name=p99371 lab=_50285_/A }
C {devices/lab_pin.sym} 100080 -27740 0 0 {name=p99372 lab=_47969_/B }
C {devices/lab_pin.sym} 100200 -27760 0 1 {name=p99373 lab=_50297_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -27760 0 0 {name=X_50297_ }
C {devices/lab_pin.sym} 100050 -27630 0 0 {name=p99374 lab=_85704_/CLK }
C {devices/lab_pin.sym} 100050 -27610 0 0 {name=p99375 lab=_51528_/Y }
C {devices/lab_pin.sym} 100230 -27630 0 1 {name=p99376 lab=_85994_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -27620 0 0 {name=X_85994_ }
C {devices/lab_pin.sym} 100100 -27490 0 0 {name=p99377 lab=_66262_/A }
C {devices/lab_pin.sym} 100180 -27490 0 1 {name=p99378 lab=_59711_/B }
C {sky130_stdcells/buf_2.sym} 100140 -27490 0 0 {name=X_59701_ }
C {devices/lab_pin.sym} 100080 -27380 0 0 {name=p99379 lab=_52014_/X }
C {devices/lab_pin.sym} 100080 -27340 0 0 {name=p99380 lab=_52036_/B }
C {devices/lab_pin.sym} 100200 -27360 0 1 {name=p99381 lab=_52036_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -27360 0 0 {name=X_52036_ }
C {devices/lab_pin.sym} 100100 -27230 0 0 {name=p99382 lab=_57272_/D }
C {devices/lab_pin.sym} 100180 -27230 0 1 {name=p99383 lab=_57319_/D }
C {sky130_stdcells/buf_2.sym} 100140 -27230 0 0 {name=X_56913_ }
C {devices/lab_pin.sym} 100050 -27110 0 0 {name=p99384 lab=_87487_/CLK }
C {devices/lab_pin.sym} 100050 -27090 0 0 {name=p99385 lab=_42762_/Y }
C {devices/lab_pin.sym} 100230 -27110 0 1 {name=p99386 lab=_87733_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -27100 0 0 {name=X_87733_ }
C {devices/lab_pin.sym} 100050 -26970 0 0 {name=p99387 lab=_84945_/CLK }
C {devices/lab_pin.sym} 100050 -26950 0 0 {name=p99388 lab=_57856_/Y }
C {devices/lab_pin.sym} 100230 -26970 0 1 {name=p99389 lab=_84945_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -26960 0 0 {name=X_84945_ }
C {devices/lab_pin.sym} 100080 -26840 0 0 {name=p99390 lab=_84936_/Q }
C {devices/lab_pin.sym} 100080 -26800 0 0 {name=p99391 lab=_65698_/C }
C {devices/lab_pin.sym} 100200 -26820 0 1 {name=p99392 lab=_80068_/X }
C {sky130_stdcells/xor2_4.sym} 100140 -26820 0 0 {name=X_80068_ }
C {devices/lab_pin.sym} 100100 -26690 0 0 {name=p99393 lab=_58007_/A }
C {devices/lab_pin.sym} 100180 -26690 0 1 {name=p99394 lab=_57893_/X }
C {sky130_stdcells/buf_2.sym} 100140 -26690 0 0 {name=X_57893_ }
C {devices/lab_pin.sym} 100060 -26590 0 0 {name=p99395 lab=_69876_/X }
C {devices/lab_pin.sym} 100060 -26550 0 0 {name=p99396 lab=_69878_/X }
C {devices/lab_pin.sym} 100060 -26510 0 0 {name=p99397 lab=_69742_/X }
C {devices/lab_pin.sym} 100220 -26550 0 1 {name=p99398 lab=_69879_/Y }
C {sky130_stdcells/a21oi_4.sym} 100140 -26550 0 0 {name=X_69879_ }
C {devices/lab_pin.sym} 100080 -26440 0 0 {name=p99399 lab=_74531_/A }
C {devices/lab_pin.sym} 100080 -26400 0 0 {name=p99400 lab=_70710_/C }
C {devices/lab_pin.sym} 100080 -26360 0 0 {name=p99401 lab=_71902_/X }
C {devices/lab_pin.sym} 100080 -26320 0 0 {name=p99402 lab=_71928_/D }
C {devices/lab_pin.sym} 100200 -26380 0 1 {name=p99403 lab=_71910_/Y }
C {sky130_stdcells/nand4_4.sym} 100140 -26380 0 0 {name=X_71910_ }
C {devices/lab_pin.sym} 100060 -26250 0 0 {name=p99404 lab=_59512_/X }
C {devices/lab_pin.sym} 100060 -26210 0 0 {name=p99405 lab=_59689_/A }
C {devices/lab_pin.sym} 100060 -26170 0 0 {name=p99406 lab=_59631_/Y }
C {devices/lab_pin.sym} 100220 -26210 0 1 {name=p99407 lab=_59632_/X }
C {sky130_stdcells/o21a_4.sym} 100140 -26210 0 0 {name=X_59632_ }
C {devices/lab_pin.sym} 100060 -26090 0 0 {name=p99408 lab=_55290_/A }
C {devices/lab_pin.sym} 100060 -26050 0 0 {name=p99409 lab=_55678_/A }
C {devices/lab_pin.sym} 100060 -26010 0 0 {name=p99410 lab=_55670_/B }
C {devices/lab_pin.sym} 100220 -26050 0 1 {name=p99411 lab=_56844_/X }
C {sky130_stdcells/a21bo_4.sym} 100140 -26050 0 0 {name=X_56844_ }
C {devices/lab_pin.sym} 100050 -25910 0 0 {name=p99412 lab=_87408_/CLK }
C {devices/lab_pin.sym} 100050 -25890 0 0 {name=p99413 lab=_87664_/D }
C {devices/lab_pin.sym} 100230 -25910 0 1 {name=p99414 lab=_67415_/B }
C {sky130_stdcells/dfxtp_4.sym} 100140 -25900 0 0 {name=X_87664_ }
C {devices/lab_pin.sym} 100050 -25770 0 0 {name=p99415 lab=_84823_/CLK }
C {devices/lab_pin.sym} 100050 -25750 0 0 {name=p99416 lab=_84876_/D }
C {devices/lab_pin.sym} 100230 -25770 0 1 {name=p99417 lab=_58329_/A }
C {sky130_stdcells/dfxtp_4.sym} 100140 -25760 0 0 {name=X_84876_ }
C {devices/lab_pin.sym} 100100 -25630 0 0 {name=p99418 lab=_72889_/X }
C {devices/lab_pin.sym} 100180 -25630 0 1 {name=p99419 lab=_72890_/X }
C {sky130_stdcells/buf_2.sym} 100140 -25630 0 0 {name=X_72890_ }
C {devices/lab_pin.sym} 100050 -25510 0 0 {name=p99420 lab=_85969_/CLK }
C {devices/lab_pin.sym} 100050 -25490 0 0 {name=p99421 lab=_47630_/Y }
C {devices/lab_pin.sym} 100230 -25510 0 1 {name=p99422 lab=_72247_/A }
C {sky130_stdcells/dfxtp_4.sym} 100140 -25500 0 0 {name=X_86615_ }
C {devices/lab_pin.sym} 100080 -25400 0 0 {name=p99423 lab=_71072_/A }
C {devices/lab_pin.sym} 100080 -25360 0 0 {name=p99424 lab=_71714_/Y }
C {devices/lab_pin.sym} 100080 -25320 0 0 {name=p99425 lab=_70790_/A }
C {devices/lab_pin.sym} 100080 -25280 0 0 {name=p99426 lab=_70721_/A }
C {devices/lab_pin.sym} 100200 -25340 0 1 {name=p99427 lab=_71841_/X }
C {sky130_stdcells/and4_4.sym} 100140 -25340 0 0 {name=X_71841_ }
C {devices/lab_pin.sym} 100050 -25190 0 0 {name=p99428 lab=_83188_/CLK }
C {devices/lab_pin.sym} 100050 -25170 0 0 {name=p99429 lab=_83827_/D }
C {devices/lab_pin.sym} 100230 -25190 0 1 {name=p99430 lab=_74755_/B }
C {sky130_stdcells/dfxtp_4.sym} 100140 -25180 0 0 {name=X_83827_ }
C {devices/lab_pin.sym} 100100 -25050 0 0 {name=p99431 lab=_59563_/A }
C {devices/lab_pin.sym} 100180 -25050 0 1 {name=p99432 lab=_59564_/B }
C {sky130_stdcells/buf_2.sym} 100140 -25050 0 0 {name=X_59563_ }
C {devices/lab_pin.sym} 100080 -24950 0 0 {name=p99433 lab=_56775_/A }
C {devices/lab_pin.sym} 100080 -24910 0 0 {name=p99434 lab=_83324_/Q }
C {devices/lab_pin.sym} 100080 -24870 0 0 {name=p99435 lab=_56768_/Y }
C {devices/lab_pin.sym} 100200 -24910 0 1 {name=p99436 lab=_56776_/B }
C {sky130_stdcells/nand3_4.sym} 100140 -24910 0 0 {name=X_56775_ }
C {devices/lab_pin.sym} 100050 -24770 0 0 {name=p99437 lab=_87595_/CLK }
C {devices/lab_pin.sym} 100050 -24750 0 0 {name=p99438 lab=_43049_/Y }
C {devices/lab_pin.sym} 100230 -24770 0 1 {name=p99439 lab=_87595_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -24760 0 0 {name=X_87595_ }
C {devices/lab_pin.sym} 100080 -24640 0 0 {name=p99440 lab=_53978_/A }
C {devices/lab_pin.sym} 100080 -24600 0 0 {name=p99441 lab=_52468_/B }
C {devices/lab_pin.sym} 100200 -24620 0 1 {name=p99442 lab=_53987_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -24620 0 0 {name=X_53987_ }
C {devices/lab_pin.sym} 100100 -24490 0 0 {name=p99443 lab=_84830_/Q }
C {devices/lab_pin.sym} 100180 -24490 0 1 {name=p99444 lab=_63496_/B }
C {sky130_stdcells/buf_2.sym} 100140 -24490 0 0 {name=X_58514_ }
C {devices/lab_pin.sym} 100100 -24370 0 0 {name=p99445 lab=_48759_/A }
C {devices/lab_pin.sym} 100180 -24370 0 1 {name=p99446 lab=_47846_/A }
C {sky130_stdcells/buf_2.sym} 100140 -24370 0 0 {name=X_43740_ }
C {devices/lab_pin.sym} 100060 -24270 0 0 {name=p99447 lab=_55723_/X }
C {devices/lab_pin.sym} 100060 -24230 0 0 {name=p99448 lab=_55725_/X }
C {devices/lab_pin.sym} 100060 -24190 0 0 {name=p99449 lab=_55138_/A }
C {devices/lab_pin.sym} 100220 -24230 0 1 {name=p99450 lab=_55726_/Y }
C {sky130_stdcells/a21oi_4.sym} 100140 -24230 0 0 {name=X_55726_ }
C {devices/lab_pin.sym} 100100 -24090 0 0 {name=p99451 lab=clkbuf_8_4_0_CLK/X }
C {devices/lab_pin.sym} 100180 -24090 0 1 {name=p99452 lab=clkbuf_9_9_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 100140 -24090 0 0 {name=Xclkbuf_9_9_0_CLK }
C {devices/lab_pin.sym} 100060 -24000 0 0 {name=p99453 lab=_74559_/X }
C {devices/lab_pin.sym} 100060 -23960 0 0 {name=p99454 lab=_74553_/X }
C {devices/lab_pin.sym} 100060 -23920 0 0 {name=p99455 lab=_56035_/A }
C {devices/lab_pin.sym} 100060 -23880 0 0 {name=p99456 lab=_74554_/X }
C {devices/lab_pin.sym} 100220 -23940 0 1 {name=p99457 lab=_74560_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -23940 0 0 {name=X_74560_ }
C {devices/lab_pin.sym} 100050 -23790 0 0 {name=p99458 lab=_86554_/CLK }
C {devices/lab_pin.sym} 100050 -23770 0 0 {name=p99459 lab=_86546_/D }
C {devices/lab_pin.sym} 100230 -23790 0 1 {name=p99460 lab=_86546_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -23780 0 0 {name=X_86546_ }
C {devices/lab_pin.sym} 100100 -23650 0 0 {name=p99461 lab=_40952_/A }
C {devices/lab_pin.sym} 100180 -23650 0 1 {name=p99462 lab=_88305_/D }
C {sky130_stdcells/inv_2.sym} 100140 -23650 0 0 {name=X_40952_ }
C {devices/lab_pin.sym} 100080 -23560 0 0 {name=p99463 lab=_52922_/A }
C {devices/lab_pin.sym} 100080 -23520 0 0 {name=p99464 lab=_52954_/B }
C {devices/lab_pin.sym} 100080 -23480 0 0 {name=p99465 lab=_52926_/X }
C {devices/lab_pin.sym} 100080 -23440 0 0 {name=p99466 lab=_52938_/D }
C {devices/lab_pin.sym} 100200 -23500 0 1 {name=p99467 lab=_52938_/X }
C {sky130_stdcells/and4_4.sym} 100140 -23500 0 0 {name=X_52938_ }
C {devices/lab_pin.sym} 100080 -23370 0 0 {name=p99468 lab=_71763_/X }
C {devices/lab_pin.sym} 100080 -23330 0 0 {name=p99469 lab=_71815_/B }
C {devices/lab_pin.sym} 100080 -23290 0 0 {name=p99470 lab=_70986_/A }
C {devices/lab_pin.sym} 100200 -23330 0 1 {name=p99471 lab=_71772_/X }
C {sky130_stdcells/and3_4.sym} 100140 -23330 0 0 {name=X_71772_ }
C {devices/lab_pin.sym} 100080 -23200 0 0 {name=p99472 lab=_58230_/A }
C {devices/lab_pin.sym} 100080 -23160 0 0 {name=p99473 lab=_59493_/Y }
C {devices/lab_pin.sym} 100200 -23180 0 1 {name=p99474 lab=_59494_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -23180 0 0 {name=X_59494_ }
C {devices/lab_pin.sym} 100050 -23050 0 0 {name=p99475 lab=_83761_/CLK }
C {devices/lab_pin.sym} 100050 -23030 0 0 {name=p99476 lab=_83758_/D }
C {devices/lab_pin.sym} 100230 -23050 0 1 {name=p99477 lab=_83758_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -23040 0 0 {name=X_83758_ }
C {devices/lab_pin.sym} 100060 -22930 0 0 {name=p99478 lab=_73508_/X }
C {devices/lab_pin.sym} 100060 -22890 0 0 {name=p99479 lab=_73510_/X }
C {devices/lab_pin.sym} 100060 -22850 0 0 {name=p99480 lab=_73347_/X }
C {devices/lab_pin.sym} 100220 -22890 0 1 {name=p99481 lab=_73524_/B }
C {sky130_stdcells/a21o_4.sym} 100140 -22890 0 0 {name=X_73511_ }
C {devices/lab_pin.sym} 100060 -22770 0 0 {name=p99482 lab=_52777_/B }
C {devices/lab_pin.sym} 100060 -22730 0 0 {name=p99483 lab=_70699_/A }
C {devices/lab_pin.sym} 100060 -22690 0 0 {name=p99484 lab=_70722_/Y }
C {devices/lab_pin.sym} 100220 -22730 0 1 {name=p99485 lab=_70723_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -22730 0 0 {name=X_70723_ }
C {devices/lab_pin.sym} 100100 -22590 0 0 {name=p99486 lab=_63230_/A }
C {devices/lab_pin.sym} 100180 -22590 0 1 {name=p99487 lab=_58446_/A }
C {sky130_stdcells/buf_2.sym} 100140 -22590 0 0 {name=X_58445_ }
C {devices/lab_pin.sym} 100050 -22470 0 0 {name=p99488 lab=_82665_/CLK }
C {devices/lab_pin.sym} 100050 -22450 0 0 {name=p99489 lab=_82709_/D }
C {devices/lab_pin.sym} 100230 -22470 0 1 {name=p99490 lab=_82709_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -22460 0 0 {name=X_82709_ }
C {devices/lab_pin.sym} 100100 -22330 0 0 {name=p99491 lab=_43685_/A }
C {devices/lab_pin.sym} 100180 -22330 0 1 {name=p99492 lab=_43671_/X }
C {sky130_stdcells/buf_2.sym} 100140 -22330 0 0 {name=X_43671_ }
C {devices/lab_pin.sym} 100080 -22220 0 0 {name=p99493 lab=_55241_/B }
C {devices/lab_pin.sym} 100080 -22180 0 0 {name=p99494 lab=_55228_/Y }
C {devices/lab_pin.sym} 100200 -22200 0 1 {name=p99495 lab=_55657_/Y }
C {sky130_stdcells/xnor2_4.sym} 100140 -22200 0 0 {name=X_55657_ }
C {devices/lab_pin.sym} 100050 -22070 0 0 {name=p99496 lab=_86499_/CLK }
C {devices/lab_pin.sym} 100050 -22050 0 0 {name=p99497 lab=_86477_/D }
C {devices/lab_pin.sym} 100230 -22070 0 1 {name=p99498 lab=_86477_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -22060 0 0 {name=X_86477_ }
C {devices/lab_pin.sym} 100060 -21950 0 0 {name=p99499 lab=_83055_/Q }
C {devices/lab_pin.sym} 100060 -21910 0 0 {name=p99500 lab=_74474_/X }
C {devices/lab_pin.sym} 100060 -21870 0 0 {name=p99501 lab=_74490_/Y }
C {devices/lab_pin.sym} 100220 -21910 0 1 {name=p99502 lab=_74491_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -21910 0 0 {name=X_74491_ }
C {devices/lab_pin.sym} 100080 -21780 0 0 {name=p99503 lab=_40883_/A }
C {devices/lab_pin.sym} 100080 -21740 0 0 {name=p99504 lab=_40883_/B }
C {devices/lab_pin.sym} 100200 -21760 0 1 {name=p99505 lab=_40883_/X }
C {sky130_stdcells/or2_4.sym} 100140 -21760 0 0 {name=X_40883_ }
C {devices/lab_pin.sym} 100080 -21640 0 0 {name=p99506 lab=_52850_/A }
C {devices/lab_pin.sym} 100080 -21600 0 0 {name=p99507 lab=_52869_/B }
C {devices/lab_pin.sym} 100200 -21620 0 1 {name=p99508 lab=_52869_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -21620 0 0 {name=X_52869_ }
C {devices/lab_pin.sym} 100050 -21490 0 0 {name=p99509 lab=_83685_/CLK }
C {devices/lab_pin.sym} 100050 -21470 0 0 {name=p99510 lab=_83689_/D }
C {devices/lab_pin.sym} 100230 -21490 0 1 {name=p99511 lab=_83689_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -21480 0 0 {name=X_83689_ }
C {devices/lab_pin.sym} 100060 -21380 0 0 {name=p99512 lab=_55625_/B }
C {devices/lab_pin.sym} 100060 -21340 0 0 {name=p99513 lab=_45388_/X }
C {devices/lab_pin.sym} 100060 -21300 0 0 {name=p99514 lab=_45390_/X }
C {devices/lab_pin.sym} 100060 -21260 0 0 {name=p99515 lab=_45409_/Y }
C {devices/lab_pin.sym} 100220 -21320 0 1 {name=p99516 lab=_45410_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -21320 0 0 {name=X_45410_ }
C {devices/lab_pin.sym} 100050 -21170 0 0 {name=p99517 lab=_88215_/CLK }
C {devices/lab_pin.sym} 100050 -21150 0 0 {name=p99518 lab=_41434_/X }
C {devices/lab_pin.sym} 100230 -21170 0 1 {name=p99519 lab=_88216_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -21160 0 0 {name=X_88216_ }
C {devices/lab_pin.sym} 100100 -21030 0 0 {name=p99520 lab=_81640_/Q }
C {devices/lab_pin.sym} 100180 -21030 0 1 {name=p99521 lab=_76230_/Y }
C {sky130_stdcells/inv_2.sym} 100140 -21030 0 0 {name=X_76230_ }
C {devices/lab_pin.sym} 100100 -20910 0 0 {name=p99522 lab=_73507_/A }
C {devices/lab_pin.sym} 100180 -20910 0 1 {name=p99523 lab=_69958_/B }
C {sky130_stdcells/inv_2.sym} 100140 -20910 0 0 {name=X_42622_ }
C {devices/lab_pin.sym} 100060 -20810 0 0 {name=p99524 lab=_54606_/Y }
C {devices/lab_pin.sym} 100060 -20770 0 0 {name=p99525 lab=_54584_/X }
C {devices/lab_pin.sym} 100060 -20730 0 0 {name=p99526 lab=_54607_/X }
C {devices/lab_pin.sym} 100220 -20770 0 1 {name=p99527 lab=_54608_/Y }
C {sky130_stdcells/a21oi_4.sym} 100140 -20770 0 0 {name=X_54608_ }
C {devices/lab_pin.sym} 100060 -20650 0 0 {name=p99528 lab=_73439_/X }
C {devices/lab_pin.sym} 100060 -20610 0 0 {name=p99529 lab=_73441_/X }
C {devices/lab_pin.sym} 100060 -20570 0 0 {name=p99530 lab=_72862_/X }
C {devices/lab_pin.sym} 100220 -20610 0 1 {name=p99531 lab=_73442_/X }
C {sky130_stdcells/a21o_4.sym} 100140 -20610 0 0 {name=X_73442_ }
C {devices/lab_pin.sym} 100050 -20470 0 0 {name=p99532 lab=_85428_/CLK }
C {devices/lab_pin.sym} 100050 -20450 0 0 {name=p99533 lab=_54517_/Y }
C {devices/lab_pin.sym} 100230 -20470 0 1 {name=p99534 lab=_85428_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -20460 0 0 {name=X_85428_ }
C {devices/lab_pin.sym} 100060 -20350 0 0 {name=p99535 lab=_46348_/X }
C {devices/lab_pin.sym} 100060 -20310 0 0 {name=p99536 lab=_49009_/A }
C {devices/lab_pin.sym} 100060 -20270 0 0 {name=p99537 lab=_46389_/X }
C {devices/lab_pin.sym} 100220 -20310 0 1 {name=p99538 lab=_46391_/A }
C {sky130_stdcells/o21ai_4.sym} 100140 -20310 0 0 {name=X_46390_ }
C {devices/lab_pin.sym} 100060 -20190 0 0 {name=p99539 lab=_53041_/B }
C {devices/lab_pin.sym} 100060 -20150 0 0 {name=p99540 lab=_70631_/X }
C {devices/lab_pin.sym} 100060 -20110 0 0 {name=p99541 lab=_70653_/Y }
C {devices/lab_pin.sym} 100220 -20150 0 1 {name=p99542 lab=_83732_/D }
C {sky130_stdcells/o21ai_4.sym} 100140 -20150 0 0 {name=X_70654_ }
C {devices/lab_pin.sym} 100100 -20010 0 0 {name=p99543 lab=_84865_/Q }
C {devices/lab_pin.sym} 100180 -20010 0 1 {name=p99544 lab=_58377_/A }
C {sky130_stdcells/inv_2.sym} 100140 -20010 0 0 {name=X_58376_ }
C {devices/lab_pin.sym} 100100 -19890 0 0 {name=p99545 lab=_55527_/X }
C {devices/lab_pin.sym} 100180 -19890 0 1 {name=p99546 lab=_55617_/A }
C {sky130_stdcells/buf_2.sym} 100140 -19890 0 0 {name=X_55588_ }
C {sky130_stdcells/decap_3.sym} 100140 -19740 0 0 {name=XPHY_50 }
C {devices/lab_pin.sym} 100060 -19610 0 0 {name=p99547 lab=_56452_/C }
C {devices/lab_pin.sym} 100060 -19570 0 0 {name=p99548 lab=_45326_/X }
C {devices/lab_pin.sym} 100060 -19530 0 0 {name=p99549 lab=_45340_/X }
C {devices/lab_pin.sym} 100220 -19570 0 1 {name=p99550 lab=_45341_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -19570 0 0 {name=X_45341_ }
C {devices/lab_pin.sym} 100080 -19450 0 0 {name=p99551 lab=_57188_/A }
C {devices/lab_pin.sym} 100080 -19410 0 0 {name=p99552 lab=_57327_/B }
C {devices/lab_pin.sym} 100080 -19370 0 0 {name=p99553 lab=_56818_/X }
C {devices/lab_pin.sym} 100200 -19410 0 1 {name=p99554 lab=_57328_/A }
C {sky130_stdcells/nand3_4.sym} 100140 -19410 0 0 {name=X_57327_ }
C {sky130_stdcells/decap_3.sym} 100140 -19240 0 0 {name=XPHY_61 }
C {devices/lab_pin.sym} 100080 -19110 0 0 {name=p99555 lab=_76158_/X }
C {devices/lab_pin.sym} 100080 -19070 0 0 {name=p99556 lab=_81635_/Q }
C {devices/lab_pin.sym} 100080 -19030 0 0 {name=p99557 lab=_76159_/Y }
C {devices/lab_pin.sym} 100200 -19070 0 1 {name=p99558 lab=_76161_/Y }
C {sky130_stdcells/nand3_4.sym} 100140 -19070 0 0 {name=X_76161_ }
C {devices/lab_pin.sym} 100050 -18930 0 0 {name=p99559 lab=_87436_/CLK }
C {devices/lab_pin.sym} 100050 -18910 0 0 {name=p99560 lab=_88147_/D }
C {devices/lab_pin.sym} 100230 -18930 0 1 {name=p99561 lab=_66583_/B }
C {sky130_stdcells/dfxtp_4.sym} 100140 -18920 0 0 {name=X_88147_ }
C {devices/lab_pin.sym} 100060 -18810 0 0 {name=p99562 lab=_54534_/Y }
C {devices/lab_pin.sym} 100060 -18770 0 0 {name=p99563 lab=_54530_/X }
C {devices/lab_pin.sym} 100060 -18730 0 0 {name=p99564 lab=_54538_/X }
C {devices/lab_pin.sym} 100220 -18770 0 1 {name=p99565 lab=_85424_/D }
C {sky130_stdcells/a21oi_4.sym} 100140 -18770 0 0 {name=X_54539_ }
C {devices/lab_pin.sym} 100100 -18630 0 0 {name=p99566 lab=_42553_/A }
C {devices/lab_pin.sym} 100180 -18630 0 1 {name=p99567 lab=_42553_/Y }
C {sky130_stdcells/inv_2.sym} 100140 -18630 0 0 {name=X_42553_ }
C {devices/lab_pin.sym} 100060 -18540 0 0 {name=p99568 lab=_69883_/B }
C {devices/lab_pin.sym} 100060 -18500 0 0 {name=p99569 lab=_44235_/X }
C {devices/lab_pin.sym} 100060 -18460 0 0 {name=p99570 lab=_73031_/X }
C {devices/lab_pin.sym} 100060 -18420 0 0 {name=p99571 lab=_73372_/Y }
C {devices/lab_pin.sym} 100220 -18480 0 1 {name=p99572 lab=_73373_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -18480 0 0 {name=X_73373_ }
C {devices/lab_pin.sym} 100050 -18330 0 0 {name=p99573 lab=_86289_/CLK }
C {devices/lab_pin.sym} 100050 -18310 0 0 {name=p99574 lab=_54891_/Y }
C {devices/lab_pin.sym} 100230 -18330 0 1 {name=p99575 lab=_85359_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -18320 0 0 {name=X_85359_ }
C {sky130_stdcells/decap_3.sym} 100140 -18160 0 0 {name=XPHY_72 }
C {devices/lab_pin.sym} 100100 -18010 0 0 {name=p99576 lab=_70984_/A }
C {devices/lab_pin.sym} 100180 -18010 0 1 {name=p99577 lab=_70585_/X }
C {sky130_stdcells/buf_2.sym} 100140 -18010 0 0 {name=X_70585_ }
C {sky130_stdcells/decap_3.sym} 100140 -17860 0 0 {name=XPHY_83 }
C {sky130_stdcells/decap_3.sym} 100140 -17680 0 0 {name=XPHY_94 }
C {devices/lab_pin.sym} 100060 -17550 0 0 {name=p99578 lab=_75113_/A }
C {devices/lab_pin.sym} 100060 -17510 0 0 {name=p99579 lab=_75113_/C }
C {devices/lab_pin.sym} 100060 -17470 0 0 {name=p99580 lab=_81061_/Q }
C {devices/lab_pin.sym} 100220 -17510 0 1 {name=p99581 lab=_75117_/B }
C {sky130_stdcells/a21o_4.sym} 100140 -17510 0 0 {name=X_75112_ }
C {devices/lab_pin.sym} 100060 -17400 0 0 {name=p99582 lab=_41503_/X }
C {devices/lab_pin.sym} 100060 -17360 0 0 {name=p99583 lab=_41486_/X }
C {devices/lab_pin.sym} 100060 -17320 0 0 {name=p99584 lab=_88203_/Q }
C {devices/lab_pin.sym} 100060 -17280 0 0 {name=p99585 lab=_41487_/X }
C {devices/lab_pin.sym} 100220 -17340 0 1 {name=p99586 lab=_88203_/D }
C {sky130_stdcells/a2bb2o_4.sym} 100140 -17340 0 0 {name=X_41504_ }
C {devices/lab_pin.sym} 100100 -17190 0 0 {name=p99587 lab=_59081_/A }
C {devices/lab_pin.sym} 100180 -17190 0 1 {name=p99588 lab=_72324_/X }
C {sky130_stdcells/buf_2.sym} 100140 -17190 0 0 {name=X_72324_ }
C {devices/lab_pin.sym} 100100 -17070 0 0 {name=p99589 lab=_48060_/A }
C {devices/lab_pin.sym} 100180 -17070 0 1 {name=p99590 lab=_53567_/B }
C {sky130_stdcells/inv_2.sym} 100140 -17070 0 0 {name=X_48060_ }
C {devices/lab_pin.sym} 100100 -16950 0 0 {name=p99591 lab=_45272_/A }
C {devices/lab_pin.sym} 100180 -16950 0 1 {name=p99592 lab=_45272_/X }
C {sky130_stdcells/buf_2.sym} 100140 -16950 0 0 {name=X_45272_ }
C {devices/lab_pin.sym} 100060 -16850 0 0 {name=p99593 lab=_56626_/X }
C {devices/lab_pin.sym} 100060 -16810 0 0 {name=p99594 lab=_57247_/Y }
C {devices/lab_pin.sym} 100060 -16770 0 0 {name=p99595 lab=_57257_/Y }
C {devices/lab_pin.sym} 100220 -16810 0 1 {name=p99596 lab=_57258_/Y }
C {sky130_stdcells/a21oi_4.sym} 100140 -16810 0 0 {name=X_57258_ }
C {devices/lab_pin.sym} 100080 -16680 0 0 {name=p99597 lab=_81722_/D }
C {devices/lab_pin.sym} 100080 -16640 0 0 {name=p99598 lab=_76092_/B }
C {devices/lab_pin.sym} 100200 -16660 0 1 {name=p99599 lab=_76093_/A }
C {sky130_stdcells/nand2_4.sym} 100140 -16660 0 0 {name=X_76092_ }
C {devices/lab_pin.sym} 100060 -16570 0 0 {name=p99600 lab=_42460_/X }
C {devices/lab_pin.sym} 100060 -16530 0 0 {name=p99601 lab=_42472_/X }
C {devices/lab_pin.sym} 100060 -16490 0 0 {name=p99602 lab=_40646_/X }
C {devices/lab_pin.sym} 100060 -16450 0 0 {name=p99603 lab=_68618_/B }
C {devices/lab_pin.sym} 100060 -16410 0 0 {name=p99604 lab=_42463_/X }
C {devices/lab_pin.sym} 100220 -16490 0 1 {name=p99605 lab=_87849_/D }
C {sky130_stdcells/o32ai_4.sym} 100140 -16490 0 0 {name=X_42484_ }
C {devices/lab_pin.sym} 100050 -16330 0 0 {name=p99606 lab=_88081_/CLK }
C {devices/lab_pin.sym} 100050 -16310 0 0 {name=p99607 lab=_88078_/D }
C {devices/lab_pin.sym} 100230 -16330 0 1 {name=p99608 lab=_88078_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -16320 0 0 {name=X_88078_ }
C {devices/lab_pin.sym} 100100 -16190 0 0 {name=p99609 lab=_82392_/Q }
C {devices/lab_pin.sym} 100180 -16190 0 1 {name=p99610 lab=_54494_/D }
C {sky130_stdcells/inv_2.sym} 100140 -16190 0 0 {name=X_47011_ }
C {devices/lab_pin.sym} 100100 -16070 0 0 {name=p99611 lab=_69751_/A }
C {devices/lab_pin.sym} 100180 -16070 0 1 {name=p99612 lab=_66608_/A }
C {sky130_stdcells/buf_2.sym} 100140 -16070 0 0 {name=X_44223_ }
C {devices/lab_pin.sym} 100060 -15970 0 0 {name=p99613 lab=_56035_/X }
C {devices/lab_pin.sym} 100060 -15930 0 0 {name=p99614 lab=_56195_/X }
C {devices/lab_pin.sym} 100060 -15890 0 0 {name=p99615 lab=_56208_/Y }
C {devices/lab_pin.sym} 100220 -15930 0 1 {name=p99616 lab=_85275_/D }
C {sky130_stdcells/o21ai_4.sym} 100140 -15930 0 0 {name=X_56209_ }
C {devices/lab_pin.sym} 100060 -15810 0 0 {name=p99617 lab=_75035_/Y }
C {devices/lab_pin.sym} 100060 -15770 0 0 {name=p99618 lab=_75047_/A }
C {devices/lab_pin.sym} 100060 -15730 0 0 {name=p99619 lab=_75042_/Y }
C {devices/lab_pin.sym} 100220 -15770 0 1 {name=p99620 lab=_75043_/Y }
C {sky130_stdcells/a21boi_4.sym} 100140 -15770 0 0 {name=X_75043_ }
C {devices/lab_pin.sym} 100080 -15640 0 0 {name=p99621 lab=_79918_/Y }
C {devices/lab_pin.sym} 100080 -15600 0 0 {name=p99622 lab=_79919_/Y }
C {devices/lab_pin.sym} 100200 -15620 0 1 {name=p99623 lab=_79920_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -15620 0 0 {name=X_79920_ }
C {devices/lab_pin.sym} 100080 -15500 0 0 {name=p99624 lab=_41435_/A }
C {devices/lab_pin.sym} 100080 -15460 0 0 {name=p99625 lab=_41435_/B }
C {devices/lab_pin.sym} 100200 -15480 0 1 {name=p99626 lab=_41435_/X }
C {sky130_stdcells/or2_4.sym} 100140 -15480 0 0 {name=X_41435_ }
C {devices/lab_pin.sym} 100050 -15350 0 0 {name=p99627 lab=_88301_/CLK }
C {devices/lab_pin.sym} 100050 -15330 0 0 {name=p99628 lab=_87029_/D }
C {devices/lab_pin.sym} 100230 -15350 0 1 {name=p99629 lab=_87029_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -15340 0 0 {name=X_87029_ }
C {devices/lab_pin.sym} 100100 -15210 0 0 {name=p99630 lab=_72255_/A }
C {devices/lab_pin.sym} 100180 -15210 0 1 {name=p99631 lab=_72255_/X }
C {sky130_stdcells/buf_2.sym} 100140 -15210 0 0 {name=X_72255_ }
C {devices/lab_pin.sym} 100060 -15110 0 0 {name=p99632 lab=_57087_/X }
C {devices/lab_pin.sym} 100060 -15070 0 0 {name=p99633 lab=_57185_/Y }
C {devices/lab_pin.sym} 100060 -15030 0 0 {name=p99634 lab=_57188_/Y }
C {devices/lab_pin.sym} 100220 -15070 0 1 {name=p99635 lab=_57189_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -15070 0 0 {name=X_57189_ }
C {devices/lab_pin.sym} 100060 -14950 0 0 {name=p99636 lab=_48816_/B }
C {devices/lab_pin.sym} 100060 -14910 0 0 {name=p99637 lab=_71190_/X }
C {devices/lab_pin.sym} 100060 -14870 0 0 {name=p99638 lab=_71205_/Y }
C {devices/lab_pin.sym} 100220 -14910 0 1 {name=p99639 lab=_83573_/D }
C {sky130_stdcells/o21ai_4.sym} 100140 -14910 0 0 {name=X_71206_ }
C {devices/lab_pin.sym} 100100 -14770 0 0 {name=p99640 lab=_45920_/A }
C {devices/lab_pin.sym} 100180 -14770 0 1 {name=p99641 lab=_66563_/A }
C {sky130_stdcells/buf_2.sym} 100140 -14770 0 0 {name=X_44154_ }
C {devices/lab_pin.sym} 100080 -14660 0 0 {name=p99642 lab=_79828_/Y }
C {devices/lab_pin.sym} 100080 -14620 0 0 {name=p99643 lab=_79850_/Y }
C {devices/lab_pin.sym} 100200 -14640 0 1 {name=p99644 lab=_79851_/Y }
C {sky130_stdcells/nor2_4.sym} 100140 -14640 0 0 {name=X_79851_ }
C {devices/lab_pin.sym} 100060 -14530 0 0 {name=p99645 lab=_41261_/X }
C {devices/lab_pin.sym} 100060 -14490 0 0 {name=p99646 lab=_81746_/Q }
C {devices/lab_pin.sym} 100060 -14450 0 0 {name=p99647 lab=_41365_/X }
C {devices/lab_pin.sym} 100220 -14490 0 1 {name=p99648 lab=_41366_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -14490 0 0 {name=X_41366_ }
C {devices/lab_pin.sym} 100060 -14370 0 0 {name=p99649 lab=_72182_/Y }
C {devices/lab_pin.sym} 100060 -14330 0 0 {name=p99650 lab=_72184_/Y }
C {devices/lab_pin.sym} 100060 -14290 0 0 {name=p99651 lab=_72185_/X }
C {devices/lab_pin.sym} 100220 -14330 0 1 {name=p99652 lab=_72186_/X }
C {sky130_stdcells/a21o_4.sym} 100140 -14330 0 0 {name=X_72186_ }
C {devices/lab_pin.sym} 100100 -14190 0 0 {name=p99653 lab=_43129_/A }
C {devices/lab_pin.sym} 100180 -14190 0 1 {name=p99654 lab=_43105_/X }
C {sky130_stdcells/buf_2.sym} 100140 -14190 0 0 {name=X_43105_ }
C {devices/lab_pin.sym} 100100 -14070 0 0 {name=p99655 lab=_82626_/Q }
C {devices/lab_pin.sym} 100180 -14070 0 1 {name=p99656 lab=_78802_/Y }
C {sky130_stdcells/inv_2.sym} 100140 -14070 0 0 {name=X_78802_ }
C {devices/lab_pin.sym} 100080 -13960 0 0 {name=p99657 lab=_71137_/A }
C {devices/lab_pin.sym} 100080 -13920 0 0 {name=p99658 lab=_71137_/B }
C {devices/lab_pin.sym} 100200 -13940 0 1 {name=p99659 lab=_71138_/A }
C {sky130_stdcells/nor2_4.sym} 100140 -13940 0 0 {name=X_71137_ }
C {devices/lab_pin.sym} 100100 -13810 0 0 {name=p99660 lab=_48962_/A }
C {devices/lab_pin.sym} 100180 -13810 0 1 {name=p99661 lab=_71996_/B }
C {sky130_stdcells/inv_2.sym} 100140 -13810 0 0 {name=X_48962_ }
C {devices/lab_pin.sym} 100080 -13720 0 0 {name=p99662 lab=_44072_/Y }
C {devices/lab_pin.sym} 100080 -13680 0 0 {name=p99663 lab=_44293_/B }
C {devices/lab_pin.sym} 100080 -13640 0 0 {name=p99664 lab=_44085_/C }
C {devices/lab_pin.sym} 100080 -13600 0 0 {name=p99665 lab=_44085_/D }
C {devices/lab_pin.sym} 100200 -13660 0 1 {name=p99666 lab=_44085_/Y }
C {sky130_stdcells/nor4_4.sym} 100140 -13660 0 0 {name=X_44085_ }
C {devices/lab_pin.sym} 100060 -13530 0 0 {name=p99667 lab=_64891_/C }
C {devices/lab_pin.sym} 100060 -13490 0 0 {name=p99668 lab=_72236_/Y }
C {devices/lab_pin.sym} 100060 -13450 0 0 {name=p99669 lab=_79781_/Y }
C {devices/lab_pin.sym} 100220 -13490 0 1 {name=p99670 lab=_79782_/X }
C {sky130_stdcells/o21a_4.sym} 100140 -13490 0 0 {name=X_79782_ }
C {devices/lab_pin.sym} 100060 -13370 0 0 {name=p99671 lab=_41290_/X }
C {devices/lab_pin.sym} 100060 -13330 0 0 {name=p99672 lab=_82911_/Q }
C {devices/lab_pin.sym} 100060 -13290 0 0 {name=p99673 lab=_41296_/X }
C {devices/lab_pin.sym} 100220 -13330 0 1 {name=p99674 lab=_41298_/A }
C {sky130_stdcells/o21ai_4.sym} 100140 -13330 0 0 {name=X_41297_ }
C {devices/lab_pin.sym} 100080 -13200 0 0 {name=p99675 lab=_84546_/Q }
C {devices/lab_pin.sym} 100080 -13160 0 0 {name=p99676 lab=_62328_/C }
C {devices/lab_pin.sym} 100200 -13180 0 1 {name=p99677 lab=_76994_/X }
C {sky130_stdcells/xor2_4.sym} 100140 -13180 0 0 {name=X_76994_ }
C {devices/lab_pin.sym} 100060 -13070 0 0 {name=p99678 lab=_66008_/B }
C {devices/lab_pin.sym} 100060 -13030 0 0 {name=p99679 lab=_47897_/X }
C {devices/lab_pin.sym} 100060 -12990 0 0 {name=p99680 lab=_47912_/Y }
C {devices/lab_pin.sym} 100220 -13030 0 1 {name=p99681 lab=_47913_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -13030 0 0 {name=X_47913_ }
C {devices/lab_pin.sym} 100060 -12930 0 0 {name=p99682 lab=_42439_/X }
C {devices/lab_pin.sym} 100060 -12890 0 0 {name=p99683 lab=_43017_/X }
C {devices/lab_pin.sym} 100060 -12850 0 0 {name=p99684 lab=_40605_/X }
C {devices/lab_pin.sym} 100060 -12810 0 0 {name=p99685 lab=_73653_/A }
C {devices/lab_pin.sym} 100060 -12770 0 0 {name=p99686 lab=_43025_/X }
C {devices/lab_pin.sym} 100220 -12850 0 1 {name=p99687 lab=_43036_/Y }
C {sky130_stdcells/o32ai_4.sym} 100140 -12850 0 0 {name=X_43036_ }
C {devices/lab_pin.sym} 100060 -12710 0 0 {name=p99688 lab=_78732_/B }
C {devices/lab_pin.sym} 100060 -12670 0 0 {name=p99689 lab=_78732_/C }
C {devices/lab_pin.sym} 100060 -12630 0 0 {name=p99690 lab=_78732_/A }
C {devices/lab_pin.sym} 100220 -12670 0 1 {name=p99691 lab=_78733_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -12670 0 0 {name=X_78733_ }
C {devices/lab_pin.sym} 100080 -12540 0 0 {name=p99692 lab=_70355_/A }
C {devices/lab_pin.sym} 100080 -12500 0 0 {name=p99693 lab=_71068_/B }
C {devices/lab_pin.sym} 100200 -12520 0 1 {name=p99694 lab=_71069_/A }
C {sky130_stdcells/and2_4.sym} 100140 -12520 0 0 {name=X_71068_ }
C {devices/lab_pin.sym} 100080 -12400 0 0 {name=p99695 lab=_81702_/D }
C {devices/lab_pin.sym} 100080 -12360 0 0 {name=p99696 lab=_75952_/B }
C {devices/lab_pin.sym} 100200 -12380 0 1 {name=p99697 lab=_75949_/A }
C {sky130_stdcells/xor2_4.sym} 100140 -12380 0 0 {name=X_75945_ }
C {devices/lab_pin.sym} 100100 -12250 0 0 {name=p99698 lab=_48893_/A }
C {devices/lab_pin.sym} 100180 -12250 0 1 {name=p99699 lab=_48894_/A }
C {sky130_stdcells/buf_2.sym} 100140 -12250 0 0 {name=X_48893_ }
C {devices/lab_pin.sym} 100100 -12130 0 0 {name=p99700 lab=_62910_/A }
C {devices/lab_pin.sym} 100180 -12130 0 1 {name=p99701 lab=_62967_/A }
C {sky130_stdcells/buf_2.sym} 100140 -12130 0 0 {name=X_62910_ }
C {devices/lab_pin.sym} 100060 -12030 0 0 {name=p99702 lab=_68620_/X }
C {devices/lab_pin.sym} 100060 -11990 0 0 {name=p99703 lab=_68622_/X }
C {devices/lab_pin.sym} 100060 -11950 0 0 {name=p99704 lab=_69992_/X }
C {devices/lab_pin.sym} 100220 -11990 0 1 {name=p99705 lab=_70021_/A }
C {sky130_stdcells/a21o_4.sym} 100140 -11990 0 0 {name=X_70019_ }
C {devices/lab_pin.sym} 100080 -11860 0 0 {name=p99706 lab=_47855_/A }
C {devices/lab_pin.sym} 100080 -11820 0 0 {name=p99707 lab=_50224_/B }
C {devices/lab_pin.sym} 100200 -11840 0 1 {name=p99708 lab=_47844_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -11840 0 0 {name=X_47844_ }
C {devices/lab_pin.sym} 100060 -11730 0 0 {name=p99709 lab=_78663_/B }
C {devices/lab_pin.sym} 100060 -11690 0 0 {name=p99710 lab=_78663_/C }
C {devices/lab_pin.sym} 100060 -11650 0 0 {name=p99711 lab=_78663_/A }
C {devices/lab_pin.sym} 100220 -11690 0 1 {name=p99712 lab=_78664_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -11690 0 0 {name=X_78664_ }
C {devices/lab_pin.sym} 100100 -11550 0 0 {name=p99713 lab=_63741_/A }
C {devices/lab_pin.sym} 100180 -11550 0 1 {name=p99714 lab=_63890_/X }
C {sky130_stdcells/buf_2.sym} 100140 -11550 0 0 {name=X_63890_ }
C {devices/lab_pin.sym} 100080 -11440 0 0 {name=p99715 lab=_75876_/A }
C {devices/lab_pin.sym} 100080 -11400 0 0 {name=p99716 lab=_75876_/B }
C {devices/lab_pin.sym} 100200 -11420 0 1 {name=p99717 lab=_80897_/D }
C {sky130_stdcells/nand2_4.sym} 100140 -11420 0 0 {name=X_75876_ }
C {devices/lab_pin.sym} 100060 -11310 0 0 {name=p99718 lab=_77614_/B }
C {devices/lab_pin.sym} 100060 -11270 0 0 {name=p99719 lab=_77614_/C }
C {devices/lab_pin.sym} 100060 -11230 0 0 {name=p99720 lab=_77614_/A }
C {devices/lab_pin.sym} 100220 -11270 0 1 {name=p99721 lab=_77619_/C }
C {sky130_stdcells/o21ai_4.sym} 100140 -11270 0 0 {name=X_77615_ }
C {devices/lab_pin.sym} 100100 -11130 0 0 {name=p99722 lab=_62979_/A }
C {devices/lab_pin.sym} 100180 -11130 0 1 {name=p99723 lab=_62841_/X }
C {sky130_stdcells/buf_2.sym} 100140 -11130 0 0 {name=X_62841_ }
C {devices/lab_pin.sym} 100080 -11020 0 0 {name=p99724 lab=_74829_/A }
C {devices/lab_pin.sym} 100080 -10980 0 0 {name=p99725 lab=_46188_/A }
C {devices/lab_pin.sym} 100200 -11000 0 1 {name=p99726 lab=_74828_/A }
C {sky130_stdcells/nand2_4.sym} 100140 -11000 0 0 {name=X_74827_ }
C {devices/lab_pin.sym} 100100 -10870 0 0 {name=p99727 lab=_81223_/Q }
C {devices/lab_pin.sym} 100180 -10870 0 1 {name=p99728 lab=_47776_/A }
C {sky130_stdcells/inv_2.sym} 100140 -10870 0 0 {name=X_47775_ }
C {devices/lab_pin.sym} 100060 -10770 0 0 {name=p99729 lab=_78584_/Y }
C {devices/lab_pin.sym} 100060 -10730 0 0 {name=p99730 lab=_78585_/Y }
C {devices/lab_pin.sym} 100060 -10690 0 0 {name=p99731 lab=_78586_/Y }
C {devices/lab_pin.sym} 100220 -10730 0 1 {name=p99732 lab=_78623_/B }
C {sky130_stdcells/o21a_4.sym} 100140 -10730 0 0 {name=X_78595_ }
C {devices/lab_pin.sym} 100060 -10610 0 0 {name=p99733 lab=_44981_/Y }
C {devices/lab_pin.sym} 100060 -10570 0 0 {name=p99734 lab=_44984_/Y }
C {devices/lab_pin.sym} 100060 -10530 0 0 {name=p99735 lab=_44986_/X }
C {devices/lab_pin.sym} 100220 -10570 0 1 {name=p99736 lab=_44987_/X }
C {sky130_stdcells/a21o_4.sym} 100140 -10570 0 0 {name=X_44987_ }
C {devices/lab_pin.sym} 100100 -10430 0 0 {name=p99737 lab=_49434_/A }
C {devices/lab_pin.sym} 100180 -10430 0 1 {name=p99738 lab=_49514_/X }
C {sky130_stdcells/buf_2.sym} 100140 -10430 0 0 {name=X_49514_ }
C {devices/lab_pin.sym} 100100 -10310 0 0 {name=p99739 lab=_46915_/A }
C {devices/lab_pin.sym} 100180 -10310 0 1 {name=p99740 lab=_46737_/A }
C {sky130_stdcells/buf_2.sym} 100140 -10310 0 0 {name=X_46726_ }
C {devices/lab_pin.sym} 100060 -10210 0 0 {name=p99741 lab=_65557_/Y }
C {devices/lab_pin.sym} 100060 -10170 0 0 {name=p99742 lab=_65529_/X }
C {devices/lab_pin.sym} 100060 -10130 0 0 {name=p99743 lab=_65559_/X }
C {devices/lab_pin.sym} 100220 -10170 0 1 {name=p99744 lab=_84193_/D }
C {sky130_stdcells/a21o_4.sym} 100140 -10170 0 0 {name=X_65560_ }
C {devices/lab_pin.sym} 100060 -10050 0 0 {name=p99745 lab=_77526_/Y }
C {devices/lab_pin.sym} 100060 -10010 0 0 {name=p99746 lab=_77561_/B }
C {devices/lab_pin.sym} 100060 -9970 0 0 {name=p99747 lab=_77561_/A }
C {devices/lab_pin.sym} 100220 -10010 0 1 {name=p99748 lab=_77547_/B }
C {sky130_stdcells/a21boi_4.sym} 100140 -10010 0 0 {name=X_77546_ }
C {devices/lab_pin.sym} 100060 -9900 0 0 {name=p99749 lab=_41447_/X }
C {devices/lab_pin.sym} 100060 -9860 0 0 {name=p99750 lab=_43928_/X }
C {devices/lab_pin.sym} 100060 -9820 0 0 {name=p99751 lab=_68044_/B }
C {devices/lab_pin.sym} 100060 -9780 0 0 {name=p99752 lab=_43929_/X }
C {devices/lab_pin.sym} 100220 -9840 0 1 {name=p99753 lab=_43938_/X }
C {sky130_stdcells/a2bb2o_4.sym} 100140 -9840 0 0 {name=X_43938_ }
C {devices/lab_pin.sym} 100100 -9690 0 0 {name=p99754 lab=_62949_/B }
C {devices/lab_pin.sym} 100180 -9690 0 1 {name=p99755 lab=_62772_/X }
C {sky130_stdcells/buf_2.sym} 100140 -9690 0 0 {name=X_62772_ }
C {devices/lab_pin.sym} 100080 -9590 0 0 {name=p99756 lab=_74741_/X }
C {devices/lab_pin.sym} 100080 -9550 0 0 {name=p99757 lab=_74758_/B }
C {devices/lab_pin.sym} 100080 -9510 0 0 {name=p99758 lab=_74758_/C }
C {devices/lab_pin.sym} 100200 -9550 0 1 {name=p99759 lab=_80644_/A }
C {sky130_stdcells/nand3_4.sym} 100140 -9550 0 0 {name=X_74758_ }
C {devices/lab_pin.sym} 100080 -9420 0 0 {name=p99760 lab=_61656_/A }
C {devices/lab_pin.sym} 100080 -9380 0 0 {name=p99761 lab=_64511_/B }
C {devices/lab_pin.sym} 100200 -9400 0 1 {name=p99762 lab=_64511_/Y }
C {sky130_stdcells/nor2_4.sym} 100140 -9400 0 0 {name=X_64511_ }
C {devices/lab_pin.sym} 100080 -9280 0 0 {name=p99763 lab=_49454_/A }
C {devices/lab_pin.sym} 100080 -9240 0 0 {name=p99764 lab=_46758_/X }
C {devices/lab_pin.sym} 100200 -9260 0 1 {name=p99765 lab=_49445_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -9260 0 0 {name=X_49445_ }
C {devices/lab_pin.sym} 100100 -9130 0 0 {name=p99766 lab=_44124_/A }
C {devices/lab_pin.sym} 100180 -9130 0 1 {name=p99767 lab=_73709_/X }
C {sky130_stdcells/buf_2.sym} 100140 -9130 0 0 {name=X_73709_ }
C {devices/lab_pin.sym} 100100 -9010 0 0 {name=p99768 lab=_61476_/A }
C {devices/lab_pin.sym} 100180 -9010 0 1 {name=p99769 lab=_61723_/X }
C {sky130_stdcells/buf_2.sym} 100140 -9010 0 0 {name=X_61723_ }
C {devices/lab_pin.sym} 100100 -8890 0 0 {name=p99770 lab=_82973_/Q }
C {devices/lab_pin.sym} 100180 -8890 0 1 {name=p99771 lab=_46658_/A }
C {sky130_stdcells/inv_2.sym} 100140 -8890 0 0 {name=X_46657_ }
C {devices/lab_pin.sym} 100060 -8790 0 0 {name=p99772 lab=_65488_/X }
C {devices/lab_pin.sym} 100060 -8750 0 0 {name=p99773 lab=_65490_/X }
C {devices/lab_pin.sym} 100060 -8710 0 0 {name=p99774 lab=_65457_/X }
C {devices/lab_pin.sym} 100220 -8750 0 1 {name=p99775 lab=_65491_/X }
C {sky130_stdcells/a21o_4.sym} 100140 -8750 0 0 {name=X_65491_ }
C {devices/lab_pin.sym} 100100 -8610 0 0 {name=p99776 lab=_77476_/Y }
C {devices/lab_pin.sym} 100180 -8610 0 1 {name=p99777 lab=_77477_/Y }
C {sky130_stdcells/inv_2.sym} 100140 -8610 0 0 {name=X_77477_ }
C {devices/lab_pin.sym} 100100 -8490 0 0 {name=p99778 lab=_43605_/A }
C {devices/lab_pin.sym} 100180 -8490 0 1 {name=p99779 lab=_43869_/X }
C {sky130_stdcells/buf_2.sym} 100140 -8490 0 0 {name=X_43869_ }
C {devices/lab_pin.sym} 100060 -8390 0 0 {name=p99780 lab=_57050_/A }
C {devices/lab_pin.sym} 100060 -8350 0 0 {name=p99781 lab=_74656_/X }
C {devices/lab_pin.sym} 100060 -8310 0 0 {name=p99782 lab=_74688_/Y }
C {devices/lab_pin.sym} 100220 -8350 0 1 {name=p99783 lab=_74689_/X }
C {sky130_stdcells/a21bo_4.sym} 100140 -8350 0 0 {name=X_74689_ }
C {devices/lab_pin.sym} 100100 -8210 0 0 {name=p99784 lab=_66868_/A }
C {devices/lab_pin.sym} 100180 -8210 0 1 {name=p99785 lab=_67230_/X }
C {sky130_stdcells/buf_2.sym} 100140 -8210 0 0 {name=X_67230_ }
C {devices/lab_pin.sym} 100080 -8100 0 0 {name=p99786 lab=_84790_/Q }
C {devices/lab_pin.sym} 100080 -8060 0 0 {name=p99787 lab=_84110_/Q }
C {devices/lab_pin.sym} 100200 -8080 0 1 {name=p99788 lab=_79236_/A }
C {sky130_stdcells/nand2_4.sym} 100140 -8080 0 0 {name=X_79216_ }
C {devices/lab_pin.sym} 100100 -7950 0 0 {name=p99789 lab=_45452_/A }
C {devices/lab_pin.sym} 100180 -7950 0 1 {name=p99790 lab=_45608_/X }
C {sky130_stdcells/buf_2.sym} 100140 -7950 0 0 {name=X_45608_ }
C {devices/lab_pin.sym} 100100 -7830 0 0 {name=p99791 lab=_64386_/A }
C {devices/lab_pin.sym} 100180 -7830 0 1 {name=p99792 lab=_64442_/X }
C {sky130_stdcells/buf_2.sym} 100140 -7830 0 0 {name=X_64442_ }
C {devices/lab_pin.sym} 100080 -7720 0 0 {name=p99793 lab=_81269_/Q }
C {devices/lab_pin.sym} 100080 -7680 0 0 {name=p99794 lab=_81525_/D }
C {devices/lab_pin.sym} 100200 -7700 0 1 {name=p99795 lab=_76429_/A }
C {sky130_stdcells/nand2_4.sym} 100140 -7700 0 0 {name=X_76428_ }
C {devices/lab_pin.sym} 100080 -7580 0 0 {name=p99796 lab=_49382_/A }
C {devices/lab_pin.sym} 100080 -7540 0 0 {name=p99797 lab=_51765_/B }
C {devices/lab_pin.sym} 100200 -7560 0 1 {name=p99798 lab=_49376_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -7560 0 0 {name=X_49376_ }
C {devices/lab_pin.sym} 100100 -7430 0 0 {name=p99799 lab=_61340_/A }
C {devices/lab_pin.sym} 100180 -7430 0 1 {name=p99800 lab=_61654_/X }
C {sky130_stdcells/buf_2.sym} 100140 -7430 0 0 {name=X_61654_ }
C {devices/lab_pin.sym} 100060 -7330 0 0 {name=p99801 lab=_86723_/Q }
C {devices/lab_pin.sym} 100060 -7290 0 0 {name=p99802 lab=_46543_/X }
C {devices/lab_pin.sym} 100060 -7250 0 0 {name=p99803 lab=_46587_/Y }
C {devices/lab_pin.sym} 100220 -7290 0 1 {name=p99804 lab=_46588_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -7290 0 0 {name=X_46588_ }
C {devices/lab_pin.sym} 100080 -7160 0 0 {name=p99805 lab=_48319_/A }
C {devices/lab_pin.sym} 100080 -7120 0 0 {name=p99806 lab=_50370_/B }
C {devices/lab_pin.sym} 100200 -7140 0 1 {name=p99807 lab=_48327_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -7140 0 0 {name=X_48327_ }
C {devices/lab_pin.sym} 100060 -7040 0 0 {name=p99808 lab=_79128_/A }
C {devices/lab_pin.sym} 100060 -7000 0 0 {name=p99809 lab=_60577_/X }
C {devices/lab_pin.sym} 100060 -6960 0 0 {name=p99810 lab=_60491_/X }
C {devices/lab_pin.sym} 100060 -6920 0 0 {name=p99811 lab=_60572_/B }
C {devices/lab_pin.sym} 100220 -6980 0 1 {name=p99812 lab=_84588_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 100140 -6980 0 0 {name=X_60605_ }
C {devices/lab_pin.sym} 100080 -6840 0 0 {name=p99813 lab=_67087_/A }
C {devices/lab_pin.sym} 100080 -6800 0 0 {name=p99814 lab=_67161_/B }
C {devices/lab_pin.sym} 100200 -6820 0 1 {name=p99815 lab=_67161_/X }
C {sky130_stdcells/and2_4.sym} 100140 -6820 0 0 {name=X_67161_ }
C {devices/lab_pin.sym} 100080 -6700 0 0 {name=p99816 lab=_79147_/A }
C {devices/lab_pin.sym} 100080 -6660 0 0 {name=p99817 lab=_84479_/Q }
C {devices/lab_pin.sym} 100200 -6680 0 1 {name=p99818 lab=_79147_/X }
C {sky130_stdcells/xor2_4.sym} 100140 -6680 0 0 {name=X_79147_ }
C {devices/lab_pin.sym} 100060 -6580 0 0 {name=p99819 lab=_55539_/B }
C {devices/lab_pin.sym} 100060 -6540 0 0 {name=p99820 lab=_45489_/X }
C {devices/lab_pin.sym} 100060 -6500 0 0 {name=p99821 lab=_45520_/X }
C {devices/lab_pin.sym} 100060 -6460 0 0 {name=p99822 lab=_45538_/Y }
C {devices/lab_pin.sym} 100220 -6520 0 1 {name=p99823 lab=_45539_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -6520 0 0 {name=X_45539_ }
C {devices/lab_pin.sym} 100100 -6370 0 0 {name=p99824 lab=_64314_/A }
C {devices/lab_pin.sym} 100180 -6370 0 1 {name=p99825 lab=_64373_/X }
C {sky130_stdcells/buf_2.sym} 100140 -6370 0 0 {name=X_64373_ }
C {devices/lab_pin.sym} 100060 -6270 0 0 {name=p99826 lab=_76336_/A }
C {devices/lab_pin.sym} 100060 -6230 0 0 {name=p99827 lab=_76336_/B }
C {devices/lab_pin.sym} 100060 -6190 0 0 {name=p99828 lab=_76338_/A }
C {devices/lab_pin.sym} 100220 -6230 0 1 {name=p99829 lab=_76359_/Y }
C {sky130_stdcells/a21boi_4.sym} 100140 -6230 0 0 {name=X_76359_ }
C {devices/lab_pin.sym} 100100 -6090 0 0 {name=p99830 lab=_61584_/X }
C {devices/lab_pin.sym} 100180 -6090 0 1 {name=p99831 lab=_61585_/Y }
C {sky130_stdcells/inv_2.sym} 100140 -6090 0 0 {name=X_61585_ }
C {devices/lab_pin.sym} 100080 -5980 0 0 {name=p99832 lab=_57694_/X }
C {devices/lab_pin.sym} 100080 -5940 0 0 {name=p99833 lab=_73901_/B }
C {devices/lab_pin.sym} 100200 -5960 0 1 {name=p99834 lab=_66112_/X }
C {sky130_stdcells/and2_4.sym} 100140 -5960 0 0 {name=X_66112_ }
C {devices/lab_pin.sym} 100080 -5860 0 0 {name=p99835 lab=_60433_/A }
C {devices/lab_pin.sym} 100080 -5820 0 0 {name=p99836 lab=_63324_/B }
C {devices/lab_pin.sym} 100080 -5780 0 0 {name=p99837 lab=_63333_/C }
C {devices/lab_pin.sym} 100080 -5740 0 0 {name=p99838 lab=_63240_/X }
C {devices/lab_pin.sym} 100200 -5800 0 1 {name=p99839 lab=_63324_/X }
C {sky130_stdcells/and4_4.sym} 100140 -5800 0 0 {name=X_63324_ }
C {devices/lab_pin.sym} 100060 -5670 0 0 {name=p99840 lab=_48255_/Y }
C {devices/lab_pin.sym} 100060 -5630 0 0 {name=p99841 lab=_48226_/X }
C {devices/lab_pin.sym} 100060 -5590 0 0 {name=p99842 lab=_48257_/Y }
C {devices/lab_pin.sym} 100220 -5630 0 1 {name=p99843 lab=_48258_/Y }
C {sky130_stdcells/a21boi_4.sym} 100140 -5630 0 0 {name=X_48258_ }
C {devices/lab_pin.sym} 100060 -5530 0 0 {name=p99844 lab=_60481_/A }
C {devices/lab_pin.sym} 100060 -5490 0 0 {name=p99845 lab=_60532_/Y }
C {devices/lab_pin.sym} 100060 -5450 0 0 {name=p99846 lab=_60586_/A }
C {devices/lab_pin.sym} 100060 -5410 0 0 {name=p99847 lab=_60534_/Y }
C {devices/lab_pin.sym} 100060 -5380 0 0 {name=p99848 lab=_60535_/Y }
C {devices/lab_pin.sym} 100220 -5450 0 1 {name=p99849 lab=_60536_/X }
C {sky130_stdcells/a41o_4.sym} 100140 -5450 0 0 {name=X_60536_ }
C {devices/lab_pin.sym} 100100 -5290 0 0 {name=p99850 lab=_66971_/A }
C {devices/lab_pin.sym} 100180 -5290 0 1 {name=p99851 lab=_67092_/X }
C {sky130_stdcells/buf_2.sym} 100140 -5290 0 0 {name=X_67092_ }
C {devices/lab_pin.sym} 100060 -5190 0 0 {name=p99852 lab=_79065_/Y }
C {devices/lab_pin.sym} 100060 -5150 0 0 {name=p99853 lab=_79070_/B }
C {devices/lab_pin.sym} 100060 -5110 0 0 {name=p99854 lab=_79077_/Y }
C {devices/lab_pin.sym} 100220 -5150 0 1 {name=p99855 lab=_79078_/Y }
C {sky130_stdcells/o21ai_4.sym} 100140 -5150 0 0 {name=X_79078_ }
C {devices/lab_pin.sym} 100100 -5010 0 0 {name=p99856 lab=clkbuf_6_51_0_CLK/A }
C {devices/lab_pin.sym} 100180 -5010 0 1 {name=p99857 lab=clkbuf_6_50_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 100140 -5010 0 0 {name=Xclkbuf_6_50_0_CLK }
C {devices/lab_pin.sym} 100100 -4890 0 0 {name=p99858 lab=_47208_/Y }
C {devices/lab_pin.sym} 100180 -4890 0 1 {name=p99859 lab=_51225_/D }
C {sky130_stdcells/buf_2.sym} 100140 -4890 0 0 {name=X_47209_ }
C {devices/lab_pin.sym} 100080 -4780 0 0 {name=p99860 lab=_66043_/A }
C {devices/lab_pin.sym} 100080 -4740 0 0 {name=p99861 lab=_66042_/X }
C {devices/lab_pin.sym} 100200 -4760 0 1 {name=p99862 lab=_66043_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -4760 0 0 {name=X_66043_ }
C {devices/lab_pin.sym} 100080 -4640 0 0 {name=p99863 lab=_82081_/Q }
C {devices/lab_pin.sym} 100080 -4600 0 0 {name=p99864 lab=_78028_/X }
C {devices/lab_pin.sym} 100200 -4620 0 1 {name=p99865 lab=_78030_/A }
C {sky130_stdcells/xor2_4.sym} 100140 -4620 0 0 {name=X_78029_ }
C {devices/lab_pin.sym} 100060 -4530 0 0 {name=p99866 lab=_63248_/X }
C {devices/lab_pin.sym} 100060 -4490 0 0 {name=p99867 lab=_63249_/Y }
C {devices/lab_pin.sym} 100060 -4450 0 0 {name=p99868 lab=_63251_/X }
C {devices/lab_pin.sym} 100060 -4410 0 0 {name=p99869 lab=_63252_/Y }
C {devices/lab_pin.sym} 100060 -4380 0 0 {name=p99870 lab=_63254_/Y }
C {devices/lab_pin.sym} 100220 -4450 0 1 {name=p99871 lab=_63255_/X }
C {sky130_stdcells/a41o_4.sym} 100140 -4450 0 0 {name=X_63255_ }
C {devices/lab_pin.sym} 100100 -4290 0 0 {name=p99872 lab=_60466_/X }
C {devices/lab_pin.sym} 100180 -4290 0 1 {name=p99873 lab=_63347_/C }
C {sky130_stdcells/buf_2.sym} 100140 -4290 0 0 {name=X_60467_ }
C {devices/lab_pin.sym} 100100 -4170 0 0 {name=p99874 lab=_48163_/X }
C {devices/lab_pin.sym} 100180 -4170 0 1 {name=p99875 lab=_48190_/A }
C {sky130_stdcells/buf_2.sym} 100140 -4170 0 0 {name=X_48189_ }
C {devices/lab_pin.sym} 100100 -4050 0 0 {name=p99876 lab=_50219_/X }
C {devices/lab_pin.sym} 100180 -4050 0 1 {name=p99877 lab=_50220_/X }
C {sky130_stdcells/buf_2.sym} 100140 -4050 0 0 {name=X_50220_ }
C {devices/lab_pin.sym} 100080 -3950 0 0 {name=p99878 lab=_62249_/A }
C {devices/lab_pin.sym} 100080 -3910 0 0 {name=p99879 lab=_59477_/A }
C {devices/lab_pin.sym} 100080 -3870 0 0 {name=p99880 lab=_59987_/X }
C {devices/lab_pin.sym} 100200 -3910 0 1 {name=p99881 lab=_62206_/Y }
C {sky130_stdcells/nand3_4.sym} 100140 -3910 0 0 {name=X_62206_ }
C {devices/lab_pin.sym} 100050 -3770 0 0 {name=p99882 lab=_81040_/CLK }
C {devices/lab_pin.sym} 100050 -3750 0 0 {name=p99883 lab=_75284_/X }
C {devices/lab_pin.sym} 100230 -3770 0 1 {name=p99884 lab=_81040_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -3760 0 0 {name=X_81040_ }
C {devices/lab_pin.sym} 100060 -3650 0 0 {name=p99885 lab=_63184_/Y }
C {devices/lab_pin.sym} 100060 -3610 0 0 {name=p99886 lab=_63185_/X }
C {devices/lab_pin.sym} 100060 -3570 0 0 {name=p99887 lab=_63172_/X }
C {devices/lab_pin.sym} 100220 -3610 0 1 {name=p99888 lab=_63186_/Y }
C {sky130_stdcells/a21oi_4.sym} 100140 -3610 0 0 {name=X_63186_ }
C {devices/lab_pin.sym} 100100 -3470 0 0 {name=p99889 lab=_60473_/B }
C {devices/lab_pin.sym} 100180 -3470 0 1 {name=p99890 lab=_60570_/A }
C {sky130_stdcells/buf_2.sym} 100140 -3470 0 0 {name=X_60398_ }
C {devices/lab_pin.sym} 100060 -3380 0 0 {name=p99891 lab=_69746_/X }
C {devices/lab_pin.sym} 100060 -3340 0 0 {name=p99892 lab=_69800_/Y }
C {devices/lab_pin.sym} 100060 -3300 0 0 {name=p99893 lab=_69733_/X }
C {devices/lab_pin.sym} 100060 -3260 0 0 {name=p99894 lab=_69801_/Y }
C {devices/lab_pin.sym} 100220 -3320 0 1 {name=p99895 lab=_69802_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -3320 0 0 {name=X_69802_ }
C {devices/lab_pin.sym} 100100 -3170 0 0 {name=p99896 lab=clkbuf_9_287_0_CLK/X }
C {devices/lab_pin.sym} 100180 -3170 0 1 {name=p99897 lab=_87675_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 100140 -3170 0 0 {name=Xclkbuf_10_574_0_CLK }
C {devices/lab_pin.sym} 100080 -3060 0 0 {name=p99898 lab=_50131_/A }
C {devices/lab_pin.sym} 100080 -3020 0 0 {name=p99899 lab=_53879_/B }
C {devices/lab_pin.sym} 100200 -3040 0 1 {name=p99900 lab=_50151_/X }
C {sky130_stdcells/and2_4.sym} 100140 -3040 0 0 {name=X_50151_ }
C {devices/lab_pin.sym} 100060 -2950 0 0 {name=p99901 lab=_58198_/A }
C {devices/lab_pin.sym} 100060 -2910 0 0 {name=p99902 lab=_62105_/X }
C {devices/lab_pin.sym} 100060 -2870 0 0 {name=p99903 lab=_62065_/D }
C {devices/lab_pin.sym} 100060 -2830 0 0 {name=p99904 lab=_61948_/X }
C {devices/lab_pin.sym} 100060 -2800 0 0 {name=p99905 lab=_62136_/X }
C {devices/lab_pin.sym} 100220 -2870 0 1 {name=p99906 lab=_62137_/X }
C {sky130_stdcells/a41o_4.sym} 100140 -2870 0 0 {name=X_62137_ }
C {devices/lab_pin.sym} 100060 -2730 0 0 {name=p99907 lab=_67990_/X }
C {devices/lab_pin.sym} 100060 -2690 0 0 {name=p99908 lab=_67993_/X }
C {devices/lab_pin.sym} 100060 -2650 0 0 {name=p99909 lab=_67875_/X }
C {devices/lab_pin.sym} 100220 -2690 0 1 {name=p99910 lab=_67994_/Y }
C {sky130_stdcells/a21oi_4.sym} 100140 -2690 0 0 {name=X_67994_ }
C {devices/lab_pin.sym} 100100 -2550 0 0 {name=p99911 lab=_69733_/A }
C {devices/lab_pin.sym} 100180 -2550 0 1 {name=p99912 lab=_69733_/X }
C {sky130_stdcells/buf_2.sym} 100140 -2550 0 0 {name=X_69733_ }
C {devices/lab_pin.sym} 100080 -2450 0 0 {name=p99913 lab=_52291_/A }
C {devices/lab_pin.sym} 100080 -2410 0 0 {name=p99914 lab=_50082_/B }
C {devices/lab_pin.sym} 100080 -2370 0 0 {name=p99915 lab=_50059_/C }
C {devices/lab_pin.sym} 100200 -2410 0 1 {name=p99916 lab=_50082_/X }
C {sky130_stdcells/and3_4.sym} 100140 -2410 0 0 {name=X_50082_ }
C {devices/lab_pin.sym} 100060 -2300 0 0 {name=p99917 lab=_66899_/X }
C {devices/lab_pin.sym} 100060 -2260 0 0 {name=p99918 lab=_66934_/Y }
C {devices/lab_pin.sym} 100060 -2220 0 0 {name=p99919 lab=_66910_/X }
C {devices/lab_pin.sym} 100060 -2180 0 0 {name=p99920 lab=_66944_/Y }
C {devices/lab_pin.sym} 100220 -2240 0 1 {name=p99921 lab=_66945_/X }
C {sky130_stdcells/a211o_4.sym} 100140 -2240 0 0 {name=X_66945_ }
C {devices/lab_pin.sym} 100080 -2110 0 0 {name=p99922 lab=_62050_/X }
C {devices/lab_pin.sym} 100080 -2070 0 0 {name=p99923 lab=_62090_/B }
C {devices/lab_pin.sym} 100080 -2030 0 0 {name=p99924 lab=_78059_/B }
C {devices/lab_pin.sym} 100200 -2070 0 1 {name=p99925 lab=_62068_/Y }
C {sky130_stdcells/nor3_4.sym} 100140 -2070 0 0 {name=X_62068_ }
C {devices/lab_pin.sym} 100050 -1930 0 0 {name=p99926 lab=_85134_/CLK }
C {devices/lab_pin.sym} 100050 -1910 0 0 {name=p99927 lab=_82991_/D }
C {devices/lab_pin.sym} 100230 -1930 0 1 {name=p99928 lab=_45681_/A }
C {sky130_stdcells/dfxtp_4.sym} 100140 -1920 0 0 {name=X_82991_ }
C {devices/lab_pin.sym} 100080 -1800 0 0 {name=p99929 lab=_53910_/A }
C {devices/lab_pin.sym} 100080 -1760 0 0 {name=p99930 lab=_53821_/B }
C {devices/lab_pin.sym} 100200 -1780 0 1 {name=p99931 lab=_53910_/Y }
C {sky130_stdcells/nand2_4.sym} 100140 -1780 0 0 {name=X_53910_ }
C {devices/lab_pin.sym} 100060 -1670 0 0 {name=p99932 lab=_60954_/X }
C {devices/lab_pin.sym} 100060 -1630 0 0 {name=p99933 lab=_60994_/B }
C {devices/lab_pin.sym} 100060 -1590 0 0 {name=p99934 lab=_60996_/Y }
C {devices/lab_pin.sym} 100220 -1630 0 1 {name=p99935 lab=_61019_/X }
C {sky130_stdcells/a21o_4.sym} 100140 -1630 0 0 {name=X_61019_ }
C {devices/lab_pin.sym} 100050 -1490 0 0 {name=p99936 lab=_83464_/CLK }
C {devices/lab_pin.sym} 100050 -1470 0 0 {name=p99937 lab=_59449_/X }
C {devices/lab_pin.sym} 100230 -1490 0 1 {name=p99938 lab=_84730_/Q }
C {sky130_stdcells/dfxtp_4.sym} 100140 -1480 0 0 {name=X_84730_ }
C {devices/lab_pin.sym} 100050 -1350 0 0 {name=p99939 lab=_82005_/CLK }
C {devices/lab_pin.sym} 100050 -1330 0 0 {name=p99940 lab=_81942_/D }
C {devices/lab_pin.sym} 100230 -1350 0 1 {name=p99941 lab=_77528_/A }
C {sky130_stdcells/dfxtp_4.sym} 100140 -1340 0 0 {name=X_81942_ }
C {devices/lab_pin.sym} 100100 -1210 0 0 {name=p99942 lab=_69796_/A }
C {devices/lab_pin.sym} 100180 -1210 0 1 {name=p99943 lab=_69664_/X }
C {sky130_stdcells/buf_2.sym} 100140 -1210 0 0 {name=X_69664_ }
C {devices/lab_pin.sym} 100080 -1120 0 0 {name=p99944 lab=_54910_/A }
C {devices/lab_pin.sym} 100080 -1080 0 0 {name=p99945 lab=_54883_/B }
C {devices/lab_pin.sym} 100080 -1040 0 0 {name=p99946 lab=_54910_/C }
C {devices/lab_pin.sym} 100080 -1000 0 0 {name=p99947 lab=_53196_/D }
C {devices/lab_pin.sym} 100200 -1060 0 1 {name=p99948 lab=_54890_/X }
C {sky130_stdcells/and4_4.sym} 100140 -1060 0 0 {name=X_54890_ }
C {devices/lab_pin.sym} 100080 -920 0 0 {name=p99949 lab=_66851_/X }
C {devices/lab_pin.sym} 100080 -880 0 0 {name=p99950 lab=_66876_/B }
C {devices/lab_pin.sym} 100200 -900 0 1 {name=p99951 lab=_66876_/X }
C {sky130_stdcells/and2_4.sym} 100140 -900 0 0 {name=X_66876_ }
C {devices/lab_pin.sym} 100100 -770 0 0 {name=p99952 lab=clkbuf_9_294_0_CLK/X }
C {devices/lab_pin.sym} 100180 -770 0 1 {name=p99953 lab=_80776_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 100140 -770 0 0 {name=Xclkbuf_10_589_0_CLK }
C {devices/lab_pin.sym} 101000 -42160 0 0 {name=p99954 lab=_69685_/A }
C {devices/lab_pin.sym} 101000 -42120 0 0 {name=p99955 lab=_73797_/A }
C {devices/lab_pin.sym} 101120 -42140 0 1 {name=p99956 lab=_68615_/X }
C {sky130_stdcells/and2_4.sym} 101060 -42140 0 0 {name=X_68615_ }
C {devices/lab_pin.sym} 101000 -42020 0 0 {name=p99957 lab=_53819_/A }
C {devices/lab_pin.sym} 101000 -41980 0 0 {name=p99958 lab=_53841_/B }
C {devices/lab_pin.sym} 101120 -42000 0 1 {name=p99959 lab=_53841_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -42000 0 0 {name=X_53841_ }
C {devices/lab_pin.sym} 101000 -41880 0 0 {name=p99960 lab=_65827_/A }
C {devices/lab_pin.sym} 101000 -41840 0 0 {name=p99961 lab=_65827_/B }
C {devices/lab_pin.sym} 101120 -41860 0 1 {name=p99962 lab=_65827_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -41860 0 0 {name=X_65827_ }
C {devices/lab_pin.sym} 100970 -41730 0 0 {name=p99963 lab=_84660_/CLK }
C {devices/lab_pin.sym} 100970 -41710 0 0 {name=p99964 lab=_84661_/D }
C {devices/lab_pin.sym} 101150 -41730 0 1 {name=p99965 lab=_60103_/C }
C {sky130_stdcells/dfxtp_4.sym} 101060 -41720 0 0 {name=X_84661_ }
C {devices/lab_pin.sym} 100970 -41590 0 0 {name=p99966 lab=_82436_/CLK }
C {devices/lab_pin.sym} 100970 -41570 0 0 {name=p99967 lab=_78064_/X }
C {devices/lab_pin.sym} 101150 -41590 0 1 {name=p99968 lab=_81841_/D }
C {sky130_stdcells/dfxtp_4.sym} 101060 -41580 0 0 {name=X_81873_ }
C {devices/lab_pin.sym} 100980 -41480 0 0 {name=p99969 lab=_88081_/Q }
C {devices/lab_pin.sym} 100980 -41440 0 0 {name=p99970 lab=_69582_/X }
C {devices/lab_pin.sym} 100980 -41400 0 0 {name=p99971 lab=_69567_/X }
C {devices/lab_pin.sym} 100980 -41360 0 0 {name=p99972 lab=_69594_/Y }
C {devices/lab_pin.sym} 101140 -41420 0 1 {name=p99973 lab=_69595_/X }
C {sky130_stdcells/a211o_4.sym} 101060 -41420 0 0 {name=X_69595_ }
C {devices/lab_pin.sym} 100970 -41270 0 0 {name=p99974 lab=_86400_/CLK }
C {devices/lab_pin.sym} 100970 -41250 0 0 {name=p99975 lab=_86400_/D }
C {devices/lab_pin.sym} 101150 -41270 0 1 {name=p99976 lab=_58576_/B }
C {sky130_stdcells/dfxtp_4.sym} 101060 -41260 0 0 {name=X_86400_ }
C {devices/lab_pin.sym} 100970 -41130 0 0 {name=p99977 lab=_85555_/CLK }
C {devices/lab_pin.sym} 100970 -41110 0 0 {name=p99978 lab=_71087_/Y }
C {devices/lab_pin.sym} 101150 -41130 0 1 {name=p99979 lab=_83612_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -41120 0 0 {name=X_83612_ }
C {devices/lab_pin.sym} 100980 -41030 0 0 {name=p99980 lab=_56558_/X }
C {devices/lab_pin.sym} 100980 -40990 0 0 {name=p99981 lab=_72641_/C }
C {devices/lab_pin.sym} 100980 -40950 0 0 {name=p99982 lab=_56564_/B }
C {devices/lab_pin.sym} 100980 -40910 0 0 {name=p99983 lab=_56564_/C }
C {devices/lab_pin.sym} 100980 -40880 0 0 {name=p99984 lab=_56564_/D }
C {devices/lab_pin.sym} 101140 -40950 0 1 {name=p99985 lab=_56560_/X }
C {sky130_stdcells/a41o_4.sym} 101060 -40950 0 0 {name=X_56560_ }
C {devices/lab_pin.sym} 101000 -40800 0 0 {name=p99986 lab=_69906_/A }
C {devices/lab_pin.sym} 101000 -40760 0 0 {name=p99987 lab=_68546_/B }
C {devices/lab_pin.sym} 101120 -40780 0 1 {name=p99988 lab=_68546_/X }
C {sky130_stdcells/and2_4.sym} 101060 -40780 0 0 {name=X_68546_ }
C {devices/lab_pin.sym} 100970 -40650 0 0 {name=p99989 lab=_80931_/CLK }
C {devices/lab_pin.sym} 100970 -40630 0 0 {name=p99990 lab=_83968_/Q }
C {devices/lab_pin.sym} 101150 -40650 0 1 {name=p99991 lab=_80824_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -40640 0 0 {name=X_80824_ }
C {devices/lab_pin.sym} 100970 -40510 0 0 {name=p99992 lab=_86914_/CLK }
C {devices/lab_pin.sym} 100970 -40490 0 0 {name=p99993 lab=_43520_/Y }
C {devices/lab_pin.sym} 101150 -40510 0 1 {name=p99994 lab=_87380_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -40500 0 0 {name=X_87380_ }
C {devices/lab_pin.sym} 101020 -40370 0 0 {name=p99995 lab=_53798_/A }
C {devices/lab_pin.sym} 101100 -40370 0 1 {name=p99996 lab=_53773_/A }
C {sky130_stdcells/buf_2.sym} 101060 -40370 0 0 {name=X_53772_ }
C {devices/lab_pin.sym} 101000 -40270 0 0 {name=p99997 lab=_65621_/A }
C {devices/lab_pin.sym} 101000 -40230 0 0 {name=p99998 lab=_65775_/B }
C {devices/lab_pin.sym} 101000 -40190 0 0 {name=p99999 lab=_84180_/Q }
C {devices/lab_pin.sym} 101120 -40230 0 1 {name=p100000 lab=_65758_/X }
C {sky130_stdcells/and3_4.sym} 101060 -40230 0 0 {name=X_65758_ }
C {devices/lab_pin.sym} 100970 -40090 0 0 {name=p100001 lab=_84333_/CLK }
C {devices/lab_pin.sym} 100970 -40070 0 0 {name=p100002 lab=_84592_/D }
C {devices/lab_pin.sym} 101150 -40090 0 1 {name=p100003 lab=_79132_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -40080 0 0 {name=X_84592_ }
C {devices/lab_pin.sym} 101020 -39950 0 0 {name=p100004 lab=_50929_/A }
C {devices/lab_pin.sym} 101100 -39950 0 1 {name=p100005 lab=_50985_/B }
C {sky130_stdcells/buf_2.sym} 101060 -39950 0 0 {name=X_50984_ }
C {devices/lab_pin.sym} 101020 -39830 0 0 {name=p100006 lab=_55510_/X }
C {devices/lab_pin.sym} 101100 -39830 0 1 {name=p100007 lab=_55511_/X }
C {sky130_stdcells/buf_2.sym} 101060 -39830 0 0 {name=X_55511_ }
C {devices/lab_pin.sym} 100970 -39710 0 0 {name=p100008 lab=_86651_/CLK }
C {devices/lab_pin.sym} 100970 -39690 0 0 {name=p100009 lab=_86331_/D }
C {devices/lab_pin.sym} 101150 -39710 0 1 {name=p100010 lab=_57820_/B }
C {sky130_stdcells/dfxtp_4.sym} 101060 -39700 0 0 {name=X_86331_ }
C {devices/lab_pin.sym} 100980 -39590 0 0 {name=p100011 lab=_85766_/Q }
C {devices/lab_pin.sym} 100980 -39550 0 0 {name=p100012 lab=_52711_/X }
C {devices/lab_pin.sym} 100980 -39510 0 0 {name=p100013 lab=_52722_/Y }
C {devices/lab_pin.sym} 101140 -39550 0 1 {name=p100014 lab=_52723_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -39550 0 0 {name=X_52723_ }
C {devices/lab_pin.sym} 101020 -39410 0 0 {name=p100015 lab=clkbuf_9_256_0_CLK/X }
C {devices/lab_pin.sym} 101100 -39410 0 1 {name=p100016 lab=_81492_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 101060 -39410 0 0 {name=Xclkbuf_10_512_0_CLK }
C {devices/lab_pin.sym} 101020 -39290 0 0 {name=p100017 lab=_64898_/A }
C {devices/lab_pin.sym} 101100 -39290 0 1 {name=p100018 lab=_64710_/A }
C {sky130_stdcells/buf_2.sym} 101060 -39290 0 0 {name=X_64709_ }
C {devices/lab_pin.sym} 100970 -39170 0 0 {name=p100019 lab=_83544_/CLK }
C {devices/lab_pin.sym} 100970 -39150 0 0 {name=p100020 lab=_83543_/D }
C {devices/lab_pin.sym} 101150 -39170 0 1 {name=p100021 lab=_83543_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -39160 0 0 {name=X_83543_ }
C {devices/lab_pin.sym} 100980 -39050 0 0 {name=p100022 lab=_56055_/X }
C {devices/lab_pin.sym} 100980 -39010 0 0 {name=p100023 lab=_56483_/X }
C {devices/lab_pin.sym} 100980 -38970 0 0 {name=p100024 lab=_56490_/Y }
C {devices/lab_pin.sym} 101140 -39010 0 1 {name=p100025 lab=_85176_/D }
C {sky130_stdcells/o21ai_4.sym} 101060 -39010 0 0 {name=X_56491_ }
C {devices/lab_pin.sym} 100970 -38870 0 0 {name=p100026 lab=_80754_/CLK }
C {devices/lab_pin.sym} 100970 -38850 0 0 {name=p100027 lab=_80755_/D }
C {devices/lab_pin.sym} 101150 -38870 0 1 {name=p100028 lab=_81131_/D }
C {sky130_stdcells/dfxtp_4.sym} 101060 -38860 0 0 {name=X_80755_ }
C {devices/lab_pin.sym} 101020 -38730 0 0 {name=p100029 lab=_70001_/A }
C {devices/lab_pin.sym} 101100 -38730 0 1 {name=p100030 lab=_68477_/X }
C {sky130_stdcells/buf_2.sym} 101060 -38730 0 0 {name=X_68477_ }
C {devices/lab_pin.sym} 101000 -38620 0 0 {name=p100031 lab=_65704_/A }
C {devices/lab_pin.sym} 101000 -38580 0 0 {name=p100032 lab=_86480_/Q }
C {devices/lab_pin.sym} 101120 -38600 0 1 {name=p100033 lab=_65689_/X }
C {sky130_stdcells/and2_4.sym} 101060 -38600 0 0 {name=X_65689_ }
C {devices/lab_pin.sym} 101000 -38480 0 0 {name=p100034 lab=_58230_/A }
C {devices/lab_pin.sym} 101000 -38440 0 0 {name=p100035 lab=_58229_/Y }
C {devices/lab_pin.sym} 101120 -38460 0 1 {name=p100036 lab=_58230_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -38460 0 0 {name=X_58230_ }
C {devices/lab_pin.sym} 101020 -38330 0 0 {name=p100037 lab=_55442_/A }
C {devices/lab_pin.sym} 101100 -38330 0 1 {name=p100038 lab=_55442_/Y }
C {sky130_stdcells/inv_2.sym} 101060 -38330 0 0 {name=X_55442_ }
C {devices/lab_pin.sym} 100980 -38240 0 0 {name=p100039 lab=_87919_/Q }
C {devices/lab_pin.sym} 100980 -38200 0 0 {name=p100040 lab=_67355_/X }
C {devices/lab_pin.sym} 100980 -38160 0 0 {name=p100041 lab=_67405_/X }
C {devices/lab_pin.sym} 100980 -38120 0 0 {name=p100042 lab=_67427_/X }
C {devices/lab_pin.sym} 101140 -38180 0 1 {name=p100043 lab=_67428_/X }
C {sky130_stdcells/a211o_4.sym} 101060 -38180 0 0 {name=X_67428_ }
C {devices/lab_pin.sym} 100970 -38030 0 0 {name=p100044 lab=_85562_/CLK }
C {devices/lab_pin.sym} 100970 -38010 0 0 {name=p100045 lab=_50111_/Y }
C {devices/lab_pin.sym} 101150 -38030 0 1 {name=p100046 lab=_86262_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -38020 0 0 {name=X_86262_ }
C {devices/lab_pin.sym} 101000 -37920 0 0 {name=p100047 lab=_52648_/X }
C {devices/lab_pin.sym} 101000 -37880 0 0 {name=p100048 lab=_52654_/B }
C {devices/lab_pin.sym} 101000 -37840 0 0 {name=p100049 lab=_52654_/C }
C {devices/lab_pin.sym} 101000 -37800 0 0 {name=p100050 lab=_52654_/D }
C {devices/lab_pin.sym} 101120 -37860 0 1 {name=p100051 lab=_52654_/X }
C {sky130_stdcells/and4_4.sym} 101060 -37860 0 0 {name=X_52654_ }
C {devices/lab_pin.sym} 100970 -37710 0 0 {name=p100052 lab=_83476_/CLK }
C {devices/lab_pin.sym} 100970 -37690 0 0 {name=p100053 lab=_71505_/Y }
C {devices/lab_pin.sym} 101150 -37710 0 1 {name=p100054 lab=_83474_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -37700 0 0 {name=X_83474_ }
C {devices/lab_pin.sym} 100970 -37570 0 0 {name=p100055 lab=_80719_/CLK }
C {devices/lab_pin.sym} 100970 -37550 0 0 {name=p100056 lab=_80718_/Q }
C {devices/lab_pin.sym} 101150 -37570 0 1 {name=p100057 lab=_75239_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -37560 0 0 {name=X_80686_ }
C {devices/lab_pin.sym} 100970 -37430 0 0 {name=p100058 lab=_88001_/CLK }
C {devices/lab_pin.sym} 100970 -37410 0 0 {name=p100059 lab=_42166_/Y }
C {devices/lab_pin.sym} 101150 -37430 0 1 {name=p100060 lab=_88001_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -37420 0 0 {name=X_88001_ }
C {sky130_stdcells/decap_3.sym} 101060 -37260 0 0 {name=XPHY_604 }
C {devices/lab_pin.sym} 100970 -37110 0 0 {name=p100061 lab=_85213_/CLK }
C {devices/lab_pin.sym} 100970 -37090 0 0 {name=p100062 lab=_56389_/Y }
C {devices/lab_pin.sym} 101150 -37110 0 1 {name=p100063 lab=_85213_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -37100 0 0 {name=X_85213_ }
C {devices/lab_pin.sym} 101000 -36980 0 0 {name=p100064 lab=_51617_/A }
C {devices/lab_pin.sym} 101000 -36940 0 0 {name=p100065 lab=_53131_/B }
C {devices/lab_pin.sym} 101120 -36960 0 1 {name=p100066 lab=_51605_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -36960 0 0 {name=X_51605_ }
C {devices/lab_pin.sym} 100970 -36830 0 0 {name=p100067 lab=_82425_/CLK }
C {devices/lab_pin.sym} 100970 -36810 0 0 {name=p100068 lab=_82457_/Q }
C {devices/lab_pin.sym} 101150 -36830 0 1 {name=p100069 lab=_78646_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -36820 0 0 {name=X_82425_ }
C {devices/lab_pin.sym} 100980 -36710 0 0 {name=p100070 lab=_58153_/X }
C {devices/lab_pin.sym} 100980 -36670 0 0 {name=p100071 lab=_83494_/Q }
C {devices/lab_pin.sym} 100980 -36630 0 0 {name=p100072 lab=_58160_/Y }
C {devices/lab_pin.sym} 101140 -36670 0 1 {name=p100073 lab=_58161_/X }
C {sky130_stdcells/o21a_4.sym} 101060 -36670 0 0 {name=X_58161_ }
C {sky130_stdcells/decap_3.sym} 101060 -36500 0 0 {name=XPHY_615 }
C {devices/lab_pin.sym} 101000 -36360 0 0 {name=p100074 lab=_55288_/Y }
C {devices/lab_pin.sym} 101000 -36320 0 0 {name=p100075 lab=_55292_/X }
C {devices/lab_pin.sym} 101120 -36340 0 1 {name=p100076 lab=_55373_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -36340 0 0 {name=X_55373_ }
C {devices/lab_pin.sym} 101020 -36210 0 0 {name=p100077 lab=_68347_/A }
C {devices/lab_pin.sym} 101100 -36210 0 1 {name=p100078 lab=_67359_/X }
C {sky130_stdcells/buf_2.sym} 101060 -36210 0 0 {name=X_67359_ }
C {devices/lab_pin.sym} 100970 -36090 0 0 {name=p100079 lab=_86193_/CLK }
C {devices/lab_pin.sym} 100970 -36070 0 0 {name=p100080 lab=_86193_/D }
C {devices/lab_pin.sym} 101150 -36090 0 1 {name=p100081 lab=_86193_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -36080 0 0 {name=X_86193_ }
C {devices/lab_pin.sym} 100980 -35970 0 0 {name=p100082 lab=_52583_/Y }
C {devices/lab_pin.sym} 100980 -35930 0 0 {name=p100083 lab=_52532_/X }
C {devices/lab_pin.sym} 100980 -35890 0 0 {name=p100084 lab=_52584_/X }
C {devices/lab_pin.sym} 101140 -35930 0 1 {name=p100085 lab=_85792_/D }
C {sky130_stdcells/a21oi_4.sym} 101060 -35930 0 0 {name=X_52585_ }
C {sky130_stdcells/decap_3.sym} 101060 -35760 0 0 {name=XPHY_626 }
C {sky130_stdcells/decap_3.sym} 101060 -35580 0 0 {name=XPHY_637 }
C {sky130_stdcells/decap_3.sym} 101060 -35400 0 0 {name=XPHY_648 }
C {devices/lab_pin.sym} 101020 -35250 0 0 {name=p100086 lab=clkbuf_9_263_0_CLK/X }
C {devices/lab_pin.sym} 101100 -35250 0 1 {name=p100087 lab=_81575_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 101060 -35250 0 0 {name=Xclkbuf_10_527_0_CLK }
C {devices/lab_pin.sym} 101020 -35130 0 0 {name=p100088 lab=_57086_/X }
C {devices/lab_pin.sym} 101100 -35130 0 1 {name=p100089 lab=_57112_/X }
C {sky130_stdcells/buf_2.sym} 101060 -35130 0 0 {name=X_57112_ }
C {devices/lab_pin.sym} 100980 -35030 0 0 {name=p100090 lab=_85463_/Q }
C {devices/lab_pin.sym} 100980 -34990 0 0 {name=p100091 lab=_54320_/X }
C {devices/lab_pin.sym} 100980 -34950 0 0 {name=p100092 lab=_54323_/Y }
C {devices/lab_pin.sym} 101140 -34990 0 1 {name=p100093 lab=_54324_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -34990 0 0 {name=X_54324_ }
C {devices/lab_pin.sym} 101020 -34850 0 0 {name=p100094 lab=clkbuf_5_9_0_CLK/X }
C {devices/lab_pin.sym} 101100 -34850 0 1 {name=p100095 lab=clkbuf_6_18_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 101060 -34850 0 0 {name=Xclkbuf_6_18_0_CLK }
C {sky130_stdcells/decap_3.sym} 101060 -34700 0 0 {name=XPHY_659 }
C {devices/lab_pin.sym} 100970 -34550 0 0 {name=p100096 lab=_85144_/CLK }
C {devices/lab_pin.sym} 100970 -34530 0 0 {name=p100097 lab=_56620_/X }
C {devices/lab_pin.sym} 101150 -34550 0 1 {name=p100098 lab=_85144_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -34540 0 0 {name=X_85144_ }
C {devices/lab_pin.sym} 100980 -34430 0 0 {name=p100099 lab=_85992_/Q }
C {devices/lab_pin.sym} 100980 -34390 0 0 {name=p100100 lab=_51511_/X }
C {devices/lab_pin.sym} 100980 -34350 0 0 {name=p100101 lab=_51535_/Y }
C {devices/lab_pin.sym} 101140 -34390 0 1 {name=p100102 lab=_51536_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -34390 0 0 {name=X_51536_ }
C {devices/lab_pin.sym} 101020 -34250 0 0 {name=p100103 lab=_70370_/A }
C {devices/lab_pin.sym} 101100 -34250 0 1 {name=p100104 lab=_70375_/C }
C {sky130_stdcells/buf_2.sym} 101060 -34250 0 0 {name=X_70370_ }
C {devices/lab_pin.sym} 100980 -34150 0 0 {name=p100105 lab=_58087_/Y }
C {devices/lab_pin.sym} 100980 -34110 0 0 {name=p100106 lab=_58091_/Y }
C {devices/lab_pin.sym} 100980 -34070 0 0 {name=p100107 lab=_58035_/X }
C {devices/lab_pin.sym} 101140 -34110 0 1 {name=p100108 lab=_58092_/X }
C {sky130_stdcells/a21o_4.sym} 101060 -34110 0 0 {name=X_58092_ }
C {devices/lab_pin.sym} 100970 -33970 0 0 {name=p100109 lab=_82349_/CLK }
C {devices/lab_pin.sym} 100970 -33950 0 0 {name=p100110 lab=_77182_/X }
C {devices/lab_pin.sym} 101150 -33970 0 1 {name=p100111 lab=_47973_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -33960 0 0 {name=X_82356_ }
C {devices/lab_pin.sym} 101000 -33850 0 0 {name=p100112 lab=_57331_/A }
C {devices/lab_pin.sym} 101000 -33810 0 0 {name=p100113 lab=_57043_/B }
C {devices/lab_pin.sym} 101000 -33770 0 0 {name=p100114 lab=_57331_/C }
C {devices/lab_pin.sym} 101120 -33810 0 1 {name=p100115 lab=_57043_/Y }
C {sky130_stdcells/nand3_4.sym} 101060 -33810 0 0 {name=X_57043_ }
C {devices/lab_pin.sym} 100970 -33670 0 0 {name=p100116 lab=_81279_/CLK }
C {devices/lab_pin.sym} 100970 -33650 0 0 {name=p100117 lab=_76995_/X }
C {devices/lab_pin.sym} 101150 -33670 0 1 {name=p100118 lab=_81275_/D }
C {sky130_stdcells/dfxtp_4.sym} 101060 -33660 0 0 {name=X_81307_ }
C {devices/lab_pin.sym} 101000 -33540 0 0 {name=p100119 lab=_69026_/X }
C {devices/lab_pin.sym} 101000 -33500 0 0 {name=p100120 lab=_69029_/B }
C {devices/lab_pin.sym} 101120 -33520 0 1 {name=p100121 lab=_69029_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -33520 0 0 {name=X_69029_ }
C {devices/lab_pin.sym} 101000 -33420 0 0 {name=p100122 lab=_54255_/A }
C {devices/lab_pin.sym} 101000 -33380 0 0 {name=p100123 lab=_54246_/X }
C {devices/lab_pin.sym} 101000 -33340 0 0 {name=p100124 lab=_54255_/C }
C {devices/lab_pin.sym} 101000 -33300 0 0 {name=p100125 lab=_53084_/D }
C {devices/lab_pin.sym} 101120 -33360 0 1 {name=p100126 lab=_54255_/X }
C {sky130_stdcells/and4_4.sym} 101060 -33360 0 0 {name=X_54255_ }
C {devices/lab_pin.sym} 100970 -33210 0 0 {name=p100127 lab=_85075_/CLK }
C {devices/lab_pin.sym} 100970 -33190 0 0 {name=p100128 lab=_85075_/D }
C {devices/lab_pin.sym} 101150 -33210 0 1 {name=p100129 lab=_45611_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -33200 0 0 {name=X_85075_ }
C {devices/lab_pin.sym} 101000 -33100 0 0 {name=p100130 lab=_51473_/A }
C {devices/lab_pin.sym} 101000 -33060 0 0 {name=p100131 lab=_51473_/B }
C {devices/lab_pin.sym} 101000 -33020 0 0 {name=p100132 lab=_51467_/C }
C {devices/lab_pin.sym} 101000 -32980 0 0 {name=p100133 lab=_52993_/D }
C {devices/lab_pin.sym} 101120 -33040 0 1 {name=p100134 lab=_51467_/X }
C {sky130_stdcells/and4_4.sym} 101060 -33040 0 0 {name=X_51467_ }
C {devices/lab_pin.sym} 100970 -32890 0 0 {name=p100135 lab=_82288_/CLK }
C {devices/lab_pin.sym} 100970 -32870 0 0 {name=p100136 lab=_82287_/D }
C {devices/lab_pin.sym} 101150 -32890 0 1 {name=p100137 lab=_41034_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -32880 0 0 {name=X_82287_ }
C {devices/lab_pin.sym} 101020 -32750 0 0 {name=p100138 lab=_41219_/X }
C {devices/lab_pin.sym} 101100 -32750 0 1 {name=p100139 lab=_41220_/X }
C {sky130_stdcells/buf_2.sym} 101060 -32750 0 0 {name=X_41220_ }
C {devices/lab_pin.sym} 101000 -32640 0 0 {name=p100140 lab=_72040_/A }
C {devices/lab_pin.sym} 101000 -32600 0 0 {name=p100141 lab=_49055_/A }
C {devices/lab_pin.sym} 101120 -32620 0 1 {name=p100142 lab=_72040_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -32620 0 0 {name=X_72040_ }
C {devices/lab_pin.sym} 100980 -32510 0 0 {name=p100143 lab=_85677_/Q }
C {devices/lab_pin.sym} 100980 -32470 0 0 {name=p100144 lab=_53198_/X }
C {devices/lab_pin.sym} 100980 -32430 0 0 {name=p100145 lab=_53205_/Y }
C {devices/lab_pin.sym} 101140 -32470 0 1 {name=p100146 lab=_53206_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -32470 0 0 {name=X_53206_ }
C {devices/lab_pin.sym} 100970 -32330 0 0 {name=p100147 lab=_86807_/CLK }
C {devices/lab_pin.sym} 100970 -32310 0 0 {name=p100148 lab=_68151_/X }
C {devices/lab_pin.sym} 101150 -32330 0 1 {name=p100149 lab=_82066_/D }
C {sky130_stdcells/dfxtp_4.sym} 101060 -32320 0 0 {name=X_84026_ }
C {devices/lab_pin.sym} 100980 -32210 0 0 {name=p100150 lab=_50415_/Y }
C {devices/lab_pin.sym} 100980 -32170 0 0 {name=p100151 lab=_50380_/X }
C {devices/lab_pin.sym} 100980 -32130 0 0 {name=p100152 lab=_50417_/Y }
C {devices/lab_pin.sym} 101140 -32170 0 1 {name=p100153 lab=_86205_/D }
C {sky130_stdcells/a21boi_4.sym} 101060 -32170 0 0 {name=X_50418_ }
C {devices/lab_pin.sym} 100970 -32030 0 0 {name=p100154 lab=_85334_/CLK }
C {devices/lab_pin.sym} 100970 -32010 0 0 {name=p100155 lab=_81046_/Q }
C {devices/lab_pin.sym} 101150 -32030 0 1 {name=p100156 lab=_81238_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -32020 0 0 {name=X_81238_ }
C {devices/lab_pin.sym} 101000 -31920 0 0 {name=p100157 lab=_54191_/A }
C {devices/lab_pin.sym} 101000 -31880 0 0 {name=p100158 lab=_54186_/B }
C {devices/lab_pin.sym} 101000 -31840 0 0 {name=p100159 lab=_54191_/C }
C {devices/lab_pin.sym} 101000 -31800 0 0 {name=p100160 lab=_53019_/D }
C {devices/lab_pin.sym} 101120 -31860 0 1 {name=p100161 lab=_54186_/X }
C {sky130_stdcells/and4_4.sym} 101060 -31860 0 0 {name=X_54186_ }
C {devices/lab_pin.sym} 101000 -31720 0 0 {name=p100162 lab=_51212_/A }
C {devices/lab_pin.sym} 101000 -31680 0 0 {name=p100163 lab=_52924_/B }
C {devices/lab_pin.sym} 101120 -31700 0 1 {name=p100164 lab=_51398_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -31700 0 0 {name=X_51398_ }
C {devices/lab_pin.sym} 101020 -31570 0 0 {name=p100165 lab=clkbuf_2_3_0_CLK/A }
C {devices/lab_pin.sym} 101100 -31570 0 1 {name=p100166 lab=clkbuf_2_3_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 101060 -31570 0 0 {name=Xclkbuf_2_3_0_CLK }
C {devices/lab_pin.sym} 101020 -31450 0 0 {name=p100167 lab=_41151_/A }
C {devices/lab_pin.sym} 101100 -31450 0 1 {name=p100168 lab=_41151_/X }
C {sky130_stdcells/buf_2.sym} 101060 -31450 0 0 {name=X_41151_ }
C {devices/lab_pin.sym} 101020 -31330 0 0 {name=p100169 lab=_53111_/A }
C {devices/lab_pin.sym} 101100 -31330 0 1 {name=p100170 lab=_53137_/X }
C {sky130_stdcells/buf_2.sym} 101060 -31330 0 0 {name=X_53137_ }
C {devices/lab_pin.sym} 101000 -31220 0 0 {name=p100171 lab=_50317_/X }
C {devices/lab_pin.sym} 101000 -31180 0 0 {name=p100172 lab=_48073_/B }
C {devices/lab_pin.sym} 101120 -31200 0 1 {name=p100173 lab=_50349_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -31200 0 0 {name=X_50349_ }
C {devices/lab_pin.sym} 100970 -31070 0 0 {name=p100174 lab=_81169_/CLK }
C {devices/lab_pin.sym} 100970 -31050 0 0 {name=p100175 lab=_74956_/B }
C {devices/lab_pin.sym} 101150 -31070 0 1 {name=p100176 lab=_81169_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -31060 0 0 {name=X_81169_ }
C {devices/lab_pin.sym} 101000 -30940 0 0 {name=p100177 lab=_58548_/A }
C {devices/lab_pin.sym} 101000 -30900 0 0 {name=p100178 lab=_83434_/Q }
C {devices/lab_pin.sym} 101120 -30920 0 1 {name=p100179 lab=_58994_/Y }
C {sky130_stdcells/nor2_4.sym} 101060 -30920 0 0 {name=X_58994_ }
C {devices/lab_pin.sym} 101020 -30790 0 0 {name=p100180 lab=_41081_/X }
C {devices/lab_pin.sym} 101100 -30790 0 1 {name=p100181 lab=_41082_/X }
C {sky130_stdcells/buf_2.sym} 101060 -30790 0 0 {name=X_41082_ }
C {devices/lab_pin.sym} 100980 -30690 0 0 {name=p100182 lab=_85703_/Q }
C {devices/lab_pin.sym} 100980 -30650 0 0 {name=p100183 lab=_53065_/X }
C {devices/lab_pin.sym} 100980 -30610 0 0 {name=p100184 lab=_53067_/Y }
C {devices/lab_pin.sym} 101140 -30650 0 1 {name=p100185 lab=_53068_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -30650 0 0 {name=X_53068_ }
C {devices/lab_pin.sym} 100980 -30530 0 0 {name=p100186 lab=_57884_/X }
C {devices/lab_pin.sym} 100980 -30490 0 0 {name=p100187 lab=_85489_/Q }
C {devices/lab_pin.sym} 100980 -30450 0 0 {name=p100188 lab=_57923_/X }
C {devices/lab_pin.sym} 101140 -30490 0 1 {name=p100189 lab=_57945_/X }
C {sky130_stdcells/o21a_4.sym} 101060 -30490 0 0 {name=X_57945_ }
C {devices/lab_pin.sym} 100970 -30350 0 0 {name=p100190 lab=_85688_/CLK }
C {devices/lab_pin.sym} 100970 -30330 0 0 {name=p100191 lab=_85977_/D }
C {devices/lab_pin.sym} 101150 -30350 0 1 {name=p100192 lab=_85977_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -30340 0 0 {name=X_85977_ }
C {devices/lab_pin.sym} 100980 -30230 0 0 {name=p100193 lab=_73988_/X }
C {devices/lab_pin.sym} 100980 -30190 0 0 {name=p100194 lab=_73990_/X }
C {devices/lab_pin.sym} 100980 -30150 0 0 {name=p100195 lab=_73421_/X }
C {devices/lab_pin.sym} 101140 -30190 0 1 {name=p100196 lab=_73991_/X }
C {sky130_stdcells/a21o_4.sym} 101060 -30190 0 0 {name=X_73991_ }
C {devices/lab_pin.sym} 101020 -30050 0 0 {name=p100197 lab=_45612_/A }
C {devices/lab_pin.sym} 101100 -30050 0 1 {name=p100198 lab=_45824_/B }
C {sky130_stdcells/buf_2.sym} 101060 -30050 0 0 {name=X_44910_ }
C {devices/lab_pin.sym} 101000 -29940 0 0 {name=p100199 lab=_52027_/A }
C {devices/lab_pin.sym} 101000 -29900 0 0 {name=p100200 lab=_48016_/B }
C {devices/lab_pin.sym} 101120 -29920 0 1 {name=p100201 lab=_52019_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -29920 0 0 {name=X_52019_ }
C {devices/lab_pin.sym} 100970 -29790 0 0 {name=p100202 lab=_87150_/CLK }
C {devices/lab_pin.sym} 100970 -29770 0 0 {name=p100203 lab=_87716_/D }
C {devices/lab_pin.sym} 101150 -29790 0 1 {name=p100204 lab=_67700_/B }
C {sky130_stdcells/dfxtp_4.sym} 101060 -29780 0 0 {name=X_87716_ }
C {devices/lab_pin.sym} 101000 -29660 0 0 {name=p100205 lab=_75736_/B }
C {devices/lab_pin.sym} 101000 -29620 0 0 {name=p100206 lab=_75730_/B }
C {devices/lab_pin.sym} 101120 -29640 0 1 {name=p100207 lab=_75731_/B }
C {sky130_stdcells/xnor2_4.sym} 101060 -29640 0 0 {name=X_75730_ }
C {devices/lab_pin.sym} 100980 -29530 0 0 {name=p100208 lab=_83171_/Q }
C {devices/lab_pin.sym} 100980 -29490 0 0 {name=p100209 lab=_72794_/X }
C {devices/lab_pin.sym} 100980 -29450 0 0 {name=p100210 lab=_72941_/Y }
C {devices/lab_pin.sym} 101140 -29490 0 1 {name=p100211 lab=_72942_/X }
C {sky130_stdcells/a21o_4.sym} 101060 -29490 0 0 {name=X_72942_ }
C {devices/lab_pin.sym} 100970 -29350 0 0 {name=p100212 lab=_84926_/CLK }
C {devices/lab_pin.sym} 100970 -29330 0 0 {name=p100213 lab=_84928_/D }
C {devices/lab_pin.sym} 101150 -29350 0 1 {name=p100214 lab=_84928_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -29340 0 0 {name=X_84928_ }
C {devices/lab_pin.sym} 101020 -29210 0 0 {name=p100215 lab=_44120_/Y }
C {devices/lab_pin.sym} 101100 -29210 0 1 {name=p100216 lab=_45890_/X }
C {sky130_stdcells/buf_2.sym} 101060 -29210 0 0 {name=X_45890_ }
C {devices/lab_pin.sym} 100980 -29110 0 0 {name=p100217 lab=_57824_/X }
C {devices/lab_pin.sym} 100980 -29070 0 0 {name=p100218 lab=_85495_/Q }
C {devices/lab_pin.sym} 100980 -29030 0 0 {name=p100219 lab=_57849_/X }
C {devices/lab_pin.sym} 101140 -29070 0 1 {name=p100220 lab=_57876_/X }
C {sky130_stdcells/o21a_4.sym} 101060 -29070 0 0 {name=X_57876_ }
C {devices/lab_pin.sym} 101020 -28930 0 0 {name=p100221 lab=_59615_/A }
C {devices/lab_pin.sym} 101100 -28930 0 1 {name=p100222 lab=_60403_/C }
C {sky130_stdcells/buf_2.sym} 101060 -28930 0 0 {name=X_59615_ }
C {devices/lab_pin.sym} 100980 -28840 0 0 {name=p100223 lab=_41720_/Y }
C {devices/lab_pin.sym} 100980 -28800 0 0 {name=p100224 lab=_44838_/X }
C {devices/lab_pin.sym} 100980 -28760 0 0 {name=p100225 lab=_86926_/Q }
C {devices/lab_pin.sym} 100980 -28720 0 0 {name=p100226 lab=_44839_/X }
C {devices/lab_pin.sym} 101140 -28780 0 1 {name=p100227 lab=_44841_/X }
C {sky130_stdcells/a2bb2o_4.sym} 101060 -28780 0 0 {name=X_44841_ }
C {devices/lab_pin.sym} 101000 -28640 0 0 {name=p100228 lab=_56820_/Y }
C {devices/lab_pin.sym} 101000 -28600 0 0 {name=p100229 lab=_56827_/B }
C {devices/lab_pin.sym} 101120 -28620 0 1 {name=p100230 lab=_56827_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -28620 0 0 {name=X_56827_ }
C {devices/lab_pin.sym} 101020 -28490 0 0 {name=p100231 lab=_75650_/Y }
C {devices/lab_pin.sym} 101100 -28490 0 1 {name=p100232 lab=_75661_/Y }
C {sky130_stdcells/inv_2.sym} 101060 -28490 0 0 {name=X_75661_ }
C {devices/lab_pin.sym} 100970 -28370 0 0 {name=p100233 lab=_87898_/CLK }
C {devices/lab_pin.sym} 100970 -28350 0 0 {name=p100234 lab=_87647_/D }
C {devices/lab_pin.sym} 101150 -28370 0 1 {name=p100235 lab=_87647_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -28360 0 0 {name=X_87647_ }
C {devices/lab_pin.sym} 101020 -28230 0 0 {name=p100236 lab=_72910_/A }
C {devices/lab_pin.sym} 101100 -28230 0 1 {name=p100237 lab=_72874_/A }
C {sky130_stdcells/buf_2.sym} 101060 -28230 0 0 {name=X_72873_ }
C {devices/lab_pin.sym} 100970 -28110 0 0 {name=p100238 lab=_84250_/CLK }
C {devices/lab_pin.sym} 100970 -28090 0 0 {name=p100239 lab=_58398_/X }
C {devices/lab_pin.sym} 101150 -28110 0 1 {name=p100240 lab=_84859_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -28100 0 0 {name=X_84859_ }
C {devices/lab_pin.sym} 100980 -27990 0 0 {name=p100241 lab=_77383_/Y }
C {devices/lab_pin.sym} 100980 -27950 0 0 {name=p100242 lab=_77382_/X }
C {devices/lab_pin.sym} 100980 -27910 0 0 {name=p100243 lab=_77386_/A }
C {devices/lab_pin.sym} 101140 -27950 0 1 {name=p100244 lab=_77400_/Y }
C {sky130_stdcells/a21boi_4.sym} 101060 -27950 0 0 {name=X_77400_ }
C {devices/lab_pin.sym} 101020 -27810 0 0 {name=p100245 lab=_74549_/Y }
C {devices/lab_pin.sym} 101100 -27810 0 1 {name=p100246 lab=_74612_/X }
C {sky130_stdcells/buf_2.sym} 101060 -27810 0 0 {name=X_74612_ }
C {devices/lab_pin.sym} 100980 -27710 0 0 {name=p100247 lab=_47554_/Y }
C {devices/lab_pin.sym} 100980 -27670 0 0 {name=p100248 lab=_47555_/X }
C {devices/lab_pin.sym} 100980 -27630 0 0 {name=p100249 lab=_47559_/X }
C {devices/lab_pin.sym} 101140 -27670 0 1 {name=p100250 lab=_47560_/Y }
C {sky130_stdcells/a21oi_4.sym} 101060 -27670 0 0 {name=X_47560_ }
C {devices/lab_pin.sym} 101020 -27530 0 0 {name=p100251 lab=_71823_/Y }
C {devices/lab_pin.sym} 101100 -27530 0 1 {name=p100252 lab=_71824_/Y }
C {sky130_stdcells/inv_2.sym} 101060 -27530 0 0 {name=X_71824_ }
C {devices/lab_pin.sym} 101020 -27410 0 0 {name=p100253 lab=_59546_/A }
C {devices/lab_pin.sym} 101100 -27410 0 1 {name=p100254 lab=_59564_/A }
C {sky130_stdcells/buf_2.sym} 101060 -27410 0 0 {name=X_59546_ }
C {devices/lab_pin.sym} 101000 -27300 0 0 {name=p100255 lab=_78380_/A }
C {devices/lab_pin.sym} 101000 -27260 0 0 {name=p100256 lab=_78380_/B }
C {devices/lab_pin.sym} 101120 -27280 0 1 {name=p100257 lab=_78397_/B }
C {sky130_stdcells/nor2_4.sym} 101060 -27280 0 0 {name=X_78380_ }
C {devices/lab_pin.sym} 101020 -27150 0 0 {name=p100258 lab=_44772_/A }
C {devices/lab_pin.sym} 101100 -27150 0 1 {name=p100259 lab=_86964_/D }
C {sky130_stdcells/inv_2.sym} 101060 -27150 0 0 {name=X_44772_ }
C {devices/lab_pin.sym} 101020 -27030 0 0 {name=p100260 lab=_56785_/B }
C {devices/lab_pin.sym} 101100 -27030 0 1 {name=p100261 lab=_56758_/X }
C {sky130_stdcells/buf_2.sym} 101060 -27030 0 0 {name=X_56758_ }
C {devices/lab_pin.sym} 101020 -26910 0 0 {name=p100262 lab=_80900_/Q }
C {devices/lab_pin.sym} 101100 -26910 0 1 {name=p100263 lab=_75594_/B }
C {sky130_stdcells/inv_2.sym} 101060 -26910 0 0 {name=X_75592_ }
C {devices/lab_pin.sym} 100970 -26790 0 0 {name=p100264 lab=_88060_/CLK }
C {devices/lab_pin.sym} 100970 -26770 0 0 {name=p100265 lab=_43095_/Y }
C {devices/lab_pin.sym} 101150 -26790 0 1 {name=p100266 lab=_87578_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -26780 0 0 {name=X_87578_ }
C {devices/lab_pin.sym} 101020 -26650 0 0 {name=p100267 lab=_42000_/A }
C {devices/lab_pin.sym} 101100 -26650 0 1 {name=p100268 lab=_41984_/X }
C {sky130_stdcells/buf_2.sym} 101060 -26650 0 0 {name=X_41984_ }
C {devices/lab_pin.sym} 101020 -26530 0 0 {name=p100269 lab=_54054_/B }
C {devices/lab_pin.sym} 101100 -26530 0 1 {name=p100270 lab=_49320_/B }
C {sky130_stdcells/buf_2.sym} 101060 -26530 0 0 {name=X_46511_ }
C {devices/lab_pin.sym} 100980 -26430 0 0 {name=p100271 lab=_77327_/Y }
C {devices/lab_pin.sym} 100980 -26390 0 0 {name=p100272 lab=_77329_/Y }
C {devices/lab_pin.sym} 100980 -26350 0 0 {name=p100273 lab=_77332_/C }
C {devices/lab_pin.sym} 101140 -26390 0 1 {name=p100274 lab=_77334_/A }
C {sky130_stdcells/a21oi_4.sym} 101060 -26390 0 0 {name=X_77331_ }
C {devices/lab_pin.sym} 101020 -26250 0 0 {name=p100275 lab=_43722_/X }
C {devices/lab_pin.sym} 101100 -26250 0 1 {name=p100276 lab=_43723_/Y }
C {sky130_stdcells/inv_2.sym} 101060 -26250 0 0 {name=X_43723_ }
C {devices/lab_pin.sym} 101000 -26140 0 0 {name=p100277 lab=_55706_/X }
C {devices/lab_pin.sym} 101000 -26100 0 0 {name=p100278 lab=_55708_/X }
C {devices/lab_pin.sym} 101120 -26120 0 1 {name=p100279 lab=_56127_/B }
C {sky130_stdcells/nand2_4.sym} 101060 -26120 0 0 {name=X_55709_ }
C {devices/lab_pin.sym} 101000 -26010 0 0 {name=p100280 lab=_74541_/A }
C {devices/lab_pin.sym} 101000 -25970 0 0 {name=p100281 lab=_46215_/B }
C {devices/lab_pin.sym} 101000 -25930 0 0 {name=p100282 lab=_44917_/A }
C {devices/lab_pin.sym} 101120 -25970 0 1 {name=p100283 lab=_74543_/Y }
C {sky130_stdcells/nand3_4.sym} 101060 -25970 0 0 {name=X_74543_ }
C {devices/lab_pin.sym} 100970 -25830 0 0 {name=p100284 lab=_83589_/CLK }
C {devices/lab_pin.sym} 100970 -25810 0 0 {name=p100285 lab=_86529_/D }
C {devices/lab_pin.sym} 101150 -25830 0 1 {name=p100286 lab=_86529_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -25820 0 0 {name=X_86529_ }
C {devices/lab_pin.sym} 101020 -25690 0 0 {name=p100287 lab=_40935_/A }
C {devices/lab_pin.sym} 101100 -25690 0 1 {name=p100288 lab=_40935_/X }
C {sky130_stdcells/buf_2.sym} 101060 -25690 0 0 {name=X_40935_ }
C {devices/lab_pin.sym} 101000 -25580 0 0 {name=p100289 lab=_47517_/A }
C {devices/lab_pin.sym} 101000 -25540 0 0 {name=p100290 lab=_53076_/B }
C {devices/lab_pin.sym} 101120 -25560 0 1 {name=p100291 lab=_47491_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -25560 0 0 {name=X_47491_ }
C {devices/lab_pin.sym} 101020 -25430 0 0 {name=p100292 lab=_71026_/A }
C {devices/lab_pin.sym} 101100 -25430 0 1 {name=p100293 lab=_71755_/X }
C {sky130_stdcells/buf_2.sym} 101060 -25430 0 0 {name=X_71755_ }
C {devices/lab_pin.sym} 101020 -25310 0 0 {name=p100294 lab=_59477_/A }
C {devices/lab_pin.sym} 101100 -25310 0 1 {name=p100295 lab=_59478_/A }
C {sky130_stdcells/inv_2.sym} 101060 -25310 0 0 {name=X_59477_ }
C {devices/lab_pin.sym} 101000 -25200 0 0 {name=p100296 lab=_56689_/A }
C {devices/lab_pin.sym} 101000 -25160 0 0 {name=p100297 lab=_56688_/X }
C {devices/lab_pin.sym} 101120 -25180 0 1 {name=p100298 lab=_56694_/A }
C {sky130_stdcells/nand2_4.sym} 101060 -25180 0 0 {name=X_56689_ }
C {devices/lab_pin.sym} 101000 -25070 0 0 {name=p100299 lab=_51256_/A }
C {devices/lab_pin.sym} 101000 -25030 0 0 {name=p100300 lab=_49113_/B }
C {devices/lab_pin.sym} 101000 -24990 0 0 {name=p100301 lab=_49091_/C }
C {devices/lab_pin.sym} 101120 -25030 0 1 {name=p100302 lab=_49230_/X }
C {sky130_stdcells/and3_4.sym} 101060 -25030 0 0 {name=X_49230_ }
C {devices/lab_pin.sym} 101020 -24890 0 0 {name=p100303 lab=_46441_/Y }
C {devices/lab_pin.sym} 101100 -24890 0 1 {name=p100304 lab=_51320_/B }
C {sky130_stdcells/buf_2.sym} 101060 -24890 0 0 {name=X_46442_ }
C {devices/lab_pin.sym} 101020 -24770 0 0 {name=p100305 lab=_74515_/C }
C {devices/lab_pin.sym} 101100 -24770 0 1 {name=p100306 lab=_70721_/A }
C {sky130_stdcells/buf_2.sym} 101060 -24770 0 0 {name=X_70706_ }
C {devices/lab_pin.sym} 100980 -24670 0 0 {name=p100307 lab=_58423_/X }
C {devices/lab_pin.sym} 100980 -24630 0 0 {name=p100308 lab=_83363_/Q }
C {devices/lab_pin.sym} 100980 -24590 0 0 {name=p100309 lab=_58427_/Y }
C {devices/lab_pin.sym} 101140 -24630 0 1 {name=p100310 lab=_84851_/D }
C {sky130_stdcells/o21a_4.sym} 101060 -24630 0 0 {name=X_58428_ }
C {devices/lab_pin.sym} 101000 -24500 0 0 {name=p100311 lab=_77262_/A }
C {devices/lab_pin.sym} 101000 -24460 0 0 {name=p100312 lab=_82180_/D }
C {devices/lab_pin.sym} 101120 -24480 0 1 {name=p100313 lab=_77262_/X }
C {sky130_stdcells/xor2_4.sym} 101060 -24480 0 0 {name=X_77262_ }
C {devices/lab_pin.sym} 100980 -24380 0 0 {name=p100314 lab=_40712_/X }
C {devices/lab_pin.sym} 100980 -24340 0 0 {name=p100315 lab=_43624_/X }
C {devices/lab_pin.sym} 100980 -24300 0 0 {name=p100316 lab=_87325_/Q }
C {devices/lab_pin.sym} 100980 -24260 0 0 {name=p100317 lab=_43625_/X }
C {devices/lab_pin.sym} 101140 -24320 0 1 {name=p100318 lab=_43654_/X }
C {sky130_stdcells/a2bb2o_4.sym} 101060 -24320 0 0 {name=X_43654_ }
C {devices/lab_pin.sym} 101020 -24170 0 0 {name=p100319 lab=_46279_/A }
C {devices/lab_pin.sym} 101100 -24170 0 1 {name=p100320 lab=_74474_/X }
C {sky130_stdcells/buf_2.sym} 101060 -24170 0 0 {name=X_74474_ }
C {devices/lab_pin.sym} 101020 -24050 0 0 {name=p100321 lab=_40866_/A }
C {devices/lab_pin.sym} 101100 -24050 0 1 {name=p100322 lab=_40866_/X }
C {sky130_stdcells/buf_2.sym} 101060 -24050 0 0 {name=X_40866_ }
C {devices/lab_pin.sym} 101000 -23950 0 0 {name=p100323 lab=_71488_/X }
C {devices/lab_pin.sym} 101000 -23910 0 0 {name=p100324 lab=_71685_/X }
C {devices/lab_pin.sym} 101000 -23870 0 0 {name=p100325 lab=_71313_/X }
C {devices/lab_pin.sym} 101120 -23910 0 1 {name=p100326 lab=_71686_/Y }
C {sky130_stdcells/nand3_4.sym} 101060 -23910 0 0 {name=X_71686_ }
C {devices/lab_pin.sym} 101000 -23780 0 0 {name=p100327 lab=_79001_/A }
C {devices/lab_pin.sym} 101000 -23740 0 0 {name=p100328 lab=_79001_/B }
C {devices/lab_pin.sym} 101120 -23760 0 1 {name=p100329 lab=_82711_/D }
C {sky130_stdcells/xor2_4.sym} 101060 -23760 0 0 {name=X_79001_ }
C {devices/lab_pin.sym} 101000 -23640 0 0 {name=p100330 lab=_81350_/Q }
C {devices/lab_pin.sym} 101000 -23600 0 0 {name=p100331 lab=_76213_/B }
C {devices/lab_pin.sym} 101120 -23620 0 1 {name=p100332 lab=_76213_/X }
C {sky130_stdcells/xor2_4.sym} 101060 -23620 0 0 {name=X_76213_ }
C {devices/lab_pin.sym} 100980 -23530 0 0 {name=p100333 lab=_42568_/X }
C {devices/lab_pin.sym} 100980 -23490 0 0 {name=p100334 lab=_42569_/X }
C {devices/lab_pin.sym} 100980 -23450 0 0 {name=p100335 lab=_40890_/X }
C {devices/lab_pin.sym} 100980 -23410 0 0 {name=p100336 lab=_42604_/Y }
C {devices/lab_pin.sym} 100980 -23370 0 0 {name=p100337 lab=_42571_/X }
C {devices/lab_pin.sym} 101140 -23450 0 1 {name=p100338 lab=_87804_/D }
C {sky130_stdcells/o32ai_4.sym} 101060 -23450 0 0 {name=X_42605_ }
C {devices/lab_pin.sym} 100980 -23320 0 0 {name=p100339 lab=_72721_/X }
C {devices/lab_pin.sym} 100980 -23280 0 0 {name=p100340 lab=_86183_/Q }
C {devices/lab_pin.sym} 100980 -23240 0 0 {name=p100341 lab=_73351_/X }
C {devices/lab_pin.sym} 100980 -23200 0 0 {name=p100342 lab=_73424_/X }
C {devices/lab_pin.sym} 101140 -23260 0 1 {name=p100343 lab=_73425_/X }
C {sky130_stdcells/a211o_4.sym} 101060 -23260 0 0 {name=X_73425_ }
C {devices/lab_pin.sym} 101000 -23120 0 0 {name=p100344 lab=_49161_/A }
C {devices/lab_pin.sym} 101000 -23080 0 0 {name=p100345 lab=_49161_/B }
C {devices/lab_pin.sym} 101120 -23100 0 1 {name=p100346 lab=_49161_/Y }
C {sky130_stdcells/nor2_4.sym} 101060 -23100 0 0 {name=X_49161_ }
C {devices/lab_pin.sym} 101020 -22970 0 0 {name=p100347 lab=_51290_/B }
C {devices/lab_pin.sym} 101100 -22970 0 1 {name=p100348 lab=_53993_/B }
C {sky130_stdcells/buf_2.sym} 101060 -22970 0 0 {name=X_46373_ }
C {devices/lab_pin.sym} 101020 -22850 0 0 {name=p100349 lab=_70637_/A }
C {devices/lab_pin.sym} 101100 -22850 0 1 {name=p100350 lab=_70638_/A }
C {sky130_stdcells/buf_2.sym} 101060 -22850 0 0 {name=X_70637_ }
C {devices/lab_pin.sym} 101020 -22730 0 0 {name=p100351 lab=_63326_/A }
C {devices/lab_pin.sym} 101100 -22730 0 1 {name=p100352 lab=_58360_/A }
C {sky130_stdcells/buf_2.sym} 101060 -22730 0 0 {name=X_58359_ }
C {devices/lab_pin.sym} 101020 -22610 0 0 {name=p100353 lab=_77193_/A }
C {devices/lab_pin.sym} 101100 -22610 0 1 {name=p100354 lab=_77202_/B }
C {sky130_stdcells/buf_2.sym} 101060 -22610 0 0 {name=X_77193_ }
C {devices/lab_pin.sym} 101020 -22490 0 0 {name=p100355 lab=_51337_/A }
C {devices/lab_pin.sym} 101100 -22490 0 1 {name=p100356 lab=_43585_/X }
C {sky130_stdcells/buf_2.sym} 101060 -22490 0 0 {name=X_43585_ }
C {devices/lab_pin.sym} 100980 -22390 0 0 {name=p100357 lab=_40773_/X }
C {devices/lab_pin.sym} 100980 -22350 0 0 {name=p100358 lab=_82299_/Q }
C {devices/lab_pin.sym} 100980 -22310 0 0 {name=p100359 lab=_40796_/X }
C {devices/lab_pin.sym} 101140 -22350 0 1 {name=p100360 lab=_40798_/A }
C {sky130_stdcells/o21ai_4.sym} 101060 -22350 0 0 {name=X_40797_ }
C {devices/lab_pin.sym} 101000 -22220 0 0 {name=p100361 lab=_48138_/A }
C {devices/lab_pin.sym} 101000 -22180 0 0 {name=p100362 lab=_48112_/B }
C {devices/lab_pin.sym} 101120 -22200 0 1 {name=p100363 lab=_48112_/X }
C {sky130_stdcells/and2_4.sym} 101060 -22200 0 0 {name=X_48112_ }
C {devices/lab_pin.sym} 100980 -22090 0 0 {name=p100364 lab=_55730_/B }
C {devices/lab_pin.sym} 100980 -22050 0 0 {name=p100365 lab=_45281_/X }
C {devices/lab_pin.sym} 100980 -22010 0 0 {name=p100366 lab=_45311_/X }
C {devices/lab_pin.sym} 101140 -22050 0 1 {name=p100367 lab=_45324_/X }
C {sky130_stdcells/o21a_4.sym} 101060 -22050 0 0 {name=X_45324_ }
C {devices/lab_pin.sym} 101000 -21920 0 0 {name=p100368 lab=_81728_/D }
C {devices/lab_pin.sym} 101000 -21880 0 0 {name=p100369 lab=_76144_/B }
C {devices/lab_pin.sym} 101120 -21900 0 1 {name=p100370 lab=_76145_/B }
C {sky130_stdcells/nand2_4.sym} 101060 -21900 0 0 {name=X_76144_ }
C {devices/lab_pin.sym} 101020 -21770 0 0 {name=p100371 lab=_42554_/A }
C {devices/lab_pin.sym} 101100 -21770 0 1 {name=p100372 lab=_42536_/X }
C {sky130_stdcells/buf_2.sym} 101060 -21770 0 0 {name=X_42536_ }
C {devices/lab_pin.sym} 100980 -21670 0 0 {name=p100373 lab=_49085_/Y }
C {devices/lab_pin.sym} 100980 -21630 0 0 {name=p100374 lab=_49086_/X }
C {devices/lab_pin.sym} 100980 -21590 0 0 {name=p100375 lab=_49091_/X }
C {devices/lab_pin.sym} 101140 -21630 0 1 {name=p100376 lab=_86445_/D }
C {sky130_stdcells/a21oi_4.sym} 101060 -21630 0 0 {name=X_49092_ }
C {devices/lab_pin.sym} 100980 -21530 0 0 {name=p100377 lab=_61364_/Y }
C {devices/lab_pin.sym} 100980 -21490 0 0 {name=p100378 lab=_61366_/Y }
C {devices/lab_pin.sym} 100980 -21450 0 0 {name=p100379 lab=_61334_/X }
C {devices/lab_pin.sym} 100980 -21410 0 0 {name=p100380 lab=_61367_/Y }
C {devices/lab_pin.sym} 100980 -21380 0 0 {name=p100381 lab=_61369_/Y }
C {devices/lab_pin.sym} 101140 -21450 0 1 {name=p100382 lab=_61370_/X }
C {sky130_stdcells/a41o_4.sym} 101060 -21450 0 0 {name=X_61370_ }
C {devices/lab_pin.sym} 101000 -21300 0 0 {name=p100383 lab=_73426_/A }
C {devices/lab_pin.sym} 101000 -21260 0 0 {name=p100384 lab=_86474_/Q }
C {devices/lab_pin.sym} 101120 -21280 0 1 {name=p100385 lab=_73356_/X }
C {sky130_stdcells/and2_4.sym} 101060 -21280 0 0 {name=X_73356_ }
C {devices/lab_pin.sym} 101000 -21180 0 0 {name=p100386 lab=_71865_/A }
C {devices/lab_pin.sym} 101000 -21140 0 0 {name=p100387 lab=_70549_/X }
C {devices/lab_pin.sym} 101000 -21100 0 0 {name=p100388 lab=_70568_/C }
C {devices/lab_pin.sym} 101000 -21060 0 0 {name=p100389 lab=_70568_/D }
C {devices/lab_pin.sym} 101120 -21120 0 1 {name=p100390 lab=_70568_/Y }
C {sky130_stdcells/nor4_4.sym} 101060 -21120 0 0 {name=X_70568_ }
C {devices/lab_pin.sym} 100980 -21010 0 0 {name=p100391 lab=_60249_/X }
C {devices/lab_pin.sym} 100980 -20970 0 0 {name=p100392 lab=_60276_/Y }
C {devices/lab_pin.sym} 100980 -20930 0 0 {name=p100393 lab=_60165_/A }
C {devices/lab_pin.sym} 100980 -20890 0 0 {name=p100394 lab=_60367_/B }
C {devices/lab_pin.sym} 100980 -20860 0 0 {name=p100395 lab=_60320_/Y }
C {devices/lab_pin.sym} 101140 -20930 0 1 {name=p100396 lab=_84634_/D }
C {sky130_stdcells/a41oi_4.sym} 101060 -20930 0 0 {name=X_60321_ }
C {devices/lab_pin.sym} 100980 -20790 0 0 {name=p100397 lab=_72305_/X }
C {devices/lab_pin.sym} 100980 -20750 0 0 {name=p100398 lab=_85362_/Q }
C {devices/lab_pin.sym} 100980 -20710 0 0 {name=p100399 lab=_72306_/X }
C {devices/lab_pin.sym} 101140 -20750 0 1 {name=p100400 lab=_72307_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -20750 0 0 {name=X_72307_ }
C {devices/lab_pin.sym} 101020 -20610 0 0 {name=p100401 lab=_48606_/A }
C {devices/lab_pin.sym} 101100 -20610 0 1 {name=p100402 lab=_48043_/X }
C {sky130_stdcells/buf_2.sym} 101060 -20610 0 0 {name=X_48043_ }
C {devices/lab_pin.sym} 100980 -20510 0 0 {name=p100403 lab=_45251_/Y }
C {devices/lab_pin.sym} 100980 -20470 0 0 {name=p100404 lab=_45254_/Y }
C {devices/lab_pin.sym} 100980 -20430 0 0 {name=p100405 lab=_45212_/X }
C {devices/lab_pin.sym} 101140 -20470 0 1 {name=p100406 lab=_45255_/X }
C {sky130_stdcells/a21o_4.sym} 101060 -20470 0 0 {name=X_45255_ }
C {devices/lab_pin.sym} 101000 -20340 0 0 {name=p100407 lab=_81720_/D }
C {devices/lab_pin.sym} 101000 -20300 0 0 {name=p100408 lab=_76075_/B }
C {devices/lab_pin.sym} 101120 -20320 0 1 {name=p100409 lab=_76082_/A }
C {sky130_stdcells/xor2_4.sym} 101060 -20320 0 0 {name=X_76075_ }
C {devices/lab_pin.sym} 101020 -20190 0 0 {name=p100410 lab=_42574_/A }
C {devices/lab_pin.sym} 101100 -20190 0 1 {name=p100411 lab=_42467_/X }
C {sky130_stdcells/buf_2.sym} 101060 -20190 0 0 {name=X_42467_ }
C {devices/lab_pin.sym} 100980 -20090 0 0 {name=p100412 lab=_73283_/X }
C {devices/lab_pin.sym} 100980 -20050 0 0 {name=p100413 lab=_73286_/X }
C {devices/lab_pin.sym} 100980 -20010 0 0 {name=p100414 lab=_73262_/X }
C {devices/lab_pin.sym} 101140 -20050 0 1 {name=p100415 lab=_73290_/A }
C {sky130_stdcells/a21o_4.sym} 101060 -20050 0 0 {name=X_73287_ }
C {devices/lab_pin.sym} 101020 -19910 0 0 {name=p100416 lab=_70502_/A }
C {devices/lab_pin.sym} 101100 -19910 0 1 {name=p100417 lab=_70500_/D }
C {sky130_stdcells/buf_2.sym} 101060 -19910 0 0 {name=X_70499_ }
C {devices/lab_pin.sym} 101020 -19790 0 0 {name=p100418 lab=_56670_/A }
C {devices/lab_pin.sym} 101100 -19790 0 1 {name=p100419 lab=_44207_/A }
C {sky130_stdcells/buf_2.sym} 101060 -19790 0 0 {name=X_44206_ }
C {devices/lab_pin.sym} 101000 -19680 0 0 {name=p100420 lab=_79903_/A }
C {devices/lab_pin.sym} 101000 -19640 0 0 {name=p100421 lab=_65888_/C }
C {devices/lab_pin.sym} 101120 -19660 0 1 {name=p100422 lab=_79903_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -19660 0 0 {name=X_79903_ }
C {devices/lab_pin.sym} 101020 -19530 0 0 {name=p100423 lab=_60469_/X }
C {devices/lab_pin.sym} 101100 -19530 0 1 {name=p100424 lab=_63041_/A }
C {sky130_stdcells/buf_2.sym} 101060 -19530 0 0 {name=X_63040_ }
C {devices/lab_pin.sym} 100980 -19430 0 0 {name=p100425 lab=_75018_/A }
C {devices/lab_pin.sym} 100980 -19390 0 0 {name=p100426 lab=_75023_/B }
C {devices/lab_pin.sym} 100980 -19350 0 0 {name=p100427 lab=_75016_/Y }
C {devices/lab_pin.sym} 101140 -19390 0 1 {name=p100428 lab=_75026_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -19390 0 0 {name=X_75026_ }
C {devices/lab_pin.sym} 101020 -19250 0 0 {name=p100429 lab=_41486_/A }
C {devices/lab_pin.sym} 101100 -19250 0 1 {name=p100430 lab=_41418_/X }
C {sky130_stdcells/buf_2.sym} 101060 -19250 0 0 {name=X_41418_ }
C {devices/lab_pin.sym} 100980 -19150 0 0 {name=p100431 lab=_60263_/A }
C {devices/lab_pin.sym} 100980 -19110 0 0 {name=p100432 lab=_60367_/C }
C {devices/lab_pin.sym} 100980 -19070 0 0 {name=p100433 lab=_60285_/A }
C {devices/lab_pin.sym} 101140 -19110 0 1 {name=p100434 lab=_60252_/X }
C {sky130_stdcells/o21a_4.sym} 101060 -19110 0 0 {name=X_60252_ }
C {devices/lab_pin.sym} 100980 -18990 0 0 {name=p100435 lab=_72180_/X }
C {devices/lab_pin.sym} 100980 -18950 0 0 {name=p100436 lab=_85335_/Q }
C {devices/lab_pin.sym} 100980 -18910 0 0 {name=p100437 lab=_72225_/X }
C {devices/lab_pin.sym} 101140 -18950 0 1 {name=p100438 lab=_72238_/X }
C {sky130_stdcells/o21a_4.sym} 101060 -18950 0 0 {name=X_72238_ }
C {devices/lab_pin.sym} 100980 -18830 0 0 {name=p100439 lab=_45179_/X }
C {devices/lab_pin.sym} 100980 -18790 0 0 {name=p100440 lab=_45183_/Y }
C {devices/lab_pin.sym} 100980 -18750 0 0 {name=p100441 lab=_45185_/Y }
C {devices/lab_pin.sym} 101140 -18790 0 1 {name=p100442 lab=_45186_/Y }
C {sky130_stdcells/a21oi_4.sym} 101060 -18790 0 0 {name=X_45186_ }
C {devices/lab_pin.sym} 101020 -18650 0 0 {name=p100443 lab=_41872_/A }
C {devices/lab_pin.sym} 101100 -18650 0 1 {name=p100444 lab=_42398_/X }
C {sky130_stdcells/buf_2.sym} 101060 -18650 0 0 {name=X_42398_ }
C {devices/lab_pin.sym} 101020 -18530 0 0 {name=p100445 lab=_44137_/A }
C {devices/lab_pin.sym} 101100 -18530 0 1 {name=p100446 lab=_44163_/B }
C {sky130_stdcells/buf_2.sym} 101060 -18530 0 0 {name=X_44137_ }
C {devices/lab_pin.sym} 101000 -18420 0 0 {name=p100447 lab=_79825_/X }
C {devices/lab_pin.sym} 101000 -18380 0 0 {name=p100448 lab=_79834_/B }
C {devices/lab_pin.sym} 101120 -18400 0 1 {name=p100449 lab=_79834_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -18400 0 0 {name=X_79834_ }
C {devices/lab_pin.sym} 101020 -18270 0 0 {name=p100450 lab=_41349_/A }
C {devices/lab_pin.sym} 101100 -18270 0 1 {name=p100451 lab=_88232_/D }
C {sky130_stdcells/inv_2.sym} 101060 -18270 0 0 {name=X_41349_ }
C {devices/lab_pin.sym} 101000 -18160 0 0 {name=p100452 lab=_60183_/A }
C {devices/lab_pin.sym} 101000 -18120 0 0 {name=p100453 lab=_59551_/A }
C {devices/lab_pin.sym} 101120 -18140 0 1 {name=p100454 lab=_60184_/A }
C {sky130_stdcells/and2_4.sym} 101060 -18140 0 0 {name=X_60183_ }
C {devices/lab_pin.sym} 100980 -18030 0 0 {name=p100455 lab=_72155_/X }
C {devices/lab_pin.sym} 100980 -17990 0 0 {name=p100456 lab=_85693_/Q }
C {devices/lab_pin.sym} 100980 -17950 0 0 {name=p100457 lab=_72156_/X }
C {devices/lab_pin.sym} 101140 -17990 0 1 {name=p100458 lab=_72169_/X }
C {sky130_stdcells/o21a_4.sym} 101060 -17990 0 0 {name=X_72169_ }
C {devices/lab_pin.sym} 101020 -17850 0 0 {name=p100459 lab=_49915_/A }
C {devices/lab_pin.sym} 101100 -17850 0 1 {name=p100460 lab=_49994_/X }
C {sky130_stdcells/buf_2.sym} 101060 -17850 0 0 {name=X_49994_ }
C {devices/lab_pin.sym} 100980 -17750 0 0 {name=p100461 lab=_86459_/Q }
C {devices/lab_pin.sym} 100980 -17710 0 0 {name=p100462 lab=_48896_/X }
C {devices/lab_pin.sym} 100980 -17670 0 0 {name=p100463 lab=_48944_/Y }
C {devices/lab_pin.sym} 101140 -17710 0 1 {name=p100464 lab=_48945_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -17710 0 0 {name=X_48945_ }
C {devices/lab_pin.sym} 101000 -17590 0 0 {name=p100465 lab=_44186_/A }
C {devices/lab_pin.sym} 101000 -17550 0 0 {name=p100466 lab=_44202_/A }
C {devices/lab_pin.sym} 101000 -17510 0 0 {name=p100467 lab=_44067_/Y }
C {devices/lab_pin.sym} 101120 -17550 0 1 {name=p100468 lab=_44068_/Y }
C {sky130_stdcells/nor3_4.sym} 101060 -17550 0 0 {name=X_44068_ }
C {devices/lab_pin.sym} 101000 -17420 0 0 {name=p100469 lab=_79763_/X }
C {devices/lab_pin.sym} 101000 -17380 0 0 {name=p100470 lab=_79765_/B }
C {devices/lab_pin.sym} 101120 -17400 0 1 {name=p100471 lab=_79766_/B }
C {sky130_stdcells/xnor2_4.sym} 101060 -17400 0 0 {name=X_79765_ }
C {devices/lab_pin.sym} 101020 -17270 0 0 {name=p100472 lab=_64991_/A }
C {devices/lab_pin.sym} 101100 -17270 0 1 {name=p100473 lab=_64991_/X }
C {sky130_stdcells/buf_2.sym} 101060 -17270 0 0 {name=X_64991_ }
C {devices/lab_pin.sym} 101000 -17160 0 0 {name=p100474 lab=_76977_/A }
C {devices/lab_pin.sym} 101000 -17120 0 0 {name=p100475 lab=_84401_/Q }
C {devices/lab_pin.sym} 101120 -17140 0 1 {name=p100476 lab=_76977_/X }
C {sky130_stdcells/xor2_4.sym} 101060 -17140 0 0 {name=X_76977_ }
C {devices/lab_pin.sym} 100980 -17030 0 0 {name=p100477 lab=_40361_/A }
C {devices/lab_pin.sym} 100980 -16990 0 0 {name=p100478 lab=_43013_/X }
C {devices/lab_pin.sym} 100980 -16950 0 0 {name=p100479 lab=_43019_/B1 }
C {devices/lab_pin.sym} 101140 -16990 0 1 {name=p100480 lab=_43020_/A }
C {sky130_stdcells/a21o_4.sym} 101060 -16990 0 0 {name=X_43019_ }
C {devices/lab_pin.sym} 100980 -16870 0 0 {name=p100481 lab=_66727_/X }
C {devices/lab_pin.sym} 100980 -16830 0 0 {name=p100482 lab=_66729_/X }
C {devices/lab_pin.sym} 100980 -16790 0 0 {name=p100483 lab=_66706_/X }
C {devices/lab_pin.sym} 101140 -16830 0 1 {name=p100484 lab=_66730_/Y }
C {sky130_stdcells/a21oi_4.sym} 101060 -16830 0 0 {name=X_66730_ }
C {devices/lab_pin.sym} 101020 -16690 0 0 {name=p100485 lab=_78715_/X }
C {devices/lab_pin.sym} 101100 -16690 0 1 {name=p100486 lab=_78716_/Y }
C {sky130_stdcells/inv_2.sym} 101060 -16690 0 0 {name=X_78716_ }
C {devices/lab_pin.sym} 101000 -16590 0 0 {name=p100487 lab=_63942_/A }
C {devices/lab_pin.sym} 101000 -16550 0 0 {name=p100488 lab=_59407_/A }
C {devices/lab_pin.sym} 101000 -16510 0 0 {name=p100489 lab=_63958_/C }
C {devices/lab_pin.sym} 101120 -16550 0 1 {name=p100490 lab=_63942_/X }
C {sky130_stdcells/and3_4.sym} 101060 -16550 0 0 {name=X_63942_ }
C {devices/lab_pin.sym} 101000 -16420 0 0 {name=p100491 lab=_75928_/A }
C {devices/lab_pin.sym} 101000 -16380 0 0 {name=p100492 lab=_75927_/X }
C {devices/lab_pin.sym} 101120 -16400 0 1 {name=p100493 lab=_75929_/B }
C {sky130_stdcells/xnor2_4.sym} 101060 -16400 0 0 {name=X_75928_ }
C {devices/lab_pin.sym} 101020 -16270 0 0 {name=p100494 lab=_83625_/Q }
C {devices/lab_pin.sym} 101100 -16270 0 1 {name=p100495 lab=_48876_/Y }
C {sky130_stdcells/inv_2.sym} 101060 -16270 0 0 {name=X_48876_ }
C {devices/lab_pin.sym} 101000 -16160 0 0 {name=p100496 lab=_79704_/A }
C {devices/lab_pin.sym} 101000 -16120 0 0 {name=p100497 lab=_79696_/B }
C {devices/lab_pin.sym} 101120 -16140 0 1 {name=p100498 lab=_79696_/Y }
C {sky130_stdcells/xnor2_4.sym} 101060 -16140 0 0 {name=X_79696_ }
C {devices/lab_pin.sym} 101000 -16020 0 0 {name=p100499 lab=_48361_/B }
C {devices/lab_pin.sym} 101000 -15980 0 0 {name=p100500 lab=_47867_/A }
C {devices/lab_pin.sym} 101120 -16000 0 1 {name=p100501 lab=_47827_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -16000 0 0 {name=X_47827_ }
C {devices/lab_pin.sym} 100980 -15890 0 0 {name=p100502 lab=_84102_/Q }
C {devices/lab_pin.sym} 100980 -15850 0 0 {name=p100503 lab=_66614_/X }
C {devices/lab_pin.sym} 100980 -15810 0 0 {name=p100504 lab=_66660_/X }
C {devices/lab_pin.sym} 101140 -15850 0 1 {name=p100505 lab=_84102_/D }
C {sky130_stdcells/a21bo_4.sym} 101060 -15850 0 0 {name=X_66661_ }
C {devices/lab_pin.sym} 101000 -15720 0 0 {name=p100506 lab=_78646_/A }
C {devices/lab_pin.sym} 101000 -15680 0 0 {name=p100507 lab=_82681_/D }
C {devices/lab_pin.sym} 101120 -15700 0 1 {name=p100508 lab=_78648_/A }
C {sky130_stdcells/nand2_4.sym} 101060 -15700 0 0 {name=X_78647_ }
C {devices/lab_pin.sym} 101000 -15600 0 0 {name=p100509 lab=_57652_/X }
C {devices/lab_pin.sym} 101000 -15560 0 0 {name=p100510 lab=_63858_/B }
C {devices/lab_pin.sym} 101000 -15520 0 0 {name=p100511 lab=_63858_/C }
C {devices/lab_pin.sym} 101000 -15480 0 0 {name=p100512 lab=_63902_/D }
C {devices/lab_pin.sym} 101120 -15540 0 1 {name=p100513 lab=_63873_/Y }
C {sky130_stdcells/nand4_4.sym} 101060 -15540 0 0 {name=X_63873_ }
C {devices/lab_pin.sym} 100980 -15410 0 0 {name=p100514 lab=_75854_/Y }
C {devices/lab_pin.sym} 100980 -15370 0 0 {name=p100515 lab=_75836_/B }
C {devices/lab_pin.sym} 100980 -15330 0 0 {name=p100516 lab=_75858_/Y }
C {devices/lab_pin.sym} 101140 -15370 0 1 {name=p100517 lab=_75860_/B }
C {sky130_stdcells/o21ai_4.sym} 101060 -15370 0 0 {name=X_75859_ }
C {devices/lab_pin.sym} 101020 -15230 0 0 {name=p100518 lab=_70001_/A }
C {devices/lab_pin.sym} 101100 -15230 0 1 {name=p100519 lab=_68400_/X }
C {sky130_stdcells/buf_2.sym} 101060 -15230 0 0 {name=X_68400_ }
C {devices/lab_pin.sym} 101000 -15120 0 0 {name=p100520 lab=_65735_/A }
C {devices/lab_pin.sym} 101000 -15080 0 0 {name=p100521 lab=_65612_/B }
C {devices/lab_pin.sym} 101120 -15100 0 1 {name=p100522 lab=_65612_/X }
C {sky130_stdcells/and2_4.sym} 101060 -15100 0 0 {name=X_65612_ }
C {devices/lab_pin.sym} 100980 -15010 0 0 {name=p100523 lab=_62820_/Y }
C {devices/lab_pin.sym} 100980 -14970 0 0 {name=p100524 lab=_62772_/X }
C {devices/lab_pin.sym} 100980 -14930 0 0 {name=p100525 lab=_62821_/Y }
C {devices/lab_pin.sym} 100980 -14890 0 0 {name=p100526 lab=_62822_/Y }
C {devices/lab_pin.sym} 100980 -14860 0 0 {name=p100527 lab=_62823_/X }
C {devices/lab_pin.sym} 101140 -14930 0 1 {name=p100528 lab=_62824_/X }
C {sky130_stdcells/a41o_4.sym} 101060 -14930 0 0 {name=X_62824_ }
C {devices/lab_pin.sym} 100980 -14790 0 0 {name=p100529 lab=_83928_/Q }
C {devices/lab_pin.sym} 100980 -14750 0 0 {name=p100530 lab=_69367_/X }
C {devices/lab_pin.sym} 100980 -14710 0 0 {name=p100531 lab=_69379_/X }
C {devices/lab_pin.sym} 101140 -14750 0 1 {name=p100532 lab=_69380_/X }
C {sky130_stdcells/a21bo_4.sym} 101060 -14750 0 0 {name=X_69380_ }
C {devices/lab_pin.sym} 101000 -14640 0 0 {name=p100533 lab=_47758_/A }
C {devices/lab_pin.sym} 101000 -14600 0 0 {name=p100534 lab=_47777_/B }
C {devices/lab_pin.sym} 101000 -14560 0 0 {name=p100535 lab=_47777_/C }
C {devices/lab_pin.sym} 101000 -14520 0 0 {name=p100536 lab=_53230_/D }
C {devices/lab_pin.sym} 101120 -14580 0 1 {name=p100537 lab=_47758_/X }
C {sky130_stdcells/and4_4.sym} 101060 -14580 0 0 {name=X_47758_ }
C {devices/lab_pin.sym} 100980 -14450 0 0 {name=p100538 lab=_66589_/X }
C {devices/lab_pin.sym} 100980 -14410 0 0 {name=p100539 lab=_66591_/X }
C {devices/lab_pin.sym} 100980 -14370 0 0 {name=p100540 lab=_66547_/X }
C {devices/lab_pin.sym} 101140 -14410 0 1 {name=p100541 lab=_66597_/A }
C {sky130_stdcells/a21o_4.sym} 101060 -14410 0 0 {name=X_66592_ }
C {devices/lab_pin.sym} 100980 -14290 0 0 {name=p100542 lab=_78525_/A }
C {devices/lab_pin.sym} 100980 -14250 0 0 {name=p100543 lab=_78528_/A }
C {devices/lab_pin.sym} 100980 -14210 0 0 {name=p100544 lab=_78536_/X }
C {devices/lab_pin.sym} 101140 -14250 0 1 {name=p100545 lab=_78578_/X }
C {sky130_stdcells/a21o_4.sym} 101060 -14250 0 0 {name=X_78578_ }
C {devices/lab_pin.sym} 101020 -14110 0 0 {name=p100546 lab=_68208_/X }
C {devices/lab_pin.sym} 101100 -14110 0 1 {name=p100547 lab=_68331_/X }
C {sky130_stdcells/buf_2.sym} 101060 -14110 0 0 {name=X_68331_ }
C {devices/lab_pin.sym} 100980 -14010 0 0 {name=p100548 lab=_46703_/Y }
C {devices/lab_pin.sym} 100980 -13970 0 0 {name=p100549 lab=_46704_/X }
C {devices/lab_pin.sym} 100980 -13930 0 0 {name=p100550 lab=_46708_/X }
C {devices/lab_pin.sym} 101140 -13970 0 1 {name=p100551 lab=_46709_/Y }
C {sky130_stdcells/a21oi_4.sym} 101060 -13970 0 0 {name=X_46709_ }
C {devices/lab_pin.sym} 101000 -13840 0 0 {name=p100552 lab=_65543_/A }
C {devices/lab_pin.sym} 101000 -13800 0 0 {name=p100553 lab=_65543_/B }
C {devices/lab_pin.sym} 101120 -13820 0 1 {name=p100554 lab=_65543_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -13820 0 0 {name=X_65543_ }
C {devices/lab_pin.sym} 101000 -13700 0 0 {name=p100555 lab=_77518_/A }
C {devices/lab_pin.sym} 101000 -13660 0 0 {name=p100556 lab=_82114_/Q }
C {devices/lab_pin.sym} 101120 -13680 0 1 {name=p100557 lab=_77529_/Y }
C {sky130_stdcells/nor2_4.sym} 101060 -13680 0 0 {name=X_77529_ }
C {devices/lab_pin.sym} 101000 -13580 0 0 {name=p100558 lab=_62731_/A }
C {devices/lab_pin.sym} 101000 -13540 0 0 {name=p100559 lab=_63103_/A }
C {devices/lab_pin.sym} 101000 -13500 0 0 {name=p100560 lab=_62744_/X }
C {devices/lab_pin.sym} 101000 -13460 0 0 {name=p100561 lab=_62717_/X }
C {devices/lab_pin.sym} 101120 -13520 0 1 {name=p100562 lab=_62755_/X }
C {sky130_stdcells/and4_4.sym} 101060 -13520 0 0 {name=X_62755_ }
C {devices/lab_pin.sym} 100980 -13390 0 0 {name=p100563 lab=_72332_/A }
C {devices/lab_pin.sym} 100980 -13350 0 0 {name=p100564 lab=_47666_/X }
C {devices/lab_pin.sym} 100980 -13310 0 0 {name=p100565 lab=_47688_/Y }
C {devices/lab_pin.sym} 101140 -13350 0 1 {name=p100566 lab=_47689_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -13350 0 0 {name=X_47689_ }
C {devices/lab_pin.sym} 101020 -13210 0 0 {name=p100567 lab=_61755_/A }
C {devices/lab_pin.sym} 101100 -13210 0 1 {name=p100568 lab=_61706_/X }
C {sky130_stdcells/buf_2.sym} 101060 -13210 0 0 {name=X_61706_ }
C {devices/lab_pin.sym} 100980 -13110 0 0 {name=p100569 lab=_58720_/B }
C {devices/lab_pin.sym} 100980 -13070 0 0 {name=p100570 lab=_49415_/X }
C {devices/lab_pin.sym} 100980 -13030 0 0 {name=p100571 lab=_49427_/Y }
C {devices/lab_pin.sym} 101140 -13070 0 1 {name=p100572 lab=_49428_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -13070 0 0 {name=X_49428_ }
C {devices/lab_pin.sym} 101000 -12940 0 0 {name=p100573 lab=_80538_/X }
C {devices/lab_pin.sym} 101000 -12900 0 0 {name=p100574 lab=_80540_/B }
C {devices/lab_pin.sym} 101120 -12920 0 1 {name=p100575 lab=_80541_/B }
C {sky130_stdcells/xnor2_4.sym} 101060 -12920 0 0 {name=X_80540_ }
C {devices/lab_pin.sym} 100980 -12820 0 0 {name=p100576 lab=_68246_/X }
C {devices/lab_pin.sym} 100980 -12780 0 0 {name=p100577 lab=_67602_/Y }
C {devices/lab_pin.sym} 100980 -12740 0 0 {name=p100578 lab=_68247_/X }
C {devices/lab_pin.sym} 100980 -12700 0 0 {name=p100579 lab=_68261_/Y }
C {devices/lab_pin.sym} 101140 -12760 0 1 {name=p100580 lab=_68262_/X }
C {sky130_stdcells/a211o_4.sym} 101060 -12760 0 0 {name=X_68262_ }
C {devices/lab_pin.sym} 101020 -12610 0 0 {name=p100581 lab=_65673_/A }
C {devices/lab_pin.sym} 101100 -12610 0 1 {name=p100582 lab=_65474_/X }
C {sky130_stdcells/buf_2.sym} 101060 -12610 0 0 {name=X_65474_ }
C {devices/lab_pin.sym} 100980 -12530 0 0 {name=p100583 lab=_62677_/Y }
C {devices/lab_pin.sym} 100980 -12490 0 0 {name=p100584 lab=_62660_/X }
C {devices/lab_pin.sym} 100980 -12450 0 0 {name=p100585 lab=_62678_/Y }
C {devices/lab_pin.sym} 100980 -12410 0 0 {name=p100586 lab=_62683_/Y }
C {devices/lab_pin.sym} 100980 -12380 0 0 {name=p100587 lab=_62685_/X }
C {devices/lab_pin.sym} 101140 -12450 0 1 {name=p100588 lab=_62686_/X }
C {sky130_stdcells/a41o_4.sym} 101060 -12450 0 0 {name=X_62686_ }
C {devices/lab_pin.sym} 101000 -12300 0 0 {name=p100589 lab=_67259_/A }
C {devices/lab_pin.sym} 101000 -12260 0 0 {name=p100590 lab=_87608_/Q }
C {devices/lab_pin.sym} 101120 -12280 0 1 {name=p100591 lab=_67213_/X }
C {sky130_stdcells/and2_4.sym} 101060 -12280 0 0 {name=X_67213_ }
C {devices/lab_pin.sym} 100980 -12170 0 0 {name=p100592 lab=_58259_/A }
C {devices/lab_pin.sym} 100980 -12130 0 0 {name=p100593 lab=_64423_/X }
C {devices/lab_pin.sym} 100980 -12090 0 0 {name=p100594 lab=_64424_/Y }
C {devices/lab_pin.sym} 101140 -12130 0 1 {name=p100595 lab=_64425_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -12130 0 0 {name=X_64425_ }
C {devices/lab_pin.sym} 100980 -12010 0 0 {name=p100596 lab=_49357_/Y }
C {devices/lab_pin.sym} 100980 -11970 0 0 {name=p100597 lab=_49316_/X }
C {devices/lab_pin.sym} 100980 -11930 0 0 {name=p100598 lab=_49358_/X }
C {devices/lab_pin.sym} 101140 -11970 0 1 {name=p100599 lab=_86402_/D }
C {sky130_stdcells/a21oi_4.sym} 101060 -11970 0 0 {name=X_49359_ }
C {devices/lab_pin.sym} 101020 -11830 0 0 {name=p100600 lab=_59430_/A }
C {devices/lab_pin.sym} 101100 -11830 0 1 {name=p100601 lab=_61637_/X }
C {sky130_stdcells/buf_2.sym} 101060 -11830 0 0 {name=X_61637_ }
C {devices/lab_pin.sym} 101000 -11720 0 0 {name=p100602 lab=_80471_/A }
C {devices/lab_pin.sym} 101000 -11680 0 0 {name=p100603 lab=_80471_/B }
C {devices/lab_pin.sym} 101120 -11700 0 1 {name=p100604 lab=_80471_/X }
C {sky130_stdcells/xor2_4.sym} 101060 -11700 0 0 {name=X_80471_ }
C {devices/lab_pin.sym} 100980 -11590 0 0 {name=p100605 lab=_67205_/X }
C {devices/lab_pin.sym} 100980 -11550 0 0 {name=p100606 lab=_67207_/X }
C {devices/lab_pin.sym} 100980 -11510 0 0 {name=p100607 lab=_68169_/X }
C {devices/lab_pin.sym} 101140 -11550 0 1 {name=p100608 lab=_68193_/Y }
C {sky130_stdcells/a21oi_4.sym} 101060 -11550 0 0 {name=X_68193_ }
C {devices/lab_pin.sym} 100970 -11410 0 0 {name=p100609 lab=_81834_/CLK }
C {devices/lab_pin.sym} 100970 -11390 0 0 {name=p100610 lab=_82242_/Q }
C {devices/lab_pin.sym} 101150 -11410 0 1 {name=p100611 lab=_77234_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -11400 0 0 {name=X_82210_ }
C {devices/lab_pin.sym} 101020 -11270 0 0 {name=p100612 lab=_67144_/A }
C {devices/lab_pin.sym} 101100 -11270 0 1 {name=p100613 lab=_67241_/A }
C {sky130_stdcells/buf_2.sym} 101060 -11270 0 0 {name=X_67144_ }
C {devices/lab_pin.sym} 101000 -11170 0 0 {name=p100614 lab=_52370_/A }
C {devices/lab_pin.sym} 101000 -11130 0 0 {name=p100615 lab=_52310_/B }
C {devices/lab_pin.sym} 101000 -11090 0 0 {name=p100616 lab=_52369_/X }
C {devices/lab_pin.sym} 101120 -11130 0 1 {name=p100617 lab=_52370_/X }
C {sky130_stdcells/and3_4.sym} 101060 -11130 0 0 {name=X_52370_ }
C {devices/lab_pin.sym} 100980 -11010 0 0 {name=p100618 lab=_58326_/A }
C {devices/lab_pin.sym} 100980 -10970 0 0 {name=p100619 lab=_64308_/X }
C {devices/lab_pin.sym} 100980 -10930 0 0 {name=p100620 lab=_64355_/Y }
C {devices/lab_pin.sym} 101140 -10970 0 1 {name=p100621 lab=_64356_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -10970 0 0 {name=X_64356_ }
C {devices/lab_pin.sym} 100970 -10830 0 0 {name=p100622 lab=_83191_/CLK }
C {devices/lab_pin.sym} 100970 -10810 0 0 {name=p100623 lab=_72684_/X }
C {devices/lab_pin.sym} 101150 -10830 0 1 {name=p100624 lab=_83190_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -10820 0 0 {name=X_83190_ }
C {devices/lab_pin.sym} 101000 -10710 0 0 {name=p100625 lab=_61558_/A }
C {devices/lab_pin.sym} 101000 -10670 0 0 {name=p100626 lab=_61568_/B }
C {devices/lab_pin.sym} 101000 -10630 0 0 {name=p100627 lab=_61538_/C }
C {devices/lab_pin.sym} 101120 -10670 0 1 {name=p100628 lab=_61568_/Y }
C {sky130_stdcells/nand3_4.sym} 101060 -10670 0 0 {name=X_61568_ }
C {devices/lab_pin.sym} 100980 -10550 0 0 {name=p100629 lab=_65051_/B }
C {devices/lab_pin.sym} 100980 -10510 0 0 {name=p100630 lab=_51309_/X }
C {devices/lab_pin.sym} 100980 -10470 0 0 {name=p100631 lab=_51320_/Y }
C {devices/lab_pin.sym} 101140 -10510 0 1 {name=p100632 lab=_51321_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -10510 0 0 {name=X_51321_ }
C {devices/lab_pin.sym} 101000 -10390 0 0 {name=p100633 lab=_63305_/X }
C {devices/lab_pin.sym} 101000 -10350 0 0 {name=p100634 lab=_63392_/B }
C {devices/lab_pin.sym} 101000 -10310 0 0 {name=p100635 lab=_79231_/A }
C {devices/lab_pin.sym} 101120 -10350 0 1 {name=p100636 lab=_63307_/Y }
C {sky130_stdcells/nor3_4.sym} 101060 -10350 0 0 {name=X_63307_ }
C {devices/lab_pin.sym} 100970 -10210 0 0 {name=p100637 lab=_82047_/CLK }
C {devices/lab_pin.sym} 100970 -10190 0 0 {name=p100638 lab=_77984_/Y }
C {devices/lab_pin.sym} 101150 -10210 0 1 {name=p100639 lab=_77444_/B }
C {sky130_stdcells/dfxtp_4.sym} 101060 -10200 0 0 {name=X_82141_ }
C {devices/lab_pin.sym} 101000 -10090 0 0 {name=p100640 lab=_60526_/A }
C {devices/lab_pin.sym} 101000 -10050 0 0 {name=p100641 lab=_60519_/B }
C {devices/lab_pin.sym} 101000 -10010 0 0 {name=p100642 lab=_79147_/A }
C {devices/lab_pin.sym} 101120 -10050 0 1 {name=p100643 lab=_60519_/Y }
C {sky130_stdcells/nor3_4.sym} 101060 -10050 0 0 {name=X_60519_ }
C {devices/lab_pin.sym} 101020 -9910 0 0 {name=p100644 lab=_66717_/A }
C {devices/lab_pin.sym} 101100 -9910 0 1 {name=p100645 lab=_67075_/X }
C {sky130_stdcells/buf_2.sym} 101060 -9910 0 0 {name=X_67075_ }
C {devices/lab_pin.sym} 101000 -9810 0 0 {name=p100646 lab=_64287_/A }
C {devices/lab_pin.sym} 101000 -9770 0 0 {name=p100647 lab=_84851_/Q }
C {devices/lab_pin.sym} 101000 -9730 0 0 {name=p100648 lab=_64287_/C }
C {devices/lab_pin.sym} 101120 -9770 0 1 {name=p100649 lab=_64287_/Y }
C {sky130_stdcells/nand3_4.sym} 101060 -9770 0 0 {name=X_64287_ }
C {devices/lab_pin.sym} 101000 -9650 0 0 {name=p100650 lab=_61499_/A }
C {devices/lab_pin.sym} 101000 -9610 0 0 {name=p100651 lab=_61499_/B }
C {devices/lab_pin.sym} 101000 -9570 0 0 {name=p100652 lab=_61459_/X }
C {devices/lab_pin.sym} 101120 -9610 0 1 {name=p100653 lab=_61499_/Y }
C {sky130_stdcells/nand3_4.sym} 101060 -9610 0 0 {name=X_61499_ }
C {devices/lab_pin.sym} 100980 -9490 0 0 {name=p100654 lab=_54038_/Y }
C {devices/lab_pin.sym} 100980 -9450 0 0 {name=p100655 lab=_54015_/X }
C {devices/lab_pin.sym} 100980 -9410 0 0 {name=p100656 lab=_54039_/X }
C {devices/lab_pin.sym} 101140 -9450 0 1 {name=p100657 lab=_54040_/Y }
C {sky130_stdcells/a21oi_4.sym} 101060 -9450 0 0 {name=X_54040_ }
C {devices/lab_pin.sym} 100980 -9330 0 0 {name=p100658 lab=_66023_/X }
C {devices/lab_pin.sym} 100980 -9290 0 0 {name=p100659 lab=_66025_/X }
C {devices/lab_pin.sym} 100980 -9250 0 0 {name=p100660 lab=_65880_/X }
C {devices/lab_pin.sym} 101140 -9290 0 1 {name=p100661 lab=_66030_/A }
C {sky130_stdcells/a21o_4.sym} 101060 -9290 0 0 {name=X_66026_ }
C {devices/lab_pin.sym} 100980 -9170 0 0 {name=p100662 lab=_51250_/Y }
C {devices/lab_pin.sym} 100980 -9130 0 0 {name=p100663 lab=_51237_/X }
C {devices/lab_pin.sym} 100980 -9090 0 0 {name=p100664 lab=_51251_/X }
C {devices/lab_pin.sym} 101140 -9130 0 1 {name=p100665 lab=_51252_/Y }
C {sky130_stdcells/a21oi_4.sym} 101060 -9130 0 0 {name=X_51252_ }
C {devices/lab_pin.sym} 101000 -9020 0 0 {name=p100666 lab=_63288_/A }
C {devices/lab_pin.sym} 101000 -8980 0 0 {name=p100667 lab=_63238_/B }
C {devices/lab_pin.sym} 101000 -8940 0 0 {name=p100668 lab=_63312_/C }
C {devices/lab_pin.sym} 101000 -8900 0 0 {name=p100669 lab=_63237_/X }
C {devices/lab_pin.sym} 101120 -8960 0 1 {name=p100670 lab=_63238_/X }
C {sky130_stdcells/and4_4.sym} 101060 -8960 0 0 {name=X_63238_ }
C {devices/lab_pin.sym} 100970 -8810 0 0 {name=p100671 lab=_81154_/CLK }
C {devices/lab_pin.sym} 100970 -8790 0 0 {name=p100672 lab=_82072_/D }
C {devices/lab_pin.sym} 101150 -8810 0 1 {name=p100673 lab=_82072_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -8800 0 0 {name=X_82072_ }
C {devices/lab_pin.sym} 101000 -8680 0 0 {name=p100674 lab=_50187_/X }
C {devices/lab_pin.sym} 101000 -8640 0 0 {name=p100675 lab=_50716_/B }
C {devices/lab_pin.sym} 101120 -8660 0 1 {name=p100676 lab=_50203_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -8660 0 0 {name=X_50203_ }
C {devices/lab_pin.sym} 100970 -8530 0 0 {name=p100677 lab=_84175_/CLK }
C {devices/lab_pin.sym} 100970 -8510 0 0 {name=p100678 lab=_64663_/C }
C {devices/lab_pin.sym} 101150 -8530 0 1 {name=p100679 lab=_81023_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -8520 0 0 {name=X_81023_ }
C {devices/lab_pin.sym} 100970 -8390 0 0 {name=p100680 lab=_86570_/CLK }
C {devices/lab_pin.sym} 100970 -8370 0 0 {name=p100681 lab=_85900_/D }
C {devices/lab_pin.sym} 101150 -8390 0 1 {name=p100682 lab=_66209_/B }
C {sky130_stdcells/dfxtp_4.sym} 101060 -8380 0 0 {name=X_85900_ }
C {devices/lab_pin.sym} 101020 -8250 0 0 {name=p100683 lab=clkbuf_4_8_1_CLK/A }
C {devices/lab_pin.sym} 101100 -8250 0 1 {name=p100684 lab=clkbuf_4_8_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 101060 -8250 0 0 {name=Xclkbuf_4_8_1_CLK }
C {devices/lab_pin.sym} 101020 -8130 0 0 {name=p100685 lab=_51128_/A }
C {devices/lab_pin.sym} 101100 -8130 0 1 {name=p100686 lab=_51183_/X }
C {sky130_stdcells/buf_2.sym} 101060 -8130 0 0 {name=X_51183_ }
C {devices/lab_pin.sym} 100980 -8050 0 0 {name=p100687 lab=_63164_/Y }
C {devices/lab_pin.sym} 100980 -8010 0 0 {name=p100688 lab=_63166_/X }
C {devices/lab_pin.sym} 100980 -7970 0 0 {name=p100689 lab=_63167_/X }
C {devices/lab_pin.sym} 100980 -7930 0 0 {name=p100690 lab=_63168_/X }
C {devices/lab_pin.sym} 100980 -7890 0 0 {name=p100691 lab=_63125_/X }
C {devices/lab_pin.sym} 101140 -7970 0 1 {name=p100692 lab=_63169_/Y }
C {sky130_stdcells/o41ai_4.sym} 101060 -7970 0 0 {name=X_63169_ }
C {devices/lab_pin.sym} 100970 -7810 0 0 {name=p100693 lab=_84418_/CLK }
C {devices/lab_pin.sym} 100970 -7790 0 0 {name=p100694 lab=_45385_/Y }
C {devices/lab_pin.sym} 101150 -7810 0 1 {name=p100695 lab=_62629_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -7800 0 0 {name=X_86880_ }
C {devices/lab_pin.sym} 100980 -7690 0 0 {name=p100696 lab=_65037_/B }
C {devices/lab_pin.sym} 100980 -7650 0 0 {name=p100697 lab=_50113_/X }
C {devices/lab_pin.sym} 100980 -7610 0 0 {name=p100698 lab=_50133_/Y }
C {devices/lab_pin.sym} 101140 -7650 0 1 {name=p100699 lab=_50134_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -7650 0 0 {name=X_50134_ }
C {devices/lab_pin.sym} 100970 -7510 0 0 {name=p100700 lab=_86154_/CLK }
C {devices/lab_pin.sym} 100970 -7490 0 0 {name=p100701 lab=_52396_/Y }
C {devices/lab_pin.sym} 101150 -7510 0 1 {name=p100702 lab=_65282_/B }
C {sky130_stdcells/dfxtp_4.sym} 101060 -7500 0 0 {name=X_85831_ }
C {devices/lab_pin.sym} 100980 -7390 0 0 {name=p100703 lab=_55688_/X }
C {devices/lab_pin.sym} 100980 -7350 0 0 {name=p100704 lab=_55987_/X }
C {devices/lab_pin.sym} 100980 -7310 0 0 {name=p100705 lab=_55990_/Y }
C {devices/lab_pin.sym} 101140 -7350 0 1 {name=p100706 lab=_55991_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -7350 0 0 {name=X_55991_ }
C {devices/lab_pin.sym} 101020 -7210 0 0 {name=p100707 lab=_68442_/A }
C {devices/lab_pin.sym} 101100 -7210 0 1 {name=p100708 lab=_67977_/X }
C {sky130_stdcells/buf_2.sym} 101060 -7210 0 0 {name=X_67977_ }
C {devices/lab_pin.sym} 100980 -7120 0 0 {name=p100709 lab=_84952_/Q }
C {devices/lab_pin.sym} 100980 -7080 0 0 {name=p100710 lab=_57691_/X }
C {devices/lab_pin.sym} 100980 -7040 0 0 {name=p100711 lab=_57723_/X }
C {devices/lab_pin.sym} 100980 -7000 0 0 {name=p100712 lab=_57729_/X }
C {devices/lab_pin.sym} 101140 -7060 0 1 {name=p100713 lab=_84952_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 101060 -7060 0 0 {name=X_57730_ }
C {devices/lab_pin.sym} 100980 -6940 0 0 {name=p100714 lab=_69293_/Y }
C {devices/lab_pin.sym} 100980 -6900 0 0 {name=p100715 lab=_69644_/X }
C {devices/lab_pin.sym} 100980 -6860 0 0 {name=p100716 lab=_69672_/X }
C {devices/lab_pin.sym} 100980 -6820 0 0 {name=p100717 lab=_69715_/Y }
C {devices/lab_pin.sym} 101140 -6880 0 1 {name=p100718 lab=_69716_/X }
C {sky130_stdcells/a211o_4.sym} 101060 -6880 0 0 {name=X_69716_ }
C {devices/lab_pin.sym} 101000 -6740 0 0 {name=p100719 lab=_50084_/A }
C {devices/lab_pin.sym} 101000 -6700 0 0 {name=p100720 lab=_48901_/B }
C {devices/lab_pin.sym} 101120 -6720 0 1 {name=p100721 lab=_50065_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -6720 0 0 {name=X_50065_ }
C {devices/lab_pin.sym} 101000 -6620 0 0 {name=p100722 lab=_54955_/A }
C {devices/lab_pin.sym} 101000 -6580 0 0 {name=p100723 lab=_54942_/B }
C {devices/lab_pin.sym} 101000 -6540 0 0 {name=p100724 lab=_46617_/A }
C {devices/lab_pin.sym} 101000 -6500 0 0 {name=p100725 lab=_53249_/D }
C {devices/lab_pin.sym} 101120 -6560 0 1 {name=p100726 lab=_54942_/X }
C {sky130_stdcells/and4_4.sym} 101060 -6560 0 0 {name=X_54942_ }
C {devices/lab_pin.sym} 100980 -6440 0 0 {name=p100727 lab=_87940_/Q }
C {devices/lab_pin.sym} 100980 -6400 0 0 {name=p100728 lab=_66875_/X }
C {devices/lab_pin.sym} 100980 -6360 0 0 {name=p100729 lab=_66926_/X }
C {devices/lab_pin.sym} 100980 -6320 0 0 {name=p100730 lab=_66927_/X }
C {devices/lab_pin.sym} 101140 -6380 0 1 {name=p100731 lab=_66928_/X }
C {sky130_stdcells/a211o_4.sym} 101060 -6380 0 0 {name=X_66928_ }
C {devices/lab_pin.sym} 100970 -6230 0 0 {name=p100732 lab=_85764_/CLK }
C {devices/lab_pin.sym} 100970 -6210 0 0 {name=p100733 lab=_52747_/Y }
C {devices/lab_pin.sym} 101150 -6230 0 1 {name=p100734 lab=_85762_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -6220 0 0 {name=X_85762_ }
C {devices/lab_pin.sym} 100970 -6090 0 0 {name=p100735 lab=_82975_/CLK }
C {devices/lab_pin.sym} 100970 -6070 0 0 {name=p100736 lab=_82782_/Q }
C {devices/lab_pin.sym} 101150 -6090 0 1 {name=p100737 lab=_82974_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -6080 0 0 {name=X_82974_ }
C {devices/lab_pin.sym} 100970 -5950 0 0 {name=p100738 lab=_87766_/CLK }
C {devices/lab_pin.sym} 100970 -5930 0 0 {name=p100739 lab=_43282_/X }
C {devices/lab_pin.sym} 101150 -5950 0 1 {name=p100740 lab=_87501_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -5940 0 0 {name=X_87501_ }
C {devices/lab_pin.sym} 100970 -5810 0 0 {name=p100741 lab=_84713_/CLK }
C {devices/lab_pin.sym} 100970 -5790 0 0 {name=p100742 lab=_59652_/X }
C {devices/lab_pin.sym} 101150 -5810 0 1 {name=p100743 lab=_80625_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -5800 0 0 {name=X_84713_ }
C {devices/lab_pin.sym} 101000 -5680 0 0 {name=p100744 lab=_57660_/X }
C {devices/lab_pin.sym} 101000 -5640 0 0 {name=p100745 lab=_57657_/B }
C {devices/lab_pin.sym} 101120 -5660 0 1 {name=p100746 lab=_57661_/Y }
C {sky130_stdcells/nor2_4.sym} 101060 -5660 0 0 {name=X_57661_ }
C {devices/lab_pin.sym} 100980 -5560 0 0 {name=p100747 lab=_87565_/Q }
C {devices/lab_pin.sym} 100980 -5520 0 0 {name=p100748 lab=_69645_/X }
C {devices/lab_pin.sym} 100980 -5480 0 0 {name=p100749 lab=_68552_/X }
C {devices/lab_pin.sym} 100980 -5440 0 0 {name=p100750 lab=_69646_/X }
C {devices/lab_pin.sym} 101140 -5500 0 1 {name=p100751 lab=_69647_/X }
C {sky130_stdcells/a211o_4.sym} 101060 -5500 0 0 {name=X_69647_ }
C {devices/lab_pin.sym} 100970 -5350 0 0 {name=p100752 lab=_82116_/CLK }
C {devices/lab_pin.sym} 100970 -5330 0 0 {name=p100753 lab=_78048_/Y }
C {devices/lab_pin.sym} 101150 -5350 0 1 {name=p100754 lab=_77277_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -5340 0 0 {name=X_81925_ }
C {devices/lab_pin.sym} 101020 -5210 0 0 {name=p100755 lab=_54900_/A }
C {devices/lab_pin.sym} 101100 -5210 0 1 {name=p100756 lab=_54883_/B }
C {sky130_stdcells/buf_2.sym} 101060 -5210 0 0 {name=X_54873_ }
C {devices/lab_pin.sym} 100970 -5090 0 0 {name=p100757 lab=_85692_/CLK }
C {devices/lab_pin.sym} 100970 -5070 0 0 {name=p100758 lab=_53126_/Y }
C {devices/lab_pin.sym} 101150 -5090 0 1 {name=p100759 lab=_85693_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -5080 0 0 {name=X_85693_ }
C {devices/lab_pin.sym} 101000 -4960 0 0 {name=p100760 lab=_66859_/A }
C {devices/lab_pin.sym} 101000 -4920 0 0 {name=p100761 lab=_66858_/X }
C {devices/lab_pin.sym} 101120 -4940 0 1 {name=p100762 lab=_66859_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -4940 0 0 {name=X_66859_ }
C {devices/lab_pin.sym} 100980 -4830 0 0 {name=p100763 lab=_59394_/X }
C {devices/lab_pin.sym} 100980 -4790 0 0 {name=p100764 lab=_83487_/Q }
C {devices/lab_pin.sym} 100980 -4750 0 0 {name=p100765 lab=_59399_/Y }
C {devices/lab_pin.sym} 101140 -4790 0 1 {name=p100766 lab=_59400_/X }
C {sky130_stdcells/o21a_4.sym} 101060 -4790 0 0 {name=X_59400_ }
C {devices/lab_pin.sym} 100980 -4680 0 0 {name=p100767 lab=_56582_/A }
C {devices/lab_pin.sym} 100980 -4640 0 0 {name=p100768 lab=_55552_/X }
C {devices/lab_pin.sym} 100980 -4600 0 0 {name=p100769 lab=_56609_/X }
C {devices/lab_pin.sym} 100980 -4560 0 0 {name=p100770 lab=_56611_/Y }
C {devices/lab_pin.sym} 101140 -4620 0 1 {name=p100771 lab=_56613_/A }
C {sky130_stdcells/a211o_4.sym} 101060 -4620 0 0 {name=X_56612_ }
C {devices/lab_pin.sym} 100970 -4470 0 0 {name=p100772 lab=_87625_/CLK }
C {devices/lab_pin.sym} 100970 -4450 0 0 {name=p100773 lab=_43416_/Y }
C {devices/lab_pin.sym} 101150 -4470 0 1 {name=p100774 lab=_87432_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -4460 0 0 {name=X_87432_ }
C {devices/lab_pin.sym} 100980 -4350 0 0 {name=p100775 lab=_85561_/Q }
C {devices/lab_pin.sym} 100980 -4310 0 0 {name=p100776 lab=_53816_/X }
C {devices/lab_pin.sym} 100980 -4270 0 0 {name=p100777 lab=_53823_/Y }
C {devices/lab_pin.sym} 101140 -4310 0 1 {name=p100778 lab=_53824_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -4310 0 0 {name=X_53824_ }
C {devices/lab_pin.sym} 100970 -4170 0 0 {name=p100779 lab=_84649_/CLK }
C {devices/lab_pin.sym} 100970 -4150 0 0 {name=p100780 lab=_84644_/D }
C {devices/lab_pin.sym} 101150 -4170 0 1 {name=p100781 lab=_79826_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -4160 0 0 {name=X_84644_ }
C {devices/lab_pin.sym} 101020 -4030 0 0 {name=p100782 lab=clkbuf_9_225_0_CLK/X }
C {devices/lab_pin.sym} 101100 -4030 0 1 {name=p100783 lab=_86301_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 101060 -4030 0 0 {name=Xclkbuf_10_451_0_CLK }
C {devices/lab_pin.sym} 101020 -3910 0 0 {name=p100784 lab=_71978_/A }
C {devices/lab_pin.sym} 101100 -3910 0 1 {name=p100785 lab=_57592_/X }
C {sky130_stdcells/buf_2.sym} 101060 -3910 0 0 {name=X_57592_ }
C {devices/lab_pin.sym} 100980 -3810 0 0 {name=p100786 lab=_81985_/D }
C {devices/lab_pin.sym} 100980 -3770 0 0 {name=p100787 lab=_69564_/X }
C {devices/lab_pin.sym} 100980 -3730 0 0 {name=p100788 lab=_69577_/X }
C {devices/lab_pin.sym} 101140 -3770 0 1 {name=p100789 lab=_83913_/D }
C {sky130_stdcells/a21bo_4.sym} 101060 -3770 0 0 {name=X_69578_ }
C {devices/lab_pin.sym} 100970 -3630 0 0 {name=p100790 lab=_82515_/CLK }
C {devices/lab_pin.sym} 100970 -3610 0 0 {name=p100791 lab=_81888_/Q }
C {devices/lab_pin.sym} 101150 -3630 0 1 {name=p100792 lab=_77712_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -3620 0 0 {name=X_81856_ }
C {devices/lab_pin.sym} 101020 -3490 0 0 {name=p100793 lab=_57759_/X }
C {devices/lab_pin.sym} 101100 -3490 0 1 {name=p100794 lab=_59331_/X }
C {sky130_stdcells/buf_2.sym} 101060 -3490 0 0 {name=X_59331_ }
C {devices/lab_pin.sym} 100980 -3390 0 0 {name=p100795 lab=_56168_/X }
C {devices/lab_pin.sym} 100980 -3350 0 0 {name=p100796 lab=_56462_/X }
C {devices/lab_pin.sym} 100980 -3310 0 0 {name=p100797 lab=_56542_/Y }
C {devices/lab_pin.sym} 101140 -3350 0 1 {name=p100798 lab=_85155_/D }
C {sky130_stdcells/o21ai_4.sym} 101060 -3350 0 0 {name=X_56543_ }
C {devices/lab_pin.sym} 100970 -3210 0 0 {name=p100799 lab=_83973_/CLK }
C {devices/lab_pin.sym} 100970 -3190 0 0 {name=p100800 lab=_83951_/Q }
C {devices/lab_pin.sym} 101150 -3210 0 1 {name=p100801 lab=_80807_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -3200 0 0 {name=X_80807_ }
C {devices/lab_pin.sym} 100980 -3100 0 0 {name=p100802 lab=_88013_/Q }
C {devices/lab_pin.sym} 100980 -3060 0 0 {name=p100803 lab=_68527_/X }
C {devices/lab_pin.sym} 100980 -3020 0 0 {name=p100804 lab=_68501_/X }
C {devices/lab_pin.sym} 100980 -2980 0 0 {name=p100805 lab=_68528_/X }
C {devices/lab_pin.sym} 101140 -3040 0 1 {name=p100806 lab=_68529_/X }
C {sky130_stdcells/a211o_4.sym} 101060 -3040 0 0 {name=X_68529_ }
C {devices/lab_pin.sym} 100970 -2890 0 0 {name=p100807 lab=_86796_/CLK }
C {devices/lab_pin.sym} 100970 -2870 0 0 {name=p100808 lab=_87363_/D }
C {devices/lab_pin.sym} 101150 -2890 0 1 {name=p100809 lab=_87363_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -2880 0 0 {name=X_87363_ }
C {devices/lab_pin.sym} 101020 -2750 0 0 {name=p100810 lab=_53755_/A }
C {devices/lab_pin.sym} 101100 -2750 0 1 {name=p100811 lab=_53766_/A }
C {sky130_stdcells/buf_2.sym} 101060 -2750 0 0 {name=X_53755_ }
C {devices/lab_pin.sym} 100970 -2630 0 0 {name=p100812 lab=_84564_/CLK }
C {devices/lab_pin.sym} 100970 -2610 0 0 {name=p100813 lab=_60753_/Y }
C {devices/lab_pin.sym} 101150 -2630 0 1 {name=p100814 lab=_84575_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -2620 0 0 {name=X_84575_ }
C {devices/lab_pin.sym} 101000 -2500 0 0 {name=p100815 lab=_50971_/A }
C {devices/lab_pin.sym} 101000 -2460 0 0 {name=p100816 lab=_46758_/X }
C {devices/lab_pin.sym} 101120 -2480 0 1 {name=p100817 lab=_50967_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -2480 0 0 {name=X_50967_ }
C {devices/lab_pin.sym} 100970 -2350 0 0 {name=p100818 lab=_80928_/CLK }
C {devices/lab_pin.sym} 100970 -2330 0 0 {name=p100819 lab=_75925_/X }
C {devices/lab_pin.sym} 101150 -2350 0 1 {name=p100820 lab=_48426_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -2340 0 0 {name=X_81787_ }
C {devices/lab_pin.sym} 100970 -2210 0 0 {name=p100821 lab=_86312_/CLK }
C {devices/lab_pin.sym} 100970 -2190 0 0 {name=p100822 lab=_86314_/D }
C {devices/lab_pin.sym} 101150 -2210 0 1 {name=p100823 lab=_58038_/B }
C {sky130_stdcells/dfxtp_4.sym} 101060 -2200 0 0 {name=X_86314_ }
C {devices/lab_pin.sym} 101020 -2070 0 0 {name=p100824 lab=_40599_/A }
C {devices/lab_pin.sym} 101100 -2070 0 1 {name=p100825 lab=_40720_/X }
C {sky130_stdcells/buf_2.sym} 101060 -2070 0 0 {name=X_40720_ }
C {devices/lab_pin.sym} 101000 -1960 0 0 {name=p100826 lab=_52706_/A }
C {devices/lab_pin.sym} 101000 -1920 0 0 {name=p100827 lab=_52706_/B }
C {devices/lab_pin.sym} 101120 -1940 0 1 {name=p100828 lab=_52706_/Y }
C {sky130_stdcells/nand2_4.sym} 101060 -1940 0 0 {name=X_52706_ }
C {devices/lab_pin.sym} 100980 -1830 0 0 {name=p100829 lab=_71531_/X }
C {devices/lab_pin.sym} 100980 -1790 0 0 {name=p100830 lab=_83464_/Q }
C {devices/lab_pin.sym} 100980 -1750 0 0 {name=p100831 lab=_71539_/Y }
C {devices/lab_pin.sym} 101140 -1790 0 1 {name=p100832 lab=_83464_/D }
C {sky130_stdcells/a21o_4.sym} 101060 -1790 0 0 {name=X_71540_ }
C {devices/lab_pin.sym} 100980 -1670 0 0 {name=p100833 lab=_59260_/X }
C {devices/lab_pin.sym} 100980 -1630 0 0 {name=p100834 lab=_85420_/Q }
C {devices/lab_pin.sym} 100980 -1590 0 0 {name=p100835 lab=_59261_/X }
C {devices/lab_pin.sym} 101140 -1630 0 1 {name=p100836 lab=_59262_/Y }
C {sky130_stdcells/o21ai_4.sym} 101060 -1630 0 0 {name=X_59262_ }
C {devices/lab_pin.sym} 100970 -1490 0 0 {name=p100837 lab=_83526_/CLK }
C {devices/lab_pin.sym} 100970 -1470 0 0 {name=p100838 lab=_71360_/X }
C {devices/lab_pin.sym} 101150 -1490 0 1 {name=p100839 lab=_83526_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101060 -1480 0 0 {name=X_83526_ }
C {devices/lab_pin.sym} 101020 -1350 0 0 {name=p100840 lab=_56528_/A }
C {devices/lab_pin.sym} 101100 -1350 0 1 {name=p100841 lab=_56474_/X }
C {sky130_stdcells/buf_2.sym} 101060 -1350 0 0 {name=X_56474_ }
C {devices/lab_pin.sym} 100970 -1230 0 0 {name=p100842 lab=_80740_/CLK }
C {devices/lab_pin.sym} 100970 -1210 0 0 {name=p100843 lab=_75081_/X }
C {devices/lab_pin.sym} 101150 -1230 0 1 {name=p100844 lab=_81146_/D }
C {sky130_stdcells/dfxtp_4.sym} 101060 -1220 0 0 {name=X_80738_ }
C {devices/lab_pin.sym} 100970 -1090 0 0 {name=p100845 lab=_87820_/CLK }
C {devices/lab_pin.sym} 100970 -1070 0 0 {name=p100846 lab=_87294_/D }
C {devices/lab_pin.sym} 101150 -1090 0 1 {name=p100847 lab=_73299_/A }
C {sky130_stdcells/dfxtp_4.sym} 101060 -1080 0 0 {name=X_87294_ }
C {devices/lab_pin.sym} 100980 -970 0 0 {name=p100848 lab=_53684_/Y }
C {devices/lab_pin.sym} 100980 -930 0 0 {name=p100849 lab=_53680_/X }
C {devices/lab_pin.sym} 100980 -890 0 0 {name=p100850 lab=_53685_/X }
C {devices/lab_pin.sym} 101140 -930 0 1 {name=p100851 lab=_85588_/D }
C {sky130_stdcells/a21oi_4.sym} 101060 -930 0 0 {name=X_53686_ }
C {devices/lab_pin.sym} 101000 -820 0 0 {name=p100852 lab=_50908_/A }
C {devices/lab_pin.sym} 101000 -780 0 0 {name=p100853 lab=_50045_/X }
C {devices/lab_pin.sym} 101000 -740 0 0 {name=p100854 lab=_50897_/X }
C {devices/lab_pin.sym} 101000 -700 0 0 {name=p100855 lab=_51761_/D }
C {devices/lab_pin.sym} 101120 -760 0 1 {name=p100856 lab=_50898_/X }
C {sky130_stdcells/and4_4.sym} 101060 -760 0 0 {name=X_50898_ }
C {devices/lab_pin.sym} 101940 -42150 0 0 {name=p100857 lab=_84906_/Q }
C {devices/lab_pin.sym} 102020 -42150 0 1 {name=p100858 lab=_63713_/A }
C {sky130_stdcells/inv_2.sym} 101980 -42150 0 0 {name=X_58213_ }
C {devices/lab_pin.sym} 101940 -42030 0 0 {name=p100859 lab=clkbuf_9_233_0_CLK/X }
C {devices/lab_pin.sym} 102020 -42030 0 1 {name=p100860 lab=_86695_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 101980 -42030 0 0 {name=Xclkbuf_10_466_0_CLK }
C {devices/lab_pin.sym} 101900 -41930 0 0 {name=p100861 lab=_55156_/X }
C {devices/lab_pin.sym} 101900 -41890 0 0 {name=p100862 lab=_55160_/X }
C {devices/lab_pin.sym} 101900 -41850 0 0 {name=p100863 lab=_57186_/B }
C {devices/lab_pin.sym} 102060 -41890 0 1 {name=p100864 lab=_55428_/C }
C {sky130_stdcells/a21o_4.sym} 101980 -41890 0 0 {name=X_55425_ }
C {devices/lab_pin.sym} 101890 -41750 0 0 {name=p100865 lab=_86149_/CLK }
C {devices/lab_pin.sym} 101890 -41730 0 0 {name=p100866 lab=_50198_/Y }
C {devices/lab_pin.sym} 102070 -41750 0 1 {name=p100867 lab=_65327_/B }
C {sky130_stdcells/dfxtp_4.sym} 101980 -41740 0 0 {name=X_86245_ }
C {devices/lab_pin.sym} 101940 -41610 0 0 {name=p100868 lab=_40595_/X }
C {devices/lab_pin.sym} 102020 -41610 0 1 {name=p100869 lab=_40651_/X }
C {sky130_stdcells/buf_2.sym} 101980 -41610 0 0 {name=X_40651_ }
C {sky130_stdcells/decap_3.sym} 101980 -41460 0 0 {name=XPHY_401 }
C {devices/lab_pin.sym} 101920 -41320 0 0 {name=p100870 lab=_52637_/A }
C {devices/lab_pin.sym} 101920 -41280 0 0 {name=p100871 lab=_52637_/B }
C {devices/lab_pin.sym} 102040 -41300 0 1 {name=p100872 lab=_52637_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -41300 0 0 {name=X_52637_ }
C {devices/lab_pin.sym} 101940 -41170 0 0 {name=p100873 lab=_58897_/A }
C {devices/lab_pin.sym} 102020 -41170 0 1 {name=p100874 lab=_59282_/B }
C {sky130_stdcells/buf_2.sym} 101980 -41170 0 0 {name=X_59193_ }
C {devices/lab_pin.sym} 101920 -41080 0 0 {name=p100875 lab=_70880_/B }
C {devices/lab_pin.sym} 101920 -41040 0 0 {name=p100876 lab=_71479_/B }
C {devices/lab_pin.sym} 101920 -41000 0 0 {name=p100877 lab=_70771_/A }
C {devices/lab_pin.sym} 101920 -40960 0 0 {name=p100878 lab=_71476_/D }
C {devices/lab_pin.sym} 102040 -41020 0 1 {name=p100879 lab=_71471_/X }
C {sky130_stdcells/and4_4.sym} 101980 -41020 0 0 {name=X_71471_ }
C {devices/lab_pin.sym} 101890 -40870 0 0 {name=p100880 lab=_83457_/CLK }
C {devices/lab_pin.sym} 101890 -40850 0 0 {name=p100881 lab=_83457_/D }
C {devices/lab_pin.sym} 102070 -40870 0 1 {name=p100882 lab=_83457_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -40860 0 0 {name=X_83457_ }
C {sky130_stdcells/decap_3.sym} 101980 -40700 0 0 {name=XPHY_412 }
C {devices/lab_pin.sym} 101890 -40550 0 0 {name=p100883 lab=_86841_/CLK }
C {devices/lab_pin.sym} 101890 -40530 0 0 {name=p100884 lab=_74813_/Y }
C {devices/lab_pin.sym} 102070 -40550 0 1 {name=p100885 lab=_80669_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -40540 0 0 {name=X_80669_ }
C {sky130_stdcells/decap_3.sym} 101980 -40380 0 0 {name=XPHY_423 }
C {devices/lab_pin.sym} 101940 -40230 0 0 {name=p100886 lab=_73355_/A }
C {devices/lab_pin.sym} 102020 -40230 0 1 {name=p100887 lab=_73210_/X }
C {sky130_stdcells/buf_2.sym} 101980 -40230 0 0 {name=X_73210_ }
C {sky130_stdcells/decap_3.sym} 101980 -40080 0 0 {name=XPHY_434 }
C {devices/lab_pin.sym} 101900 -39960 0 0 {name=p100888 lab=_84922_/Q }
C {devices/lab_pin.sym} 101900 -39920 0 0 {name=p100889 lab=_58095_/X }
C {devices/lab_pin.sym} 101900 -39880 0 0 {name=p100890 lab=_58137_/X }
C {devices/lab_pin.sym} 101900 -39840 0 0 {name=p100891 lab=_58143_/X }
C {devices/lab_pin.sym} 102060 -39900 0 1 {name=p100892 lab=_84922_/D }
C {sky130_stdcells/a2bb2oi_4.sym} 101980 -39900 0 0 {name=X_58144_ }
C {devices/lab_pin.sym} 101940 -39750 0 0 {name=p100893 lab=_70421_/Y }
C {devices/lab_pin.sym} 102020 -39750 0 1 {name=p100894 lab=_70422_/X }
C {sky130_stdcells/buf_2.sym} 101980 -39750 0 0 {name=X_70422_ }
C {sky130_stdcells/decap_3.sym} 101980 -39600 0 0 {name=XPHY_445 }
C {devices/lab_pin.sym} 101890 -39450 0 0 {name=p100895 lab=_82248_/CLK }
C {devices/lab_pin.sym} 101890 -39430 0 0 {name=p100896 lab=_82440_/Q }
C {devices/lab_pin.sym} 102070 -39450 0 1 {name=p100897 lab=_78385_/A }
C {sky130_stdcells/dfxtp_4.sym} 101980 -39440 0 0 {name=X_82408_ }
C {devices/lab_pin.sym} 101920 -39320 0 0 {name=p100898 lab=_55356_/A }
C {devices/lab_pin.sym} 101920 -39280 0 0 {name=p100899 lab=_55362_/A }
C {devices/lab_pin.sym} 102040 -39300 0 1 {name=p100900 lab=_56708_/A }
C {sky130_stdcells/nand2_4.sym} 101980 -39300 0 0 {name=X_55356_ }
C {devices/lab_pin.sym} 101940 -39170 0 0 {name=p100901 lab=_43178_/X }
C {devices/lab_pin.sym} 102020 -39170 0 1 {name=p100902 lab=_43396_/A }
C {sky130_stdcells/buf_2.sym} 101980 -39170 0 0 {name=X_43370_ }
C {devices/lab_pin.sym} 101900 -39070 0 0 {name=p100903 lab=_44738_/Y }
C {devices/lab_pin.sym} 101900 -39030 0 0 {name=p100904 lab=_73491_/X }
C {devices/lab_pin.sym} 101900 -38990 0 0 {name=p100905 lab=_74189_/Y }
C {devices/lab_pin.sym} 102060 -39030 0 1 {name=p100906 lab=_74190_/X }
C {sky130_stdcells/a21o_4.sym} 101980 -39030 0 0 {name=X_74190_ }
C {devices/lab_pin.sym} 101890 -38890 0 0 {name=p100907 lab=_85566_/CLK }
C {devices/lab_pin.sym} 101890 -38870 0 0 {name=p100908 lab=_50569_/Y }
C {devices/lab_pin.sym} 102070 -38890 0 1 {name=p100909 lab=_86176_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -38880 0 0 {name=X_86176_ }
C {sky130_stdcells/decap_3.sym} 101980 -38720 0 0 {name=XPHY_456 }
C {devices/lab_pin.sym} 101900 -38610 0 0 {name=p100910 lab=_40550_/X }
C {devices/lab_pin.sym} 101900 -38570 0 0 {name=p100911 lab=_40556_/X }
C {devices/lab_pin.sym} 101900 -38530 0 0 {name=p100912 lab=_40581_/X }
C {devices/lab_pin.sym} 101900 -38490 0 0 {name=p100913 lab=_88369_/Q }
C {devices/lab_pin.sym} 101900 -38450 0 0 {name=p100914 lab=_40568_/X }
C {devices/lab_pin.sym} 102060 -38530 0 1 {name=p100915 lab=_40583_/A }
C {sky130_stdcells/o32ai_4.sym} 101980 -38530 0 0 {name=X_40582_ }
C {devices/lab_pin.sym} 101900 -38390 0 0 {name=p100916 lab=_65375_/B }
C {devices/lab_pin.sym} 101900 -38350 0 0 {name=p100917 lab=_52549_/X }
C {devices/lab_pin.sym} 101900 -38310 0 0 {name=p100918 lab=_52567_/Y }
C {devices/lab_pin.sym} 102060 -38350 0 1 {name=p100919 lab=_52568_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -38350 0 0 {name=X_52568_ }
C {devices/lab_pin.sym} 101890 -38210 0 0 {name=p100920 lab=_85404_/CLK }
C {devices/lab_pin.sym} 101890 -38190 0 0 {name=p100921 lab=_83388_/D }
C {devices/lab_pin.sym} 102070 -38210 0 1 {name=p100922 lab=_83388_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -38200 0 0 {name=X_83388_ }
C {sky130_stdcells/decap_3.sym} 101980 -38040 0 0 {name=XPHY_467 }
C {sky130_stdcells/decap_3.sym} 101980 -37860 0 0 {name=XPHY_478 }
C {devices/lab_pin.sym} 101900 -37750 0 0 {name=p100923 lab=_42307_/X }
C {devices/lab_pin.sym} 101900 -37710 0 0 {name=p100924 lab=_42319_/X }
C {devices/lab_pin.sym} 101900 -37670 0 0 {name=p100925 lab=_41631_/X }
C {devices/lab_pin.sym} 101900 -37630 0 0 {name=p100926 lab=_87923_/Q }
C {devices/lab_pin.sym} 101900 -37590 0 0 {name=p100927 lab=_42320_/X }
C {devices/lab_pin.sym} 102060 -37670 0 1 {name=p100928 lab=_42321_/Y }
C {sky130_stdcells/o32ai_4.sym} 101980 -37670 0 0 {name=X_42321_ }
C {devices/lab_pin.sym} 101920 -37540 0 0 {name=p100929 lab=_54312_/A }
C {devices/lab_pin.sym} 101920 -37500 0 0 {name=p100930 lab=_54325_/B }
C {devices/lab_pin.sym} 101920 -37460 0 0 {name=p100931 lab=_54312_/C }
C {devices/lab_pin.sym} 101920 -37420 0 0 {name=p100932 lab=_46688_/Y }
C {devices/lab_pin.sym} 102040 -37480 0 1 {name=p100933 lab=_54307_/X }
C {sky130_stdcells/and4_4.sym} 101980 -37480 0 0 {name=X_54307_ }
C {devices/lab_pin.sym} 101920 -37340 0 0 {name=p100934 lab=_48514_/A }
C {devices/lab_pin.sym} 101920 -37300 0 0 {name=p100935 lab=_73141_/B }
C {devices/lab_pin.sym} 102040 -37320 0 1 {name=p100936 lab=_73141_/X }
C {sky130_stdcells/xor2_4.sym} 101980 -37320 0 0 {name=X_73141_ }
C {sky130_stdcells/decap_3.sym} 101980 -37160 0 0 {name=XPHY_489 }
C {devices/lab_pin.sym} 101890 -37010 0 0 {name=p100937 lab=_85128_/CLK }
C {devices/lab_pin.sym} 101890 -36990 0 0 {name=p100938 lab=_56875_/X }
C {devices/lab_pin.sym} 102070 -37010 0 1 {name=p100939 lab=_55281_/A }
C {sky130_stdcells/dfxtp_4.sym} 101980 -37000 0 0 {name=X_85127_ }
C {devices/lab_pin.sym} 101900 -36890 0 0 {name=p100940 lab=_85995_/Q }
C {devices/lab_pin.sym} 101900 -36850 0 0 {name=p100941 lab=_51511_/X }
C {devices/lab_pin.sym} 101900 -36810 0 0 {name=p100942 lab=_51518_/Y }
C {devices/lab_pin.sym} 102060 -36850 0 1 {name=p100943 lab=_51519_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -36850 0 0 {name=X_51519_ }
C {devices/lab_pin.sym} 101900 -36730 0 0 {name=p100944 lab=_58065_/X }
C {devices/lab_pin.sym} 101900 -36690 0 0 {name=p100945 lab=_85703_/Q }
C {devices/lab_pin.sym} 101900 -36650 0 0 {name=p100946 lab=_58020_/X }
C {devices/lab_pin.sym} 102060 -36690 0 1 {name=p100947 lab=_58075_/X }
C {sky130_stdcells/o21a_4.sym} 101980 -36690 0 0 {name=X_58075_ }
C {devices/lab_pin.sym} 101940 -36550 0 0 {name=p100948 lab=HASH_ADDR[5] }
C {devices/lab_pin.sym} 102020 -36550 0 1 {name=p100949 lab=_70412_/A }
C {sky130_stdcells/inv_2.sym} 101980 -36550 0 0 {name=X_70353_ }
C {devices/lab_pin.sym} 101890 -36430 0 0 {name=p100950 lab=_82339_/CLK }
C {devices/lab_pin.sym} 101890 -36410 0 0 {name=p100951 lab=_77060_/X }
C {devices/lab_pin.sym} 102070 -36430 0 1 {name=p100952 lab=_48146_/A }
C {sky130_stdcells/dfxtp_4.sym} 101980 -36420 0 0 {name=X_82339_ }
C {devices/lab_pin.sym} 101920 -36320 0 0 {name=p100953 lab=_55287_/A }
C {devices/lab_pin.sym} 101920 -36280 0 0 {name=p100954 lab=_55284_/X }
C {devices/lab_pin.sym} 101920 -36240 0 0 {name=p100955 lab=_55674_/B }
C {devices/lab_pin.sym} 101920 -36200 0 0 {name=p100956 lab=_55286_/Y }
C {devices/lab_pin.sym} 102040 -36260 0 1 {name=p100957 lab=_55287_/X }
C {sky130_stdcells/and4_4.sym} 101980 -36260 0 0 {name=X_55287_ }
C {devices/lab_pin.sym} 101900 -36130 0 0 {name=p100958 lab=_52495_/Y }
C {devices/lab_pin.sym} 101900 -36090 0 0 {name=p100959 lab=_52496_/X }
C {devices/lab_pin.sym} 101900 -36050 0 0 {name=p100960 lab=_52498_/X }
C {devices/lab_pin.sym} 102060 -36090 0 1 {name=p100961 lab=_52499_/Y }
C {sky130_stdcells/a21oi_4.sym} 101980 -36090 0 0 {name=X_52499_ }
C {devices/lab_pin.sym} 101940 -35950 0 0 {name=p100962 lab=_45720_/A }
C {devices/lab_pin.sym} 102020 -35950 0 1 {name=p100963 lab=_45040_/X }
C {sky130_stdcells/buf_2.sym} 101980 -35950 0 0 {name=X_45040_ }
C {devices/lab_pin.sym} 101940 -35830 0 0 {name=p100964 lab=_56551_/X }
C {devices/lab_pin.sym} 102020 -35830 0 1 {name=p100965 lab=_57026_/X }
C {sky130_stdcells/buf_2.sym} 101980 -35830 0 0 {name=X_57026_ }
C {devices/lab_pin.sym} 101940 -35710 0 0 {name=p100966 lab=_42204_/X }
C {devices/lab_pin.sym} 102020 -35710 0 1 {name=p100967 lab=_42252_/X }
C {sky130_stdcells/buf_2.sym} 101980 -35710 0 0 {name=X_42252_ }
C {devices/lab_pin.sym} 101900 -35610 0 0 {name=p100968 lab=_54235_/Y }
C {devices/lab_pin.sym} 101900 -35570 0 0 {name=p100969 lab=_54226_/X }
C {devices/lab_pin.sym} 101900 -35530 0 0 {name=p100970 lab=_54237_/X }
C {devices/lab_pin.sym} 102060 -35570 0 1 {name=p100971 lab=_54238_/Y }
C {sky130_stdcells/a21oi_4.sym} 101980 -35570 0 0 {name=X_54238_ }
C {devices/lab_pin.sym} 101920 -35440 0 0 {name=p100972 lab=_73068_/X }
C {devices/lab_pin.sym} 101920 -35400 0 0 {name=p100973 lab=_73071_/X }
C {devices/lab_pin.sym} 102040 -35420 0 1 {name=p100974 lab=_73073_/B }
C {sky130_stdcells/nand2_4.sym} 101980 -35420 0 0 {name=X_73072_ }
C {devices/lab_pin.sym} 101890 -35290 0 0 {name=p100975 lab=_85100_/CLK }
C {devices/lab_pin.sym} 101890 -35270 0 0 {name=p100976 lab=_85058_/D }
C {devices/lab_pin.sym} 102070 -35290 0 1 {name=p100977 lab=_55211_/B }
C {sky130_stdcells/dfxtp_4.sym} 101980 -35280 0 0 {name=X_85058_ }
C {devices/lab_pin.sym} 101940 -35150 0 0 {name=p100978 lab=_70249_/X }
C {devices/lab_pin.sym} 102020 -35150 0 1 {name=p100979 lab=_70292_/D }
C {sky130_stdcells/buf_2.sym} 101980 -35150 0 0 {name=X_70284_ }
C {devices/lab_pin.sym} 101940 -35030 0 0 {name=p100980 lab=_41203_/A }
C {devices/lab_pin.sym} 102020 -35030 0 1 {name=p100981 lab=_41203_/X }
C {sky130_stdcells/buf_2.sym} 101980 -35030 0 0 {name=X_41203_ }
C {devices/lab_pin.sym} 101900 -34930 0 0 {name=p100982 lab=_83300_/Q }
C {devices/lab_pin.sym} 101900 -34890 0 0 {name=p100983 lab=_72016_/X }
C {devices/lab_pin.sym} 101900 -34850 0 0 {name=p100984 lab=_72022_/Y }
C {devices/lab_pin.sym} 102060 -34890 0 1 {name=p100985 lab=_72023_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -34890 0 0 {name=X_72023_ }
C {devices/lab_pin.sym} 101900 -34770 0 0 {name=p100986 lab=_76901_/A }
C {devices/lab_pin.sym} 101900 -34730 0 0 {name=p100987 lab=_76893_/Y }
C {devices/lab_pin.sym} 101900 -34690 0 0 {name=p100988 lab=_76899_/Y }
C {devices/lab_pin.sym} 102060 -34730 0 1 {name=p100989 lab=_76904_/A }
C {sky130_stdcells/a21o_4.sym} 101980 -34730 0 0 {name=X_76900_ }
C {devices/lab_pin.sym} 101890 -34590 0 0 {name=p100990 lab=_84074_/CLK }
C {devices/lab_pin.sym} 101890 -34570 0 0 {name=p100991 lab=_68219_/X }
C {devices/lab_pin.sym} 102070 -34590 0 1 {name=p100992 lab=_82657_/D }
C {sky130_stdcells/dfxtp_4.sym} 101980 -34580 0 0 {name=X_84009_ }
C {devices/lab_pin.sym} 101940 -34450 0 0 {name=p100993 lab=clkbuf_9_510_0_CLK/A }
C {devices/lab_pin.sym} 102020 -34450 0 1 {name=p100994 lab=clkbuf_9_510_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 101980 -34450 0 0 {name=Xclkbuf_9_510_0_CLK }
C {devices/lab_pin.sym} 101940 -34330 0 0 {name=p100995 lab=_42137_/A }
C {devices/lab_pin.sym} 102020 -34330 0 1 {name=p100996 lab=_42183_/X }
C {sky130_stdcells/buf_2.sym} 101980 -34330 0 0 {name=X_42183_ }
C {devices/lab_pin.sym} 101920 -34220 0 0 {name=p100997 lab=_54184_/A }
C {devices/lab_pin.sym} 101920 -34180 0 0 {name=p100998 lab=_47352_/A }
C {devices/lab_pin.sym} 102040 -34200 0 1 {name=p100999 lab=_54169_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -34200 0 0 {name=X_54169_ }
C {devices/lab_pin.sym} 101920 -34080 0 0 {name=p101000 lab=_77880_/A }
C {devices/lab_pin.sym} 101920 -34040 0 0 {name=p101001 lab=_77880_/B }
C {devices/lab_pin.sym} 102040 -34060 0 1 {name=p101002 lab=_77880_/X }
C {sky130_stdcells/xor2_4.sym} 101980 -34060 0 0 {name=X_77880_ }
C {devices/lab_pin.sym} 101940 -33930 0 0 {name=p101003 lab=_41133_/Y }
C {devices/lab_pin.sym} 102020 -33930 0 1 {name=p101004 lab=_41134_/X }
C {sky130_stdcells/buf_2.sym} 101980 -33930 0 0 {name=X_41134_ }
C {devices/lab_pin.sym} 101940 -33810 0 0 {name=p101005 lab=clkbuf_9_202_0_CLK/X }
C {devices/lab_pin.sym} 102020 -33810 0 1 {name=p101006 lab=_85372_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 101980 -33810 0 0 {name=Xclkbuf_10_404_0_CLK }
C {devices/lab_pin.sym} 101940 -33690 0 0 {name=p101007 lab=_76831_/A }
C {devices/lab_pin.sym} 102020 -33690 0 1 {name=p101008 lab=_76831_/Y }
C {sky130_stdcells/inv_2.sym} 101980 -33690 0 0 {name=X_76831_ }
C {devices/lab_pin.sym} 101920 -33600 0 0 {name=p101009 lab=_46981_/A }
C {devices/lab_pin.sym} 101920 -33560 0 0 {name=p101010 lab=_47029_/B }
C {devices/lab_pin.sym} 101920 -33520 0 0 {name=p101011 lab=_46981_/C }
C {devices/lab_pin.sym} 101920 -33480 0 0 {name=p101012 lab=_52790_/D }
C {devices/lab_pin.sym} 102040 -33540 0 1 {name=p101013 lab=_46991_/X }
C {sky130_stdcells/and4_4.sym} 101980 -33540 0 0 {name=X_46991_ }
C {devices/lab_pin.sym} 101900 -33410 0 0 {name=p101014 lab=_58559_/X }
C {devices/lab_pin.sym} 101900 -33370 0 0 {name=p101015 lab=_83439_/Q }
C {devices/lab_pin.sym} 101900 -33330 0 0 {name=p101016 lab=_58976_/Y }
C {devices/lab_pin.sym} 102060 -33370 0 1 {name=p101017 lab=_58977_/X }
C {sky130_stdcells/o21a_4.sym} 101980 -33370 0 0 {name=X_58977_ }
C {devices/lab_pin.sym} 101940 -33230 0 0 {name=p101018 lab=_48781_/A }
C {devices/lab_pin.sym} 102020 -33230 0 1 {name=p101019 lab=_48730_/X }
C {sky130_stdcells/buf_2.sym} 101980 -33230 0 0 {name=X_48730_ }
C {devices/lab_pin.sym} 101920 -33120 0 0 {name=p101020 lab=_84204_/Q }
C {devices/lab_pin.sym} 101920 -33080 0 0 {name=p101021 lab=_83252_/Q }
C {devices/lab_pin.sym} 102040 -33100 0 1 {name=p101022 lab=_79550_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -33100 0 0 {name=X_79550_ }
C {devices/lab_pin.sym} 101940 -32970 0 0 {name=p101023 lab=_59539_/A }
C {devices/lab_pin.sym} 102020 -32970 0 1 {name=p101024 lab=_45943_/A }
C {sky130_stdcells/buf_2.sym} 101980 -32970 0 0 {name=X_45942_ }
C {devices/lab_pin.sym} 101900 -32870 0 0 {name=p101025 lab=_57926_/X }
C {devices/lab_pin.sym} 101900 -32830 0 0 {name=p101026 lab=_86003_/Q }
C {devices/lab_pin.sym} 101900 -32790 0 0 {name=p101027 lab=_57927_/X }
C {devices/lab_pin.sym} 102060 -32830 0 1 {name=p101028 lab=_57928_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -32830 0 0 {name=X_57928_ }
C {devices/lab_pin.sym} 101940 -32690 0 0 {name=p101029 lab=_40941_/A }
C {devices/lab_pin.sym} 102020 -32690 0 1 {name=p101030 lab=_41065_/X }
C {sky130_stdcells/buf_2.sym} 101980 -32690 0 0 {name=X_41065_ }
C {devices/lab_pin.sym} 101920 -32580 0 0 {name=p101031 lab=_76758_/Y }
C {devices/lab_pin.sym} 101920 -32540 0 0 {name=p101032 lab=_76761_/Y }
C {devices/lab_pin.sym} 102040 -32560 0 1 {name=p101033 lab=_76762_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -32560 0 0 {name=X_76762_ }
C {devices/lab_pin.sym} 101900 -32460 0 0 {name=p101034 lab=_73854_/X }
C {devices/lab_pin.sym} 101900 -32420 0 0 {name=p101035 lab=_85616_/Q }
C {devices/lab_pin.sym} 101900 -32380 0 0 {name=p101036 lab=_73903_/X }
C {devices/lab_pin.sym} 101900 -32340 0 0 {name=p101037 lab=_73973_/X }
C {devices/lab_pin.sym} 102060 -32400 0 1 {name=p101038 lab=_73974_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -32400 0 0 {name=X_73974_ }
C {devices/lab_pin.sym} 101940 -32250 0 0 {name=p101039 lab=_82800_/Q }
C {devices/lab_pin.sym} 102020 -32250 0 1 {name=p101040 lab=_78501_/Y }
C {sky130_stdcells/inv_2.sym} 101980 -32250 0 0 {name=X_78501_ }
C {devices/lab_pin.sym} 101940 -32130 0 0 {name=p101041 lab=_80914_/Q }
C {devices/lab_pin.sym} 102020 -32130 0 1 {name=p101042 lab=_75715_/A }
C {sky130_stdcells/inv_2.sym} 101980 -32130 0 0 {name=X_75713_ }
C {devices/lab_pin.sym} 101920 -32020 0 0 {name=p101043 lab=_48661_/A }
C {devices/lab_pin.sym} 101920 -31980 0 0 {name=p101044 lab=_48851_/B }
C {devices/lab_pin.sym} 102040 -32000 0 1 {name=p101045 lab=_48661_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -32000 0 0 {name=X_48661_ }
C {devices/lab_pin.sym} 101900 -31900 0 0 {name=p101046 lab=_43131_/Y }
C {devices/lab_pin.sym} 101900 -31860 0 0 {name=p101047 lab=_72830_/X }
C {devices/lab_pin.sym} 101900 -31820 0 0 {name=p101048 lab=_72799_/X }
C {devices/lab_pin.sym} 101900 -31780 0 0 {name=p101049 lab=_72924_/Y }
C {devices/lab_pin.sym} 102060 -31840 0 1 {name=p101050 lab=_72925_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -31840 0 0 {name=X_72925_ }
C {devices/lab_pin.sym} 101920 -31700 0 0 {name=p101051 lab=_79481_/A }
C {devices/lab_pin.sym} 101920 -31660 0 0 {name=p101052 lab=_79480_/Y }
C {devices/lab_pin.sym} 102040 -31680 0 1 {name=p101053 lab=_79481_/Y }
C {sky130_stdcells/nor2_4.sym} 101980 -31680 0 0 {name=X_79481_ }
C {devices/lab_pin.sym} 101900 -31570 0 0 {name=p101054 lab=_45869_/X }
C {devices/lab_pin.sym} 101900 -31530 0 0 {name=p101055 lab=_45872_/X }
C {devices/lab_pin.sym} 101900 -31490 0 0 {name=p101056 lab=_44898_/X }
C {devices/lab_pin.sym} 102060 -31530 0 1 {name=p101057 lab=_45873_/X }
C {sky130_stdcells/a21o_4.sym} 101980 -31530 0 0 {name=X_45873_ }
C {devices/lab_pin.sym} 101900 -31430 0 0 {name=p101058 lab=_57801_/X }
C {devices/lab_pin.sym} 101900 -31390 0 0 {name=p101059 lab=_57857_/Y }
C {devices/lab_pin.sym} 101900 -31350 0 0 {name=p101060 lab=_57858_/Y }
C {devices/lab_pin.sym} 101900 -31310 0 0 {name=p101061 lab=_57822_/X }
C {devices/lab_pin.sym} 101900 -31270 0 0 {name=p101062 lab=_57809_/X }
C {devices/lab_pin.sym} 102060 -31350 0 1 {name=p101063 lab=_57859_/X }
C {sky130_stdcells/o32a_4.sym} 101980 -31350 0 0 {name=X_57859_ }
C {devices/lab_pin.sym} 101900 -31210 0 0 {name=p101064 lab=_76688_/A }
C {devices/lab_pin.sym} 101900 -31170 0 0 {name=p101065 lab=_76687_/Y }
C {devices/lab_pin.sym} 101900 -31130 0 0 {name=p101066 lab=_76692_/Y }
C {devices/lab_pin.sym} 102060 -31170 0 1 {name=p101067 lab=_76694_/B }
C {sky130_stdcells/o21ai_4.sym} 101980 -31170 0 0 {name=X_76693_ }
C {devices/lab_pin.sym} 101940 -31030 0 0 {name=p101068 lab=clkbuf_9_209_0_CLK/X }
C {devices/lab_pin.sym} 102020 -31030 0 1 {name=p101069 lab=_82463_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 101980 -31030 0 0 {name=Xclkbuf_10_419_0_CLK }
C {devices/lab_pin.sym} 101900 -30930 0 0 {name=p101070 lab=_86616_/Q }
C {devices/lab_pin.sym} 101900 -30890 0 0 {name=p101071 lab=_47570_/X }
C {devices/lab_pin.sym} 101900 -30850 0 0 {name=p101072 lab=_47611_/Y }
C {devices/lab_pin.sym} 102060 -30890 0 1 {name=p101073 lab=_47612_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -30890 0 0 {name=X_47612_ }
C {devices/lab_pin.sym} 101920 -30760 0 0 {name=p101074 lab=_78432_/A }
C {devices/lab_pin.sym} 101920 -30720 0 0 {name=p101075 lab=_82667_/D }
C {devices/lab_pin.sym} 102040 -30740 0 1 {name=p101076 lab=_78434_/A }
C {sky130_stdcells/xor2_4.sym} 101980 -30740 0 0 {name=X_78432_ }
C {devices/lab_pin.sym} 101900 -30650 0 0 {name=p101077 lab=_44807_/X }
C {devices/lab_pin.sym} 101900 -30610 0 0 {name=p101078 lab=_44821_/X }
C {devices/lab_pin.sym} 101900 -30570 0 0 {name=p101079 lab=_41675_/X }
C {devices/lab_pin.sym} 101900 -30530 0 0 {name=p101080 lab=_67536_/B }
C {devices/lab_pin.sym} 101900 -30490 0 0 {name=p101081 lab=_44808_/X }
C {devices/lab_pin.sym} 102060 -30570 0 1 {name=p101082 lab=_44825_/A }
C {sky130_stdcells/o32ai_4.sym} 101980 -30570 0 0 {name=X_44824_ }
C {devices/lab_pin.sym} 101900 -30430 0 0 {name=p101083 lab=_75642_/X }
C {devices/lab_pin.sym} 101900 -30390 0 0 {name=p101084 lab=_75631_/X }
C {devices/lab_pin.sym} 101900 -30350 0 0 {name=p101085 lab=_75643_/X }
C {devices/lab_pin.sym} 102060 -30390 0 1 {name=p101086 lab=_75644_/X }
C {sky130_stdcells/a21o_4.sym} 101980 -30390 0 0 {name=X_75644_ }
C {devices/lab_pin.sym} 101940 -30250 0 0 {name=p101087 lab=_83572_/Q }
C {devices/lab_pin.sym} 102020 -30250 0 1 {name=p101088 lab=_48593_/A }
C {sky130_stdcells/inv_2.sym} 101980 -30250 0 0 {name=X_48592_ }
C {devices/lab_pin.sym} 101940 -30130 0 0 {name=p101089 lab=_64191_/B }
C {devices/lab_pin.sym} 102020 -30130 0 1 {name=p101090 lab=_60870_/X }
C {sky130_stdcells/buf_2.sym} 101980 -30130 0 0 {name=X_60870_ }
C {devices/lab_pin.sym} 101900 -30040 0 0 {name=p101091 lab=_69619_/B }
C {devices/lab_pin.sym} 101900 -30000 0 0 {name=p101092 lab=_72853_/X }
C {devices/lab_pin.sym} 101900 -29960 0 0 {name=p101093 lab=_45897_/X }
C {devices/lab_pin.sym} 101900 -29920 0 0 {name=p101094 lab=_72855_/Y }
C {devices/lab_pin.sym} 102060 -29980 0 1 {name=p101095 lab=_72856_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -29980 0 0 {name=X_72856_ }
C {devices/lab_pin.sym} 101940 -29830 0 0 {name=p101096 lab=_83711_/Q }
C {devices/lab_pin.sym} 102020 -29830 0 1 {name=p101097 lab=_47543_/Y }
C {sky130_stdcells/inv_2.sym} 101980 -29830 0 0 {name=X_47543_ }
C {devices/lab_pin.sym} 101900 -29730 0 0 {name=p101098 lab=_71805_/X }
C {devices/lab_pin.sym} 101900 -29690 0 0 {name=p101099 lab=_83369_/Q }
C {devices/lab_pin.sym} 101900 -29650 0 0 {name=p101100 lab=_71806_/X }
C {devices/lab_pin.sym} 102060 -29690 0 1 {name=p101101 lab=_83369_/D }
C {sky130_stdcells/a21o_4.sym} 101980 -29690 0 0 {name=X_71807_ }
C {devices/lab_pin.sym} 101920 -29580 0 0 {name=p101102 lab=_59521_/A }
C {devices/lab_pin.sym} 101920 -29540 0 0 {name=p101103 lab=_59876_/B }
C {devices/lab_pin.sym} 101920 -29500 0 0 {name=p101104 lab=_43995_/A }
C {devices/lab_pin.sym} 101920 -29460 0 0 {name=p101105 lab=_59609_/D }
C {devices/lab_pin.sym} 102040 -29520 0 1 {name=p101106 lab=_59529_/X }
C {sky130_stdcells/and4_4.sym} 101980 -29520 0 0 {name=X_59529_ }
C {devices/lab_pin.sym} 101900 -29390 0 0 {name=p101107 lab=_78359_/X }
C {devices/lab_pin.sym} 101900 -29350 0 0 {name=p101108 lab=_78364_/C }
C {devices/lab_pin.sym} 101900 -29310 0 0 {name=p101109 lab=_78362_/Y }
C {devices/lab_pin.sym} 102060 -29350 0 1 {name=p101110 lab=_78363_/Y }
C {sky130_stdcells/a21oi_4.sym} 101980 -29350 0 0 {name=X_78363_ }
C {devices/lab_pin.sym} 101940 -29210 0 0 {name=p101111 lab=_44650_/A }
C {devices/lab_pin.sym} 102020 -29210 0 1 {name=p101112 lab=_44755_/X }
C {sky130_stdcells/buf_2.sym} 101980 -29210 0 0 {name=X_44755_ }
C {devices/lab_pin.sym} 101920 -29100 0 0 {name=p101113 lab=_75575_/A }
C {devices/lab_pin.sym} 101920 -29060 0 0 {name=p101114 lab=_80818_/Q }
C {devices/lab_pin.sym} 102040 -29080 0 1 {name=p101115 lab=_75575_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -29080 0 0 {name=X_75575_ }
C {devices/lab_pin.sym} 101940 -28950 0 0 {name=p101116 lab=_41967_/A }
C {devices/lab_pin.sym} 102020 -28950 0 1 {name=p101117 lab=_41967_/X }
C {sky130_stdcells/buf_2.sym} 101980 -28950 0 0 {name=X_41967_ }
C {devices/lab_pin.sym} 101900 -28860 0 0 {name=p101118 lab=_72755_/X }
C {devices/lab_pin.sym} 101900 -28820 0 0 {name=p101119 lab=_83080_/Q }
C {devices/lab_pin.sym} 101900 -28780 0 0 {name=p101120 lab=_72785_/X }
C {devices/lab_pin.sym} 101900 -28740 0 0 {name=p101121 lab=_72786_/X }
C {devices/lab_pin.sym} 102060 -28800 0 1 {name=p101122 lab=_72788_/B }
C {sky130_stdcells/a211o_4.sym} 101980 -28800 0 0 {name=X_72787_ }
C {devices/lab_pin.sym} 101900 -28670 0 0 {name=p101123 lab=_77315_/A }
C {devices/lab_pin.sym} 101900 -28630 0 0 {name=p101124 lab=_77315_/B }
C {devices/lab_pin.sym} 101900 -28590 0 0 {name=p101125 lab=_77315_/C }
C {devices/lab_pin.sym} 102060 -28630 0 1 {name=p101126 lab=_77316_/A }
C {sky130_stdcells/a21o_4.sym} 101980 -28630 0 0 {name=X_77314_ }
C {devices/lab_pin.sym} 101940 -28490 0 0 {name=p101127 lab=_87301_/Q }
C {devices/lab_pin.sym} 102020 -28490 0 1 {name=p101128 lab=_69752_/B }
C {sky130_stdcells/inv_2.sym} 101980 -28490 0 0 {name=X_43706_ }
C {devices/lab_pin.sym} 101940 -28370 0 0 {name=p101129 lab=_62395_/X }
C {devices/lab_pin.sym} 102020 -28370 0 1 {name=p101130 lab=_62540_/X }
C {sky130_stdcells/buf_2.sym} 101980 -28370 0 0 {name=X_62540_ }
C {devices/lab_pin.sym} 101900 -28270 0 0 {name=p101131 lab=_52807_/B }
C {devices/lab_pin.sym} 101900 -28230 0 0 {name=p101132 lab=_74517_/X }
C {devices/lab_pin.sym} 101900 -28190 0 0 {name=p101133 lab=_74525_/Y }
C {devices/lab_pin.sym} 102060 -28230 0 1 {name=p101134 lab=_74526_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -28230 0 0 {name=X_74526_ }
C {devices/lab_pin.sym} 101940 -28090 0 0 {name=p101135 lab=_40918_/A }
C {devices/lab_pin.sym} 102020 -28090 0 1 {name=p101136 lab=_88311_/D }
C {sky130_stdcells/inv_2.sym} 101980 -28090 0 0 {name=X_40918_ }
C {devices/lab_pin.sym} 101940 -27970 0 0 {name=p101137 lab=_47474_/A }
C {devices/lab_pin.sym} 102020 -27970 0 1 {name=p101138 lab=_53070_/D }
C {sky130_stdcells/buf_2.sym} 101980 -27970 0 0 {name=X_47474_ }
C {devices/lab_pin.sym} 101940 -27850 0 0 {name=p101139 lab=_71735_/D }
C {devices/lab_pin.sym} 102020 -27850 0 1 {name=p101140 lab=_71738_/X }
C {sky130_stdcells/buf_2.sym} 101980 -27850 0 0 {name=X_71738_ }
C {devices/lab_pin.sym} 101920 -27740 0 0 {name=p101141 lab=_78301_/A }
C {devices/lab_pin.sym} 101920 -27700 0 0 {name=p101142 lab=_82472_/Q }
C {devices/lab_pin.sym} 102040 -27720 0 1 {name=p101143 lab=_78298_/A }
C {sky130_stdcells/xor2_4.sym} 101980 -27720 0 0 {name=X_78294_ }
C {devices/lab_pin.sym} 101940 -27590 0 0 {name=p101144 lab=_44529_/A }
C {devices/lab_pin.sym} 102020 -27590 0 1 {name=p101145 lab=_44686_/X }
C {sky130_stdcells/buf_2.sym} 101980 -27590 0 0 {name=X_44686_ }
C {devices/lab_pin.sym} 101940 -27470 0 0 {name=p101146 lab=_41897_/Y }
C {devices/lab_pin.sym} 102020 -27470 0 1 {name=p101147 lab=_88110_/D }
C {sky130_stdcells/inv_2.sym} 101980 -27470 0 0 {name=X_41898_ }
C {devices/lab_pin.sym} 101900 -27370 0 0 {name=p101148 lab=_86432_/Q }
C {devices/lab_pin.sym} 101900 -27330 0 0 {name=p101149 lab=_48548_/X }
C {devices/lab_pin.sym} 101900 -27290 0 0 {name=p101150 lab=_49212_/Y }
C {devices/lab_pin.sym} 102060 -27330 0 1 {name=p101151 lab=_49213_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -27330 0 0 {name=X_49213_ }
C {devices/lab_pin.sym} 101920 -27200 0 0 {name=p101152 lab=_47991_/B }
C {devices/lab_pin.sym} 101920 -27160 0 0 {name=p101153 lab=_46469_/B }
C {devices/lab_pin.sym} 102040 -27180 0 1 {name=p101154 lab=_46425_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -27180 0 0 {name=X_46425_ }
C {devices/lab_pin.sym} 101940 -27050 0 0 {name=p101155 lab=clkbuf_8_93_0_CLK/A }
C {devices/lab_pin.sym} 102020 -27050 0 1 {name=p101156 lab=clkbuf_8_93_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 101980 -27050 0 0 {name=Xclkbuf_8_93_0_CLK }
C {devices/lab_pin.sym} 101920 -26950 0 0 {name=p101157 lab=_77245_/A }
C {devices/lab_pin.sym} 101920 -26910 0 0 {name=p101158 lab=_77243_/X }
C {devices/lab_pin.sym} 101920 -26870 0 0 {name=p101159 lab=_77245_/C }
C {devices/lab_pin.sym} 102040 -26910 0 1 {name=p101160 lab=_77261_/A }
C {sky130_stdcells/nand3_4.sym} 101980 -26910 0 0 {name=X_77245_ }
C {devices/lab_pin.sym} 101900 -26800 0 0 {name=p101161 lab=_40667_/A }
C {devices/lab_pin.sym} 101900 -26760 0 0 {name=p101162 lab=_43634_/X }
C {devices/lab_pin.sym} 101900 -26720 0 0 {name=p101163 lab=_68732_/B }
C {devices/lab_pin.sym} 101900 -26680 0 0 {name=p101164 lab=_43636_/X }
C {devices/lab_pin.sym} 102060 -26740 0 1 {name=p101165 lab=_43637_/X }
C {sky130_stdcells/a2bb2o_4.sym} 101980 -26740 0 0 {name=X_43637_ }
C {devices/lab_pin.sym} 101940 -26590 0 0 {name=p101166 lab=_62471_/A }
C {devices/lab_pin.sym} 102020 -26590 0 1 {name=p101167 lab=_62566_/D }
C {sky130_stdcells/buf_2.sym} 101980 -26590 0 0 {name=X_62471_ }
C {devices/lab_pin.sym} 101900 -26490 0 0 {name=p101168 lab=_83062_/Q }
C {devices/lab_pin.sym} 101900 -26450 0 0 {name=p101169 lab=_74441_/X }
C {devices/lab_pin.sym} 101900 -26410 0 0 {name=p101170 lab=_74456_/Y }
C {devices/lab_pin.sym} 102060 -26450 0 1 {name=p101171 lab=_74457_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -26450 0 0 {name=X_74457_ }
C {devices/lab_pin.sym} 101940 -26310 0 0 {name=p101172 lab=_40848_/X }
C {devices/lab_pin.sym} 102020 -26310 0 1 {name=p101173 lab=_40849_/X }
C {sky130_stdcells/buf_2.sym} 101980 -26310 0 0 {name=X_40849_ }
C {devices/lab_pin.sym} 101940 -26190 0 0 {name=p101174 lab=_71669_/A }
C {devices/lab_pin.sym} 102020 -26190 0 1 {name=p101175 lab=_71669_/X }
C {sky130_stdcells/buf_2.sym} 101980 -26190 0 0 {name=X_71669_ }
C {devices/lab_pin.sym} 101920 -26100 0 0 {name=p101176 lab=_64210_/A }
C {devices/lab_pin.sym} 101920 -26060 0 0 {name=p101177 lab=_64457_/C }
C {devices/lab_pin.sym} 101920 -26020 0 0 {name=p101178 lab=_64208_/Y }
C {devices/lab_pin.sym} 101920 -25980 0 0 {name=p101179 lab=_64209_/Y }
C {devices/lab_pin.sym} 102040 -26040 0 1 {name=p101180 lab=_64210_/Y }
C {sky130_stdcells/nand4_4.sym} 101980 -26040 0 0 {name=X_64210_ }
C {devices/lab_pin.sym} 101920 -25920 0 0 {name=p101181 lab=_64292_/A }
C {devices/lab_pin.sym} 101920 -25880 0 0 {name=p101182 lab=_61452_/B }
C {devices/lab_pin.sym} 101920 -25840 0 0 {name=p101183 lab=_61452_/C }
C {devices/lab_pin.sym} 101920 -25800 0 0 {name=p101184 lab=_61391_/D }
C {devices/lab_pin.sym} 102040 -25860 0 1 {name=p101185 lab=_61422_/Y }
C {sky130_stdcells/nand4_4.sym} 101980 -25860 0 0 {name=X_61422_ }
C {devices/lab_pin.sym} 101940 -25710 0 0 {name=p101186 lab=_49144_/A }
C {devices/lab_pin.sym} 102020 -25710 0 1 {name=p101187 lab=_49144_/X }
C {sky130_stdcells/buf_2.sym} 101980 -25710 0 0 {name=X_49144_ }
C {devices/lab_pin.sym} 101900 -25620 0 0 {name=p101188 lab=_73359_/X }
C {devices/lab_pin.sym} 101900 -25580 0 0 {name=p101189 lab=_83056_/Q }
C {devices/lab_pin.sym} 101900 -25540 0 0 {name=p101190 lab=_73406_/X }
C {devices/lab_pin.sym} 101900 -25500 0 0 {name=p101191 lab=_73407_/X }
C {devices/lab_pin.sym} 102060 -25560 0 1 {name=p101192 lab=_73408_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -25560 0 0 {name=X_73408_ }
C {devices/lab_pin.sym} 101940 -25410 0 0 {name=p101193 lab=_53985_/B }
C {devices/lab_pin.sym} 102020 -25410 0 1 {name=p101194 lab=_46356_/X }
C {sky130_stdcells/buf_2.sym} 101980 -25410 0 0 {name=X_46356_ }
C {devices/lab_pin.sym} 101920 -25300 0 0 {name=p101195 lab=_65753_/A }
C {devices/lab_pin.sym} 101920 -25260 0 0 {name=p101196 lab=_86443_/Q }
C {devices/lab_pin.sym} 102040 -25280 0 1 {name=p101197 lab=_65190_/X }
C {sky130_stdcells/and2_4.sym} 101980 -25280 0 0 {name=X_65190_ }
C {devices/lab_pin.sym} 101900 -25170 0 0 {name=p101198 lab=_77159_/Y }
C {devices/lab_pin.sym} 101900 -25130 0 0 {name=p101199 lab=_77173_/X }
C {devices/lab_pin.sym} 101900 -25090 0 0 {name=p101200 lab=_77175_/Y }
C {devices/lab_pin.sym} 102060 -25130 0 1 {name=p101201 lab=_77177_/B }
C {sky130_stdcells/a21oi_4.sym} 101980 -25130 0 0 {name=X_77176_ }
C {devices/lab_pin.sym} 101940 -24990 0 0 {name=p101202 lab=_43568_/A }
C {devices/lab_pin.sym} 102020 -24990 0 1 {name=p101203 lab=_43568_/Y }
C {sky130_stdcells/inv_2.sym} 101980 -24990 0 0 {name=X_43568_ }
C {devices/lab_pin.sym} 101940 -24870 0 0 {name=p101204 lab=_72052_/A }
C {devices/lab_pin.sym} 102020 -24870 0 1 {name=p101205 lab=_74466_/A }
C {sky130_stdcells/buf_2.sym} 101980 -24870 0 0 {name=X_74388_ }
C {devices/lab_pin.sym} 101900 -24770 0 0 {name=p101206 lab=_45304_/X }
C {devices/lab_pin.sym} 101900 -24730 0 0 {name=p101207 lab=_45306_/Y }
C {devices/lab_pin.sym} 101900 -24690 0 0 {name=p101208 lab=_45275_/X }
C {devices/lab_pin.sym} 102060 -24730 0 1 {name=p101209 lab=_45307_/Y }
C {sky130_stdcells/a21oi_4.sym} 101980 -24730 0 0 {name=X_45307_ }
C {devices/lab_pin.sym} 101900 -24610 0 0 {name=p101210 lab=_64137_/Y }
C {devices/lab_pin.sym} 101900 -24570 0 0 {name=p101211 lab=_64129_/X }
C {devices/lab_pin.sym} 101900 -24530 0 0 {name=p101212 lab=_64140_/Y }
C {devices/lab_pin.sym} 102060 -24570 0 1 {name=p101213 lab=_64141_/Y }
C {sky130_stdcells/a21oi_4.sym} 101980 -24570 0 0 {name=X_64141_ }
C {devices/lab_pin.sym} 101920 -24450 0 0 {name=p101214 lab=_76125_/X }
C {devices/lab_pin.sym} 101920 -24410 0 0 {name=p101215 lab=_76127_/B }
C {devices/lab_pin.sym} 101920 -24370 0 0 {name=p101216 lab=_76126_/Y }
C {devices/lab_pin.sym} 102040 -24410 0 1 {name=p101217 lab=_76127_/X }
C {sky130_stdcells/and3_4.sym} 101980 -24410 0 0 {name=X_76127_ }
C {devices/lab_pin.sym} 101940 -24270 0 0 {name=p101218 lab=_42556_/A }
C {devices/lab_pin.sym} 102020 -24270 0 1 {name=p101219 lab=_42519_/X }
C {sky130_stdcells/buf_2.sym} 101980 -24270 0 0 {name=X_42519_ }
C {devices/lab_pin.sym} 101900 -24170 0 0 {name=p101220 lab=_65100_/B }
C {devices/lab_pin.sym} 101900 -24130 0 0 {name=p101221 lab=_49052_/X }
C {devices/lab_pin.sym} 101900 -24090 0 0 {name=p101222 lab=_49074_/Y }
C {devices/lab_pin.sym} 102060 -24130 0 1 {name=p101223 lab=_49075_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -24130 0 0 {name=X_49075_ }
C {devices/lab_pin.sym} 101900 -24010 0 0 {name=p101224 lab=_61346_/X }
C {devices/lab_pin.sym} 101900 -23970 0 0 {name=p101225 lab=_61349_/X }
C {devices/lab_pin.sym} 101900 -23930 0 0 {name=p101226 lab=_61352_/Y }
C {devices/lab_pin.sym} 102060 -23970 0 1 {name=p101227 lab=_84488_/D }
C {sky130_stdcells/a21oi_4.sym} 101980 -23970 0 0 {name=X_61353_ }
C {devices/lab_pin.sym} 101920 -23840 0 0 {name=p101228 lab=_73339_/A }
C {devices/lab_pin.sym} 101920 -23800 0 0 {name=p101229 lab=_73339_/B }
C {devices/lab_pin.sym} 102040 -23820 0 1 {name=p101230 lab=_73339_/Y }
C {sky130_stdcells/nor2_4.sym} 101980 -23820 0 0 {name=X_73339_ }
C {devices/lab_pin.sym} 101940 -23690 0 0 {name=p101231 lab=_51251_/B }
C {devices/lab_pin.sym} 102020 -23690 0 1 {name=p101232 lab=_53959_/B }
C {sky130_stdcells/buf_2.sym} 101980 -23690 0 0 {name=X_46287_ }
C {devices/lab_pin.sym} 101940 -23570 0 0 {name=p101233 lab=_43466_/X }
C {devices/lab_pin.sym} 102020 -23570 0 1 {name=p101234 lab=_43499_/X }
C {sky130_stdcells/buf_2.sym} 101980 -23570 0 0 {name=X_43499_ }
C {devices/lab_pin.sym} 101920 -23460 0 0 {name=p101235 lab=_82351_/Q }
C {devices/lab_pin.sym} 101920 -23420 0 0 {name=p101236 lab=_47973_/B }
C {devices/lab_pin.sym} 102040 -23440 0 1 {name=p101237 lab=_48026_/X }
C {sky130_stdcells/or2_4.sym} 101980 -23440 0 0 {name=X_48026_ }
C {devices/lab_pin.sym} 101940 -23310 0 0 {name=p101238 lab=_60304_/A }
C {devices/lab_pin.sym} 102020 -23310 0 1 {name=p101239 lab=_60337_/C }
C {sky130_stdcells/buf_2.sym} 101980 -23310 0 0 {name=X_60304_ }
C {devices/lab_pin.sym} 101900 -23210 0 0 {name=p101240 lab=_55783_/B }
C {devices/lab_pin.sym} 101900 -23170 0 0 {name=p101241 lab=_45206_/X }
C {devices/lab_pin.sym} 101900 -23130 0 0 {name=p101242 lab=_45237_/X }
C {devices/lab_pin.sym} 102060 -23170 0 1 {name=p101243 lab=_45238_/X }
C {sky130_stdcells/o21a_4.sym} 101980 -23170 0 0 {name=X_45238_ }
C {devices/lab_pin.sym} 101900 -23070 0 0 {name=p101244 lab=_64064_/X }
C {devices/lab_pin.sym} 101900 -23030 0 0 {name=p101245 lab=_64048_/X }
C {devices/lab_pin.sym} 101900 -22990 0 0 {name=p101246 lab=_64066_/Y }
C {devices/lab_pin.sym} 101900 -22950 0 0 {name=p101247 lab=_64069_/Y }
C {devices/lab_pin.sym} 101900 -22920 0 0 {name=p101248 lab=_64071_/X }
C {devices/lab_pin.sym} 102060 -22990 0 1 {name=p101249 lab=_64072_/X }
C {sky130_stdcells/a41o_4.sym} 101980 -22990 0 0 {name=X_64072_ }
C {devices/lab_pin.sym} 101920 -22840 0 0 {name=p101250 lab=_81716_/D }
C {devices/lab_pin.sym} 101920 -22800 0 0 {name=p101251 lab=_76058_/B }
C {devices/lab_pin.sym} 102040 -22820 0 1 {name=p101252 lab=_76058_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -22820 0 0 {name=X_76058_ }
C {devices/lab_pin.sym} 101920 -22700 0 0 {name=p101253 lab=_61283_/Y }
C {devices/lab_pin.sym} 101920 -22660 0 0 {name=p101254 lab=_60596_/A }
C {devices/lab_pin.sym} 102040 -22680 0 1 {name=p101255 lab=_61284_/Y }
C {sky130_stdcells/nor2_4.sym} 101980 -22680 0 0 {name=X_61284_ }
C {devices/lab_pin.sym} 101900 -22570 0 0 {name=p101256 lab=_81482_/D }
C {devices/lab_pin.sym} 101900 -22530 0 0 {name=p101257 lab=_67806_/X }
C {devices/lab_pin.sym} 101900 -22490 0 0 {name=p101258 lab=_67899_/X }
C {devices/lab_pin.sym} 102060 -22530 0 1 {name=p101259 lab=_84050_/D }
C {sky130_stdcells/a21bo_4.sym} 101980 -22530 0 0 {name=X_67900_ }
C {devices/lab_pin.sym} 101900 -22410 0 0 {name=p101260 lab=_63021_/Y }
C {devices/lab_pin.sym} 101900 -22370 0 0 {name=p101261 lab=_63022_/X }
C {devices/lab_pin.sym} 101900 -22330 0 0 {name=p101262 lab=_61194_/X }
C {devices/lab_pin.sym} 102060 -22370 0 1 {name=p101263 lab=_63023_/Y }
C {sky130_stdcells/a21oi_4.sym} 101980 -22370 0 0 {name=X_63023_ }
C {devices/lab_pin.sym} 101920 -22240 0 0 {name=p101264 lab=_75008_/A }
C {devices/lab_pin.sym} 101920 -22200 0 0 {name=p101265 lab=_75008_/B }
C {devices/lab_pin.sym} 102040 -22220 0 1 {name=p101266 lab=_75021_/B }
C {sky130_stdcells/nand2_4.sym} 101980 -22220 0 0 {name=X_75009_ }
C {devices/lab_pin.sym} 101940 -22090 0 0 {name=p101267 lab=_60235_/A }
C {devices/lab_pin.sym} 102020 -22090 0 1 {name=p101268 lab=_60259_/B }
C {sky130_stdcells/inv_2.sym} 101980 -22090 0 0 {name=X_60235_ }
C {devices/lab_pin.sym} 101920 -21980 0 0 {name=p101269 lab=_45169_/A }
C {devices/lab_pin.sym} 101920 -21940 0 0 {name=p101270 lab=_45182_/B }
C {devices/lab_pin.sym} 102040 -21960 0 1 {name=p101271 lab=_45169_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -21960 0 0 {name=X_45169_ }
C {devices/lab_pin.sym} 101900 -21860 0 0 {name=p101272 lab=_68666_/X }
C {devices/lab_pin.sym} 101900 -21820 0 0 {name=p101273 lab=_68612_/X }
C {devices/lab_pin.sym} 101900 -21780 0 0 {name=p101274 lab=_68867_/Y }
C {devices/lab_pin.sym} 101900 -21740 0 0 {name=p101275 lab=_68879_/Y }
C {devices/lab_pin.sym} 102060 -21800 0 1 {name=p101276 lab=_68880_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -21800 0 0 {name=X_68880_ }
C {devices/lab_pin.sym} 101940 -21650 0 0 {name=p101277 lab=_67354_/X }
C {devices/lab_pin.sym} 102020 -21650 0 1 {name=p101278 lab=_67831_/X }
C {sky130_stdcells/buf_2.sym} 101980 -21650 0 0 {name=X_67831_ }
C {devices/lab_pin.sym} 101920 -21540 0 0 {name=p101279 lab=_79817_/A }
C {devices/lab_pin.sym} 101920 -21500 0 0 {name=p101280 lab=_79817_/B }
C {devices/lab_pin.sym} 102040 -21520 0 1 {name=p101281 lab=_79817_/X }
C {sky130_stdcells/xor2_4.sym} 101980 -21520 0 0 {name=X_79817_ }
C {devices/lab_pin.sym} 101940 -21390 0 0 {name=p101282 lab=clkbuf_8_31_0_CLK/A }
C {devices/lab_pin.sym} 102020 -21390 0 1 {name=p101283 lab=clkbuf_9_63_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 101980 -21390 0 0 {name=Xclkbuf_8_31_0_CLK }
C {devices/lab_pin.sym} 101940 -21270 0 0 {name=p101284 lab=_60165_/X }
C {devices/lab_pin.sym} 102020 -21270 0 1 {name=p101285 lab=_60166_/X }
C {sky130_stdcells/buf_2.sym} 101980 -21270 0 0 {name=X_60166_ }
C {devices/lab_pin.sym} 101940 -21150 0 0 {name=p101286 lab=_40595_/X }
C {devices/lab_pin.sym} 102020 -21150 0 1 {name=p101287 lab=_49977_/X }
C {sky130_stdcells/buf_2.sym} 101980 -21150 0 0 {name=X_49977_ }
C {devices/lab_pin.sym} 101920 -21050 0 0 {name=p101288 lab=_48928_/A }
C {devices/lab_pin.sym} 101920 -21010 0 0 {name=p101289 lab=_48894_/B }
C {devices/lab_pin.sym} 101920 -20970 0 0 {name=p101290 lab=_48928_/C }
C {devices/lab_pin.sym} 102040 -21010 0 1 {name=p101291 lab=_48928_/X }
C {sky130_stdcells/and3_4.sym} 101980 -21010 0 0 {name=X_48928_ }
C {devices/lab_pin.sym} 101920 -20880 0 0 {name=p101292 lab=_67690_/X }
C {devices/lab_pin.sym} 101920 -20840 0 0 {name=p101293 lab=_87713_/Q }
C {devices/lab_pin.sym} 102040 -20860 0 1 {name=p101294 lab=_67762_/X }
C {sky130_stdcells/and2_4.sym} 101980 -20860 0 0 {name=X_67762_ }
C {devices/lab_pin.sym} 101920 -20740 0 0 {name=p101295 lab=_79734_/Y }
C {devices/lab_pin.sym} 101920 -20700 0 0 {name=p101296 lab=_79731_/Y }
C {devices/lab_pin.sym} 102040 -20720 0 1 {name=p101297 lab=_79748_/X }
C {sky130_stdcells/and2_4.sym} 101980 -20720 0 0 {name=X_79748_ }
C {devices/lab_pin.sym} 101920 -20600 0 0 {name=p101298 lab=_65074_/A }
C {devices/lab_pin.sym} 101920 -20560 0 0 {name=p101299 lab=_64974_/B }
C {devices/lab_pin.sym} 102040 -20580 0 1 {name=p101300 lab=_64974_/X }
C {sky130_stdcells/and2_4.sym} 101980 -20580 0 0 {name=X_64974_ }
C {devices/lab_pin.sym} 101920 -20470 0 0 {name=p101301 lab=_60081_/A }
C {devices/lab_pin.sym} 101920 -20430 0 0 {name=p101302 lab=_60103_/B }
C {devices/lab_pin.sym} 101920 -20390 0 0 {name=p101303 lab=_60097_/C }
C {devices/lab_pin.sym} 102040 -20430 0 1 {name=p101304 lab=_60097_/Y }
C {sky130_stdcells/nor3_4.sym} 101980 -20430 0 0 {name=X_60097_ }
C {devices/lab_pin.sym} 101900 -20310 0 0 {name=p101305 lab=_69013_/X }
C {devices/lab_pin.sym} 101900 -20270 0 0 {name=p101306 lab=_69016_/X }
C {devices/lab_pin.sym} 101900 -20230 0 0 {name=p101307 lab=_69500_/X }
C {devices/lab_pin.sym} 102060 -20270 0 1 {name=p101308 lab=_69501_/Y }
C {sky130_stdcells/a21oi_4.sym} 101980 -20270 0 0 {name=X_69501_ }
C {devices/lab_pin.sym} 101900 -20160 0 0 {name=p101309 lab=_87437_/Q }
C {devices/lab_pin.sym} 101900 -20120 0 0 {name=p101310 lab=_66642_/X }
C {devices/lab_pin.sym} 101900 -20080 0 0 {name=p101311 lab=_66643_/X }
C {devices/lab_pin.sym} 101900 -20040 0 0 {name=p101312 lab=_66712_/X }
C {devices/lab_pin.sym} 102060 -20100 0 1 {name=p101313 lab=_66713_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -20100 0 0 {name=X_66713_ }
C {devices/lab_pin.sym} 101940 -19950 0 0 {name=p101314 lab=_64184_/C }
C {devices/lab_pin.sym} 102020 -19950 0 1 {name=p101315 lab=_63958_/C }
C {sky130_stdcells/buf_2.sym} 101980 -19950 0 0 {name=X_63925_ }
C {devices/lab_pin.sym} 101920 -19850 0 0 {name=p101316 lab=_48680_/A }
C {devices/lab_pin.sym} 101920 -19810 0 0 {name=p101317 lab=_48859_/B }
C {devices/lab_pin.sym} 101920 -19770 0 0 {name=p101318 lab=_48854_/C }
C {devices/lab_pin.sym} 102040 -19810 0 1 {name=p101319 lab=_48859_/X }
C {sky130_stdcells/and3_4.sym} 101980 -19810 0 0 {name=X_48859_ }
C {devices/lab_pin.sym} 101920 -19680 0 0 {name=p101320 lab=_67615_/X }
C {devices/lab_pin.sym} 101920 -19640 0 0 {name=p101321 lab=_67693_/B }
C {devices/lab_pin.sym} 102040 -19660 0 1 {name=p101322 lab=_67693_/X }
C {sky130_stdcells/and2_4.sym} 101980 -19660 0 0 {name=X_67693_ }
C {devices/lab_pin.sym} 101920 -19540 0 0 {name=p101323 lab=_84214_/Q }
C {devices/lab_pin.sym} 101920 -19500 0 0 {name=p101324 lab=_83262_/Q }
C {devices/lab_pin.sym} 102040 -19520 0 1 {name=p101325 lab=_79679_/X }
C {sky130_stdcells/xor2_4.sym} 101980 -19520 0 0 {name=X_79679_ }
C {devices/lab_pin.sym} 101890 -19390 0 0 {name=p101326 lab=_88121_/CLK }
C {devices/lab_pin.sym} 101890 -19370 0 0 {name=p101327 lab=_81710_/D }
C {devices/lab_pin.sym} 102070 -19390 0 1 {name=p101328 lab=_41043_/B }
C {sky130_stdcells/dfxtp_4.sym} 101980 -19380 0 0 {name=X_81710_ }
C {devices/lab_pin.sym} 101940 -19250 0 0 {name=p101329 lab=clkbuf_8_47_0_CLK/A }
C {devices/lab_pin.sym} 102020 -19250 0 1 {name=p101330 lab=clkbuf_9_93_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 101980 -19250 0 0 {name=Xclkbuf_8_46_0_CLK }
C {devices/lab_pin.sym} 101900 -19160 0 0 {name=p101331 lab=_87018_/Q }
C {devices/lab_pin.sym} 101900 -19120 0 0 {name=p101332 lab=_69414_/X }
C {devices/lab_pin.sym} 101900 -19080 0 0 {name=p101333 lab=_69430_/X }
C {devices/lab_pin.sym} 101900 -19040 0 0 {name=p101334 lab=_69431_/X }
C {devices/lab_pin.sym} 102060 -19100 0 1 {name=p101335 lab=_69432_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -19100 0 0 {name=X_69432_ }
C {devices/lab_pin.sym} 101920 -18960 0 0 {name=p101336 lab=_68999_/A }
C {devices/lab_pin.sym} 101920 -18920 0 0 {name=p101337 lab=_66644_/B }
C {devices/lab_pin.sym} 102040 -18940 0 1 {name=p101338 lab=_66644_/X }
C {sky130_stdcells/and2_4.sym} 101980 -18940 0 0 {name=X_66644_ }
C {devices/lab_pin.sym} 101920 -18840 0 0 {name=p101339 lab=_51870_/A }
C {devices/lab_pin.sym} 101920 -18800 0 0 {name=p101340 lab=_51870_/B }
C {devices/lab_pin.sym} 101920 -18760 0 0 {name=p101341 lab=_51870_/C }
C {devices/lab_pin.sym} 101920 -18720 0 0 {name=p101342 lab=_52698_/D }
C {devices/lab_pin.sym} 102040 -18780 0 1 {name=p101343 lab=_51870_/X }
C {sky130_stdcells/and4_4.sym} 101980 -18780 0 0 {name=X_51870_ }
C {devices/lab_pin.sym} 101940 -18630 0 0 {name=p101344 lab=_64045_/A }
C {devices/lab_pin.sym} 102020 -18630 0 1 {name=p101345 lab=_63920_/D }
C {sky130_stdcells/buf_2.sym} 101980 -18630 0 0 {name=X_63856_ }
C {devices/lab_pin.sym} 101890 -18510 0 0 {name=p101346 lab=_81216_/CLK }
C {devices/lab_pin.sym} 101890 -18490 0 0 {name=p101347 lab=_78805_/X }
C {devices/lab_pin.sym} 102070 -18510 0 1 {name=p101348 lab=_82678_/D }
C {sky130_stdcells/dfxtp_4.sym} 101980 -18500 0 0 {name=X_82690_ }
C {devices/lab_pin.sym} 101940 -18370 0 0 {name=p101349 lab=_50728_/A }
C {devices/lab_pin.sym} 102020 -18370 0 1 {name=p101350 lab=_50822_/A }
C {sky130_stdcells/buf_2.sym} 101980 -18370 0 0 {name=X_50821_ }
C {devices/lab_pin.sym} 101900 -18270 0 0 {name=p101351 lab=_62805_/X }
C {devices/lab_pin.sym} 101900 -18230 0 0 {name=p101352 lab=_62779_/X }
C {devices/lab_pin.sym} 101900 -18190 0 0 {name=p101353 lab=_62806_/Y }
C {devices/lab_pin.sym} 102060 -18230 0 1 {name=p101354 lab=_84381_/D }
C {sky130_stdcells/a21oi_4.sym} 101980 -18230 0 0 {name=X_62807_ }
C {devices/lab_pin.sym} 101890 -18090 0 0 {name=p101355 lab=_81671_/CLK }
C {devices/lab_pin.sym} 101890 -18070 0 0 {name=p101356 lab=_81673_/Q }
C {devices/lab_pin.sym} 102070 -18090 0 1 {name=p101357 lab=_81641_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -18080 0 0 {name=X_81641_ }
C {devices/lab_pin.sym} 101900 -17980 0 0 {name=p101358 lab=_87023_/Q }
C {devices/lab_pin.sym} 101900 -17940 0 0 {name=p101359 lab=_69239_/X }
C {devices/lab_pin.sym} 101900 -17900 0 0 {name=p101360 lab=_69361_/X }
C {devices/lab_pin.sym} 101900 -17860 0 0 {name=p101361 lab=_69362_/X }
C {devices/lab_pin.sym} 102060 -17920 0 1 {name=p101362 lab=_69363_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -17920 0 0 {name=X_69363_ }
C {devices/lab_pin.sym} 101940 -17770 0 0 {name=p101363 lab=_66553_/X }
C {devices/lab_pin.sym} 102020 -17770 0 1 {name=p101364 lab=_68742_/A }
C {sky130_stdcells/buf_2.sym} 101980 -17770 0 0 {name=X_66575_ }
C {devices/lab_pin.sym} 101920 -17680 0 0 {name=p101365 lab=_61367_/A }
C {devices/lab_pin.sym} 101920 -17640 0 0 {name=p101366 lab=_63772_/B }
C {devices/lab_pin.sym} 101920 -17600 0 0 {name=p101367 lab=_63721_/C }
C {devices/lab_pin.sym} 101920 -17560 0 0 {name=p101368 lab=_63787_/D }
C {devices/lab_pin.sym} 102040 -17620 0 1 {name=p101369 lab=_63787_/Y }
C {sky130_stdcells/nand4_4.sym} 101980 -17620 0 0 {name=X_63787_ }
C {devices/lab_pin.sym} 101900 -17500 0 0 {name=p101370 lab=_60996_/Y }
C {devices/lab_pin.sym} 101900 -17460 0 0 {name=p101371 lab=_60998_/X }
C {devices/lab_pin.sym} 101900 -17420 0 0 {name=p101372 lab=_60895_/X }
C {devices/lab_pin.sym} 101900 -17380 0 0 {name=p101373 lab=_60901_/X }
C {devices/lab_pin.sym} 102060 -17440 0 1 {name=p101374 lab=_60999_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -17440 0 0 {name=X_60999_ }
C {devices/lab_pin.sym} 101900 -17310 0 0 {name=p101375 lab=_82633_/D }
C {devices/lab_pin.sym} 101900 -17270 0 0 {name=p101376 lab=_68299_/X }
C {devices/lab_pin.sym} 101900 -17230 0 0 {name=p101377 lab=_68313_/X }
C {devices/lab_pin.sym} 102060 -17270 0 1 {name=p101378 lab=_68314_/X }
C {sky130_stdcells/a21bo_4.sym} 101980 -17270 0 0 {name=X_68314_ }
C {devices/lab_pin.sym} 101940 -17130 0 0 {name=p101379 lab=_53448_/X }
C {devices/lab_pin.sym} 102020 -17130 0 1 {name=p101380 lab=_53540_/X }
C {sky130_stdcells/buf_2.sym} 101980 -17130 0 0 {name=X_53540_ }
C {devices/lab_pin.sym} 101900 -17040 0 0 {name=p101381 lab=_65524_/X }
C {devices/lab_pin.sym} 101900 -17000 0 0 {name=p101382 lab=_83075_/Q }
C {devices/lab_pin.sym} 101900 -16960 0 0 {name=p101383 lab=_65391_/X }
C {devices/lab_pin.sym} 101900 -16920 0 0 {name=p101384 lab=_65525_/X }
C {devices/lab_pin.sym} 102060 -16980 0 1 {name=p101385 lab=_65526_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -16980 0 0 {name=X_65526_ }
C {devices/lab_pin.sym} 101890 -16830 0 0 {name=p101386 lab=_84360_/CLK }
C {devices/lab_pin.sym} 101890 -16810 0 0 {name=p101387 lab=_84360_/D }
C {devices/lab_pin.sym} 102070 -16830 0 1 {name=p101388 lab=_79502_/A }
C {sky130_stdcells/dfxtp_4.sym} 101980 -16820 0 0 {name=X_84360_ }
C {devices/lab_pin.sym} 101900 -16710 0 0 {name=p101389 lab=_50749_/Y }
C {devices/lab_pin.sym} 101900 -16670 0 0 {name=p101390 lab=_50676_/X }
C {devices/lab_pin.sym} 101900 -16630 0 0 {name=p101391 lab=_50751_/X }
C {devices/lab_pin.sym} 102060 -16670 0 1 {name=p101392 lab=_50752_/Y }
C {sky130_stdcells/a21oi_4.sym} 101980 -16670 0 0 {name=X_50752_ }
C {devices/lab_pin.sym} 101920 -16560 0 0 {name=p101393 lab=_62711_/A }
C {devices/lab_pin.sym} 101920 -16520 0 0 {name=p101394 lab=_64295_/C }
C {devices/lab_pin.sym} 101920 -16480 0 0 {name=p101395 lab=_62737_/X }
C {devices/lab_pin.sym} 101920 -16440 0 0 {name=p101396 lab=_62738_/D }
C {devices/lab_pin.sym} 102040 -16500 0 1 {name=p101397 lab=_62738_/X }
C {sky130_stdcells/and4_4.sym} 101980 -16500 0 0 {name=X_62738_ }
C {devices/lab_pin.sym} 101890 -16350 0 0 {name=p101398 lab=_81587_/CLK }
C {devices/lab_pin.sym} 101890 -16330 0 0 {name=p101399 lab=_84172_/Q }
C {devices/lab_pin.sym} 102070 -16350 0 1 {name=p101400 lab=_76675_/A }
C {sky130_stdcells/dfxtp_4.sym} 101980 -16340 0 0 {name=X_81572_ }
C {devices/lab_pin.sym} 101940 -16210 0 0 {name=p101401 lab=_67013_/X }
C {devices/lab_pin.sym} 102020 -16210 0 1 {name=p101402 lab=_69575_/A }
C {sky130_stdcells/buf_2.sym} 101980 -16210 0 0 {name=X_69294_ }
C {devices/lab_pin.sym} 101890 -16090 0 0 {name=p101403 lab=_83311_/CLK }
C {devices/lab_pin.sym} 101890 -16070 0 0 {name=p101404 lab=_71971_/Y }
C {devices/lab_pin.sym} 102070 -16090 0 1 {name=p101405 lab=_83311_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -16080 0 0 {name=X_83311_ }
C {devices/lab_pin.sym} 101920 -15960 0 0 {name=p101406 lab=_84767_/Q }
C {devices/lab_pin.sym} 101920 -15920 0 0 {name=p101407 lab=_84159_/Q }
C {devices/lab_pin.sym} 102040 -15940 0 1 {name=p101408 lab=_80523_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -15940 0 0 {name=X_80523_ }
C {devices/lab_pin.sym} 101900 -15830 0 0 {name=p101409 lab=_84002_/Q }
C {devices/lab_pin.sym} 101900 -15790 0 0 {name=p101410 lab=_68238_/X }
C {devices/lab_pin.sym} 101900 -15750 0 0 {name=p101411 lab=_68244_/X }
C {devices/lab_pin.sym} 102060 -15790 0 1 {name=p101412 lab=_84002_/D }
C {sky130_stdcells/a21bo_4.sym} 101980 -15790 0 0 {name=X_68245_ }
C {devices/lab_pin.sym} 101940 -15650 0 0 {name=p101413 lab=_53798_/A }
C {devices/lab_pin.sym} 102020 -15650 0 1 {name=p101414 lab=_53982_/A }
C {sky130_stdcells/buf_2.sym} 101980 -15650 0 0 {name=X_53471_ }
C {devices/lab_pin.sym} 101940 -15530 0 0 {name=p101415 lab=_64851_/A }
C {devices/lab_pin.sym} 102020 -15530 0 1 {name=p101416 lab=_65457_/X }
C {sky130_stdcells/buf_2.sym} 101980 -15530 0 0 {name=X_65457_ }
C {devices/lab_pin.sym} 101890 -15410 0 0 {name=p101417 lab=_84671_/CLK }
C {devices/lab_pin.sym} 101890 -15390 0 0 {name=p101418 lab=_63851_/Y }
C {devices/lab_pin.sym} 102070 -15410 0 1 {name=p101419 lab=_84291_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -15400 0 0 {name=X_84291_ }
C {devices/lab_pin.sym} 101900 -15290 0 0 {name=p101420 lab=_86154_/Q }
C {devices/lab_pin.sym} 101900 -15250 0 0 {name=p101421 lab=_50680_/X }
C {devices/lab_pin.sym} 101900 -15210 0 0 {name=p101422 lab=_50682_/Y }
C {devices/lab_pin.sym} 102060 -15250 0 1 {name=p101423 lab=_50683_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -15250 0 0 {name=X_50683_ }
C {devices/lab_pin.sym} 101920 -15140 0 0 {name=p101424 lab=_62669_/A }
C {devices/lab_pin.sym} 101920 -15100 0 0 {name=p101425 lab=_63022_/A }
C {devices/lab_pin.sym} 101920 -15060 0 0 {name=p101426 lab=_62927_/A }
C {devices/lab_pin.sym} 101920 -15020 0 0 {name=p101427 lab=_62669_/D }
C {devices/lab_pin.sym} 102040 -15080 0 1 {name=p101428 lab=_62669_/X }
C {sky130_stdcells/and4_4.sym} 101980 -15080 0 0 {name=X_62669_ }
C {devices/lab_pin.sym} 101900 -14950 0 0 {name=p101429 lab=_72712_/C }
C {devices/lab_pin.sym} 101900 -14910 0 0 {name=p101430 lab=_55209_/X }
C {devices/lab_pin.sym} 101900 -14870 0 0 {name=p101431 lab=_83317_/Q }
C {devices/lab_pin.sym} 102060 -14910 0 1 {name=p101432 lab=_55288_/A }
C {sky130_stdcells/a21o_4.sym} 101980 -14910 0 0 {name=X_55210_ }
C {devices/lab_pin.sym} 101890 -14770 0 0 {name=p101433 lab=_86030_/CLK }
C {devices/lab_pin.sym} 101890 -14750 0 0 {name=p101434 lab=_86030_/D }
C {devices/lab_pin.sym} 102070 -14770 0 1 {name=p101435 lab=_65105_/B }
C {sky130_stdcells/dfxtp_4.sym} 101980 -14760 0 0 {name=X_86030_ }
C {devices/lab_pin.sym} 101940 -14630 0 0 {name=p101436 lab=_52324_/A }
C {devices/lab_pin.sym} 102020 -14630 0 1 {name=p101437 lab=_52422_/X }
C {sky130_stdcells/buf_2.sym} 101980 -14630 0 0 {name=X_52422_ }
C {devices/lab_pin.sym} 101900 -14530 0 0 {name=p101438 lab=_79713_/B }
C {devices/lab_pin.sym} 101900 -14490 0 0 {name=p101439 lab=_64373_/X }
C {devices/lab_pin.sym} 101900 -14450 0 0 {name=p101440 lab=_64407_/X }
C {devices/lab_pin.sym} 102060 -14490 0 1 {name=p101441 lab=_64408_/X }
C {sky130_stdcells/a21o_4.sym} 101980 -14490 0 0 {name=X_64408_ }
C {devices/lab_pin.sym} 101890 -14350 0 0 {name=p101442 lab=_83242_/CLK }
C {devices/lab_pin.sym} 101890 -14330 0 0 {name=p101443 lab=_83242_/D }
C {devices/lab_pin.sym} 102070 -14350 0 1 {name=p101444 lab=_62081_/B }
C {sky130_stdcells/dfxtp_4.sym} 101980 -14340 0 0 {name=X_83242_ }
C {devices/lab_pin.sym} 101920 -14220 0 0 {name=p101445 lab=_84761_/Q }
C {devices/lab_pin.sym} 101920 -14180 0 0 {name=p101446 lab=_84153_/Q }
C {devices/lab_pin.sym} 102040 -14200 0 1 {name=p101447 lab=_80456_/A }
C {sky130_stdcells/xor2_4.sym} 101980 -14200 0 0 {name=X_80454_ }
C {devices/lab_pin.sym} 101940 -14070 0 0 {name=p101448 lab=_56252_/A }
C {devices/lab_pin.sym} 102020 -14070 0 1 {name=p101449 lab=_56280_/A }
C {sky130_stdcells/buf_2.sym} 101980 -14070 0 0 {name=X_56190_ }
C {devices/lab_pin.sym} 101900 -13970 0 0 {name=p101450 lab=_82060_/D }
C {devices/lab_pin.sym} 101900 -13930 0 0 {name=p101451 lab=_68160_/X }
C {devices/lab_pin.sym} 101900 -13890 0 0 {name=p101452 lab=_68175_/X }
C {devices/lab_pin.sym} 102060 -13930 0 1 {name=p101453 lab=_68176_/X }
C {sky130_stdcells/a21bo_4.sym} 101980 -13930 0 0 {name=X_68176_ }
C {devices/lab_pin.sym} 101900 -13820 0 0 {name=p101454 lab=_65059_/X }
C {devices/lab_pin.sym} 101900 -13780 0 0 {name=p101455 lab=_85539_/Q }
C {devices/lab_pin.sym} 101900 -13740 0 0 {name=p101456 lab=_65060_/X }
C {devices/lab_pin.sym} 101900 -13700 0 0 {name=p101457 lab=_65387_/X }
C {devices/lab_pin.sym} 102060 -13760 0 1 {name=p101458 lab=_65388_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -13760 0 0 {name=X_65388_ }
C {devices/lab_pin.sym} 101940 -13610 0 0 {name=p101459 lab=_55125_/A }
C {devices/lab_pin.sym} 102020 -13610 0 1 {name=p101460 lab=_55142_/A }
C {sky130_stdcells/buf_2.sym} 101980 -13610 0 0 {name=X_55141_ }
C {devices/lab_pin.sym} 101940 -13490 0 0 {name=p101461 lab=_67126_/X }
C {devices/lab_pin.sym} 102020 -13490 0 1 {name=p101462 lab=_67149_/A }
C {sky130_stdcells/buf_2.sym} 101980 -13490 0 0 {name=X_67127_ }
C {devices/lab_pin.sym} 101920 -13380 0 0 {name=p101463 lab=_52349_/A }
C {devices/lab_pin.sym} 101920 -13340 0 0 {name=p101464 lab=_50144_/B }
C {devices/lab_pin.sym} 102040 -13360 0 1 {name=p101465 lab=_52353_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -13360 0 0 {name=X_52353_ }
C {devices/lab_pin.sym} 101900 -13250 0 0 {name=p101466 lab=_64331_/Y }
C {devices/lab_pin.sym} 101900 -13210 0 0 {name=p101467 lab=_64338_/X }
C {devices/lab_pin.sym} 101900 -13170 0 0 {name=p101468 lab=_64328_/X }
C {devices/lab_pin.sym} 102060 -13210 0 1 {name=p101469 lab=_64339_/X }
C {sky130_stdcells/o21a_4.sym} 101980 -13210 0 0 {name=X_64339_ }
C {devices/lab_pin.sym} 101890 -13070 0 0 {name=p101470 lab=_84980_/CLK }
C {devices/lab_pin.sym} 101890 -13050 0 0 {name=p101471 lab=_83173_/D }
C {devices/lab_pin.sym} 102070 -13070 0 1 {name=p101472 lab=_83173_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -13060 0 0 {name=X_83173_ }
C {devices/lab_pin.sym} 101900 -12950 0 0 {name=p101473 lab=_80361_/A }
C {devices/lab_pin.sym} 101900 -12910 0 0 {name=p101474 lab=_80384_/D }
C {devices/lab_pin.sym} 101900 -12870 0 0 {name=p101475 lab=_80382_/X }
C {devices/lab_pin.sym} 102060 -12910 0 1 {name=p101476 lab=_80385_/X }
C {sky130_stdcells/a21bo_4.sym} 101980 -12910 0 0 {name=X_80385_ }
C {devices/lab_pin.sym} 101920 -12780 0 0 {name=p101477 lab=_51296_/A }
C {devices/lab_pin.sym} 101920 -12740 0 0 {name=p101478 lab=_46412_/B }
C {devices/lab_pin.sym} 102040 -12760 0 1 {name=p101479 lab=_51304_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -12760 0 0 {name=X_51304_ }
C {devices/lab_pin.sym} 101890 -12630 0 0 {name=p101480 lab=_82124_/CLK }
C {devices/lab_pin.sym} 101890 -12610 0 0 {name=p101481 lab=_82124_/D }
C {devices/lab_pin.sym} 102070 -12630 0 1 {name=p101482 lab=_82124_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -12620 0 0 {name=X_82124_ }
C {devices/lab_pin.sym} 101940 -12490 0 0 {name=p101483 lab=_55072_/A }
C {devices/lab_pin.sym} 102020 -12490 0 1 {name=p101484 lab=_55072_/X }
C {sky130_stdcells/buf_2.sym} 101980 -12490 0 0 {name=X_55072_ }
C {devices/lab_pin.sym} 101900 -12400 0 0 {name=p101485 lab=_87871_/Q }
C {devices/lab_pin.sym} 101900 -12360 0 0 {name=p101486 lab=_67056_/X }
C {devices/lab_pin.sym} 101900 -12320 0 0 {name=p101487 lab=_67032_/X }
C {devices/lab_pin.sym} 101900 -12280 0 0 {name=p101488 lab=_67057_/X }
C {devices/lab_pin.sym} 102060 -12340 0 1 {name=p101489 lab=_67058_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -12340 0 0 {name=X_67058_ }
C {devices/lab_pin.sym} 101900 -12210 0 0 {name=p101490 lab=_64719_/B }
C {devices/lab_pin.sym} 101900 -12170 0 0 {name=p101491 lab=_52269_/X }
C {devices/lab_pin.sym} 101900 -12130 0 0 {name=p101492 lab=_52283_/Y }
C {devices/lab_pin.sym} 102060 -12170 0 1 {name=p101493 lab=_52284_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -12170 0 0 {name=X_52284_ }
C {devices/lab_pin.sym} 101890 -12030 0 0 {name=p101494 lab=_87144_/CLK }
C {devices/lab_pin.sym} 101890 -12010 0 0 {name=p101495 lab=_42203_/Y }
C {devices/lab_pin.sym} 102070 -12030 0 1 {name=p101496 lab=_87981_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -12020 0 0 {name=X_87981_ }
C {devices/lab_pin.sym} 101940 -11890 0 0 {name=p101497 lab=_58810_/A }
C {devices/lab_pin.sym} 102020 -11890 0 1 {name=p101498 lab=_58900_/X }
C {sky130_stdcells/buf_2.sym} 101980 -11890 0 0 {name=X_58900_ }
C {devices/lab_pin.sym} 101900 -11790 0 0 {name=p101499 lab=_54021_/Y }
C {devices/lab_pin.sym} 101900 -11750 0 0 {name=p101500 lab=_54006_/X }
C {devices/lab_pin.sym} 101900 -11710 0 0 {name=p101501 lab=_54022_/Y }
C {devices/lab_pin.sym} 102060 -11750 0 1 {name=p101502 lab=_85521_/D }
C {sky130_stdcells/a21boi_4.sym} 101980 -11750 0 0 {name=X_54023_ }
C {devices/lab_pin.sym} 101900 -11640 0 0 {name=p101503 lab=_64722_/X }
C {devices/lab_pin.sym} 101900 -11600 0 0 {name=p101504 lab=_85626_/Q }
C {devices/lab_pin.sym} 101900 -11560 0 0 {name=p101505 lab=_64724_/X }
C {devices/lab_pin.sym} 101900 -11520 0 0 {name=p101506 lab=_66008_/X }
C {devices/lab_pin.sym} 102060 -11580 0 1 {name=p101507 lab=_66009_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -11580 0 0 {name=X_66009_ }
C {devices/lab_pin.sym} 101920 -11440 0 0 {name=p101508 lab=_51240_/A }
C {devices/lab_pin.sym} 101920 -11400 0 0 {name=p101509 lab=_51235_/B }
C {devices/lab_pin.sym} 102040 -11420 0 1 {name=p101510 lab=_51235_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -11420 0 0 {name=X_51235_ }
C {devices/lab_pin.sym} 101890 -11290 0 0 {name=p101511 lab=_86932_/CLK }
C {devices/lab_pin.sym} 101890 -11270 0 0 {name=p101512 lab=_86932_/D }
C {devices/lab_pin.sym} 102070 -11290 0 1 {name=p101513 lab=_67605_/B }
C {sky130_stdcells/dfxtp_4.sym} 101980 -11280 0 0 {name=X_86932_ }
C {devices/lab_pin.sym} 101890 -11150 0 0 {name=p101514 lab=_83933_/CLK }
C {devices/lab_pin.sym} 101890 -11130 0 0 {name=p101515 lab=_82055_/D }
C {devices/lab_pin.sym} 102070 -11150 0 1 {name=p101516 lab=_77780_/B }
C {sky130_stdcells/dfxtp_4.sym} 101980 -11140 0 0 {name=X_82055_ }
C {devices/lab_pin.sym} 101920 -11040 0 0 {name=p101517 lab=_60418_/D }
C {devices/lab_pin.sym} 101920 -11000 0 0 {name=p101518 lab=_60174_/D }
C {devices/lab_pin.sym} 101920 -10960 0 0 {name=p101519 lab=_60407_/A }
C {devices/lab_pin.sym} 101920 -10920 0 0 {name=p101520 lab=_59552_/C }
C {devices/lab_pin.sym} 102040 -10980 0 1 {name=p101521 lab=_59880_/X }
C {sky130_stdcells/and4_4.sym} 101980 -10980 0 0 {name=X_59880_ }
C {devices/lab_pin.sym} 101890 -10830 0 0 {name=p101522 lab=_82515_/CLK }
C {devices/lab_pin.sym} 101890 -10810 0 0 {name=p101523 lab=_84214_/Q }
C {devices/lab_pin.sym} 102070 -10830 0 1 {name=p101524 lab=_81006_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -10820 0 0 {name=X_81006_ }
C {devices/lab_pin.sym} 101920 -10700 0 0 {name=p101525 lab=_86700_/Q }
C {devices/lab_pin.sym} 101920 -10660 0 0 {name=p101526 lab=_58873_/B }
C {devices/lab_pin.sym} 102040 -10680 0 1 {name=p101527 lab=_58831_/Y }
C {sky130_stdcells/nor2_4.sym} 101980 -10680 0 0 {name=X_58831_ }
C {devices/lab_pin.sym} 101900 -10570 0 0 {name=p101528 lab=_51163_/Y }
C {devices/lab_pin.sym} 101900 -10530 0 0 {name=p101529 lab=_51147_/X }
C {devices/lab_pin.sym} 101900 -10490 0 0 {name=p101530 lab=_51165_/X }
C {devices/lab_pin.sym} 102060 -10530 0 1 {name=p101531 lab=_51166_/Y }
C {sky130_stdcells/a21oi_4.sym} 101980 -10530 0 0 {name=X_51166_ }
C {devices/lab_pin.sym} 101890 -10390 0 0 {name=p101532 lab=_86861_/CLK }
C {devices/lab_pin.sym} 101890 -10370 0 0 {name=p101533 lab=_45658_/Y }
C {devices/lab_pin.sym} 102070 -10390 0 1 {name=p101534 lab=_63196_/B }
C {sky130_stdcells/dfxtp_4.sym} 101980 -10380 0 0 {name=X_86863_ }
C {devices/lab_pin.sym} 101940 -10250 0 0 {name=p101535 lab=_50092_/A }
C {devices/lab_pin.sym} 102020 -10250 0 1 {name=p101536 lab=_50117_/X }
C {sky130_stdcells/buf_2.sym} 101980 -10250 0 0 {name=X_50117_ }
C {devices/lab_pin.sym} 101890 -10130 0 0 {name=p101537 lab=_85815_/CLK }
C {devices/lab_pin.sym} 101890 -10110 0 0 {name=p101538 lab=_52479_/Y }
C {devices/lab_pin.sym} 102070 -10130 0 1 {name=p101539 lab=_85814_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -10120 0 0 {name=X_85814_ }
C {devices/lab_pin.sym} 101900 -10010 0 0 {name=p101540 lab=_58758_/Y }
C {devices/lab_pin.sym} 101900 -9970 0 0 {name=p101541 lab=_58760_/Y }
C {devices/lab_pin.sym} 101900 -9930 0 0 {name=p101542 lab=_58761_/X }
C {devices/lab_pin.sym} 102060 -9970 0 1 {name=p101543 lab=_58762_/X }
C {sky130_stdcells/a21o_4.sym} 101980 -9970 0 0 {name=X_58762_ }
C {devices/lab_pin.sym} 101920 -9840 0 0 {name=p101544 lab=_51097_/A }
C {devices/lab_pin.sym} 101920 -9800 0 0 {name=p101545 lab=_52787_/B }
C {devices/lab_pin.sym} 102040 -9820 0 1 {name=p101546 lab=_51097_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -9820 0 0 {name=X_51097_ }
C {devices/lab_pin.sym} 101920 -9700 0 0 {name=p101547 lab=_55974_/A }
C {devices/lab_pin.sym} 101920 -9660 0 0 {name=p101548 lab=_55974_/B }
C {devices/lab_pin.sym} 102040 -9680 0 1 {name=p101549 lab=_55975_/A }
C {sky130_stdcells/and2_4.sym} 101980 -9680 0 0 {name=X_55974_ }
C {devices/lab_pin.sym} 101890 -9550 0 0 {name=p101550 lab=_88245_/CLK }
C {devices/lab_pin.sym} 101890 -9530 0 0 {name=p101551 lab=_46051_/Y }
C {devices/lab_pin.sym} 102070 -9550 0 1 {name=p101552 lab=_86794_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -9540 0 0 {name=X_86794_ }
C {devices/lab_pin.sym} 101900 -9430 0 0 {name=p101553 lab=_57712_/X }
C {devices/lab_pin.sym} 101900 -9390 0 0 {name=p101554 lab=_85729_/Q }
C {devices/lab_pin.sym} 101900 -9350 0 0 {name=p101555 lab=_44252_/X }
C {devices/lab_pin.sym} 102060 -9390 0 1 {name=p101556 lab=_57713_/X }
C {sky130_stdcells/o21a_4.sym} 101980 -9390 0 0 {name=X_57713_ }
C {devices/lab_pin.sym} 101920 -9260 0 0 {name=p101557 lab=_50048_/A }
C {devices/lab_pin.sym} 101920 -9220 0 0 {name=p101558 lab=_53259_/B }
C {devices/lab_pin.sym} 102040 -9240 0 1 {name=p101559 lab=_50048_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -9240 0 0 {name=X_50048_ }
C {devices/lab_pin.sym} 101900 -9130 0 0 {name=p101560 lab=_85352_/Q }
C {devices/lab_pin.sym} 101900 -9090 0 0 {name=p101561 lab=_54918_/X }
C {devices/lab_pin.sym} 101900 -9050 0 0 {name=p101562 lab=_54924_/Y }
C {devices/lab_pin.sym} 102060 -9090 0 1 {name=p101563 lab=_54925_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -9090 0 0 {name=X_54925_ }
C {devices/lab_pin.sym} 101890 -8950 0 0 {name=p101564 lab=_85745_/CLK }
C {devices/lab_pin.sym} 101890 -8930 0 0 {name=p101565 lab=_52842_/Y }
C {devices/lab_pin.sym} 102070 -8950 0 1 {name=p101566 lab=_85745_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -8940 0 0 {name=X_85745_ }
C {devices/lab_pin.sym} 101900 -8830 0 0 {name=p101567 lab=_58618_/X }
C {devices/lab_pin.sym} 101900 -8790 0 0 {name=p101568 lab=_86103_/Q }
C {devices/lab_pin.sym} 101900 -8750 0 0 {name=p101569 lab=_58692_/X }
C {devices/lab_pin.sym} 102060 -8790 0 1 {name=p101570 lab=_58693_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -8790 0 0 {name=X_58693_ }
C {devices/lab_pin.sym} 101940 -8650 0 0 {name=p101571 lab=_70944_/A }
C {devices/lab_pin.sym} 102020 -8650 0 1 {name=p101572 lab=_70976_/A }
C {sky130_stdcells/buf_2.sym} 101980 -8650 0 0 {name=X_70971_ }
C {devices/lab_pin.sym} 101890 -8530 0 0 {name=p101573 lab=_82769_/CLK }
C {devices/lab_pin.sym} 101890 -8510 0 0 {name=p101574 lab=_82957_/D }
C {devices/lab_pin.sym} 102070 -8530 0 1 {name=p101575 lab=_82957_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -8520 0 0 {name=X_82957_ }
C {devices/lab_pin.sym} 101940 -8390 0 0 {name=p101576 lab=clkbuf_9_195_0_CLK/X }
C {devices/lab_pin.sym} 102020 -8390 0 1 {name=p101577 lab=_83231_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 101980 -8390 0 0 {name=Xclkbuf_10_390_0_CLK }
C {devices/lab_pin.sym} 101920 -8300 0 0 {name=p101578 lab=_72710_/A }
C {devices/lab_pin.sym} 101920 -8260 0 0 {name=p101579 lab=_44907_/A }
C {devices/lab_pin.sym} 101920 -8220 0 0 {name=p101580 lab=_55285_/A }
C {devices/lab_pin.sym} 101920 -8180 0 0 {name=p101581 lab=_55274_/X }
C {devices/lab_pin.sym} 102040 -8240 0 1 {name=p101582 lab=_72710_/X }
C {sky130_stdcells/and4_4.sym} 101980 -8240 0 0 {name=X_72710_ }
C {devices/lab_pin.sym} 101920 -8100 0 0 {name=p101583 lab=_71970_/A }
C {devices/lab_pin.sym} 101920 -8060 0 0 {name=p101584 lab=_50385_/B }
C {devices/lab_pin.sym} 102040 -8080 0 1 {name=p101585 lab=_57644_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -8080 0 0 {name=X_57644_ }
C {devices/lab_pin.sym} 101890 -7950 0 0 {name=p101586 lab=_82133_/CLK }
C {devices/lab_pin.sym} 101890 -7930 0 0 {name=p101587 lab=_81908_/D }
C {devices/lab_pin.sym} 102070 -7950 0 1 {name=p101588 lab=_82284_/D }
C {sky130_stdcells/dfxtp_4.sym} 101980 -7940 0 0 {name=X_81908_ }
C {devices/lab_pin.sym} 101940 -7810 0 0 {name=p101589 lab=_54882_/A }
C {devices/lab_pin.sym} 102020 -7810 0 1 {name=p101590 lab=_54856_/X }
C {sky130_stdcells/buf_2.sym} 101980 -7810 0 0 {name=X_54856_ }
C {devices/lab_pin.sym} 101940 -7690 0 0 {name=p101591 lab=_42870_/A }
C {devices/lab_pin.sym} 102020 -7690 0 1 {name=p101592 lab=_42870_/Y }
C {sky130_stdcells/inv_2.sym} 101980 -7690 0 0 {name=X_42870_ }
C {devices/lab_pin.sym} 101900 -7600 0 0 {name=p101593 lab=_73665_/X }
C {devices/lab_pin.sym} 101900 -7560 0 0 {name=p101594 lab=_84988_/Q }
C {devices/lab_pin.sym} 101900 -7520 0 0 {name=p101595 lab=_73614_/X }
C {devices/lab_pin.sym} 101900 -7480 0 0 {name=p101596 lab=_73689_/X }
C {devices/lab_pin.sym} 102060 -7540 0 1 {name=p101597 lab=_73690_/X }
C {sky130_stdcells/a211o_4.sym} 101980 -7540 0 0 {name=X_73690_ }
C {devices/lab_pin.sym} 101890 -7390 0 0 {name=p101598 lab=_84802_/CLK }
C {devices/lab_pin.sym} 101890 -7370 0 0 {name=p101599 lab=_85676_/D }
C {devices/lab_pin.sym} 102070 -7390 0 1 {name=p101600 lab=_85676_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -7380 0 0 {name=X_85676_ }
C {devices/lab_pin.sym} 101890 -7250 0 0 {name=p101601 lab=_82888_/CLK }
C {devices/lab_pin.sym} 101890 -7230 0 0 {name=p101602 lab=_78123_/B }
C {devices/lab_pin.sym} 102070 -7250 0 1 {name=p101603 lab=_82888_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -7240 0 0 {name=X_82888_ }
C {devices/lab_pin.sym} 101890 -7110 0 0 {name=p101604 lab=_87417_/CLK }
C {devices/lab_pin.sym} 101890 -7090 0 0 {name=p101605 lab=_87415_/D }
C {devices/lab_pin.sym} 102070 -7110 0 1 {name=p101606 lab=_87415_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -7100 0 0 {name=X_87415_ }
C {devices/lab_pin.sym} 101940 -6970 0 0 {name=p101607 lab=_41607_/X }
C {devices/lab_pin.sym} 102020 -6970 0 1 {name=p101608 lab=_41821_/X }
C {sky130_stdcells/buf_2.sym} 101980 -6970 0 0 {name=X_41821_ }
C {devices/lab_pin.sym} 101900 -6870 0 0 {name=p101609 lab=_53804_/Y }
C {devices/lab_pin.sym} 101900 -6830 0 0 {name=p101610 lab=_53773_/X }
C {devices/lab_pin.sym} 101900 -6790 0 0 {name=p101611 lab=_53806_/X }
C {devices/lab_pin.sym} 102060 -6830 0 1 {name=p101612 lab=_85565_/D }
C {sky130_stdcells/a21oi_4.sym} 101980 -6830 0 0 {name=X_53807_ }
C {devices/lab_pin.sym} 101920 -6710 0 0 {name=p101613 lab=_72633_/X }
C {devices/lab_pin.sym} 101920 -6670 0 0 {name=p101614 lab=_72643_/B }
C {devices/lab_pin.sym} 101920 -6630 0 0 {name=p101615 lab=_72641_/C }
C {devices/lab_pin.sym} 102040 -6670 0 1 {name=p101616 lab=_72641_/Y }
C {sky130_stdcells/nand3_4.sym} 101980 -6670 0 0 {name=X_72641_ }
C {devices/lab_pin.sym} 101890 -6530 0 0 {name=p101617 lab=_84624_/CLK }
C {devices/lab_pin.sym} 101890 -6510 0 0 {name=p101618 lab=_60342_/X }
C {devices/lab_pin.sym} 102070 -6530 0 1 {name=p101619 lab=_79649_/A }
C {sky130_stdcells/dfxtp_4.sym} 101980 -6520 0 0 {name=X_84627_ }
C {devices/lab_pin.sym} 101900 -6410 0 0 {name=p101620 lab=_84976_/Q }
C {devices/lab_pin.sym} 101900 -6370 0 0 {name=p101621 lab=_57550_/X }
C {devices/lab_pin.sym} 101900 -6330 0 0 {name=p101622 lab=_57574_/Y }
C {devices/lab_pin.sym} 102060 -6370 0 1 {name=p101623 lab=_57575_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -6370 0 0 {name=X_57575_ }
C {devices/lab_pin.sym} 101890 -6230 0 0 {name=p101624 lab=_81839_/CLK }
C {devices/lab_pin.sym} 101890 -6210 0 0 {name=p101625 lab=_81839_/D }
C {devices/lab_pin.sym} 102070 -6230 0 1 {name=p101626 lab=_77409_/A }
C {sky130_stdcells/dfxtp_4.sym} 101980 -6220 0 0 {name=X_81839_ }
C {devices/lab_pin.sym} 101890 -6090 0 0 {name=p101627 lab=_86824_/CLK }
C {devices/lab_pin.sym} 101890 -6070 0 0 {name=p101628 lab=_88395_/D }
C {devices/lab_pin.sym} 102070 -6090 0 1 {name=p101629 lab=_88395_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -6080 0 0 {name=X_88395_ }
C {devices/lab_pin.sym} 101900 -5970 0 0 {name=p101630 lab=_85378_/Q }
C {devices/lab_pin.sym} 101900 -5930 0 0 {name=p101631 lab=_54784_/X }
C {devices/lab_pin.sym} 101900 -5890 0 0 {name=p101632 lab=_54786_/Y }
C {devices/lab_pin.sym} 102060 -5930 0 1 {name=p101633 lab=_54787_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -5930 0 0 {name=X_54787_ }
C {devices/lab_pin.sym} 101920 -5800 0 0 {name=p101634 lab=_51982_/X }
C {devices/lab_pin.sym} 101920 -5760 0 0 {name=p101635 lab=_53520_/B }
C {devices/lab_pin.sym} 102040 -5780 0 1 {name=p101636 lab=_51999_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -5780 0 0 {name=X_51999_ }
C {devices/lab_pin.sym} 101900 -5670 0 0 {name=p101637 lab=_59310_/Y }
C {devices/lab_pin.sym} 101900 -5630 0 0 {name=p101638 lab=_59313_/Y }
C {devices/lab_pin.sym} 101900 -5590 0 0 {name=p101639 lab=_59278_/X }
C {devices/lab_pin.sym} 102060 -5630 0 1 {name=p101640 lab=_59314_/X }
C {sky130_stdcells/a21o_4.sym} 101980 -5630 0 0 {name=X_59314_ }
C {devices/lab_pin.sym} 101900 -5530 0 0 {name=p101641 lab=_44529_/X }
C {devices/lab_pin.sym} 101900 -5490 0 0 {name=p101642 lab=_44530_/X }
C {devices/lab_pin.sym} 101900 -5450 0 0 {name=p101643 lab=_40810_/A }
C {devices/lab_pin.sym} 101900 -5410 0 0 {name=p101644 lab=_44539_/Y }
C {devices/lab_pin.sym} 101900 -5370 0 0 {name=p101645 lab=_44533_/X }
C {devices/lab_pin.sym} 102060 -5450 0 1 {name=p101646 lab=_44540_/Y }
C {sky130_stdcells/o32ai_4.sym} 101980 -5450 0 0 {name=X_44540_ }
C {devices/lab_pin.sym} 101920 -5310 0 0 {name=p101647 lab=_56533_/A }
C {devices/lab_pin.sym} 101920 -5270 0 0 {name=p101648 lab=_56533_/B }
C {devices/lab_pin.sym} 101920 -5230 0 0 {name=p101649 lab=_85162_/Q }
C {devices/lab_pin.sym} 102040 -5270 0 1 {name=p101650 lab=_56526_/Y }
C {sky130_stdcells/nand3_4.sym} 101980 -5270 0 0 {name=X_56526_ }
C {devices/lab_pin.sym} 101940 -5130 0 0 {name=p101651 lab=_75360_/A }
C {devices/lab_pin.sym} 102020 -5130 0 1 {name=p101652 lab=_75362_/A }
C {sky130_stdcells/inv_2.sym} 101980 -5130 0 0 {name=X_75360_ }
C {devices/lab_pin.sym} 101900 -5040 0 0 {name=p101653 lab=_41749_/X }
C {devices/lab_pin.sym} 101900 -5000 0 0 {name=p101654 lab=_41750_/X }
C {devices/lab_pin.sym} 101900 -4960 0 0 {name=p101655 lab=_67885_/B }
C {devices/lab_pin.sym} 101900 -4920 0 0 {name=p101656 lab=_41751_/X }
C {devices/lab_pin.sym} 102060 -4980 0 1 {name=p101657 lab=_88156_/D }
C {sky130_stdcells/a2bb2o_4.sym} 101980 -4980 0 0 {name=X_41752_ }
C {devices/lab_pin.sym} 101890 -4830 0 0 {name=p101658 lab=_87345_/CLK }
C {devices/lab_pin.sym} 101890 -4810 0 0 {name=p101659 lab=_43598_/Y }
C {devices/lab_pin.sym} 102070 -4830 0 1 {name=p101660 lab=_43596_/A }
C {sky130_stdcells/dfxtp_4.sym} 101980 -4820 0 0 {name=X_87346_ }
C {devices/lab_pin.sym} 101940 -4690 0 0 {name=p101661 lab=_53763_/A }
C {devices/lab_pin.sym} 102020 -4690 0 1 {name=p101662 lab=_53748_/C }
C {sky130_stdcells/buf_2.sym} 101980 -4690 0 0 {name=X_53738_ }
C {devices/lab_pin.sym} 101920 -4580 0 0 {name=p101663 lab=_72572_/A }
C {devices/lab_pin.sym} 101920 -4540 0 0 {name=p101664 lab=_72572_/B }
C {devices/lab_pin.sym} 102040 -4560 0 1 {name=p101665 lab=_72572_/X }
C {sky130_stdcells/and2_4.sym} 101980 -4560 0 0 {name=X_72572_ }
C {devices/lab_pin.sym} 101890 -4430 0 0 {name=p101666 lab=_83216_/CLK }
C {devices/lab_pin.sym} 101890 -4410 0 0 {name=p101667 lab=_60824_/Y }
C {devices/lab_pin.sym} 102070 -4430 0 1 {name=p101668 lab=_60822_/C }
C {sky130_stdcells/dfxtp_4.sym} 101980 -4420 0 0 {name=X_84558_ }
C {devices/lab_pin.sym} 101900 -4310 0 0 {name=p101669 lab=_83103_/Q }
C {devices/lab_pin.sym} 101900 -4270 0 0 {name=p101670 lab=_74301_/X }
C {devices/lab_pin.sym} 101900 -4230 0 0 {name=p101671 lab=_74310_/Y }
C {devices/lab_pin.sym} 102060 -4270 0 1 {name=p101672 lab=_74311_/X }
C {sky130_stdcells/a21bo_4.sym} 101980 -4270 0 0 {name=X_74311_ }
C {devices/lab_pin.sym} 101900 -4170 0 0 {name=p101673 lab=_40687_/X }
C {devices/lab_pin.sym} 101900 -4130 0 0 {name=p101674 lab=_40688_/X }
C {devices/lab_pin.sym} 101900 -4090 0 0 {name=p101675 lab=_40702_/X }
C {devices/lab_pin.sym} 101900 -4050 0 0 {name=p101676 lab=_88351_/Q }
C {devices/lab_pin.sym} 101900 -4010 0 0 {name=p101677 lab=_40683_/X }
C {devices/lab_pin.sym} 102060 -4090 0 1 {name=p101678 lab=_40703_/Y }
C {sky130_stdcells/o32ai_4.sym} 101980 -4090 0 0 {name=X_40703_ }
C {devices/lab_pin.sym} 101920 -3940 0 0 {name=p101679 lab=_59245_/A }
C {devices/lab_pin.sym} 101920 -3900 0 0 {name=p101680 lab=_59282_/B }
C {devices/lab_pin.sym} 102040 -3920 0 1 {name=p101681 lab=_59245_/Y }
C {sky130_stdcells/nor2_4.sym} 101980 -3920 0 0 {name=X_59245_ }
C {devices/lab_pin.sym} 101920 -3800 0 0 {name=p101682 lab=_71521_/A }
C {devices/lab_pin.sym} 101920 -3760 0 0 {name=p101683 lab=_70724_/A }
C {devices/lab_pin.sym} 102040 -3780 0 1 {name=p101684 lab=_71523_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -3780 0 0 {name=X_71523_ }
C {devices/lab_pin.sym} 101890 -3650 0 0 {name=p101685 lab=_83508_/CLK }
C {devices/lab_pin.sym} 101890 -3630 0 0 {name=p101686 lab=_83509_/D }
C {devices/lab_pin.sym} 102070 -3650 0 1 {name=p101687 lab=_83509_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -3640 0 0 {name=X_83509_ }
C {devices/lab_pin.sym} 101900 -3550 0 0 {name=p101688 lab=_44447_/X }
C {devices/lab_pin.sym} 101900 -3510 0 0 {name=p101689 lab=_44448_/X }
C {devices/lab_pin.sym} 101900 -3470 0 0 {name=p101690 lab=_41173_/X }
C {devices/lab_pin.sym} 101900 -3430 0 0 {name=p101691 lab=_87091_/Q }
C {devices/lab_pin.sym} 101900 -3390 0 0 {name=p101692 lab=_44449_/X }
C {devices/lab_pin.sym} 102060 -3470 0 1 {name=p101693 lab=_44472_/A }
C {sky130_stdcells/o32ai_4.sym} 101980 -3470 0 0 {name=X_44471_ }
C {devices/lab_pin.sym} 101920 -3330 0 0 {name=p101694 lab=_56279_/A }
C {devices/lab_pin.sym} 101920 -3290 0 0 {name=p101695 lab=_57364_/D }
C {devices/lab_pin.sym} 101920 -3250 0 0 {name=p101696 lab=_56174_/X }
C {devices/lab_pin.sym} 102040 -3290 0 1 {name=p101697 lab=_56459_/A }
C {sky130_stdcells/nand3_4.sym} 101980 -3290 0 0 {name=X_56457_ }
C {devices/lab_pin.sym} 101920 -3170 0 0 {name=p101698 lab=_75287_/Y }
C {devices/lab_pin.sym} 101920 -3130 0 0 {name=p101699 lab=_75288_/Y }
C {devices/lab_pin.sym} 101920 -3090 0 0 {name=p101700 lab=_75291_/C }
C {devices/lab_pin.sym} 102040 -3130 0 1 {name=p101701 lab=_75291_/X }
C {sky130_stdcells/or3_4.sym} 101980 -3130 0 0 {name=X_75291_ }
C {devices/lab_pin.sym} 101890 -2990 0 0 {name=p101702 lab=_88087_/CLK }
C {devices/lab_pin.sym} 101890 -2970 0 0 {name=p101703 lab=_43764_/X }
C {devices/lab_pin.sym} 102070 -2990 0 1 {name=p101704 lab=_87277_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -2980 0 0 {name=X_87277_ }
C {devices/lab_pin.sym} 101940 -2850 0 0 {name=p101705 lab=_40565_/Y }
C {devices/lab_pin.sym} 102020 -2850 0 1 {name=p101706 lab=_41814_/A }
C {sky130_stdcells/buf_2.sym} 101980 -2850 0 0 {name=X_41683_ }
C {devices/lab_pin.sym} 101920 -2740 0 0 {name=p101707 lab=_53662_/X }
C {devices/lab_pin.sym} 101920 -2700 0 0 {name=p101708 lab=_74414_/B }
C {devices/lab_pin.sym} 102040 -2720 0 1 {name=p101709 lab=_53669_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -2720 0 0 {name=X_53669_ }
C {devices/lab_pin.sym} 101890 -2590 0 0 {name=p101710 lab=_83218_/CLK }
C {devices/lab_pin.sym} 101890 -2570 0 0 {name=p101711 lab=_84489_/D }
C {devices/lab_pin.sym} 102070 -2590 0 1 {name=p101712 lab=_84489_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -2580 0 0 {name=X_84489_ }
C {devices/lab_pin.sym} 101940 -2450 0 0 {name=p101713 lab=_46210_/A }
C {devices/lab_pin.sym} 102020 -2450 0 1 {name=p101714 lab=_69611_/A }
C {sky130_stdcells/buf_2.sym} 101980 -2450 0 0 {name=X_46210_ }
C {sky130_stdcells/decap_3.sym} 101980 -2300 0 0 {name=XPHY_220 }
C {devices/lab_pin.sym} 101920 -2160 0 0 {name=p101715 lab=_77023_/A }
C {devices/lab_pin.sym} 101920 -2120 0 0 {name=p101716 lab=_77023_/B }
C {devices/lab_pin.sym} 102040 -2140 0 1 {name=p101717 lab=_77030_/Y }
C {sky130_stdcells/nand2_4.sym} 101980 -2140 0 0 {name=X_77030_ }
C {devices/lab_pin.sym} 101940 -2010 0 0 {name=p101718 lab=_43518_/A }
C {devices/lab_pin.sym} 102020 -2010 0 1 {name=p101719 lab=_43422_/X }
C {sky130_stdcells/buf_2.sym} 101980 -2010 0 0 {name=X_43422_ }
C {devices/lab_pin.sym} 101920 -1910 0 0 {name=p101720 lab=_55403_/A }
C {devices/lab_pin.sym} 101920 -1870 0 0 {name=p101721 lab=_55408_/B }
C {devices/lab_pin.sym} 101920 -1830 0 0 {name=p101722 lab=_55403_/B }
C {devices/lab_pin.sym} 102040 -1870 0 1 {name=p101723 lab=_55415_/B }
C {sky130_stdcells/nand3_4.sym} 101980 -1870 0 0 {name=X_55408_ }
C {devices/lab_pin.sym} 101890 -1730 0 0 {name=p101724 lab=_86578_/CLK }
C {devices/lab_pin.sym} 101890 -1710 0 0 {name=p101725 lab=_50301_/Y }
C {devices/lab_pin.sym} 102070 -1730 0 1 {name=p101726 lab=_86228_/Q }
C {sky130_stdcells/dfxtp_4.sym} 101980 -1720 0 0 {name=X_86228_ }
C {devices/lab_pin.sym} 101920 -1600 0 0 {name=p101727 lab=_74202_/A }
C {devices/lab_pin.sym} 101920 -1560 0 0 {name=p101728 lab=_74241_/Y }
C {devices/lab_pin.sym} 102040 -1580 0 1 {name=p101729 lab=_74242_/Y }
C {sky130_stdcells/nor2_4.sym} 101980 -1580 0 0 {name=X_74242_ }
C {sky130_stdcells/decap_3.sym} 101980 -1420 0 0 {name=XPHY_231 }
C {devices/lab_pin.sym} 101900 -1300 0 0 {name=p101730 lab=_40633_/X }
C {devices/lab_pin.sym} 101900 -1260 0 0 {name=p101731 lab=_40596_/X }
C {devices/lab_pin.sym} 101900 -1220 0 0 {name=p101732 lab=_88363_/Q }
C {devices/lab_pin.sym} 101900 -1180 0 0 {name=p101733 lab=_40599_/X }
C {devices/lab_pin.sym} 102060 -1240 0 1 {name=p101734 lab=_88363_/D }
C {sky130_stdcells/a2bb2o_4.sym} 101980 -1240 0 0 {name=X_40634_ }
C {devices/lab_pin.sym} 101920 -1120 0 0 {name=p101735 lab=_47152_/X }
C {devices/lab_pin.sym} 101920 -1080 0 0 {name=p101736 lab=_47181_/B }
C {devices/lab_pin.sym} 101920 -1040 0 0 {name=p101737 lab=_47210_/C }
C {devices/lab_pin.sym} 101920 -1000 0 0 {name=p101738 lab=_51214_/D }
C {devices/lab_pin.sym} 102040 -1060 0 1 {name=p101739 lab=_47190_/X }
C {sky130_stdcells/and4_4.sym} 101980 -1060 0 0 {name=X_47190_ }
C {devices/lab_pin.sym} 101900 -930 0 0 {name=p101740 lab=_59121_/X }
C {devices/lab_pin.sym} 101900 -890 0 0 {name=p101741 lab=_85427_/Q }
C {devices/lab_pin.sym} 101900 -850 0 0 {name=p101742 lab=_59175_/X }
C {devices/lab_pin.sym} 102060 -890 0 1 {name=p101743 lab=_59176_/Y }
C {sky130_stdcells/o21ai_4.sym} 101980 -890 0 0 {name=X_59176_ }
C {devices/lab_pin.sym} 101920 -770 0 0 {name=p101744 lab=_70682_/A }
C {devices/lab_pin.sym} 101920 -730 0 0 {name=p101745 lab=_71626_/C }
C {devices/lab_pin.sym} 101920 -690 0 0 {name=p101746 lab=_71450_/C }
C {devices/lab_pin.sym} 102040 -730 0 1 {name=p101747 lab=_71454_/Y }
C {sky130_stdcells/nor3_4.sym} 101980 -730 0 0 {name=X_71454_ }
C {devices/lab_pin.sym} 102840 -42170 0 0 {name=p101748 lab=_56383_/X }
C {devices/lab_pin.sym} 102840 -42130 0 0 {name=p101749 lab=_56386_/B }
C {devices/lab_pin.sym} 102840 -42090 0 0 {name=p101750 lab=_85213_/Q }
C {devices/lab_pin.sym} 102960 -42130 0 1 {name=p101751 lab=_56388_/Y }
C {sky130_stdcells/nand3_4.sym} 102900 -42130 0 0 {name=X_56388_ }
C {sky130_stdcells/decap_3.sym} 102900 -41960 0 0 {name=XPHY_242 }
C {sky130_stdcells/decap_3.sym} 102900 -41780 0 0 {name=XPHY_253 }
C {sky130_stdcells/decap_3.sym} 102900 -41600 0 0 {name=XPHY_264 }
C {devices/lab_pin.sym} 102860 -41450 0 0 {name=p101752 lab=_46141_/A }
C {devices/lab_pin.sym} 102940 -41450 0 1 {name=p101753 lab=_46143_/B }
C {sky130_stdcells/inv_2.sym} 102900 -41450 0 0 {name=X_46141_ }
C {devices/lab_pin.sym} 102820 -41350 0 0 {name=p101754 lab=_58125_/X }
C {devices/lab_pin.sym} 102820 -41310 0 0 {name=p101755 lab=_85699_/Q }
C {devices/lab_pin.sym} 102820 -41270 0 0 {name=p101756 lab=_58126_/X }
C {devices/lab_pin.sym} 102980 -41310 0 1 {name=p101757 lab=_58127_/X }
C {sky130_stdcells/o21a_4.sym} 102900 -41310 0 0 {name=X_58127_ }
C {devices/lab_pin.sym} 102860 -41170 0 0 {name=p101758 lab=_71090_/A }
C {devices/lab_pin.sym} 102940 -41170 0 1 {name=p101759 lab=_70824_/A }
C {sky130_stdcells/buf_2.sym} 102900 -41170 0 0 {name=X_70405_ }
C {sky130_stdcells/decap_3.sym} 102900 -41020 0 0 {name=XPHY_275 }
C {devices/lab_pin.sym} 102860 -40870 0 0 {name=p101760 lab=_43329_/X }
C {devices/lab_pin.sym} 102940 -40870 0 1 {name=p101761 lab=_43353_/X }
C {sky130_stdcells/buf_2.sym} 102900 -40870 0 0 {name=X_43353_ }
C {devices/lab_pin.sym} 102820 -40770 0 0 {name=p101762 lab=_55336_/X }
C {devices/lab_pin.sym} 102820 -40730 0 0 {name=p101763 lab=_55365_/B }
C {devices/lab_pin.sym} 102820 -40690 0 0 {name=p101764 lab=_83752_/Q }
C {devices/lab_pin.sym} 102980 -40730 0 1 {name=p101765 lab=_55445_/B }
C {sky130_stdcells/a21o_4.sym} 102900 -40730 0 0 {name=X_55339_ }
C {devices/lab_pin.sym} 102820 -40620 0 0 {name=p101766 lab=_74080_/X }
C {devices/lab_pin.sym} 102820 -40580 0 0 {name=p101767 lab=_86215_/Q }
C {devices/lab_pin.sym} 102820 -40540 0 0 {name=p101768 lab=_74103_/X }
C {devices/lab_pin.sym} 102820 -40500 0 0 {name=p101769 lab=_74172_/X }
C {devices/lab_pin.sym} 102980 -40560 0 1 {name=p101770 lab=_74173_/X }
C {sky130_stdcells/a211o_4.sym} 102900 -40560 0 0 {name=X_74173_ }
C {devices/lab_pin.sym} 102810 -40410 0 0 {name=p101771 lab=_86256_/CLK }
C {devices/lab_pin.sym} 102810 -40390 0 0 {name=p101772 lab=_86159_/D }
C {devices/lab_pin.sym} 102990 -40410 0 1 {name=p101773 lab=_86159_/Q }
C {sky130_stdcells/dfxtp_4.sym} 102900 -40400 0 0 {name=X_86159_ }
C {devices/lab_pin.sym} 102820 -40290 0 0 {name=p101774 lab=_40344_/A }
C {devices/lab_pin.sym} 102820 -40250 0 0 {name=p101775 lab=_42446_/A }
C {devices/lab_pin.sym} 102820 -40210 0 0 {name=p101776 lab=_48162_/A }
C {devices/lab_pin.sym} 102980 -40250 0 1 {name=p101777 lab=_40565_/Y }
C {sky130_stdcells/a21oi_4.sym} 102900 -40250 0 0 {name=X_40565_ }
C {sky130_stdcells/decap_3.sym} 102900 -40080 0 0 {name=XPHY_286 }
C {devices/lab_pin.sym} 102860 -39930 0 0 {name=p101778 lab=_71163_/A }
C {devices/lab_pin.sym} 102940 -39930 0 1 {name=p101779 lab=_71386_/B }
C {sky130_stdcells/buf_2.sym} 102900 -39930 0 0 {name=X_71385_ }
C {sky130_stdcells/decap_3.sym} 102900 -39780 0 0 {name=XPHY_297 }
C {devices/lab_pin.sym} 102860 -39630 0 0 {name=p101780 lab=_41909_/Y }
C {devices/lab_pin.sym} 102940 -39630 0 1 {name=p101781 lab=_42304_/X }
C {sky130_stdcells/buf_2.sym} 102900 -39630 0 0 {name=X_42304_ }
C {devices/lab_pin.sym} 102840 -39520 0 0 {name=p101782 lab=_73124_/A }
C {devices/lab_pin.sym} 102840 -39480 0 0 {name=p101783 lab=_73124_/B }
C {devices/lab_pin.sym} 102960 -39500 0 1 {name=p101784 lab=_73124_/Y }
C {sky130_stdcells/nor2_4.sym} 102900 -39500 0 0 {name=X_73124_ }
C {devices/lab_pin.sym} 102820 -39390 0 0 {name=p101785 lab=_70320_/X }
C {devices/lab_pin.sym} 102820 -39350 0 0 {name=p101786 lab=_83793_/Q }
C {devices/lab_pin.sym} 102820 -39310 0 0 {name=p101787 lab=_70335_/X }
C {devices/lab_pin.sym} 102980 -39350 0 1 {name=p101788 lab=_83793_/D }
C {sky130_stdcells/a21o_4.sym} 102900 -39350 0 0 {name=X_70336_ }
C {devices/lab_pin.sym} 102820 -39240 0 0 {name=p101789 lab=_41585_/Y }
C {devices/lab_pin.sym} 102820 -39200 0 0 {name=p101790 lab=_46061_/X }
C {devices/lab_pin.sym} 102820 -39160 0 0 {name=p101791 lab=_86782_/Q }
C {devices/lab_pin.sym} 102820 -39120 0 0 {name=p101792 lab=_46062_/X }
C {devices/lab_pin.sym} 102980 -39180 0 1 {name=p101793 lab=_86782_/D }
C {sky130_stdcells/a2bb2o_4.sym} 102900 -39180 0 0 {name=X_46072_ }
C {devices/lab_pin.sym} 102840 -39040 0 0 {name=p101794 lab=_58070_/A }
C {devices/lab_pin.sym} 102840 -39000 0 0 {name=p101795 lab=_58058_/B }
C {devices/lab_pin.sym} 102960 -39020 0 1 {name=p101796 lab=_58058_/Y }
C {sky130_stdcells/nor2_4.sym} 102900 -39020 0 0 {name=X_58058_ }
C {devices/lab_pin.sym} 102820 -38920 0 0 {name=p101797 lab=_41157_/X }
C {devices/lab_pin.sym} 102820 -38880 0 0 {name=p101798 lab=_43277_/X }
C {devices/lab_pin.sym} 102820 -38840 0 0 {name=p101799 lab=_87499_/Q }
C {devices/lab_pin.sym} 102820 -38800 0 0 {name=p101800 lab=_43278_/X }
C {devices/lab_pin.sym} 102980 -38860 0 1 {name=p101801 lab=_87499_/D }
C {sky130_stdcells/a2bb2o_4.sym} 102900 -38860 0 0 {name=X_43284_ }
C {devices/lab_pin.sym} 102840 -38720 0 0 {name=p101802 lab=_78986_/B }
C {devices/lab_pin.sym} 102840 -38680 0 0 {name=p101803 lab=_78981_/B }
C {devices/lab_pin.sym} 102960 -38700 0 1 {name=p101804 lab=_78982_/B }
C {sky130_stdcells/xor2_4.sym} 102900 -38700 0 0 {name=X_78981_ }
C {devices/lab_pin.sym} 102820 -38590 0 0 {name=p101805 lab=_40325_/X }
C {devices/lab_pin.sym} 102820 -38550 0 0 {name=p101806 lab=_82316_/Q }
C {devices/lab_pin.sym} 102820 -38510 0 0 {name=p101807 lab=_40495_/X }
C {devices/lab_pin.sym} 102980 -38550 0 1 {name=p101808 lab=_40496_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -38550 0 0 {name=X_40496_ }
C {devices/lab_pin.sym} 102820 -38430 0 0 {name=p101809 lab=_49896_/Y }
C {devices/lab_pin.sym} 102820 -38390 0 0 {name=p101810 lab=_49897_/X }
C {devices/lab_pin.sym} 102820 -38350 0 0 {name=p101811 lab=_49899_/X }
C {devices/lab_pin.sym} 102980 -38390 0 1 {name=p101812 lab=_49900_/Y }
C {sky130_stdcells/a21oi_4.sym} 102900 -38390 0 0 {name=X_49900_ }
C {devices/lab_pin.sym} 102820 -38270 0 0 {name=p101813 lab=_44975_/X }
C {devices/lab_pin.sym} 102820 -38230 0 0 {name=p101814 lab=_61417_/B }
C {devices/lab_pin.sym} 102820 -38190 0 0 {name=p101815 lab=_44995_/X }
C {devices/lab_pin.sym} 102980 -38230 0 1 {name=p101816 lab=_45023_/Y }
C {sky130_stdcells/o21ai_4.sym} 102900 -38230 0 0 {name=X_45023_ }
C {devices/lab_pin.sym} 102820 -38130 0 0 {name=p101817 lab=_56783_/X }
C {devices/lab_pin.sym} 102820 -38090 0 0 {name=p101818 lab=_56737_/X }
C {devices/lab_pin.sym} 102820 -38050 0 0 {name=p101819 lab=_56785_/D }
C {devices/lab_pin.sym} 102820 -38010 0 0 {name=p101820 lab=_57024_/D }
C {devices/lab_pin.sym} 102820 -37980 0 0 {name=p101821 lab=_57010_/A }
C {devices/lab_pin.sym} 102980 -38050 0 1 {name=p101822 lab=_57009_/Y }
C {sky130_stdcells/a41oi_4.sym} 102900 -38050 0 0 {name=X_57009_ }
C {devices/lab_pin.sym} 102860 -37890 0 0 {name=p101823 lab=_42234_/Y }
C {devices/lab_pin.sym} 102940 -37890 0 1 {name=p101824 lab=_87968_/D }
C {sky130_stdcells/inv_2.sym} 102900 -37890 0 0 {name=X_42235_ }
C {devices/lab_pin.sym} 102820 -37790 0 0 {name=p101825 lab=_77916_/B }
C {devices/lab_pin.sym} 102820 -37750 0 0 {name=p101826 lab=_77929_/X }
C {devices/lab_pin.sym} 102820 -37710 0 0 {name=p101827 lab=_77931_/Y }
C {devices/lab_pin.sym} 102980 -37750 0 1 {name=p101828 lab=_77933_/B }
C {sky130_stdcells/a21oi_4.sym} 102900 -37750 0 0 {name=X_77932_ }
C {devices/lab_pin.sym} 102860 -37610 0 0 {name=p101829 lab=_72798_/X }
C {devices/lab_pin.sym} 102940 -37610 0 1 {name=p101830 lab=_73055_/X }
C {sky130_stdcells/buf_2.sym} 102900 -37610 0 0 {name=X_73055_ }
C {devices/lab_pin.sym} 102860 -37490 0 0 {name=p101831 lab=clkbuf_9_171_0_CLK/X }
C {devices/lab_pin.sym} 102940 -37490 0 1 {name=p101832 lab=_85741_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 102900 -37490 0 0 {name=Xclkbuf_10_343_0_CLK }
C {devices/lab_pin.sym} 102840 -37400 0 0 {name=p101833 lab=_70267_/A }
C {devices/lab_pin.sym} 102840 -37360 0 0 {name=p101834 lab=_70267_/B }
C {devices/lab_pin.sym} 102840 -37320 0 0 {name=p101835 lab=_70267_/C }
C {devices/lab_pin.sym} 102840 -37280 0 0 {name=p101836 lab=_70264_/X }
C {devices/lab_pin.sym} 102960 -37340 0 1 {name=p101837 lab=_70267_/X }
C {sky130_stdcells/and4_4.sym} 102900 -37340 0 0 {name=X_70267_ }
C {devices/lab_pin.sym} 102860 -37190 0 0 {name=p101838 lab=_59842_/A }
C {devices/lab_pin.sym} 102940 -37190 0 1 {name=p101839 lab=_60064_/A }
C {sky130_stdcells/buf_2.sym} 102900 -37190 0 0 {name=X_60020_ }
C {devices/lab_pin.sym} 102820 -37090 0 0 {name=p101840 lab=_72004_/Y }
C {devices/lab_pin.sym} 102820 -37050 0 0 {name=p101841 lab=_71978_/X }
C {devices/lab_pin.sym} 102820 -37010 0 0 {name=p101842 lab=_72005_/X }
C {devices/lab_pin.sym} 102980 -37050 0 1 {name=p101843 lab=_72006_/Y }
C {sky130_stdcells/a21oi_4.sym} 102900 -37050 0 0 {name=X_72006_ }
C {devices/lab_pin.sym} 102860 -36910 0 0 {name=p101844 lab=clkbuf_9_486_0_CLK/X }
C {devices/lab_pin.sym} 102940 -36910 0 1 {name=p101845 lab=_85547_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 102900 -36910 0 0 {name=Xclkbuf_10_973_0_CLK }
C {devices/lab_pin.sym} 102820 -36810 0 0 {name=p101846 lab=_49829_/Y }
C {devices/lab_pin.sym} 102820 -36770 0 0 {name=p101847 lab=_49815_/X }
C {devices/lab_pin.sym} 102820 -36730 0 0 {name=p101848 lab=_49830_/X }
C {devices/lab_pin.sym} 102980 -36770 0 1 {name=p101849 lab=_49831_/Y }
C {sky130_stdcells/a21oi_4.sym} 102900 -36770 0 0 {name=X_49831_ }
C {devices/lab_pin.sym} 102860 -36630 0 0 {name=p101850 lab=_42166_/A }
C {devices/lab_pin.sym} 102940 -36630 0 1 {name=p101851 lab=_42166_/Y }
C {sky130_stdcells/inv_2.sym} 102900 -36630 0 0 {name=X_42166_ }
C {devices/lab_pin.sym} 102860 -36510 0 0 {name=p101852 lab=_82065_/Q }
C {devices/lab_pin.sym} 102940 -36510 0 1 {name=p101853 lab=_77863_/Y }
C {sky130_stdcells/inv_2.sym} 102900 -36510 0 0 {name=X_77863_ }
C {devices/lab_pin.sym} 102840 -36420 0 0 {name=p101854 lab=_70200_/A }
C {devices/lab_pin.sym} 102840 -36380 0 0 {name=p101855 lab=_70200_/B }
C {devices/lab_pin.sym} 102840 -36340 0 0 {name=p101856 lab=_70198_/C }
C {devices/lab_pin.sym} 102840 -36300 0 0 {name=p101857 lab=_70200_/D }
C {devices/lab_pin.sym} 102960 -36360 0 1 {name=p101858 lab=_70198_/X }
C {sky130_stdcells/and4_4.sym} 102900 -36360 0 0 {name=X_70198_ }
C {devices/lab_pin.sym} 102840 -36220 0 0 {name=p101859 lab=_65294_/C }
C {devices/lab_pin.sym} 102840 -36180 0 0 {name=p101860 lab=_83255_/Q }
C {devices/lab_pin.sym} 102960 -36200 0 1 {name=p101861 lab=_79602_/X }
C {sky130_stdcells/or2_4.sym} 102900 -36200 0 0 {name=X_79602_ }
C {devices/lab_pin.sym} 102820 -36110 0 0 {name=p101862 lab=_41112_/X }
C {devices/lab_pin.sym} 102820 -36070 0 0 {name=p101863 lab=_41113_/X }
C {devices/lab_pin.sym} 102820 -36030 0 0 {name=p101864 lab=_41116_/X }
C {devices/lab_pin.sym} 102820 -35990 0 0 {name=p101865 lab=_88275_/Q }
C {devices/lab_pin.sym} 102820 -35950 0 0 {name=p101866 lab=_41088_/X }
C {devices/lab_pin.sym} 102980 -36030 0 1 {name=p101867 lab=_41118_/A }
C {sky130_stdcells/o32ai_4.sym} 102900 -36030 0 0 {name=X_41117_ }
C {devices/lab_pin.sym} 102840 -35880 0 0 {name=p101868 lab=_76801_/A }
C {devices/lab_pin.sym} 102840 -35840 0 0 {name=p101869 lab=_76808_/A }
C {devices/lab_pin.sym} 102960 -35860 0 1 {name=p101870 lab=_76814_/X }
C {sky130_stdcells/and2_4.sym} 102900 -35860 0 0 {name=X_76814_ }
C {devices/lab_pin.sym} 102860 -35730 0 0 {name=p101871 lab=clkbuf_8_232_0_CLK/X }
C {devices/lab_pin.sym} 102940 -35730 0 1 {name=p101872 lab=clkbuf_9_464_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 102900 -35730 0 0 {name=Xclkbuf_9_464_0_CLK }
C {devices/lab_pin.sym} 102820 -35630 0 0 {name=p101873 lab=_49758_/Y }
C {devices/lab_pin.sym} 102820 -35590 0 0 {name=p101874 lab=_49759_/X }
C {devices/lab_pin.sym} 102820 -35550 0 0 {name=p101875 lab=_49761_/X }
C {devices/lab_pin.sym} 102980 -35590 0 1 {name=p101876 lab=_49762_/Y }
C {sky130_stdcells/a21oi_4.sym} 102900 -35590 0 0 {name=X_49762_ }
C {devices/lab_pin.sym} 102820 -35470 0 0 {name=p101877 lab=_46970_/Y }
C {devices/lab_pin.sym} 102820 -35430 0 0 {name=p101878 lab=_46940_/X }
C {devices/lab_pin.sym} 102820 -35390 0 0 {name=p101879 lab=_46973_/X }
C {devices/lab_pin.sym} 102980 -35430 0 1 {name=p101880 lab=_86684_/D }
C {sky130_stdcells/a21oi_4.sym} 102900 -35430 0 0 {name=X_46974_ }
