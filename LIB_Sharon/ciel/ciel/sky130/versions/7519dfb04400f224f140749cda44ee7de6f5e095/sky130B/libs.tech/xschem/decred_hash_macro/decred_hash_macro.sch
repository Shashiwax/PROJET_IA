C {devices/lab_pin.sym} 154340 -18610 0 0 {name=p153569 lab=_74314_/X }
C {devices/lab_pin.sym} 154340 -18570 0 0 {name=p153570 lab=_74325_/Y }
C {devices/lab_pin.sym} 154500 -18610 0 1 {name=p153571 lab=_83097_/D }
C {sky130_stdcells/a21bo_4.sym} 154420 -18610 0 0 {name=X_74326_ }
C {devices/lab_pin.sym} 154380 -18470 0 0 {name=p153572 lab=_40717_/X }
C {devices/lab_pin.sym} 154460 -18470 0 1 {name=p153573 lab=_40793_/A }
C {sky130_stdcells/buf_2.sym} 154420 -18470 0 0 {name=X_40718_ }
C {devices/lab_pin.sym} 154380 -18350 0 0 {name=p153574 lab=_54645_/D }
C {devices/lab_pin.sym} 154460 -18350 0 1 {name=p153575 lab=_52954_/D }
C {sky130_stdcells/buf_2.sym} 154420 -18350 0 0 {name=X_47274_ }
C {devices/lab_pin.sym} 154340 -18250 0 0 {name=p153576 lab=_71531_/X }
C {devices/lab_pin.sym} 154340 -18210 0 0 {name=p153577 lab=_83465_/Q }
C {devices/lab_pin.sym} 154340 -18170 0 0 {name=p153578 lab=_71537_/Y }
C {devices/lab_pin.sym} 154500 -18210 0 1 {name=p153579 lab=_83465_/D }
C {sky130_stdcells/a21o_4.sym} 154420 -18210 0 0 {name=X_71538_ }
C {devices/lab_pin.sym} 154360 -18080 0 0 {name=p153580 lab=_78090_/Y }
C {devices/lab_pin.sym} 154360 -18040 0 0 {name=p153581 lab=_78093_/Y }
C {devices/lab_pin.sym} 154480 -18060 0 1 {name=p153582 lab=_78096_/B }
C {sky130_stdcells/xnor2_4.sym} 154420 -18060 0 0 {name=X_78094_ }
C {devices/lab_pin.sym} 154380 -17930 0 0 {name=p153583 lab=_44486_/A }
C {devices/lab_pin.sym} 154460 -17930 0 1 {name=p153584 lab=_44486_/Y }
C {sky130_stdcells/inv_2.sym} 154420 -17930 0 0 {name=X_44486_ }
C {devices/lab_pin.sym} 154340 -17840 0 0 {name=p153585 lab=_41697_/X }
C {devices/lab_pin.sym} 154340 -17800 0 0 {name=p153586 lab=_41682_/X }
C {devices/lab_pin.sym} 154340 -17760 0 0 {name=p153587 lab=_67634_/B }
C {devices/lab_pin.sym} 154340 -17720 0 0 {name=p153588 lab=_41684_/X }
C {devices/lab_pin.sym} 154500 -17780 0 1 {name=p153589 lab=_88167_/D }
C {sky130_stdcells/a2bb2o_4.sym} 154420 -17780 0 0 {name=X_41698_ }
C {devices/lab_pin.sym} 154340 -17650 0 0 {name=p153590 lab=_49008_/Y }
C {devices/lab_pin.sym} 154340 -17610 0 0 {name=p153591 lab=_48985_/X }
C {devices/lab_pin.sym} 154340 -17570 0 0 {name=p153592 lab=_49012_/X }
C {devices/lab_pin.sym} 154500 -17610 0 1 {name=p153593 lab=_86453_/D }
C {sky130_stdcells/a21oi_4.sym} 154420 -17610 0 0 {name=X_49013_ }
C {devices/lab_pin.sym} 154360 -17500 0 0 {name=p153594 lab=_46224_/X }
C {devices/lab_pin.sym} 154360 -17460 0 0 {name=p153595 lab=_46098_/A }
C {devices/lab_pin.sym} 154360 -17420 0 0 {name=p153596 lab=_46214_/C }
C {devices/lab_pin.sym} 154360 -17380 0 0 {name=p153597 lab=_46214_/D }
C {devices/lab_pin.sym} 154480 -17440 0 1 {name=p153598 lab=_46225_/Y }
C {sky130_stdcells/nand4_4.sym} 154420 -17440 0 0 {name=X_46225_ }
C {sky130_stdcells/decap_3.sym} 154420 -17260 0 0 {name=XPHY_370 }
C {devices/lab_pin.sym} 154360 -17120 0 0 {name=p153599 lab=_77054_/A }
C {devices/lab_pin.sym} 154360 -17080 0 0 {name=p153600 lab=_82281_/D }
C {devices/lab_pin.sym} 154480 -17100 0 1 {name=p153601 lab=_77045_/X }
C {sky130_stdcells/xor2_4.sym} 154420 -17100 0 0 {name=X_77045_ }
C {devices/lab_pin.sym} 154340 -17000 0 0 {name=p153602 lab=_41570_/X }
C {devices/lab_pin.sym} 154340 -16960 0 0 {name=p153603 lab=_43431_/X }
C {devices/lab_pin.sym} 154340 -16920 0 0 {name=p153604 lab=_87422_/Q }
C {devices/lab_pin.sym} 154340 -16880 0 0 {name=p153605 lab=_43432_/X }
C {devices/lab_pin.sym} 154500 -16940 0 1 {name=p153606 lab=_43437_/X }
C {sky130_stdcells/a2bb2o_4.sym} 154420 -16940 0 0 {name=X_43437_ }
C {devices/lab_pin.sym} 154360 -16820 0 0 {name=p153607 lab=_62304_/A }
C {devices/lab_pin.sym} 154360 -16780 0 0 {name=p153608 lab=_58232_/X }
C {devices/lab_pin.sym} 154360 -16740 0 0 {name=p153609 lab=_62244_/C }
C {devices/lab_pin.sym} 154360 -16700 0 0 {name=p153610 lab=_62244_/D }
C {devices/lab_pin.sym} 154480 -16760 0 1 {name=p153611 lab=_62271_/X }
C {sky130_stdcells/and4_4.sym} 154420 -16760 0 0 {name=X_62271_ }
C {devices/lab_pin.sym} 154340 -16640 0 0 {name=p153612 lab=_72730_/X }
C {devices/lab_pin.sym} 154340 -16600 0 0 {name=p153613 lab=_84963_/Q }
C {devices/lab_pin.sym} 154340 -16560 0 0 {name=p153614 lab=_74021_/X }
C {devices/lab_pin.sym} 154340 -16520 0 0 {name=p153615 lab=_74256_/X }
C {devices/lab_pin.sym} 154500 -16580 0 1 {name=p153616 lab=_74258_/B }
C {sky130_stdcells/a211o_4.sym} 154420 -16580 0 0 {name=X_74257_ }
C {devices/lab_pin.sym} 154340 -16450 0 0 {name=p153617 lab=_40585_/X }
C {devices/lab_pin.sym} 154340 -16410 0 0 {name=p153618 lab=_82870_/Q }
C {devices/lab_pin.sym} 154340 -16370 0 0 {name=p153619 lab=_40648_/X }
C {devices/lab_pin.sym} 154500 -16410 0 1 {name=p153620 lab=_40649_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -16410 0 0 {name=X_40649_ }
C {sky130_stdcells/decap_3.sym} 154420 -16240 0 0 {name=XPHY_381 }
C {devices/lab_pin.sym} 154340 -16110 0 0 {name=p153621 lab=_71464_/X }
C {devices/lab_pin.sym} 154340 -16070 0 0 {name=p153622 lab=_83488_/Q }
C {devices/lab_pin.sym} 154340 -16030 0 0 {name=p153623 lab=_71468_/X }
C {devices/lab_pin.sym} 154500 -16070 0 1 {name=p153624 lab=_83488_/D }
C {sky130_stdcells/a21o_4.sym} 154420 -16070 0 0 {name=X_71469_ }
C {sky130_stdcells/decap_3.sym} 154420 -15900 0 0 {name=XPHY_392 }
C {devices/lab_pin.sym} 154340 -15770 0 0 {name=p153625 lab=_64006_/X }
C {devices/lab_pin.sym} 154340 -15730 0 0 {name=p153626 lab=_63994_/X }
C {devices/lab_pin.sym} 154340 -15690 0 0 {name=p153627 lab=_64009_/Y }
C {devices/lab_pin.sym} 154500 -15730 0 1 {name=p153628 lab=_64010_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -15730 0 0 {name=X_64010_ }
C {devices/lab_pin.sym} 154380 -15590 0 0 {name=p153629 lab=_72564_/A }
C {devices/lab_pin.sym} 154460 -15590 0 1 {name=p153630 lab=_61250_/B }
C {sky130_stdcells/buf_2.sym} 154420 -15590 0 0 {name=X_61222_ }
C {devices/lab_pin.sym} 154340 -15500 0 0 {name=p153631 lab=_73062_/X }
C {devices/lab_pin.sym} 154340 -15460 0 0 {name=p153632 lab=_86192_/Q }
C {devices/lab_pin.sym} 154340 -15420 0 0 {name=p153633 lab=_73205_/X }
C {devices/lab_pin.sym} 154340 -15380 0 0 {name=p153634 lab=_73207_/X }
C {devices/lab_pin.sym} 154500 -15440 0 1 {name=p153635 lab=_73208_/X }
C {sky130_stdcells/a211o_4.sym} 154420 -15440 0 0 {name=X_73208_ }
C {devices/lab_pin.sym} 154380 -15290 0 0 {name=p153636 lab=_46155_/X }
C {devices/lab_pin.sym} 154460 -15290 0 1 {name=p153637 lab=_46158_/B }
C {sky130_stdcells/buf_2.sym} 154420 -15290 0 0 {name=X_46156_ }
C {devices/lab_pin.sym} 154340 -15210 0 0 {name=p153638 lab=_43367_/X }
C {devices/lab_pin.sym} 154340 -15170 0 0 {name=p153639 lab=_43350_/X }
C {devices/lab_pin.sym} 154340 -15130 0 0 {name=p153640 lab=_41387_/X }
C {devices/lab_pin.sym} 154340 -15090 0 0 {name=p153641 lab=_87456_/Q }
C {devices/lab_pin.sym} 154340 -15050 0 0 {name=p153642 lab=_43353_/X }
C {devices/lab_pin.sym} 154500 -15130 0 1 {name=p153643 lab=_43369_/A }
C {sky130_stdcells/o32ai_4.sym} 154420 -15130 0 0 {name=X_43368_ }
C {devices/lab_pin.sym} 154340 -14990 0 0 {name=p153644 lab=_74185_/X }
C {devices/lab_pin.sym} 154340 -14950 0 0 {name=p153645 lab=_74187_/X }
C {devices/lab_pin.sym} 154340 -14910 0 0 {name=p153646 lab=_73602_/X }
C {devices/lab_pin.sym} 154500 -14950 0 1 {name=p153647 lab=_74188_/X }
C {sky130_stdcells/a21o_4.sym} 154420 -14950 0 0 {name=X_74188_ }
C {devices/lab_pin.sym} 154380 -14810 0 0 {name=p153648 lab=_45107_/A }
C {devices/lab_pin.sym} 154460 -14810 0 1 {name=p153649 lab=_45108_/A }
C {sky130_stdcells/inv_2.sym} 154420 -14810 0 0 {name=X_45107_ }
C {devices/lab_pin.sym} 154380 -14690 0 0 {name=p153650 lab=_42397_/A }
C {devices/lab_pin.sym} 154460 -14690 0 1 {name=p153651 lab=_42319_/X }
C {sky130_stdcells/buf_2.sym} 154420 -14690 0 0 {name=X_42319_ }
C {devices/lab_pin.sym} 154340 -14600 0 0 {name=p153652 lab=_72963_/X }
C {devices/lab_pin.sym} 154340 -14560 0 0 {name=p153653 lab=_83067_/Q }
C {devices/lab_pin.sym} 154340 -14520 0 0 {name=p153654 lab=_73015_/X }
C {devices/lab_pin.sym} 154340 -14480 0 0 {name=p153655 lab=_73138_/X }
C {devices/lab_pin.sym} 154500 -14540 0 1 {name=p153656 lab=_73139_/X }
C {sky130_stdcells/a211o_4.sym} 154420 -14540 0 0 {name=X_73139_ }
C {devices/lab_pin.sym} 154360 -14410 0 0 {name=p153657 lab=_61153_/A }
C {devices/lab_pin.sym} 154360 -14370 0 0 {name=p153658 lab=_61108_/Y }
C {devices/lab_pin.sym} 154360 -14330 0 0 {name=p153659 lab=_61153_/C }
C {devices/lab_pin.sym} 154480 -14370 0 1 {name=p153660 lab=_61272_/B }
C {sky130_stdcells/nand3_4.sym} 154420 -14370 0 0 {name=X_61153_ }
C {devices/lab_pin.sym} 154380 -14230 0 0 {name=p153661 lab=_46087_/A }
C {devices/lab_pin.sym} 154460 -14230 0 1 {name=p153662 lab=_46089_/C }
C {sky130_stdcells/inv_2.sym} 154420 -14230 0 0 {name=X_46087_ }
C {devices/lab_pin.sym} 154340 -14140 0 0 {name=p153663 lab=_41199_/X }
C {devices/lab_pin.sym} 154340 -14100 0 0 {name=p153664 lab=_43287_/X }
C {devices/lab_pin.sym} 154340 -14060 0 0 {name=p153665 lab=_87491_/Q }
C {devices/lab_pin.sym} 154340 -14020 0 0 {name=p153666 lab=_43288_/X }
C {devices/lab_pin.sym} 154500 -14080 0 1 {name=p153667 lab=_43299_/X }
C {sky130_stdcells/a2bb2o_4.sym} 154420 -14080 0 0 {name=X_43299_ }
C {devices/lab_pin.sym} 154360 -13940 0 0 {name=p153668 lab=_82823_/Q }
C {devices/lab_pin.sym} 154360 -13900 0 0 {name=p153669 lab=_82535_/Q }
C {devices/lab_pin.sym} 154480 -13920 0 1 {name=p153670 lab=_78997_/B }
C {sky130_stdcells/xnor2_4.sym} 154420 -13920 0 0 {name=X_78996_ }
C {devices/lab_pin.sym} 154340 -13830 0 0 {name=p153671 lab=_59971_/X }
C {devices/lab_pin.sym} 154340 -13790 0 0 {name=p153672 lab=_60099_/X }
C {devices/lab_pin.sym} 154340 -13750 0 0 {name=p153673 lab=_60102_/Y }
C {devices/lab_pin.sym} 154340 -13710 0 0 {name=p153674 lab=_60072_/Y }
C {devices/lab_pin.sym} 154340 -13680 0 0 {name=p153675 lab=_60103_/Y }
C {devices/lab_pin.sym} 154500 -13750 0 1 {name=p153676 lab=_84661_/D }
C {sky130_stdcells/a41oi_4.sym} 154420 -13750 0 0 {name=X_60104_ }
C {devices/lab_pin.sym} 154380 -13590 0 0 {name=p153677 lab=_49915_/A }
C {devices/lab_pin.sym} 154460 -13590 0 1 {name=p153678 lab=_49915_/X }
C {sky130_stdcells/buf_2.sym} 154420 -13590 0 0 {name=X_49915_ }
C {devices/lab_pin.sym} 154340 -13490 0 0 {name=p153679 lab=_55908_/B }
C {devices/lab_pin.sym} 154340 -13450 0 0 {name=p153680 lab=_44979_/X }
C {devices/lab_pin.sym} 154340 -13410 0 0 {name=p153681 lab=_45012_/X }
C {devices/lab_pin.sym} 154500 -13450 0 1 {name=p153682 lab=_45038_/X }
C {sky130_stdcells/o21a_4.sym} 154420 -13450 0 0 {name=X_45038_ }
C {devices/lab_pin.sym} 154380 -13310 0 0 {name=p153683 lab=_65614_/A }
C {devices/lab_pin.sym} 154460 -13310 0 1 {name=p153684 lab=_65961_/X }
C {sky130_stdcells/buf_2.sym} 154420 -13310 0 0 {name=X_65961_ }
C {devices/lab_pin.sym} 154380 -13190 0 0 {name=p153685 lab=_64367_/A }
C {devices/lab_pin.sym} 154460 -13190 0 1 {name=p153686 lab=_64249_/A }
C {sky130_stdcells/buf_2.sym} 154420 -13190 0 0 {name=X_61084_ }
C {devices/lab_pin.sym} 154340 -13100 0 0 {name=p153687 lab=_77935_/Y }
C {devices/lab_pin.sym} 154340 -13060 0 0 {name=p153688 lab=_77946_/A }
C {devices/lab_pin.sym} 154340 -13020 0 0 {name=p153689 lab=_82072_/Q }
C {devices/lab_pin.sym} 154340 -12980 0 0 {name=p153690 lab=_81944_/D }
C {devices/lab_pin.sym} 154500 -13040 0 1 {name=p153691 lab=_77947_/X }
C {sky130_stdcells/a2bb2o_4.sym} 154420 -13040 0 0 {name=X_77947_ }
C {devices/lab_pin.sym} 154360 -12900 0 0 {name=p153692 lab=_67793_/A }
C {devices/lab_pin.sym} 154360 -12860 0 0 {name=p153693 lab=_67700_/B }
C {devices/lab_pin.sym} 154480 -12880 0 1 {name=p153694 lab=_67700_/X }
C {sky130_stdcells/and2_4.sym} 154420 -12880 0 0 {name=X_67700_ }
C {devices/lab_pin.sym} 154360 -12760 0 0 {name=p153695 lab=_64901_/Y }
C {devices/lab_pin.sym} 154360 -12720 0 0 {name=p153696 lab=_64911_/Y }
C {devices/lab_pin.sym} 154480 -12740 0 1 {name=p153697 lab=_64912_/Y }
C {sky130_stdcells/nand2_4.sym} 154420 -12740 0 0 {name=X_64912_ }
C {devices/lab_pin.sym} 154380 -12610 0 0 {name=p153698 lab=_60034_/X }
C {devices/lab_pin.sym} 154460 -12610 0 1 {name=p153699 lab=_64689_/A }
C {sky130_stdcells/buf_2.sym} 154420 -12610 0 0 {name=X_60035_ }
C {devices/lab_pin.sym} 154360 -12520 0 0 {name=p153700 lab=_49851_/A }
C {devices/lab_pin.sym} 154360 -12480 0 0 {name=p153701 lab=_49851_/B }
C {devices/lab_pin.sym} 154360 -12440 0 0 {name=p153702 lab=_49830_/C }
C {devices/lab_pin.sym} 154360 -12400 0 0 {name=p153703 lab=_53058_/D }
C {devices/lab_pin.sym} 154480 -12460 0 1 {name=p153704 lab=_49846_/X }
C {sky130_stdcells/and4_4.sym} 154420 -12460 0 0 {name=X_49846_ }
C {devices/lab_pin.sym} 154340 -12340 0 0 {name=p153705 lab=_88007_/Q }
C {devices/lab_pin.sym} 154340 -12300 0 0 {name=p153706 lab=_68650_/X }
C {devices/lab_pin.sym} 154340 -12260 0 0 {name=p153707 lab=_68651_/X }
C {devices/lab_pin.sym} 154340 -12220 0 0 {name=p153708 lab=_68679_/X }
C {devices/lab_pin.sym} 154500 -12280 0 1 {name=p153709 lab=_68680_/X }
C {sky130_stdcells/a211o_4.sym} 154420 -12280 0 0 {name=X_68680_ }
C {devices/lab_pin.sym} 154360 -12140 0 0 {name=p153710 lab=_65807_/A }
C {devices/lab_pin.sym} 154360 -12100 0 0 {name=p153711 lab=_86466_/Q }
C {devices/lab_pin.sym} 154480 -12120 0 1 {name=p153712 lab=_65892_/X }
C {sky130_stdcells/and2_4.sym} 154420 -12120 0 0 {name=X_65892_ }
C {devices/lab_pin.sym} 154340 -12010 0 0 {name=p153713 lab=_82065_/Q }
C {devices/lab_pin.sym} 154340 -11970 0 0 {name=p153714 lab=_77876_/Y }
C {devices/lab_pin.sym} 154340 -11930 0 0 {name=p153715 lab=_77877_/X }
C {devices/lab_pin.sym} 154500 -11970 0 1 {name=p153716 lab=_77878_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -11970 0 0 {name=X_77878_ }
C {devices/lab_pin.sym} 154340 -11850 0 0 {name=p153717 lab=_67627_/X }
C {devices/lab_pin.sym} 154340 -11810 0 0 {name=p153718 lab=_67630_/X }
C {devices/lab_pin.sym} 154340 -11770 0 0 {name=p153719 lab=_67561_/X }
C {devices/lab_pin.sym} 154500 -11810 0 1 {name=p153720 lab=_67631_/X }
C {sky130_stdcells/a21o_4.sym} 154420 -11810 0 0 {name=X_67631_ }
C {devices/lab_pin.sym} 154340 -11690 0 0 {name=p153721 lab=_79603_/Y }
C {devices/lab_pin.sym} 154340 -11650 0 0 {name=p153722 lab=_79609_/A }
C {devices/lab_pin.sym} 154340 -11610 0 0 {name=p153723 lab=_79616_/Y }
C {devices/lab_pin.sym} 154500 -11650 0 1 {name=p153724 lab=_79619_/A }
C {sky130_stdcells/a21o_4.sym} 154420 -11650 0 0 {name=X_79617_ }
C {devices/lab_pin.sym} 154340 -11530 0 0 {name=p153725 lab=_64839_/Y }
C {devices/lab_pin.sym} 154340 -11490 0 0 {name=p153726 lab=_64814_/X }
C {devices/lab_pin.sym} 154340 -11450 0 0 {name=p153727 lab=_64842_/Y }
C {devices/lab_pin.sym} 154500 -11490 0 1 {name=p153728 lab=_84225_/D }
C {sky130_stdcells/a21o_4.sym} 154420 -11490 0 0 {name=X_64843_ }
C {devices/lab_pin.sym} 154360 -11360 0 0 {name=p153729 lab=_76829_/A }
C {devices/lab_pin.sym} 154360 -11320 0 0 {name=p153730 lab=_76828_/Y }
C {devices/lab_pin.sym} 154480 -11340 0 1 {name=p153731 lab=_76837_/A }
C {sky130_stdcells/xor2_4.sym} 154420 -11340 0 0 {name=X_76829_ }
C {devices/lab_pin.sym} 154380 -11210 0 0 {name=p153732 lab=_51012_/A }
C {devices/lab_pin.sym} 154460 -11210 0 1 {name=p153733 lab=_49861_/A }
C {sky130_stdcells/buf_2.sym} 154420 -11210 0 0 {name=X_49777_ }
C {devices/lab_pin.sym} 154380 -11090 0 0 {name=p153734 lab=_82394_/Q }
C {devices/lab_pin.sym} 154460 -11090 0 1 {name=p153735 lab=_46990_/A }
C {sky130_stdcells/inv_2.sym} 154420 -11090 0 0 {name=X_46989_ }
C {devices/lab_pin.sym} 154360 -10990 0 0 {name=p153736 lab=_53636_/A }
C {devices/lab_pin.sym} 154360 -10950 0 0 {name=p153737 lab=_48099_/X }
C {devices/lab_pin.sym} 154360 -10910 0 0 {name=p153738 lab=_48761_/C }
C {devices/lab_pin.sym} 154480 -10950 0 1 {name=p153739 lab=_48728_/X }
C {sky130_stdcells/and3_4.sym} 154420 -10950 0 0 {name=X_48728_ }
C {devices/lab_pin.sym} 154340 -10830 0 0 {name=p153740 lab=_67557_/X }
C {devices/lab_pin.sym} 154340 -10790 0 0 {name=p153741 lab=_67560_/X }
C {devices/lab_pin.sym} 154340 -10750 0 0 {name=p153742 lab=_67561_/X }
C {devices/lab_pin.sym} 154500 -10790 0 1 {name=p153743 lab=_67562_/X }
C {sky130_stdcells/a21o_4.sym} 154420 -10790 0 0 {name=X_67562_ }
C {devices/lab_pin.sym} 154340 -10670 0 0 {name=p153744 lab=_79545_/B }
C {devices/lab_pin.sym} 154340 -10630 0 0 {name=p153745 lab=_79534_/Y }
C {devices/lab_pin.sym} 154340 -10590 0 0 {name=p153746 lab=_79542_/Y }
C {devices/lab_pin.sym} 154500 -10630 0 1 {name=p153747 lab=_79548_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -10630 0 0 {name=X_79548_ }
C {devices/lab_pin.sym} 154340 -10520 0 0 {name=p153748 lab=_64577_/X }
C {devices/lab_pin.sym} 154340 -10480 0 0 {name=p153749 lab=_83307_/Q }
C {devices/lab_pin.sym} 154340 -10440 0 0 {name=p153750 lab=_64772_/X }
C {devices/lab_pin.sym} 154340 -10400 0 0 {name=p153751 lab=_64773_/X }
C {devices/lab_pin.sym} 154500 -10460 0 1 {name=p153752 lab=_64775_/B }
C {sky130_stdcells/a211o_4.sym} 154420 -10460 0 0 {name=X_64774_ }
C {devices/lab_pin.sym} 154360 -10340 0 0 {name=p153753 lab=_63561_/B }
C {devices/lab_pin.sym} 154360 -10300 0 0 {name=p153754 lab=_61924_/B }
C {devices/lab_pin.sym} 154360 -10260 0 0 {name=p153755 lab=_61971_/C }
C {devices/lab_pin.sym} 154360 -10220 0 0 {name=p153756 lab=_61971_/D }
C {devices/lab_pin.sym} 154480 -10280 0 1 {name=p153757 lab=_61986_/Y }
C {sky130_stdcells/nand4_4.sym} 154420 -10280 0 0 {name=X_61986_ }
C {devices/lab_pin.sym} 154380 -10130 0 0 {name=p153758 lab=_68742_/A }
C {devices/lab_pin.sym} 154460 -10130 0 1 {name=p153759 lab=_69302_/A }
C {sky130_stdcells/buf_2.sym} 154420 -10130 0 0 {name=X_69301_ }
C {devices/lab_pin.sym} 154380 -10010 0 0 {name=p153760 lab=_84108_/Q }
C {devices/lab_pin.sym} 154460 -10010 0 1 {name=p153761 lab=_66514_/C }
C {sky130_stdcells/inv_2.sym} 154420 -10010 0 0 {name=X_66513_ }
C {devices/lab_pin.sym} 154380 -9890 0 0 {name=p153762 lab=clkbuf_8_53_0_CLK/A }
C {devices/lab_pin.sym} 154460 -9890 0 1 {name=p153763 lab=clkbuf_8_52_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 154420 -9890 0 0 {name=Xclkbuf_8_52_0_CLK }
C {devices/lab_pin.sym} 154380 -9770 0 0 {name=p153764 lab=_60855_/X }
C {devices/lab_pin.sym} 154460 -9770 0 1 {name=p153765 lab=_64189_/D }
C {sky130_stdcells/buf_2.sym} 154420 -9770 0 0 {name=X_63725_ }
C {devices/lab_pin.sym} 154380 -9650 0 0 {name=p153766 lab=_48659_/A }
C {devices/lab_pin.sym} 154460 -9650 0 1 {name=p153767 lab=_48660_/A }
C {sky130_stdcells/inv_2.sym} 154420 -9650 0 0 {name=X_48659_ }
C {devices/lab_pin.sym} 154360 -9550 0 0 {name=p153768 lab=_60891_/Y }
C {devices/lab_pin.sym} 154360 -9510 0 0 {name=p153769 lab=_60937_/B }
C {devices/lab_pin.sym} 154360 -9470 0 0 {name=p153770 lab=_60988_/A }
C {devices/lab_pin.sym} 154480 -9510 0 1 {name=p153771 lab=_60938_/A }
C {sky130_stdcells/nand3_4.sym} 154420 -9510 0 0 {name=X_60937_ }
C {devices/lab_pin.sym} 154340 -9400 0 0 {name=p153772 lab=_67305_/X }
C {devices/lab_pin.sym} 154340 -9360 0 0 {name=p153773 lab=_67484_/Y }
C {devices/lab_pin.sym} 154340 -9320 0 0 {name=p153774 lab=_67390_/X }
C {devices/lab_pin.sym} 154340 -9280 0 0 {name=p153775 lab=_67492_/Y }
C {devices/lab_pin.sym} 154500 -9340 0 1 {name=p153776 lab=_67493_/X }
C {sky130_stdcells/a211o_4.sym} 154420 -9340 0 0 {name=X_67493_ }
C {devices/lab_pin.sym} 154380 -9190 0 0 {name=p153777 lab=_79505_/A }
C {devices/lab_pin.sym} 154460 -9190 0 1 {name=p153778 lab=_79489_/A }
C {sky130_stdcells/inv_2.sym} 154420 -9190 0 0 {name=X_79479_ }
C {devices/lab_pin.sym} 154330 -9070 0 0 {name=p153779 lab=_84087_/CLK }
C {devices/lab_pin.sym} 154330 -9050 0 0 {name=p153780 lab=_76200_/B }
C {devices/lab_pin.sym} 154510 -9070 0 1 {name=p153781 lab=_75950_/A }
C {sky130_stdcells/dfxtp_4.sym} 154420 -9060 0 0 {name=X_81510_ }
C {devices/lab_pin.sym} 154380 -8930 0 0 {name=p153782 lab=_69478_/A }
C {devices/lab_pin.sym} 154460 -8930 0 1 {name=p153783 lab=_69232_/X }
C {sky130_stdcells/buf_2.sym} 154420 -8930 0 0 {name=X_69232_ }
C {devices/lab_pin.sym} 154380 -8810 0 0 {name=p153784 lab=_84122_/Q }
C {devices/lab_pin.sym} 154460 -8810 0 1 {name=p153785 lab=_66445_/C }
C {sky130_stdcells/inv_2.sym} 154420 -8810 0 0 {name=X_66444_ }
C {devices/lab_pin.sym} 154340 -8710 0 0 {name=p153786 lab=_51666_/Y }
C {devices/lab_pin.sym} 154340 -8670 0 0 {name=p153787 lab=_51667_/X }
C {devices/lab_pin.sym} 154340 -8630 0 0 {name=p153788 lab=_51669_/X }
C {devices/lab_pin.sym} 154500 -8670 0 1 {name=p153789 lab=_51670_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -8670 0 0 {name=X_51670_ }
C {devices/lab_pin.sym} 154340 -8560 0 0 {name=p153790 lab=_59427_/Y }
C {devices/lab_pin.sym} 154340 -8520 0 0 {name=p153791 lab=_63626_/X }
C {devices/lab_pin.sym} 154340 -8480 0 0 {name=p153792 lab=_61630_/A }
C {devices/lab_pin.sym} 154340 -8440 0 0 {name=p153793 lab=_63627_/X }
C {devices/lab_pin.sym} 154500 -8500 0 1 {name=p153794 lab=_63656_/X }
C {sky130_stdcells/a2bb2o_4.sym} 154420 -8500 0 0 {name=X_63656_ }
C {devices/lab_pin.sym} 154330 -8350 0 0 {name=p153795 lab=_82491_/CLK }
C {devices/lab_pin.sym} 154330 -8330 0 0 {name=p153796 lab=_78676_/X }
C {devices/lab_pin.sym} 154510 -8350 0 1 {name=p153797 lab=_78199_/B }
C {sky130_stdcells/dfxtp_4.sym} 154420 -8340 0 0 {name=X_82490_ }
C {devices/lab_pin.sym} 154380 -8210 0 0 {name=p153798 lab=_60867_/Y }
C {devices/lab_pin.sym} 154460 -8210 0 1 {name=p153799 lab=_60930_/A }
C {sky130_stdcells/buf_2.sym} 154420 -8210 0 0 {name=X_60868_ }
C {sky130_stdcells/decap_3.sym} 154420 -8060 0 0 {name=XPHY_18 }
C {sky130_stdcells/decap_3.sym} 154420 -7880 0 0 {name=XPHY_29 }
C {devices/lab_pin.sym} 154340 -7750 0 0 {name=p153800 lab=_50618_/Y }
C {devices/lab_pin.sym} 154340 -7710 0 0 {name=p153801 lab=_50619_/X }
C {devices/lab_pin.sym} 154340 -7670 0 0 {name=p153802 lab=_50620_/Y }
C {devices/lab_pin.sym} 154500 -7710 0 1 {name=p153803 lab=_50621_/Y }
C {sky130_stdcells/a21boi_4.sym} 154420 -7710 0 0 {name=X_50621_ }
C {devices/lab_pin.sym} 154340 -7590 0 0 {name=p153804 lab=_62603_/Y }
C {devices/lab_pin.sym} 154340 -7550 0 0 {name=p153805 lab=_62593_/X }
C {devices/lab_pin.sym} 154340 -7510 0 0 {name=p153806 lab=_62606_/Y }
C {devices/lab_pin.sym} 154500 -7550 0 1 {name=p153807 lab=_84397_/D }
C {sky130_stdcells/a21oi_4.sym} 154420 -7550 0 0 {name=X_62607_ }
C {devices/lab_pin.sym} 154330 -7410 0 0 {name=p153808 lab=_83940_/CLK }
C {devices/lab_pin.sym} 154330 -7390 0 0 {name=p153809 lab=_81473_/Q }
C {devices/lab_pin.sym} 154510 -7410 0 1 {name=p153810 lab=_76146_/B }
C {sky130_stdcells/dfxtp_4.sym} 154420 -7400 0 0 {name=X_81441_ }
C {devices/lab_pin.sym} 154360 -7280 0 0 {name=p153811 lab=_69067_/A }
C {devices/lab_pin.sym} 154360 -7240 0 0 {name=p153812 lab=_87793_/Q }
C {devices/lab_pin.sym} 154480 -7260 0 1 {name=p153813 lab=_69163_/X }
C {sky130_stdcells/and2_4.sym} 154420 -7260 0 0 {name=X_69163_ }
C {devices/lab_pin.sym} 154360 -7150 0 0 {name=p153814 lab=_65949_/X }
C {devices/lab_pin.sym} 154360 -7110 0 0 {name=p153815 lab=_66367_/B }
C {devices/lab_pin.sym} 154360 -7070 0 0 {name=p153816 lab=_65952_/X }
C {devices/lab_pin.sym} 154480 -7110 0 1 {name=p153817 lab=_66375_/Y }
C {sky130_stdcells/nand3_4.sym} 154420 -7110 0 0 {name=X_66375_ }
C {devices/lab_pin.sym} 154340 -7000 0 0 {name=p153818 lab=_61548_/B }
C {devices/lab_pin.sym} 154340 -6960 0 0 {name=p153819 lab=_63548_/X }
C {devices/lab_pin.sym} 154340 -6920 0 0 {name=p153820 lab=_63585_/X }
C {devices/lab_pin.sym} 154340 -6880 0 0 {name=p153821 lab=_63586_/Y }
C {devices/lab_pin.sym} 154500 -6940 0 1 {name=p153822 lab=_63587_/X }
C {sky130_stdcells/a211o_4.sym} 154420 -6940 0 0 {name=X_63587_ }
C {devices/lab_pin.sym} 154340 -6830 0 0 {name=p153823 lab=_60798_/X }
C {devices/lab_pin.sym} 154340 -6790 0 0 {name=p153824 lab=_60736_/X }
C {devices/lab_pin.sym} 154340 -6750 0 0 {name=p153825 lab=_63374_/A }
C {devices/lab_pin.sym} 154340 -6710 0 0 {name=p153826 lab=_60767_/X }
C {devices/lab_pin.sym} 154340 -6670 0 0 {name=p153827 lab=_60758_/X }
C {devices/lab_pin.sym} 154500 -6750 0 1 {name=p153828 lab=_60799_/X }
C {sky130_stdcells/a2111o_4.sym} 154420 -6750 0 0 {name=X_60799_ }
C {devices/lab_pin.sym} 154380 -6590 0 0 {name=p153829 lab=clkbuf_8_67_0_CLK/A }
C {devices/lab_pin.sym} 154460 -6590 0 1 {name=p153830 lab=clkbuf_8_67_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 154420 -6590 0 0 {name=Xclkbuf_8_67_0_CLK }
C {devices/lab_pin.sym} 154340 -6490 0 0 {name=p153831 lab=_66727_/X }
C {devices/lab_pin.sym} 154340 -6450 0 0 {name=p153832 lab=_66729_/X }
C {devices/lab_pin.sym} 154340 -6410 0 0 {name=p153833 lab=_68106_/X }
C {devices/lab_pin.sym} 154500 -6450 0 1 {name=p153834 lab=_68114_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -6450 0 0 {name=X_68114_ }
C {devices/lab_pin.sym} 154340 -6330 0 0 {name=p153835 lab=_53337_/Y }
C {devices/lab_pin.sym} 154340 -6290 0 0 {name=p153836 lab=_53328_/X }
C {devices/lab_pin.sym} 154340 -6250 0 0 {name=p153837 lab=_53339_/X }
C {devices/lab_pin.sym} 154500 -6290 0 1 {name=p153838 lab=_85652_/D }
C {sky130_stdcells/a21oi_4.sym} 154420 -6290 0 0 {name=X_53340_ }
C {devices/lab_pin.sym} 154380 -6150 0 0 {name=p153839 lab=_65669_/A }
C {devices/lab_pin.sym} 154460 -6150 0 1 {name=p153840 lab=_65326_/X }
C {sky130_stdcells/buf_2.sym} 154420 -6150 0 0 {name=X_65326_ }
C {devices/lab_pin.sym} 154330 -6030 0 0 {name=p153841 lab=_84161_/CLK }
C {devices/lab_pin.sym} 154330 -6010 0 0 {name=p153842 lab=_84160_/D }
C {devices/lab_pin.sym} 154510 -6030 0 1 {name=p153843 lab=_84160_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -6020 0 0 {name=X_84160_ }
C {devices/lab_pin.sym} 154360 -5910 0 0 {name=p153844 lab=_48702_/A }
C {devices/lab_pin.sym} 154360 -5870 0 0 {name=p153845 lab=_50552_/B }
C {devices/lab_pin.sym} 154360 -5830 0 0 {name=p153846 lab=_50552_/C }
C {devices/lab_pin.sym} 154480 -5870 0 1 {name=p153847 lab=_50552_/X }
C {sky130_stdcells/and3_4.sym} 154420 -5870 0 0 {name=X_50552_ }
C {devices/lab_pin.sym} 154340 -5770 0 0 {name=p153848 lab=_61590_/B }
C {devices/lab_pin.sym} 154340 -5730 0 0 {name=p153849 lab=_62462_/X }
C {devices/lab_pin.sym} 154340 -5690 0 0 {name=p153850 lab=_62507_/X }
C {devices/lab_pin.sym} 154340 -5650 0 0 {name=p153851 lab=_62478_/X }
C {devices/lab_pin.sym} 154340 -5620 0 0 {name=p153852 lab=_62537_/X }
C {devices/lab_pin.sym} 154500 -5690 0 1 {name=p153853 lab=_62538_/X }
C {sky130_stdcells/a41o_4.sym} 154420 -5690 0 0 {name=X_62538_ }
C {devices/lab_pin.sym} 154330 -5530 0 0 {name=p153854 lab=_81482_/CLK }
C {devices/lab_pin.sym} 154330 -5510 0 0 {name=p153855 lab=_76884_/X }
C {devices/lab_pin.sym} 154510 -5530 0 1 {name=p153856 lab=_81372_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -5520 0 0 {name=X_81372_ }
C {devices/lab_pin.sym} 154360 -5400 0 0 {name=p153857 lab=_69091_/X }
C {devices/lab_pin.sym} 154360 -5360 0 0 {name=p153858 lab=_69093_/X }
C {devices/lab_pin.sym} 154480 -5380 0 1 {name=p153859 lab=_69094_/Y }
C {sky130_stdcells/nand2_4.sym} 154420 -5380 0 0 {name=X_69094_ }
C {devices/lab_pin.sym} 154330 -5250 0 0 {name=p153860 lab=_82998_/CLK }
C {devices/lab_pin.sym} 154330 -5230 0 0 {name=p153861 lab=_74292_/X }
C {devices/lab_pin.sym} 154510 -5250 0 1 {name=p153862 lab=_70273_/A }
C {sky130_stdcells/dfxtp_4.sym} 154420 -5240 0 0 {name=X_83111_ }
C {devices/lab_pin.sym} 154340 -5140 0 0 {name=p153863 lab=_87445_/Q }
C {devices/lab_pin.sym} 154340 -5100 0 0 {name=p153864 lab=_67953_/X }
C {devices/lab_pin.sym} 154340 -5060 0 0 {name=p153865 lab=_67954_/X }
C {devices/lab_pin.sym} 154340 -5020 0 0 {name=p153866 lab=_68044_/X }
C {devices/lab_pin.sym} 154500 -5080 0 1 {name=p153867 lab=_68045_/X }
C {sky130_stdcells/a211o_4.sym} 154420 -5080 0 0 {name=X_68045_ }
C {devices/lab_pin.sym} 154360 -4940 0 0 {name=p153868 lab=_80323_/A }
C {devices/lab_pin.sym} 154360 -4900 0 0 {name=p153869 lab=_80323_/B }
C {devices/lab_pin.sym} 154480 -4920 0 1 {name=p153870 lab=_80324_/A }
C {sky130_stdcells/xor2_4.sym} 154420 -4920 0 0 {name=X_80323_ }
C {devices/lab_pin.sym} 154340 -4810 0 0 {name=p153871 lab=_85664_/Q }
C {devices/lab_pin.sym} 154340 -4770 0 0 {name=p153872 lab=_53268_/X }
C {devices/lab_pin.sym} 154340 -4730 0 0 {name=p153873 lab=_53270_/Y }
C {devices/lab_pin.sym} 154500 -4770 0 1 {name=p153874 lab=_53271_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -4770 0 0 {name=X_53271_ }
C {devices/lab_pin.sym} 154380 -4630 0 0 {name=p153875 lab=_65791_/A }
C {devices/lab_pin.sym} 154460 -4630 0 1 {name=p153876 lab=_65258_/A }
C {sky130_stdcells/buf_2.sym} 154420 -4630 0 0 {name=X_65257_ }
C {devices/lab_pin.sym} 154330 -4510 0 0 {name=p153877 lab=_81507_/CLK }
C {devices/lab_pin.sym} 154330 -4490 0 0 {name=p153878 lab=_66924_/X }
C {devices/lab_pin.sym} 154510 -4510 0 1 {name=p153879 lab=_80915_/D }
C {sky130_stdcells/dfxtp_4.sym} 154420 -4500 0 0 {name=X_84091_ }
C {devices/lab_pin.sym} 154360 -4380 0 0 {name=p153880 lab=_50556_/A }
C {devices/lab_pin.sym} 154360 -4340 0 0 {name=p153881 lab=_52188_/B }
C {devices/lab_pin.sym} 154480 -4360 0 1 {name=p153882 lab=_50483_/Y }
C {sky130_stdcells/nand2_4.sym} 154420 -4360 0 0 {name=X_50483_ }
C {devices/lab_pin.sym} 154340 -4250 0 0 {name=p153883 lab=_62466_/Y }
C {devices/lab_pin.sym} 154340 -4210 0 0 {name=p153884 lab=_62467_/X }
C {devices/lab_pin.sym} 154340 -4170 0 0 {name=p153885 lab=_62468_/Y }
C {devices/lab_pin.sym} 154500 -4210 0 1 {name=p153886 lab=_62469_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -4210 0 0 {name=X_62469_ }
C {devices/lab_pin.sym} 154340 -4090 0 0 {name=p153887 lab=_55008_/Y }
C {devices/lab_pin.sym} 154340 -4050 0 0 {name=p153888 lab=_54998_/X }
C {devices/lab_pin.sym} 154340 -4010 0 0 {name=p153889 lab=_55009_/X }
C {devices/lab_pin.sym} 154500 -4050 0 1 {name=p153890 lab=_55010_/Y }
C {sky130_stdcells/a21oi_4.sym} 154420 -4050 0 0 {name=X_55010_ }
C {devices/lab_pin.sym} 154380 -3910 0 0 {name=p153891 lab=_52247_/A }
C {devices/lab_pin.sym} 154460 -3910 0 1 {name=p153892 lab=_52223_/C }
C {sky130_stdcells/buf_2.sym} 154420 -3910 0 0 {name=X_52222_ }
C {devices/lab_pin.sym} 154360 -3810 0 0 {name=p153893 lab=_64545_/A }
C {devices/lab_pin.sym} 154360 -3770 0 0 {name=p153894 lab=_61298_/B }
C {devices/lab_pin.sym} 154360 -3730 0 0 {name=p153895 lab=_64545_/C }
C {devices/lab_pin.sym} 154480 -3770 0 1 {name=p153896 lab=_64208_/Y }
C {sky130_stdcells/nand3_4.sym} 154420 -3770 0 0 {name=X_64208_ }
C {devices/lab_pin.sym} 154330 -3630 0 0 {name=p153897 lab=_85428_/CLK }
C {devices/lab_pin.sym} 154330 -3610 0 0 {name=p153898 lab=_74534_/Y }
C {devices/lab_pin.sym} 154510 -3630 0 1 {name=p153899 lab=_83042_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -3620 0 0 {name=X_83042_ }
C {devices/lab_pin.sym} 154360 -3500 0 0 {name=p153900 lab=_84952_/Q }
C {devices/lab_pin.sym} 154360 -3460 0 0 {name=p153901 lab=_65449_/C }
C {devices/lab_pin.sym} 154480 -3480 0 1 {name=p153902 lab=_80254_/Y }
C {sky130_stdcells/nand2_4.sym} 154420 -3480 0 0 {name=X_80254_ }
C {devices/lab_pin.sym} 154340 -3370 0 0 {name=p153903 lab=_65185_/X }
C {devices/lab_pin.sym} 154340 -3330 0 0 {name=p153904 lab=_65187_/X }
C {devices/lab_pin.sym} 154340 -3290 0 0 {name=p153905 lab=_64989_/X }
C {devices/lab_pin.sym} 154500 -3330 0 1 {name=p153906 lab=_65188_/X }
C {sky130_stdcells/a21o_4.sym} 154420 -3330 0 0 {name=X_65188_ }
C {devices/lab_pin.sym} 154380 -3190 0 0 {name=p153907 lab=_52215_/A }
C {devices/lab_pin.sym} 154460 -3190 0 1 {name=p153908 lab=_52168_/A }
C {sky130_stdcells/buf_2.sym} 154420 -3190 0 0 {name=X_52153_ }
C {devices/lab_pin.sym} 154380 -3070 0 0 {name=p153909 lab=_64508_/A }
C {devices/lab_pin.sym} 154460 -3070 0 1 {name=p153910 lab=_64187_/B }
C {sky130_stdcells/buf_2.sym} 154420 -3070 0 0 {name=X_64139_ }
C {devices/lab_pin.sym} 154330 -2950 0 0 {name=p153911 lab=_87850_/CLK }
C {devices/lab_pin.sym} 154330 -2930 0 0 {name=p153912 lab=_42482_/Y }
C {devices/lab_pin.sym} 154510 -2950 0 1 {name=p153913 lab=_68588_/A }
C {sky130_stdcells/dfxtp_4.sym} 154420 -2940 0 0 {name=X_87850_ }
C {devices/lab_pin.sym} 154360 -2820 0 0 {name=p153914 lab=_84947_/Q }
C {devices/lab_pin.sym} 154360 -2780 0 0 {name=p153915 lab=_65531_/C }
C {devices/lab_pin.sym} 154480 -2800 0 1 {name=p153916 lab=_80187_/A }
C {sky130_stdcells/xor2_4.sym} 154420 -2800 0 0 {name=X_80185_ }
C {devices/lab_pin.sym} 154360 -2690 0 0 {name=p153917 lab=_69993_/X }
C {devices/lab_pin.sym} 154360 -2650 0 0 {name=p153918 lab=_69995_/X }
C {devices/lab_pin.sym} 154360 -2610 0 0 {name=p153919 lab=_70021_/C }
C {devices/lab_pin.sym} 154480 -2650 0 1 {name=p153920 lab=_69996_/Y }
C {sky130_stdcells/nand3_4.sym} 154420 -2650 0 0 {name=X_69996_ }
C {devices/lab_pin.sym} 154340 -2530 0 0 {name=p153921 lab=_86073_/Q }
C {devices/lab_pin.sym} 154340 -2490 0 0 {name=p153922 lab=_51101_/X }
C {devices/lab_pin.sym} 154340 -2450 0 0 {name=p153923 lab=_51103_/Y }
C {devices/lab_pin.sym} 154500 -2490 0 1 {name=p153924 lab=_51104_/Y }
C {sky130_stdcells/o21ai_4.sym} 154420 -2490 0 0 {name=X_51104_ }
C {devices/lab_pin.sym} 154330 -2350 0 0 {name=p153925 lab=_87484_/CLK }
C {devices/lab_pin.sym} 154330 -2330 0 0 {name=p153926 lab=_46036_/X }
C {devices/lab_pin.sym} 154510 -2350 0 1 {name=p153927 lab=_66691_/B }
C {sky130_stdcells/dfxtp_4.sym} 154420 -2340 0 0 {name=X_86801_ }
C {devices/lab_pin.sym} 154340 -2230 0 0 {name=p153928 lab=_52082_/Y }
C {devices/lab_pin.sym} 154340 -2190 0 0 {name=p153929 lab=_52066_/X }
C {devices/lab_pin.sym} 154340 -2150 0 0 {name=p153930 lab=_52083_/Y }
C {devices/lab_pin.sym} 154500 -2190 0 1 {name=p153931 lab=_85892_/D }
C {sky130_stdcells/a21boi_4.sym} 154420 -2190 0 0 {name=X_52084_ }
C {devices/lab_pin.sym} 154360 -2070 0 0 {name=p153932 lab=_56960_/X }
C {devices/lab_pin.sym} 154360 -2030 0 0 {name=p153933 lab=_45549_/A }
C {devices/lab_pin.sym} 154360 -1990 0 0 {name=p153934 lab=_56953_/X }
C {devices/lab_pin.sym} 154480 -2030 0 1 {name=p153935 lab=_56961_/Y }
C {sky130_stdcells/nor3_4.sym} 154420 -2030 0 0 {name=X_56961_ }
C {devices/lab_pin.sym} 154380 -1890 0 0 {name=p153936 lab=_68377_/A }
C {devices/lab_pin.sym} 154460 -1890 0 1 {name=p153937 lab=_69485_/A }
C {sky130_stdcells/buf_2.sym} 154420 -1890 0 0 {name=X_68947_ }
C {devices/lab_pin.sym} 154330 -1770 0 0 {name=p153938 lab=_87782_/CLK }
C {devices/lab_pin.sym} 154330 -1750 0 0 {name=p153939 lab=_42664_/Y }
C {devices/lab_pin.sym} 154510 -1770 0 1 {name=p153940 lab=_87781_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -1760 0 0 {name=X_87781_ }
C {devices/lab_pin.sym} 154330 -1630 0 0 {name=p153941 lab=_85826_/CLK }
C {devices/lab_pin.sym} 154330 -1610 0 0 {name=p153942 lab=_57492_/Y }
C {devices/lab_pin.sym} 154510 -1630 0 1 {name=p153943 lab=_84993_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -1620 0 0 {name=X_84993_ }
C {devices/lab_pin.sym} 154360 -1500 0 0 {name=p153944 lab=_58700_/A }
C {devices/lab_pin.sym} 154360 -1460 0 0 {name=p153945 lab=_58688_/B }
C {devices/lab_pin.sym} 154480 -1480 0 1 {name=p153946 lab=_58700_/Y }
C {sky130_stdcells/nor2_4.sym} 154420 -1480 0 0 {name=X_58700_ }
C {devices/lab_pin.sym} 154340 -1370 0 0 {name=p153947 lab=_55909_/X }
C {devices/lab_pin.sym} 154340 -1330 0 0 {name=p153948 lab=_55911_/X }
C {devices/lab_pin.sym} 154340 -1290 0 0 {name=p153949 lab=_44115_/A }
C {devices/lab_pin.sym} 154500 -1330 0 1 {name=p153950 lab=_55912_/X }
C {sky130_stdcells/a21o_4.sym} 154420 -1330 0 0 {name=X_55912_ }
C {devices/lab_pin.sym} 154360 -1220 0 0 {name=p153951 lab=_51029_/A }
C {devices/lab_pin.sym} 154360 -1180 0 0 {name=p153952 lab=_51029_/B }
C {devices/lab_pin.sym} 154360 -1140 0 0 {name=p153953 lab=_51045_/C }
C {devices/lab_pin.sym} 154360 -1100 0 0 {name=p153954 lab=_52724_/D }
C {devices/lab_pin.sym} 154480 -1160 0 1 {name=p153955 lab=_51035_/X }
C {sky130_stdcells/and4_4.sym} 154420 -1160 0 0 {name=X_51035_ }
C {devices/lab_pin.sym} 154330 -1010 0 0 {name=p153956 lab=_86733_/CLK }
C {devices/lab_pin.sym} 154330 -990 0 0 {name=p153957 lab=_46499_/Y }
C {devices/lab_pin.sym} 154510 -1010 0 1 {name=p153958 lab=_86732_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -1000 0 0 {name=X_86732_ }
C {devices/lab_pin.sym} 154330 -870 0 0 {name=p153959 lab=_83944_/CLK }
C {devices/lab_pin.sym} 154330 -850 0 0 {name=p153960 lab=_83944_/D }
C {devices/lab_pin.sym} 154510 -870 0 1 {name=p153961 lab=_83944_/Q }
C {sky130_stdcells/dfxtp_4.sym} 154420 -860 0 0 {name=X_83944_ }
C {devices/lab_pin.sym} 154360 -750 0 0 {name=p153962 lab=_59680_/A }
C {devices/lab_pin.sym} 154360 -710 0 0 {name=p153963 lab=_59754_/D }
C {devices/lab_pin.sym} 154360 -670 0 0 {name=p153964 lab=_59687_/A }
C {devices/lab_pin.sym} 154480 -710 0 1 {name=p153965 lab=_59680_/Y }
C {sky130_stdcells/nand3_4.sym} 154420 -710 0 0 {name=X_59680_ }
C {devices/lab_pin.sym} 155280 -42180 0 0 {name=p153966 lab=_46173_/X }
C {devices/lab_pin.sym} 155280 -42140 0 0 {name=p153967 lab=_56892_/B }
C {devices/lab_pin.sym} 155280 -42100 0 0 {name=p153968 lab=_56892_/C }
C {devices/lab_pin.sym} 155280 -42060 0 0 {name=p153969 lab=_73939_/A }
C {devices/lab_pin.sym} 155400 -42120 0 1 {name=p153970 lab=_56892_/Y }
C {sky130_stdcells/nand4_4.sym} 155340 -42120 0 0 {name=X_56892_ }
C {devices/lab_pin.sym} 155300 -41970 0 0 {name=p153971 lab=_68660_/X }
C {devices/lab_pin.sym} 155380 -41970 0 1 {name=p153972 lab=_68878_/X }
C {sky130_stdcells/buf_2.sym} 155340 -41970 0 0 {name=X_68878_ }
C {devices/lab_pin.sym} 155300 -41850 0 0 {name=p153973 lab=_58631_/A }
C {devices/lab_pin.sym} 155380 -41850 0 1 {name=p153974 lab=_58631_/X }
C {sky130_stdcells/buf_2.sym} 155340 -41850 0 0 {name=X_58631_ }
C {devices/lab_pin.sym} 155280 -41740 0 0 {name=p153975 lab=_55843_/A }
C {devices/lab_pin.sym} 155280 -41700 0 0 {name=p153976 lab=_85296_/Q }
C {devices/lab_pin.sym} 155400 -41720 0 1 {name=p153977 lab=_55843_/X }
C {sky130_stdcells/and2_4.sym} 155340 -41720 0 0 {name=X_55843_ }
C {devices/lab_pin.sym} 155260 -41620 0 0 {name=p153978 lab=_67664_/X }
C {devices/lab_pin.sym} 155260 -41580 0 0 {name=p153979 lab=_67815_/Y }
C {devices/lab_pin.sym} 155260 -41540 0 0 {name=p153980 lab=_67747_/X }
C {devices/lab_pin.sym} 155260 -41500 0 0 {name=p153981 lab=_67828_/Y }
C {devices/lab_pin.sym} 155420 -41560 0 1 {name=p153982 lab=_67829_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -41560 0 0 {name=X_67829_ }
C {devices/lab_pin.sym} 155250 -41410 0 0 {name=p153983 lab=_86342_/CLK }
C {devices/lab_pin.sym} 155250 -41390 0 0 {name=p153984 lab=_47172_/Y }
C {devices/lab_pin.sym} 155430 -41410 0 1 {name=p153985 lab=_86663_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -41400 0 0 {name=X_86663_ }
C {devices/lab_pin.sym} 155250 -41270 0 0 {name=p153986 lab=_82557_/CLK }
C {devices/lab_pin.sym} 155250 -41250 0 0 {name=p153987 lab=_70004_/X }
C {devices/lab_pin.sym} 155430 -41270 0 1 {name=p153988 lab=_82555_/D }
C {sky130_stdcells/dfxtp_4.sym} 155340 -41260 0 0 {name=X_83875_ }
C {devices/lab_pin.sym} 155250 -41130 0 0 {name=p153989 lab=_86834_/CLK }
C {devices/lab_pin.sym} 155250 -41110 0 0 {name=p153990 lab=_88402_/D }
C {devices/lab_pin.sym} 155430 -41130 0 1 {name=p153991 lab=_88402_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -41120 0 0 {name=X_88402_ }
C {devices/lab_pin.sym} 155250 -40990 0 0 {name=p153992 lab=_86222_/CLK }
C {devices/lab_pin.sym} 155250 -40970 0 0 {name=p153993 lab=_85614_/D }
C {devices/lab_pin.sym} 155430 -40990 0 1 {name=p153994 lab=_85614_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -40980 0 0 {name=X_85614_ }
C {devices/lab_pin.sym} 155260 -40870 0 0 {name=p153995 lab=_50893_/B }
C {devices/lab_pin.sym} 155260 -40830 0 0 {name=p153996 lab=_70831_/X }
C {devices/lab_pin.sym} 155260 -40790 0 0 {name=p153997 lab=_70839_/Y }
C {devices/lab_pin.sym} 155420 -40830 0 1 {name=p153998 lab=_70840_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -40830 0 0 {name=X_70840_ }
C {devices/lab_pin.sym} 155280 -40700 0 0 {name=p153999 lab=_58562_/A }
C {devices/lab_pin.sym} 155280 -40660 0 0 {name=p154000 lab=_58973_/B }
C {devices/lab_pin.sym} 155400 -40680 0 1 {name=p154001 lab=_58562_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -40680 0 0 {name=X_58562_ }
C {devices/lab_pin.sym} 155250 -40550 0 0 {name=p154002 lab=_83167_/CLK }
C {devices/lab_pin.sym} 155250 -40530 0 0 {name=p154003 lab=_79275_/X }
C {devices/lab_pin.sym} 155430 -40550 0 1 {name=p154004 lab=_82826_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -40540 0 0 {name=X_82826_ }
C {devices/lab_pin.sym} 155280 -40420 0 0 {name=p154005 lab=_55711_/X }
C {devices/lab_pin.sym} 155280 -40380 0 0 {name=p154006 lab=_55774_/B }
C {devices/lab_pin.sym} 155400 -40400 0 1 {name=p154007 lab=_55774_/X }
C {sky130_stdcells/and2_4.sym} 155340 -40400 0 0 {name=X_55774_ }
C {devices/lab_pin.sym} 155250 -40270 0 0 {name=p154008 lab=_85955_/CLK }
C {devices/lab_pin.sym} 155250 -40250 0 0 {name=p154009 lab=_86594_/D }
C {devices/lab_pin.sym} 155430 -40270 0 1 {name=p154010 lab=_72476_/A }
C {sky130_stdcells/dfxtp_4.sym} 155340 -40260 0 0 {name=X_86594_ }
C {devices/lab_pin.sym} 155280 -40140 0 0 {name=p154011 lab=_52999_/A }
C {devices/lab_pin.sym} 155280 -40100 0 0 {name=p154012 lab=_52986_/B }
C {devices/lab_pin.sym} 155400 -40120 0 1 {name=p154013 lab=_52986_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -40120 0 0 {name=X_52986_ }
C {devices/lab_pin.sym} 155280 -40000 0 0 {name=p154014 lab=_57499_/A }
C {devices/lab_pin.sym} 155280 -39960 0 0 {name=p154015 lab=_73692_/A }
C {devices/lab_pin.sym} 155400 -39980 0 1 {name=p154016 lab=_57513_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -39980 0 0 {name=X_57513_ }
C {devices/lab_pin.sym} 155250 -39850 0 0 {name=p154017 lab=_84970_/CLK }
C {devices/lab_pin.sym} 155250 -39830 0 0 {name=p154018 lab=_88333_/D }
C {devices/lab_pin.sym} 155430 -39850 0 1 {name=p154019 lab=_88333_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -39840 0 0 {name=X_88333_ }
C {devices/lab_pin.sym} 155300 -39710 0 0 {name=p154020 lab=_54616_/X }
C {devices/lab_pin.sym} 155380 -39710 0 1 {name=p154021 lab=_54748_/A }
C {sky130_stdcells/buf_2.sym} 155340 -39710 0 0 {name=X_54725_ }
C {devices/lab_pin.sym} 155250 -39590 0 0 {name=p154022 lab=_85536_/CLK }
C {devices/lab_pin.sym} 155250 -39570 0 0 {name=p154023 lab=_85545_/D }
C {devices/lab_pin.sym} 155430 -39590 0 1 {name=p154024 lab=_85545_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -39580 0 0 {name=X_85545_ }
C {devices/lab_pin.sym} 155280 -39460 0 0 {name=p154025 lab=_51941_/A }
C {devices/lab_pin.sym} 155280 -39420 0 0 {name=p154026 lab=_48178_/X }
C {devices/lab_pin.sym} 155400 -39440 0 1 {name=p154027 lab=_51937_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -39440 0 0 {name=X_51937_ }
C {devices/lab_pin.sym} 155300 -39310 0 0 {name=p154028 lab=_70771_/A }
C {devices/lab_pin.sym} 155380 -39310 0 1 {name=p154029 lab=_70867_/A }
C {sky130_stdcells/buf_2.sym} 155340 -39310 0 0 {name=X_70771_ }
C {devices/lab_pin.sym} 155300 -39190 0 0 {name=p154030 lab=_83411_/Q }
C {devices/lab_pin.sym} 155380 -39190 0 1 {name=p154031 lab=_58493_/Y }
C {sky130_stdcells/inv_2.sym} 155340 -39190 0 0 {name=X_58493_ }
C {devices/lab_pin.sym} 155250 -39070 0 0 {name=p154032 lab=_86697_/CLK }
C {devices/lab_pin.sym} 155250 -39050 0 0 {name=p154033 lab=_78355_/Y }
C {devices/lab_pin.sym} 155430 -39070 0 1 {name=p154034 lab=_82757_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -39060 0 0 {name=X_82757_ }
C {devices/lab_pin.sym} 155280 -38960 0 0 {name=p154035 lab=_72607_/B }
C {devices/lab_pin.sym} 155280 -38920 0 0 {name=p154036 lab=_72516_/A }
C {devices/lab_pin.sym} 155280 -38880 0 0 {name=p154037 lab=_72510_/C }
C {devices/lab_pin.sym} 155280 -38840 0 0 {name=p154038 lab=_72515_/D }
C {devices/lab_pin.sym} 155400 -38900 0 1 {name=p154039 lab=_72510_/Y }
C {sky130_stdcells/nand4_4.sym} 155340 -38900 0 0 {name=X_72510_ }
C {devices/lab_pin.sym} 155260 -38770 0 0 {name=p154040 lab=_57441_/X }
C {devices/lab_pin.sym} 155260 -38730 0 0 {name=p154041 lab=_56801_/X }
C {devices/lab_pin.sym} 155260 -38690 0 0 {name=p154042 lab=_57443_/X }
C {devices/lab_pin.sym} 155420 -38730 0 1 {name=p154043 lab=_57444_/X }
C {sky130_stdcells/o21a_4.sym} 155340 -38730 0 0 {name=X_57444_ }
C {devices/lab_pin.sym} 155250 -38590 0 0 {name=p154044 lab=_81755_/CLK }
C {devices/lab_pin.sym} 155250 -38570 0 0 {name=p154045 lab=_81708_/D }
C {devices/lab_pin.sym} 155430 -38590 0 1 {name=p154046 lab=_41223_/A }
C {sky130_stdcells/dfxtp_4.sym} 155340 -38580 0 0 {name=X_81708_ }
C {devices/lab_pin.sym} 155250 -38450 0 0 {name=p154047 lab=_88268_/CLK }
C {devices/lab_pin.sym} 155250 -38430 0 0 {name=p154048 lab=_41170_/X }
C {devices/lab_pin.sym} 155430 -38450 0 1 {name=p154049 lab=_68658_/B }
C {sky130_stdcells/dfxtp_4.sym} 155340 -38440 0 0 {name=X_88264_ }
C {devices/lab_pin.sym} 155260 -38340 0 0 {name=p154050 lab=_41032_/X }
C {devices/lab_pin.sym} 155260 -38300 0 0 {name=p154051 lab=_42652_/X }
C {devices/lab_pin.sym} 155260 -38260 0 0 {name=p154052 lab=_87778_/Q }
C {devices/lab_pin.sym} 155260 -38220 0 0 {name=p154053 lab=_42653_/X }
C {devices/lab_pin.sym} 155420 -38280 0 1 {name=p154054 lab=_87778_/D }
C {sky130_stdcells/a2bb2o_4.sym} 155340 -38280 0 0 {name=X_42670_ }
C {devices/lab_pin.sym} 155300 -38130 0 0 {name=p154055 lab=_54245_/A }
C {devices/lab_pin.sym} 155380 -38130 0 1 {name=p154056 lab=_54656_/X }
C {sky130_stdcells/buf_2.sym} 155340 -38130 0 0 {name=X_54656_ }
C {devices/lab_pin.sym} 155260 -38030 0 0 {name=p154057 lab=_73485_/X }
C {devices/lab_pin.sym} 155260 -37990 0 0 {name=p154058 lab=_73488_/X }
C {devices/lab_pin.sym} 155260 -37950 0 0 {name=p154059 lab=_73489_/X }
C {devices/lab_pin.sym} 155420 -37990 0 1 {name=p154060 lab=_73494_/A }
C {sky130_stdcells/a21o_4.sym} 155340 -37990 0 0 {name=X_73490_ }
C {devices/lab_pin.sym} 155250 -37850 0 0 {name=p154061 lab=_84926_/CLK }
C {devices/lab_pin.sym} 155250 -37830 0 0 {name=p154062 lab=_54256_/Y }
C {devices/lab_pin.sym} 155430 -37850 0 1 {name=p154063 lab=_85476_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -37840 0 0 {name=X_85476_ }
C {devices/lab_pin.sym} 155260 -37730 0 0 {name=p154064 lab=_85931_/Q }
C {devices/lab_pin.sym} 155260 -37690 0 0 {name=p154065 lab=_51846_/X }
C {devices/lab_pin.sym} 155260 -37650 0 0 {name=p154066 lab=_51867_/Y }
C {devices/lab_pin.sym} 155420 -37690 0 1 {name=p154067 lab=_51868_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -37690 0 0 {name=X_51868_ }
C {devices/lab_pin.sym} 155250 -37550 0 0 {name=p154068 lab=_84111_/CLK }
C {devices/lab_pin.sym} 155250 -37530 0 0 {name=p154069 lab=_82700_/Q }
C {devices/lab_pin.sym} 155430 -37550 0 1 {name=p154070 lab=_82688_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -37540 0 0 {name=X_82688_ }
C {devices/lab_pin.sym} 155250 -37410 0 0 {name=p154071 lab=_87471_/CLK }
C {devices/lab_pin.sym} 155250 -37390 0 0 {name=p154072 lab=_43888_/X }
C {devices/lab_pin.sym} 155430 -37410 0 1 {name=p154073 lab=_67440_/B }
C {sky130_stdcells/dfxtp_4.sym} 155340 -37400 0 0 {name=X_87215_ }
C {devices/lab_pin.sym} 155260 -37290 0 0 {name=p154074 lab=_85603_/Q }
C {devices/lab_pin.sym} 155260 -37250 0 0 {name=p154075 lab=_53586_/X }
C {devices/lab_pin.sym} 155260 -37210 0 0 {name=p154076 lab=_53606_/Y }
C {devices/lab_pin.sym} 155420 -37250 0 1 {name=p154077 lab=_53607_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -37250 0 0 {name=X_53607_ }
C {devices/lab_pin.sym} 155300 -37110 0 0 {name=p154078 lab=_41620_/X }
C {devices/lab_pin.sym} 155380 -37110 0 1 {name=p154079 lab=_41621_/X }
C {sky130_stdcells/buf_2.sym} 155340 -37110 0 0 {name=X_41621_ }
C {devices/lab_pin.sym} 155260 -37010 0 0 {name=p154080 lab=_72389_/X }
C {devices/lab_pin.sym} 155260 -36970 0 0 {name=p154081 lab=_85670_/Q }
C {devices/lab_pin.sym} 155260 -36930 0 0 {name=p154082 lab=_72422_/X }
C {devices/lab_pin.sym} 155420 -36970 0 1 {name=p154083 lab=_72441_/X }
C {sky130_stdcells/o21a_4.sym} 155340 -36970 0 0 {name=X_72441_ }
C {devices/lab_pin.sym} 155250 -36830 0 0 {name=p154084 lab=_84426_/CLK }
C {devices/lab_pin.sym} 155250 -36810 0 0 {name=p154085 lab=_84427_/D }
C {devices/lab_pin.sym} 155430 -36830 0 1 {name=p154086 lab=_78050_/B }
C {sky130_stdcells/dfxtp_4.sym} 155340 -36820 0 0 {name=X_84427_ }
C {devices/lab_pin.sym} 155300 -36690 0 0 {name=p154087 lab=_50991_/A }
C {devices/lab_pin.sym} 155380 -36690 0 1 {name=p154088 lab=_50819_/X }
C {sky130_stdcells/buf_2.sym} 155340 -36690 0 0 {name=X_50819_ }
C {devices/lab_pin.sym} 155300 -36570 0 0 {name=p154089 lab=_73040_/A }
C {devices/lab_pin.sym} 155380 -36570 0 1 {name=p154090 lab=_73476_/A }
C {sky130_stdcells/buf_2.sym} 155340 -36570 0 0 {name=X_57375_ }
C {devices/lab_pin.sym} 155250 -36450 0 0 {name=p154091 lab=_81582_/CLK }
C {devices/lab_pin.sym} 155250 -36430 0 0 {name=p154092 lab=_81671_/Q }
C {devices/lab_pin.sym} 155430 -36450 0 1 {name=p154093 lab=_76234_/A }
C {sky130_stdcells/dfxtp_4.sym} 155340 -36440 0 0 {name=X_81639_ }
C {devices/lab_pin.sym} 155250 -36310 0 0 {name=p154094 lab=_87421_/CLK }
C {devices/lab_pin.sym} 155250 -36290 0 0 {name=p154095 lab=_88195_/D }
C {devices/lab_pin.sym} 155430 -36310 0 1 {name=p154096 lab=_66966_/B }
C {sky130_stdcells/dfxtp_4.sym} 155340 -36300 0 0 {name=X_88195_ }
C {devices/lab_pin.sym} 155280 -36180 0 0 {name=p154097 lab=_54578_/A }
C {devices/lab_pin.sym} 155280 -36140 0 0 {name=p154098 lab=_54587_/B }
C {devices/lab_pin.sym} 155400 -36160 0 1 {name=p154099 lab=_54587_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -36160 0 0 {name=X_54587_ }
C {devices/lab_pin.sym} 155260 -36050 0 0 {name=p154100 lab=_51797_/Y }
C {devices/lab_pin.sym} 155260 -36010 0 0 {name=p154101 lab=_51793_/X }
C {devices/lab_pin.sym} 155260 -35970 0 0 {name=p154102 lab=_51798_/X }
C {devices/lab_pin.sym} 155420 -36010 0 1 {name=p154103 lab=_85944_/D }
C {sky130_stdcells/a21oi_4.sym} 155340 -36010 0 0 {name=X_51799_ }
C {devices/lab_pin.sym} 155260 -35900 0 0 {name=p154104 lab=_59102_/Y }
C {devices/lab_pin.sym} 155260 -35860 0 0 {name=p154105 lab=_58857_/X }
C {devices/lab_pin.sym} 155260 -35820 0 0 {name=p154106 lab=_59109_/X }
C {devices/lab_pin.sym} 155260 -35780 0 0 {name=p154107 lab=_59113_/X }
C {devices/lab_pin.sym} 155420 -35840 0 1 {name=p154108 lab=_59114_/Y }
C {sky130_stdcells/a22oi_4.sym} 155340 -35840 0 0 {name=X_59114_ }
C {devices/lab_pin.sym} 155260 -35720 0 0 {name=p154109 lab=_41681_/X }
C {devices/lab_pin.sym} 155260 -35680 0 0 {name=p154110 lab=_44326_/X }
C {devices/lab_pin.sym} 155260 -35640 0 0 {name=p154111 lab=_87158_/Q }
C {devices/lab_pin.sym} 155260 -35600 0 0 {name=p154112 lab=_44327_/X }
C {devices/lab_pin.sym} 155420 -35660 0 1 {name=p154113 lab=_87158_/D }
C {sky130_stdcells/a2bb2o_4.sym} 155340 -35660 0 0 {name=X_44340_ }
C {devices/lab_pin.sym} 155280 -35530 0 0 {name=p154114 lab=_56332_/A }
C {devices/lab_pin.sym} 155280 -35490 0 0 {name=p154115 lab=_56335_/B }
C {devices/lab_pin.sym} 155280 -35450 0 0 {name=p154116 lab=_55855_/B }
C {devices/lab_pin.sym} 155400 -35490 0 1 {name=p154117 lab=_56326_/Y }
C {sky130_stdcells/nand3_4.sym} 155340 -35490 0 0 {name=X_56326_ }
C {devices/lab_pin.sym} 155260 -35370 0 0 {name=p154118 lab=_75155_/Y }
C {devices/lab_pin.sym} 155260 -35330 0 0 {name=p154119 lab=_75161_/B }
C {devices/lab_pin.sym} 155260 -35290 0 0 {name=p154120 lab=_75159_/Y }
C {devices/lab_pin.sym} 155420 -35330 0 1 {name=p154121 lab=_75162_/A }
C {sky130_stdcells/a21o_4.sym} 155340 -35330 0 0 {name=X_75160_ }
C {devices/lab_pin.sym} 155250 -35190 0 0 {name=p154122 lab=_87144_/CLK }
C {devices/lab_pin.sym} 155250 -35170 0 0 {name=p154123 lab=_44366_/X }
C {devices/lab_pin.sym} 155430 -35190 0 1 {name=p154124 lab=_87146_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -35180 0 0 {name=X_87146_ }
C {devices/lab_pin.sym} 155300 -35050 0 0 {name=p154125 lab=_41552_/A }
C {devices/lab_pin.sym} 155380 -35050 0 1 {name=p154126 lab=_41552_/X }
C {sky130_stdcells/buf_2.sym} 155340 -35050 0 0 {name=X_41552_ }
C {devices/lab_pin.sym} 155280 -34950 0 0 {name=p154127 lab=_50314_/A }
C {devices/lab_pin.sym} 155280 -34910 0 0 {name=p154128 lab=_53474_/B }
C {devices/lab_pin.sym} 155280 -34870 0 0 {name=p154129 lab=_53492_/X }
C {devices/lab_pin.sym} 155400 -34910 0 1 {name=p154130 lab=_53538_/X }
C {sky130_stdcells/and3_4.sym} 155340 -34910 0 0 {name=X_53538_ }
C {devices/lab_pin.sym} 155260 -34790 0 0 {name=p154131 lab=_72287_/X }
C {devices/lab_pin.sym} 155260 -34750 0 0 {name=p154132 lab=_85324_/Q }
C {devices/lab_pin.sym} 155260 -34710 0 0 {name=p154133 lab=_72324_/X }
C {devices/lab_pin.sym} 155420 -34750 0 1 {name=p154134 lab=_72372_/X }
C {sky130_stdcells/o21a_4.sym} 155340 -34750 0 0 {name=X_72372_ }
C {devices/lab_pin.sym} 155300 -34610 0 0 {name=p154135 lab=clkbuf_3_6_1_CLK/A }
C {devices/lab_pin.sym} 155380 -34610 0 1 {name=p154136 lab=clkbuf_3_6_1_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 155340 -34610 0 0 {name=Xclkbuf_3_6_1_CLK }
C {devices/lab_pin.sym} 155250 -34490 0 0 {name=p154137 lab=_84358_/CLK }
C {devices/lab_pin.sym} 155250 -34470 0 0 {name=p154138 lab=_63046_/X }
C {devices/lab_pin.sym} 155430 -34490 0 1 {name=p154139 lab=_79476_/A }
C {sky130_stdcells/dfxtp_4.sym} 155340 -34480 0 0 {name=X_84358_ }
C {devices/lab_pin.sym} 155260 -34370 0 0 {name=p154140 lab=_74105_/X }
C {devices/lab_pin.sym} 155260 -34330 0 0 {name=p154141 lab=_74110_/X }
C {devices/lab_pin.sym} 155260 -34290 0 0 {name=p154142 lab=_74085_/X }
C {devices/lab_pin.sym} 155420 -34330 0 1 {name=p154143 lab=_74111_/X }
C {sky130_stdcells/a21o_4.sym} 155340 -34330 0 0 {name=X_74111_ }
C {devices/lab_pin.sym} 155300 -34190 0 0 {name=p154144 lab=_40502_/Y }
C {devices/lab_pin.sym} 155380 -34190 0 1 {name=p154145 lab=_40503_/Y }
C {sky130_stdcells/inv_2.sym} 155340 -34190 0 0 {name=X_40503_ }
C {devices/lab_pin.sym} 155280 -34080 0 0 {name=p154146 lab=_86685_/Q }
C {devices/lab_pin.sym} 155280 -34040 0 0 {name=p154147 lab=_59008_/B }
C {devices/lab_pin.sym} 155400 -34060 0 1 {name=p154148 lab=_59045_/Y }
C {sky130_stdcells/nor2_4.sym} 155340 -34060 0 0 {name=X_59045_ }
C {devices/lab_pin.sym} 155280 -33950 0 0 {name=p154149 lab=_71323_/A }
C {devices/lab_pin.sym} 155280 -33910 0 0 {name=p154150 lab=_71314_/B }
C {devices/lab_pin.sym} 155280 -33870 0 0 {name=p154151 lab=_71297_/X }
C {devices/lab_pin.sym} 155400 -33910 0 1 {name=p154152 lab=_71323_/Y }
C {sky130_stdcells/nand3_4.sym} 155340 -33910 0 0 {name=X_71323_ }
C {devices/lab_pin.sym} 155250 -33770 0 0 {name=p154153 lab=_85547_/CLK }
C {devices/lab_pin.sym} 155250 -33750 0 0 {name=p154154 lab=_71980_/Y }
C {devices/lab_pin.sym} 155430 -33770 0 1 {name=p154155 lab=_83309_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -33760 0 0 {name=X_83309_ }
C {devices/lab_pin.sym} 155260 -33650 0 0 {name=p154156 lab=_56139_/X }
C {devices/lab_pin.sym} 155260 -33610 0 0 {name=p154157 lab=_56255_/X }
C {devices/lab_pin.sym} 155260 -33570 0 0 {name=p154158 lab=_56256_/Y }
C {devices/lab_pin.sym} 155420 -33610 0 1 {name=p154159 lab=_56257_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -33610 0 0 {name=X_56257_ }
C {devices/lab_pin.sym} 155300 -33470 0 0 {name=p154160 lab=_44270_/X }
C {devices/lab_pin.sym} 155380 -33470 0 1 {name=p154161 lab=_72896_/B }
C {sky130_stdcells/buf_2.sym} 155340 -33470 0 0 {name=X_44271_ }
C {devices/lab_pin.sym} 155280 -33370 0 0 {name=p154162 lab=_75091_/A }
C {devices/lab_pin.sym} 155280 -33330 0 0 {name=p154163 lab=_75091_/B }
C {devices/lab_pin.sym} 155280 -33290 0 0 {name=p154164 lab=_75102_/A }
C {devices/lab_pin.sym} 155400 -33330 0 1 {name=p154165 lab=_75107_/A }
C {sky130_stdcells/nand3_4.sym} 155340 -33330 0 0 {name=X_75091_ }
C {devices/lab_pin.sym} 155250 -33190 0 0 {name=p154166 lab=_87077_/CLK }
C {devices/lab_pin.sym} 155250 -33170 0 0 {name=p154167 lab=_87077_/D }
C {devices/lab_pin.sym} 155430 -33190 0 1 {name=p154168 lab=_87077_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -33180 0 0 {name=X_87077_ }
C {devices/lab_pin.sym} 155260 -33070 0 0 {name=p154169 lab=_85630_/Q }
C {devices/lab_pin.sym} 155260 -33030 0 0 {name=p154170 lab=_53466_/X }
C {devices/lab_pin.sym} 155260 -32990 0 0 {name=p154171 lab=_53468_/Y }
C {devices/lab_pin.sym} 155420 -33030 0 1 {name=p154172 lab=_53469_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -33030 0 0 {name=X_53469_ }
C {devices/lab_pin.sym} 155280 -32900 0 0 {name=p154173 lab=_81180_/Q }
C {devices/lab_pin.sym} 155280 -32860 0 0 {name=p154174 lab=_41523_/B }
C {devices/lab_pin.sym} 155400 -32880 0 1 {name=p154175 lab=_41483_/X }
C {sky130_stdcells/or2_4.sym} 155340 -32880 0 0 {name=X_41483_ }
C {devices/lab_pin.sym} 155250 -32750 0 0 {name=p154176 lab=_84287_/CLK }
C {devices/lab_pin.sym} 155250 -32730 0 0 {name=p154177 lab=_84289_/D }
C {devices/lab_pin.sym} 155430 -32750 0 1 {name=p154178 lab=_84289_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -32740 0 0 {name=X_84289_ }
C {devices/lab_pin.sym} 155260 -32650 0 0 {name=p154179 lab=_45994_/X }
C {devices/lab_pin.sym} 155260 -32610 0 0 {name=p154180 lab=_46001_/X }
C {devices/lab_pin.sym} 155260 -32570 0 0 {name=p154181 lab=_40500_/X }
C {devices/lab_pin.sym} 155260 -32530 0 0 {name=p154182 lab=_67107_/B }
C {devices/lab_pin.sym} 155260 -32490 0 0 {name=p154183 lab=_45995_/X }
C {devices/lab_pin.sym} 155420 -32570 0 1 {name=p154184 lab=_46011_/A }
C {sky130_stdcells/o32ai_4.sym} 155340 -32570 0 0 {name=X_46010_ }
C {devices/lab_pin.sym} 155280 -32420 0 0 {name=p154185 lab=_55177_/A }
C {devices/lab_pin.sym} 155280 -32380 0 0 {name=p154186 lab=_55208_/B }
C {devices/lab_pin.sym} 155400 -32400 0 1 {name=p154187 lab=_55208_/Y }
C {sky130_stdcells/nor2_4.sym} 155340 -32400 0 0 {name=X_55208_ }
C {devices/lab_pin.sym} 155260 -32310 0 0 {name=p154188 lab=_43196_/X }
C {devices/lab_pin.sym} 155260 -32270 0 0 {name=p154189 lab=_43207_/X }
C {devices/lab_pin.sym} 155260 -32230 0 0 {name=p154190 lab=_40977_/X }
C {devices/lab_pin.sym} 155260 -32190 0 0 {name=p154191 lab=_87531_/Q }
C {devices/lab_pin.sym} 155260 -32150 0 0 {name=p154192 lab=_43212_/X }
C {devices/lab_pin.sym} 155420 -32230 0 1 {name=p154193 lab=_43223_/A }
C {sky130_stdcells/o32ai_4.sym} 155340 -32230 0 0 {name=X_43222_ }
C {devices/lab_pin.sym} 155260 -32090 0 0 {name=p154194 lab=_74039_/X }
C {devices/lab_pin.sym} 155260 -32050 0 0 {name=p154195 lab=_74041_/X }
C {devices/lab_pin.sym} 155260 -32010 0 0 {name=p154196 lab=_74019_/X }
C {devices/lab_pin.sym} 155420 -32050 0 1 {name=p154197 lab=_74045_/A }
C {sky130_stdcells/a21o_4.sym} 155340 -32050 0 0 {name=X_74042_ }
C {devices/lab_pin.sym} 155250 -31910 0 0 {name=p154198 lab=_86029_/CLK }
C {devices/lab_pin.sym} 155250 -31890 0 0 {name=p154199 lab=_51349_/Y }
C {devices/lab_pin.sym} 155430 -31910 0 1 {name=p154200 lab=_65147_/B }
C {sky130_stdcells/dfxtp_4.sym} 155340 -31900 0 0 {name=X_86028_ }
C {devices/lab_pin.sym} 155300 -31770 0 0 {name=p154201 lab=_40434_/A }
C {devices/lab_pin.sym} 155380 -31770 0 1 {name=p154202 lab=_40434_/Y }
C {sky130_stdcells/inv_2.sym} 155340 -31770 0 0 {name=X_40434_ }
C {devices/lab_pin.sym} 155300 -31650 0 0 {name=p154203 lab=_71241_/A }
C {devices/lab_pin.sym} 155380 -31650 0 1 {name=p154204 lab=_71258_/A }
C {sky130_stdcells/buf_2.sym} 155340 -31650 0 0 {name=X_71254_ }
C {devices/lab_pin.sym} 155300 -31530 0 0 {name=p154205 lab=_56255_/A }
C {devices/lab_pin.sym} 155380 -31530 0 1 {name=p154206 lab=_56188_/X }
C {sky130_stdcells/buf_2.sym} 155340 -31530 0 0 {name=X_56188_ }
C {devices/lab_pin.sym} 155280 -31440 0 0 {name=p154207 lab=_70214_/A }
C {devices/lab_pin.sym} 155280 -31400 0 0 {name=p154208 lab=_70214_/B }
C {devices/lab_pin.sym} 155280 -31360 0 0 {name=p154209 lab=_70205_/C }
C {devices/lab_pin.sym} 155280 -31320 0 0 {name=p154210 lab=_70204_/X }
C {devices/lab_pin.sym} 155400 -31380 0 1 {name=p154211 lab=_70205_/X }
C {sky130_stdcells/and4_4.sym} 155340 -31380 0 0 {name=X_70205_ }
C {devices/lab_pin.sym} 155260 -31270 0 0 {name=p154212 lab=_43129_/X }
C {devices/lab_pin.sym} 155260 -31230 0 0 {name=p154213 lab=_43130_/X }
C {devices/lab_pin.sym} 155260 -31190 0 0 {name=p154214 lab=_40845_/X }
C {devices/lab_pin.sym} 155260 -31150 0 0 {name=p154215 lab=_43152_/Y }
C {devices/lab_pin.sym} 155260 -31110 0 0 {name=p154216 lab=_43142_/X }
C {devices/lab_pin.sym} 155420 -31190 0 1 {name=p154217 lab=_43153_/Y }
C {sky130_stdcells/o32ai_4.sym} 155340 -31190 0 0 {name=X_43153_ }
C {devices/lab_pin.sym} 155260 -31050 0 0 {name=p154218 lab=_55132_/X }
C {devices/lab_pin.sym} 155260 -31010 0 0 {name=p154219 lab=_55136_/X }
C {devices/lab_pin.sym} 155260 -30970 0 0 {name=p154220 lab=_55138_/X }
C {devices/lab_pin.sym} 155420 -31010 0 1 {name=p154221 lab=_55139_/X }
C {sky130_stdcells/a21o_4.sym} 155340 -31010 0 0 {name=X_55139_ }
C {devices/lab_pin.sym} 155280 -30880 0 0 {name=p154222 lab=_78874_/B }
C {devices/lab_pin.sym} 155280 -30840 0 0 {name=p154223 lab=_78849_/Y }
C {devices/lab_pin.sym} 155400 -30860 0 1 {name=p154224 lab=_78851_/B }
C {sky130_stdcells/xnor2_4.sym} 155340 -30860 0 0 {name=X_78850_ }
C {devices/lab_pin.sym} 155300 -30730 0 0 {name=p154225 lab=_48135_/A }
C {devices/lab_pin.sym} 155380 -30730 0 1 {name=p154226 lab=_40365_/X }
C {sky130_stdcells/buf_2.sym} 155340 -30730 0 0 {name=X_40365_ }
C {devices/lab_pin.sym} 155280 -30640 0 0 {name=p154227 lab=_71041_/X }
C {devices/lab_pin.sym} 155280 -30600 0 0 {name=p154228 lab=_71185_/B }
C {devices/lab_pin.sym} 155280 -30560 0 0 {name=p154229 lab=_70966_/A }
C {devices/lab_pin.sym} 155280 -30520 0 0 {name=p154230 lab=_74518_/D }
C {devices/lab_pin.sym} 155400 -30580 0 1 {name=p154231 lab=_71185_/Y }
C {sky130_stdcells/nand4_4.sym} 155340 -30580 0 0 {name=X_71185_ }
C {devices/lab_pin.sym} 155300 -30430 0 0 {name=p154232 lab=_41912_/A }
C {devices/lab_pin.sym} 155380 -30430 0 1 {name=p154233 lab=_42104_/X }
C {sky130_stdcells/buf_2.sym} 155340 -30430 0 0 {name=X_42104_ }
C {devices/lab_pin.sym} 155260 -30330 0 0 {name=p154234 lab=_77799_/X }
C {devices/lab_pin.sym} 155260 -30290 0 0 {name=p154235 lab=_77788_/X }
C {devices/lab_pin.sym} 155260 -30250 0 0 {name=p154236 lab=_77800_/X }
C {devices/lab_pin.sym} 155420 -30290 0 1 {name=p154237 lab=_77801_/X }
C {sky130_stdcells/a21o_4.sym} 155340 -30290 0 0 {name=X_77801_ }
C {devices/lab_pin.sym} 155260 -30180 0 0 {name=p154238 lab=_83506_/Q }
C {devices/lab_pin.sym} 155260 -30140 0 0 {name=p154239 lab=_83154_/Q }
C {devices/lab_pin.sym} 155260 -30100 0 0 {name=p154240 lab=_83499_/Q }
C {devices/lab_pin.sym} 155260 -30060 0 0 {name=p154241 lab=_83147_/Q }
C {devices/lab_pin.sym} 155420 -30120 0 1 {name=p154242 lab=_70139_/B }
C {sky130_stdcells/a22oi_4.sym} 155340 -30120 0 0 {name=X_70136_ }
C {devices/lab_pin.sym} 155280 -29980 0 0 {name=p154243 lab=_47988_/A }
C {devices/lab_pin.sym} 155280 -29940 0 0 {name=p154244 lab=_50293_/B }
C {devices/lab_pin.sym} 155400 -29960 0 1 {name=p154245 lab=_47961_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -29960 0 0 {name=X_47961_ }
C {devices/lab_pin.sym} 155300 -29830 0 0 {name=p154246 lab=_59929_/C }
C {devices/lab_pin.sym} 155380 -29830 0 1 {name=p154247 lab=_62198_/B }
C {sky130_stdcells/buf_2.sym} 155340 -29830 0 0 {name=X_59947_ }
C {devices/lab_pin.sym} 155300 -29710 0 0 {name=p154248 lab=_43083_/Y }
C {devices/lab_pin.sym} 155380 -29710 0 1 {name=p154249 lab=_87582_/D }
C {sky130_stdcells/inv_2.sym} 155340 -29710 0 0 {name=X_43084_ }
C {devices/lab_pin.sym} 155260 -29610 0 0 {name=p154250 lab=_78772_/A }
C {devices/lab_pin.sym} 155260 -29570 0 0 {name=p154251 lab=_78746_/Y }
C {devices/lab_pin.sym} 155260 -29530 0 0 {name=p154252 lab=_78773_/X }
C {devices/lab_pin.sym} 155420 -29570 0 1 {name=p154253 lab=_78782_/A }
C {sky130_stdcells/o21ai_4.sym} 155340 -29570 0 0 {name=X_78781_ }
C {devices/lab_pin.sym} 155260 -29450 0 0 {name=p154254 lab=_75984_/Y }
C {devices/lab_pin.sym} 155260 -29410 0 0 {name=p154255 lab=_75991_/Y }
C {devices/lab_pin.sym} 155260 -29370 0 0 {name=p154256 lab=_75992_/Y }
C {devices/lab_pin.sym} 155420 -29410 0 1 {name=p154257 lab=_75993_/X }
C {sky130_stdcells/o21a_4.sym} 155340 -29410 0 0 {name=X_75993_ }
C {devices/lab_pin.sym} 155250 -29270 0 0 {name=p154258 lab=_88232_/CLK }
C {devices/lab_pin.sym} 155250 -29250 0 0 {name=p154259 lab=_42211_/X }
C {devices/lab_pin.sym} 155430 -29270 0 1 {name=p154260 lab=_87979_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -29260 0 0 {name=X_87979_ }
C {devices/lab_pin.sym} 155260 -29150 0 0 {name=p154261 lab=_59372_/B }
C {devices/lab_pin.sym} 155260 -29110 0 0 {name=p154262 lab=_49687_/X }
C {devices/lab_pin.sym} 155260 -29070 0 0 {name=p154263 lab=_49699_/Y }
C {devices/lab_pin.sym} 155420 -29110 0 1 {name=p154264 lab=_49700_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -29110 0 0 {name=X_49700_ }
C {devices/lab_pin.sym} 155300 -28970 0 0 {name=p154265 lab=_52744_/B }
C {devices/lab_pin.sym} 155380 -28970 0 1 {name=p154266 lab=_46912_/X }
C {sky130_stdcells/buf_2.sym} 155340 -28970 0 0 {name=X_46912_ }
C {devices/lab_pin.sym} 155300 -28850 0 0 {name=p154267 lab=_41998_/A }
C {devices/lab_pin.sym} 155380 -28850 0 1 {name=p154268 lab=_42035_/X }
C {sky130_stdcells/buf_2.sym} 155340 -28850 0 0 {name=X_42035_ }
C {devices/lab_pin.sym} 155280 -28740 0 0 {name=p154269 lab=_77731_/Y }
C {devices/lab_pin.sym} 155280 -28700 0 0 {name=p154270 lab=_77732_/B }
C {devices/lab_pin.sym} 155400 -28720 0 1 {name=p154271 lab=_77732_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -28720 0 0 {name=X_77732_ }
C {devices/lab_pin.sym} 155280 -28600 0 0 {name=p154272 lab=_81135_/D }
C {devices/lab_pin.sym} 155280 -28560 0 0 {name=p154273 lab=_74945_/B }
C {devices/lab_pin.sym} 155400 -28580 0 1 {name=p154274 lab=_74944_/Y }
C {sky130_stdcells/nor2_4.sym} 155340 -28580 0 0 {name=X_74944_ }
C {devices/lab_pin.sym} 155300 -28450 0 0 {name=p154275 lab=_70048_/A }
C {devices/lab_pin.sym} 155380 -28450 0 1 {name=p154276 lab=_70067_/X }
C {sky130_stdcells/buf_2.sym} 155340 -28450 0 0 {name=X_70067_ }
C {devices/lab_pin.sym} 155260 -28350 0 0 {name=p154277 lab=_65977_/B }
C {devices/lab_pin.sym} 155260 -28310 0 0 {name=p154278 lab=_47840_/X }
C {devices/lab_pin.sym} 155260 -28270 0 0 {name=p154279 lab=_47891_/Y }
C {devices/lab_pin.sym} 155420 -28310 0 1 {name=p154280 lab=_47892_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -28310 0 0 {name=X_47892_ }
C {devices/lab_pin.sym} 155260 -28190 0 0 {name=p154281 lab=_59877_/X }
C {devices/lab_pin.sym} 155260 -28150 0 0 {name=p154282 lab=_59564_/B }
C {devices/lab_pin.sym} 155260 -28110 0 0 {name=p154283 lab=_59551_/A }
C {devices/lab_pin.sym} 155420 -28150 0 1 {name=p154284 lab=_60418_/D }
C {sky130_stdcells/a21boi_4.sym} 155340 -28150 0 0 {name=X_59878_ }
C {devices/lab_pin.sym} 155260 -28030 0 0 {name=p154285 lab=_49628_/Y }
C {devices/lab_pin.sym} 155260 -27990 0 0 {name=p154286 lab=_49623_/X }
C {devices/lab_pin.sym} 155260 -27950 0 0 {name=p154287 lab=_49630_/X }
C {devices/lab_pin.sym} 155420 -27990 0 1 {name=p154288 lab=_86352_/D }
C {sky130_stdcells/a21oi_4.sym} 155340 -27990 0 0 {name=X_49631_ }
C {devices/lab_pin.sym} 155260 -27870 0 0 {name=p154289 lab=_86697_/Q }
C {devices/lab_pin.sym} 155260 -27830 0 0 {name=p154290 lab=_46813_/X }
C {devices/lab_pin.sym} 155260 -27790 0 0 {name=p154291 lab=_46842_/Y }
C {devices/lab_pin.sym} 155420 -27830 0 1 {name=p154292 lab=_46843_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -27830 0 0 {name=X_46843_ }
C {devices/lab_pin.sym} 155300 -27690 0 0 {name=p154293 lab=_58698_/A }
C {devices/lab_pin.sym} 155380 -27690 0 1 {name=p154294 lab=_58872_/A }
C {sky130_stdcells/buf_2.sym} 155340 -27690 0 0 {name=X_58829_ }
C {devices/lab_pin.sym} 155300 -27570 0 0 {name=p154295 lab=clkbuf_9_471_0_CLK/A }
C {devices/lab_pin.sym} 155380 -27570 0 1 {name=p154296 lab=clkbuf_9_470_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 155340 -27570 0 0 {name=Xclkbuf_9_470_0_CLK }
C {devices/lab_pin.sym} 155280 -27480 0 0 {name=p154297 lab=_77622_/A }
C {devices/lab_pin.sym} 155280 -27440 0 0 {name=p154298 lab=_77596_/A }
C {devices/lab_pin.sym} 155280 -27400 0 0 {name=p154299 lab=_77621_/A }
C {devices/lab_pin.sym} 155280 -27360 0 0 {name=p154300 lab=_77645_/B }
C {devices/lab_pin.sym} 155400 -27420 0 1 {name=p154301 lab=_77663_/X }
C {sky130_stdcells/and4_4.sym} 155340 -27420 0 0 {name=X_77663_ }
C {devices/lab_pin.sym} 155280 -27280 0 0 {name=p154302 lab=_81127_/D }
C {devices/lab_pin.sym} 155280 -27240 0 0 {name=p154303 lab=_74875_/B }
C {devices/lab_pin.sym} 155400 -27260 0 1 {name=p154304 lab=_74897_/B }
C {sky130_stdcells/xor2_4.sym} 155340 -27260 0 0 {name=X_74875_ }
C {devices/lab_pin.sym} 155280 -27140 0 0 {name=p154305 lab=_84806_/Q }
C {devices/lab_pin.sym} 155280 -27100 0 0 {name=p154306 lab=_84126_/Q }
C {devices/lab_pin.sym} 155400 -27120 0 1 {name=p154307 lab=_79402_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -27120 0 0 {name=X_79402_ }
C {devices/lab_pin.sym} 155280 -27020 0 0 {name=p154308 lab=_76614_/A }
C {devices/lab_pin.sym} 155280 -26980 0 0 {name=p154309 lab=_76614_/B }
C {devices/lab_pin.sym} 155280 -26940 0 0 {name=p154310 lab=_76614_/C }
C {devices/lab_pin.sym} 155280 -26900 0 0 {name=p154311 lab=_76602_/Y }
C {devices/lab_pin.sym} 155400 -26960 0 1 {name=p154312 lab=_76614_/X }
C {sky130_stdcells/and4_4.sym} 155340 -26960 0 0 {name=X_76614_ }
C {devices/lab_pin.sym} 155300 -26810 0 0 {name=p154313 lab=clkbuf_9_182_0_CLK/X }
C {devices/lab_pin.sym} 155380 -26810 0 1 {name=p154314 lab=_85993_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 155340 -26810 0 0 {name=Xclkbuf_10_364_0_CLK }
C {devices/lab_pin.sym} 155260 -26730 0 0 {name=p154315 lab=_58248_/A }
C {devices/lab_pin.sym} 155260 -26690 0 0 {name=p154316 lab=_61824_/X }
C {devices/lab_pin.sym} 155260 -26650 0 0 {name=p154317 lab=_61838_/X }
C {devices/lab_pin.sym} 155260 -26610 0 0 {name=p154318 lab=_61790_/X }
C {devices/lab_pin.sym} 155260 -26580 0 0 {name=p154319 lab=_61839_/X }
C {devices/lab_pin.sym} 155420 -26650 0 1 {name=p154320 lab=_61840_/X }
C {sky130_stdcells/a41o_4.sym} 155340 -26650 0 0 {name=X_61840_ }
C {devices/lab_pin.sym} 155260 -26510 0 0 {name=p154321 lab=_49559_/Y }
C {devices/lab_pin.sym} 155260 -26470 0 0 {name=p154322 lab=_49541_/X }
C {devices/lab_pin.sym} 155260 -26430 0 0 {name=p154323 lab=_49561_/X }
C {devices/lab_pin.sym} 155420 -26470 0 1 {name=p154324 lab=_49562_/Y }
C {sky130_stdcells/a21oi_4.sym} 155340 -26470 0 0 {name=X_49562_ }
C {devices/lab_pin.sym} 155260 -26350 0 0 {name=p154325 lab=_44697_/Y }
C {devices/lab_pin.sym} 155260 -26310 0 0 {name=p154326 lab=_73728_/X }
C {devices/lab_pin.sym} 155260 -26270 0 0 {name=p154327 lab=_73825_/Y }
C {devices/lab_pin.sym} 155420 -26310 0 1 {name=p154328 lab=_73838_/C }
C {sky130_stdcells/a21o_4.sym} 155340 -26310 0 0 {name=X_73826_ }
C {devices/lab_pin.sym} 155300 -26170 0 0 {name=p154329 lab=_82961_/Q }
C {devices/lab_pin.sym} 155380 -26170 0 1 {name=p154330 lab=_46774_/Y }
C {sky130_stdcells/inv_2.sym} 155340 -26170 0 0 {name=X_46774_ }
C {devices/lab_pin.sym} 155260 -26070 0 0 {name=p154331 lab=_77559_/B }
C {devices/lab_pin.sym} 155260 -26030 0 0 {name=p154332 lab=_77576_/B }
C {devices/lab_pin.sym} 155260 -25990 0 0 {name=p154333 lab=_77576_/A }
C {devices/lab_pin.sym} 155420 -26030 0 1 {name=p154334 lab=_77594_/X }
C {sky130_stdcells/a21bo_4.sym} 155340 -26030 0 0 {name=X_77594_ }
C {devices/lab_pin.sym} 155300 -25890 0 0 {name=p154335 lab=_43986_/A }
C {devices/lab_pin.sym} 155380 -25890 0 1 {name=p154336 lab=_43986_/Y }
C {sky130_stdcells/inv_2.sym} 155340 -25890 0 0 {name=X_43986_ }
C {devices/lab_pin.sym} 155300 -25770 0 0 {name=p154337 lab=clkbuf_9_497_0_CLK/X }
C {devices/lab_pin.sym} 155380 -25770 0 1 {name=p154338 lab=_85601_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 155340 -25770 0 0 {name=Xclkbuf_10_994_0_CLK }
C {devices/lab_pin.sym} 155300 -25650 0 0 {name=p154339 lab=_83579_/Q }
C {devices/lab_pin.sym} 155380 -25650 0 1 {name=p154340 lab=_48514_/A }
C {sky130_stdcells/inv_2.sym} 155340 -25650 0 0 {name=X_48513_ }
C {devices/lab_pin.sym} 155300 -25530 0 0 {name=p154341 lab=_79332_/X }
C {devices/lab_pin.sym} 155380 -25530 0 1 {name=p154342 lab=_79333_/Y }
C {sky130_stdcells/inv_2.sym} 155340 -25530 0 0 {name=X_79333_ }
C {devices/lab_pin.sym} 155260 -25430 0 0 {name=p154343 lab=_45722_/X }
C {devices/lab_pin.sym} 155260 -25390 0 0 {name=p154344 lab=_45724_/Y }
C {devices/lab_pin.sym} 155260 -25350 0 0 {name=p154345 lab=_45678_/X }
C {devices/lab_pin.sym} 155420 -25390 0 1 {name=p154346 lab=_45725_/X }
C {sky130_stdcells/a21o_4.sym} 155340 -25390 0 0 {name=X_45725_ }
C {devices/lab_pin.sym} 155260 -25270 0 0 {name=p154347 lab=_76519_/X }
C {devices/lab_pin.sym} 155260 -25230 0 0 {name=p154348 lab=_76544_/Y }
C {devices/lab_pin.sym} 155260 -25190 0 0 {name=p154349 lab=_76511_/B }
C {devices/lab_pin.sym} 155420 -25230 0 1 {name=p154350 lab=_76545_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -25230 0 0 {name=X_76545_ }
C {devices/lab_pin.sym} 155260 -25130 0 0 {name=p154351 lab=_42916_/X }
C {devices/lab_pin.sym} 155260 -25090 0 0 {name=p154352 lab=_42917_/X }
C {devices/lab_pin.sym} 155260 -25050 0 0 {name=p154353 lab=_41762_/X }
C {devices/lab_pin.sym} 155260 -25010 0 0 {name=p154354 lab=_67927_/B }
C {devices/lab_pin.sym} 155260 -24970 0 0 {name=p154355 lab=_42934_/X }
C {devices/lab_pin.sym} 155420 -25050 0 1 {name=p154356 lab=_42937_/Y }
C {sky130_stdcells/o32ai_4.sym} 155340 -25050 0 0 {name=X_42937_ }
C {devices/lab_pin.sym} 155300 -24890 0 0 {name=p154357 lab=_49493_/A }
C {devices/lab_pin.sym} 155380 -24890 0 1 {name=p154358 lab=_49493_/X }
C {sky130_stdcells/buf_2.sym} 155340 -24890 0 0 {name=X_49493_ }
C {devices/lab_pin.sym} 155300 -24770 0 0 {name=p154359 lab=_61711_/X }
C {devices/lab_pin.sym} 155380 -24770 0 1 {name=p154360 lab=_61839_/A }
C {sky130_stdcells/buf_2.sym} 155340 -24770 0 0 {name=X_61771_ }
C {devices/lab_pin.sym} 155280 -24660 0 0 {name=p154361 lab=_73733_/A }
C {devices/lab_pin.sym} 155280 -24620 0 0 {name=p154362 lab=_66022_/B }
C {devices/lab_pin.sym} 155400 -24640 0 1 {name=p154363 lab=_73757_/X }
C {sky130_stdcells/and2_4.sym} 155340 -24640 0 0 {name=X_73757_ }
C {devices/lab_pin.sym} 155280 -24530 0 0 {name=p154364 lab=_70969_/A }
C {devices/lab_pin.sym} 155280 -24490 0 0 {name=p154365 lab=_70947_/B }
C {devices/lab_pin.sym} 155280 -24450 0 0 {name=p154366 lab=_70969_/C }
C {devices/lab_pin.sym} 155400 -24490 0 1 {name=p154367 lab=_70969_/Y }
C {sky130_stdcells/nand3_4.sym} 155340 -24490 0 0 {name=X_70969_ }
C {devices/lab_pin.sym} 155260 -24380 0 0 {name=p154368 lab=_58551_/A }
C {devices/lab_pin.sym} 155260 -24340 0 0 {name=p154369 lab=_63497_/X }
C {devices/lab_pin.sym} 155260 -24300 0 0 {name=p154370 lab=_61483_/A }
C {devices/lab_pin.sym} 155260 -24260 0 0 {name=p154371 lab=_63498_/X }
C {devices/lab_pin.sym} 155420 -24320 0 1 {name=p154372 lab=_63510_/X }
C {sky130_stdcells/a2bb2o_4.sym} 155340 -24320 0 0 {name=X_63510_ }
C {devices/lab_pin.sym} 155300 -24170 0 0 {name=p154373 lab=clkbuf_8_242_0_CLK/X }
C {devices/lab_pin.sym} 155380 -24170 0 1 {name=p154374 lab=clkbuf_9_485_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 155340 -24170 0 0 {name=Xclkbuf_9_485_0_CLK }
C {devices/lab_pin.sym} 155300 -24050 0 0 {name=p154375 lab=_48444_/A }
C {devices/lab_pin.sym} 155380 -24050 0 1 {name=p154376 lab=_74403_/B }
C {sky130_stdcells/inv_2.sym} 155340 -24050 0 0 {name=X_48444_ }
C {devices/lab_pin.sym} 155280 -23950 0 0 {name=p154377 lab=_60722_/A }
C {devices/lab_pin.sym} 155280 -23910 0 0 {name=p154378 lab=_63672_/C }
C {devices/lab_pin.sym} 155280 -23870 0 0 {name=p154379 lab=_60711_/A }
C {devices/lab_pin.sym} 155400 -23910 0 1 {name=p154380 lab=_60722_/Y }
C {sky130_stdcells/nand3_4.sym} 155340 -23910 0 0 {name=X_60722_ }
C {devices/lab_pin.sym} 155300 -23770 0 0 {name=p154381 lab=_73078_/A }
C {devices/lab_pin.sym} 155380 -23770 0 1 {name=p154382 lab=_72943_/A }
C {sky130_stdcells/buf_2.sym} 155340 -23770 0 0 {name=X_72708_ }
C {devices/lab_pin.sym} 155280 -23660 0 0 {name=p154383 lab=_84793_/Q }
C {devices/lab_pin.sym} 155280 -23620 0 0 {name=p154384 lab=_66490_/C }
C {devices/lab_pin.sym} 155400 -23640 0 1 {name=p154385 lab=_79264_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -23640 0 0 {name=X_79264_ }
C {devices/lab_pin.sym} 155300 -23510 0 0 {name=p154386 lab=_63196_/B }
C {devices/lab_pin.sym} 155380 -23510 0 1 {name=p154387 lab=_61528_/A }
C {sky130_stdcells/buf_2.sym} 155340 -23510 0 0 {name=X_45656_ }
C {devices/lab_pin.sym} 155280 -23410 0 0 {name=p154388 lab=_64490_/A }
C {devices/lab_pin.sym} 155280 -23370 0 0 {name=p154389 lab=_64490_/B }
C {devices/lab_pin.sym} 155280 -23330 0 0 {name=p154390 lab=_79629_/B }
C {devices/lab_pin.sym} 155400 -23370 0 1 {name=p154391 lab=_64490_/Y }
C {sky130_stdcells/nor3_4.sym} 155340 -23370 0 0 {name=X_64490_ }
C {devices/lab_pin.sym} 155260 -23250 0 0 {name=p154392 lab=_76453_/Y }
C {devices/lab_pin.sym} 155260 -23210 0 0 {name=p154393 lab=_76455_/A }
C {devices/lab_pin.sym} 155260 -23170 0 0 {name=p154394 lab=_76451_/Y }
C {devices/lab_pin.sym} 155420 -23210 0 1 {name=p154395 lab=_76477_/A }
C {sky130_stdcells/o21a_4.sym} 155340 -23210 0 0 {name=X_76476_ }
C {devices/lab_pin.sym} 155260 -23100 0 0 {name=p154396 lab=_41570_/X }
C {devices/lab_pin.sym} 155260 -23060 0 0 {name=p154397 lab=_42866_/X }
C {devices/lab_pin.sym} 155260 -23020 0 0 {name=p154398 lab=_67079_/B }
C {devices/lab_pin.sym} 155260 -22980 0 0 {name=p154399 lab=_42867_/X }
C {devices/lab_pin.sym} 155420 -23040 0 1 {name=p154400 lab=_87678_/D }
C {sky130_stdcells/a2bb2o_4.sym} 155340 -23040 0 0 {name=X_42868_ }
C {devices/lab_pin.sym} 155260 -22910 0 0 {name=p154401 lab=_73685_/X }
C {devices/lab_pin.sym} 155260 -22870 0 0 {name=p154402 lab=_73687_/X }
C {devices/lab_pin.sym} 155260 -22830 0 0 {name=p154403 lab=_73612_/X }
C {devices/lab_pin.sym} 155420 -22870 0 1 {name=p154404 lab=_73688_/X }
C {sky130_stdcells/a21o_4.sym} 155340 -22870 0 0 {name=X_73688_ }
C {devices/lab_pin.sym} 155300 -22730 0 0 {name=p154405 lab=clkbuf_9_189_0_CLK/X }
C {devices/lab_pin.sym} 155380 -22730 0 1 {name=p154406 lab=_83721_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 155340 -22730 0 0 {name=Xclkbuf_10_379_0_CLK }
C {devices/lab_pin.sym} 155260 -22630 0 0 {name=p154407 lab=_78209_/A }
C {devices/lab_pin.sym} 155260 -22590 0 0 {name=p154408 lab=_78208_/X }
C {devices/lab_pin.sym} 155260 -22550 0 0 {name=p154409 lab=_78220_/A }
C {devices/lab_pin.sym} 155420 -22590 0 1 {name=p154410 lab=_78215_/Y }
C {sky130_stdcells/a21boi_4.sym} 155340 -22590 0 0 {name=X_78215_ }
C {devices/lab_pin.sym} 155300 -22450 0 0 {name=p154411 lab=_44606_/Y }
C {devices/lab_pin.sym} 155380 -22450 0 1 {name=p154412 lab=_87037_/D }
C {sky130_stdcells/inv_2.sym} 155340 -22450 0 0 {name=X_44607_ }
C {devices/lab_pin.sym} 155280 -22350 0 0 {name=p154413 lab=_75423_/Y }
C {devices/lab_pin.sym} 155280 -22310 0 0 {name=p154414 lab=_75427_/B }
C {devices/lab_pin.sym} 155280 -22270 0 0 {name=p154415 lab=_75427_/C }
C {devices/lab_pin.sym} 155400 -22310 0 1 {name=p154416 lab=_75427_/X }
C {sky130_stdcells/or3_4.sym} 155340 -22310 0 0 {name=X_75427_ }
C {devices/lab_pin.sym} 155280 -22190 0 0 {name=p154417 lab=_63463_/A }
C {devices/lab_pin.sym} 155280 -22150 0 0 {name=p154418 lab=_64283_/C }
C {devices/lab_pin.sym} 155280 -22110 0 0 {name=p154419 lab=_63463_/C }
C {devices/lab_pin.sym} 155400 -22150 0 1 {name=p154420 lab=_63441_/X }
C {sky130_stdcells/and3_4.sym} 155340 -22150 0 0 {name=X_63441_ }
C {devices/lab_pin.sym} 155260 -22050 0 0 {name=p154421 lab=_41802_/X }
C {devices/lab_pin.sym} 155260 -22010 0 0 {name=p154422 lab=_41803_/X }
C {devices/lab_pin.sym} 155260 -21970 0 0 {name=p154423 lab=_40432_/X }
C {devices/lab_pin.sym} 155260 -21930 0 0 {name=p154424 lab=_66845_/B }
C {devices/lab_pin.sym} 155260 -21890 0 0 {name=p154425 lab=_41792_/X }
C {devices/lab_pin.sym} 155420 -21970 0 1 {name=p154426 lab=_41819_/Y }
C {sky130_stdcells/o32ai_4.sym} 155340 -21970 0 0 {name=X_41819_ }
C {devices/lab_pin.sym} 155260 -21830 0 0 {name=p154427 lab=_48372_/X }
C {devices/lab_pin.sym} 155260 -21790 0 0 {name=p154428 lab=_82368_/Q }
C {devices/lab_pin.sym} 155260 -21750 0 0 {name=p154429 lab=_48374_/Y }
C {devices/lab_pin.sym} 155420 -21790 0 1 {name=p154430 lab=_74371_/A }
C {sky130_stdcells/o21ai_4.sym} 155340 -21790 0 0 {name=X_48375_ }
C {devices/lab_pin.sym} 155280 -21670 0 0 {name=p154431 lab=_72633_/X }
C {devices/lab_pin.sym} 155280 -21630 0 0 {name=p154432 lab=_72643_/B }
C {devices/lab_pin.sym} 155280 -21590 0 0 {name=p154433 lab=_56564_/B }
C {devices/lab_pin.sym} 155400 -21630 0 1 {name=p154434 lab=_72639_/Y }
C {sky130_stdcells/nand3_4.sym} 155340 -21630 0 0 {name=X_72639_ }
C {devices/lab_pin.sym} 155300 -21490 0 0 {name=p154435 lab=_60652_/X }
C {devices/lab_pin.sym} 155380 -21490 0 1 {name=p154436 lab=_63471_/A }
C {sky130_stdcells/buf_2.sym} 155340 -21490 0 0 {name=X_60653_ }
C {devices/lab_pin.sym} 155300 -21370 0 0 {name=p154437 lab=_79207_/B }
C {devices/lab_pin.sym} 155380 -21370 0 1 {name=p154438 lab=_79195_/Y }
C {sky130_stdcells/inv_2.sym} 155340 -21370 0 0 {name=X_79195_ }
C {devices/lab_pin.sym} 155260 -21270 0 0 {name=p154439 lab=_45583_/X }
C {devices/lab_pin.sym} 155260 -21230 0 0 {name=p154440 lab=_45586_/X }
C {devices/lab_pin.sym} 155260 -21190 0 0 {name=p154441 lab=_45523_/X }
C {devices/lab_pin.sym} 155420 -21230 0 1 {name=p154442 lab=_45587_/X }
C {sky130_stdcells/a21o_4.sym} 155340 -21230 0 0 {name=X_45587_ }
C {devices/lab_pin.sym} 155260 -21130 0 0 {name=p154443 lab=_42795_/X }
C {devices/lab_pin.sym} 155260 -21090 0 0 {name=p154444 lab=_42796_/X }
C {devices/lab_pin.sym} 155260 -21050 0 0 {name=p154445 lab=_41387_/X }
C {devices/lab_pin.sym} 155260 -21010 0 0 {name=p154446 lab=_67793_/B }
C {devices/lab_pin.sym} 155260 -20970 0 0 {name=p154447 lab=_42781_/X }
C {devices/lab_pin.sym} 155420 -21050 0 1 {name=p154448 lab=_42799_/Y }
C {sky130_stdcells/o32ai_4.sym} 155340 -21050 0 0 {name=X_42799_ }
C {devices/lab_pin.sym} 155260 -20910 0 0 {name=p154449 lab=_86646_/Q }
C {devices/lab_pin.sym} 155260 -20870 0 0 {name=p154450 lab=_47286_/X }
C {devices/lab_pin.sym} 155260 -20830 0 0 {name=p154451 lab=_47325_/Y }
C {devices/lab_pin.sym} 155420 -20870 0 1 {name=p154452 lab=_47326_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -20870 0 0 {name=X_47326_ }
C {devices/lab_pin.sym} 155260 -20760 0 0 {name=p154453 lab=_57773_/X }
C {devices/lab_pin.sym} 155260 -20720 0 0 {name=p154454 lab=_84976_/Q }
C {devices/lab_pin.sym} 155260 -20680 0 0 {name=p154455 lab=_64579_/X }
C {devices/lab_pin.sym} 155260 -20640 0 0 {name=p154456 lab=_66159_/X }
C {devices/lab_pin.sym} 155420 -20700 0 1 {name=p154457 lab=_66160_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -20700 0 0 {name=X_66160_ }
C {devices/lab_pin.sym} 155280 -20560 0 0 {name=p154458 lab=_78129_/X }
C {devices/lab_pin.sym} 155280 -20520 0 0 {name=p154459 lab=_78143_/A }
C {devices/lab_pin.sym} 155400 -20540 0 1 {name=p154460 lab=_78146_/X }
C {sky130_stdcells/and2_4.sym} 155340 -20540 0 0 {name=X_78146_ }
C {devices/lab_pin.sym} 155260 -20450 0 0 {name=p154461 lab=_44529_/X }
C {devices/lab_pin.sym} 155260 -20410 0 0 {name=p154462 lab=_44530_/X }
C {devices/lab_pin.sym} 155260 -20370 0 0 {name=p154463 lab=_40806_/A }
C {devices/lab_pin.sym} 155260 -20330 0 0 {name=p154464 lab=_44537_/Y }
C {devices/lab_pin.sym} 155260 -20290 0 0 {name=p154465 lab=_44533_/X }
C {devices/lab_pin.sym} 155420 -20370 0 1 {name=p154466 lab=_44538_/Y }
C {sky130_stdcells/o32ai_4.sym} 155340 -20370 0 0 {name=X_44538_ }
C {devices/lab_pin.sym} 155300 -20210 0 0 {name=p154467 lab=_63372_/A }
C {devices/lab_pin.sym} 155380 -20210 0 1 {name=p154468 lab=_63372_/X }
C {sky130_stdcells/buf_2.sym} 155340 -20210 0 0 {name=X_63372_ }
C {devices/lab_pin.sym} 155280 -20100 0 0 {name=p154469 lab=_75358_/A }
C {devices/lab_pin.sym} 155280 -20060 0 0 {name=p154470 lab=_75357_/Y }
C {devices/lab_pin.sym} 155400 -20080 0 1 {name=p154471 lab=_75358_/X }
C {sky130_stdcells/xor2_4.sym} 155340 -20080 0 0 {name=X_75358_ }
C {devices/lab_pin.sym} 155280 -19960 0 0 {name=p154472 lab=_60555_/Y }
C {devices/lab_pin.sym} 155280 -19920 0 0 {name=p154473 lab=_60493_/X }
C {devices/lab_pin.sym} 155400 -19940 0 1 {name=p154474 lab=_60584_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -19940 0 0 {name=X_60584_ }
C {devices/lab_pin.sym} 155280 -19830 0 0 {name=p154475 lab=_65107_/X }
C {devices/lab_pin.sym} 155280 -19790 0 0 {name=p154476 lab=_65111_/B }
C {devices/lab_pin.sym} 155280 -19750 0 0 {name=p154477 lab=_65110_/X }
C {devices/lab_pin.sym} 155400 -19790 0 1 {name=p154478 lab=_65111_/Y }
C {sky130_stdcells/nand3_4.sym} 155340 -19790 0 0 {name=X_65111_ }
C {devices/lab_pin.sym} 155300 -19650 0 0 {name=p154479 lab=_62515_/A }
C {devices/lab_pin.sym} 155380 -19650 0 1 {name=p154480 lab=_62323_/X }
C {sky130_stdcells/buf_2.sym} 155340 -19650 0 0 {name=X_62323_ }
C {devices/lab_pin.sym} 155260 -19550 0 0 {name=p154481 lab=_70292_/C }
C {devices/lab_pin.sym} 155260 -19510 0 0 {name=p154482 lab=_74301_/X }
C {devices/lab_pin.sym} 155260 -19470 0 0 {name=p154483 lab=_74308_/Y }
C {devices/lab_pin.sym} 155420 -19510 0 1 {name=p154484 lab=_74309_/X }
C {sky130_stdcells/a21bo_4.sym} 155340 -19510 0 0 {name=X_74309_ }
C {devices/lab_pin.sym} 155280 -19400 0 0 {name=p154485 lab=_47246_/X }
C {devices/lab_pin.sym} 155280 -19360 0 0 {name=p154486 lab=_47228_/B }
C {devices/lab_pin.sym} 155280 -19320 0 0 {name=p154487 lab=_47234_/X }
C {devices/lab_pin.sym} 155280 -19280 0 0 {name=p154488 lab=_52942_/D }
C {devices/lab_pin.sym} 155400 -19340 0 1 {name=p154489 lab=_47257_/X }
C {sky130_stdcells/and4_4.sym} 155340 -19340 0 0 {name=X_47257_ }
C {devices/lab_pin.sym} 155300 -19190 0 0 {name=p154490 lab=_84157_/Q }
C {devices/lab_pin.sym} 155380 -19190 0 1 {name=p154491 lab=_66092_/C }
C {sky130_stdcells/inv_2.sym} 155340 -19190 0 0 {name=X_66091_ }
C {devices/lab_pin.sym} 155300 -19070 0 0 {name=p154492 lab=clkbuf_9_151_0_CLK/X }
C {devices/lab_pin.sym} 155380 -19070 0 1 {name=p154493 lab=_84355_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 155340 -19070 0 0 {name=Xclkbuf_10_302_0_CLK }
C {devices/lab_pin.sym} 155280 -18960 0 0 {name=p154494 lab=_84582_/Q }
C {devices/lab_pin.sym} 155280 -18920 0 0 {name=p154495 lab=_78077_/B }
C {devices/lab_pin.sym} 155400 -18940 0 1 {name=p154496 lab=_81886_/D }
C {sky130_stdcells/xor2_4.sym} 155340 -18940 0 0 {name=X_78077_ }
C {devices/lab_pin.sym} 155260 -18840 0 0 {name=p154497 lab=_41165_/A }
C {devices/lab_pin.sym} 155260 -18800 0 0 {name=p154498 lab=_44464_/X }
C {devices/lab_pin.sym} 155260 -18760 0 0 {name=p154499 lab=_87093_/Q }
C {devices/lab_pin.sym} 155260 -18720 0 0 {name=p154500 lab=_44466_/X }
C {devices/lab_pin.sym} 155420 -18780 0 1 {name=p154501 lab=_87093_/D }
C {sky130_stdcells/a2bb2o_4.sym} 155340 -18780 0 0 {name=X_44469_ }
C {devices/lab_pin.sym} 155280 -18640 0 0 {name=p154502 lab=_75288_/A }
C {devices/lab_pin.sym} 155280 -18600 0 0 {name=p154503 lab=_80945_/D }
C {devices/lab_pin.sym} 155400 -18620 0 1 {name=p154504 lab=_75289_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -18620 0 0 {name=X_75289_ }
C {devices/lab_pin.sym} 155300 -18490 0 0 {name=p154505 lab=clkbuf_9_466_0_CLK/X }
C {devices/lab_pin.sym} 155380 -18490 0 1 {name=p154506 lab=_87588_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 155340 -18490 0 0 {name=Xclkbuf_10_932_0_CLK }
C {devices/lab_pin.sym} 155300 -18370 0 0 {name=p154507 lab=_46187_/A }
C {devices/lab_pin.sym} 155380 -18370 0 1 {name=p154508 lab=_46215_/B }
C {sky130_stdcells/buf_2.sym} 155340 -18370 0 0 {name=X_46208_ }
C {devices/lab_pin.sym} 155280 -18270 0 0 {name=p154509 lab=_65039_/X }
C {devices/lab_pin.sym} 155280 -18230 0 0 {name=p154510 lab=_64937_/B }
C {devices/lab_pin.sym} 155280 -18190 0 0 {name=p154511 lab=_65041_/X }
C {devices/lab_pin.sym} 155400 -18230 0 1 {name=p154512 lab=_65042_/Y }
C {sky130_stdcells/nand3_4.sym} 155340 -18230 0 0 {name=X_65042_ }
C {devices/lab_pin.sym} 155280 -18100 0 0 {name=p154513 lab=_82086_/Q }
C {devices/lab_pin.sym} 155280 -18060 0 0 {name=p154514 lab=_77028_/B }
C {devices/lab_pin.sym} 155400 -18080 0 1 {name=p154515 lab=_77028_/X }
C {sky130_stdcells/xor2_4.sym} 155340 -18080 0 0 {name=X_77028_ }
C {devices/lab_pin.sym} 155280 -17970 0 0 {name=p154516 lab=_62181_/A }
C {devices/lab_pin.sym} 155280 -17930 0 0 {name=p154517 lab=_62181_/B }
C {devices/lab_pin.sym} 155280 -17890 0 0 {name=p154518 lab=_62254_/C }
C {devices/lab_pin.sym} 155400 -17930 0 1 {name=p154519 lab=_62254_/Y }
C {sky130_stdcells/nor3_4.sym} 155340 -17930 0 0 {name=X_62254_ }
C {devices/lab_pin.sym} 155300 -17790 0 0 {name=p154520 lab=_82373_/Q }
C {devices/lab_pin.sym} 155380 -17790 0 1 {name=p154521 lab=_47189_/A }
C {sky130_stdcells/inv_2.sym} 155340 -17790 0 0 {name=X_47188_ }
C {devices/lab_pin.sym} 155280 -17700 0 0 {name=p154522 lab=_61205_/A }
C {devices/lab_pin.sym} 155280 -17660 0 0 {name=p154523 lab=_61205_/B }
C {devices/lab_pin.sym} 155280 -17620 0 0 {name=p154524 lab=_60631_/D }
C {devices/lab_pin.sym} 155280 -17580 0 0 {name=p154525 lab=_61075_/X }
C {devices/lab_pin.sym} 155400 -17640 0 1 {name=p154526 lab=_64274_/A }
C {sky130_stdcells/and4_4.sym} 155340 -17640 0 0 {name=X_61205_ }
C {devices/lab_pin.sym} 155300 -17490 0 0 {name=p154527 lab=clkbuf_9_423_0_CLK/A }
C {devices/lab_pin.sym} 155380 -17490 0 1 {name=p154528 lab=clkbuf_9_423_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 155340 -17490 0 0 {name=Xclkbuf_9_423_0_CLK }
C {devices/lab_pin.sym} 155300 -17370 0 0 {name=p154529 lab=_46138_/Y }
C {devices/lab_pin.sym} 155380 -17370 0 1 {name=p154530 lab=_46139_/Y }
C {sky130_stdcells/inv_2.sym} 155340 -17370 0 0 {name=X_46139_ }
C {devices/lab_pin.sym} 155280 -17260 0 0 {name=p154531 lab=_68360_/X }
C {devices/lab_pin.sym} 155280 -17220 0 0 {name=p154532 lab=_42600_/Y }
C {devices/lab_pin.sym} 155400 -17240 0 1 {name=p154533 lab=_69850_/Y }
C {sky130_stdcells/nor2_4.sym} 155340 -17240 0 0 {name=X_69850_ }
C {devices/lab_pin.sym} 155280 -17140 0 0 {name=p154534 lab=_61694_/B }
C {devices/lab_pin.sym} 155280 -17100 0 0 {name=p154535 lab=_62185_/B }
C {devices/lab_pin.sym} 155280 -17060 0 0 {name=p154536 lab=_59649_/A }
C {devices/lab_pin.sym} 155280 -17020 0 0 {name=p154537 lab=_59761_/A }
C {devices/lab_pin.sym} 155400 -17080 0 1 {name=p154538 lab=_62188_/C }
C {sky130_stdcells/nand4_4.sym} 155340 -17080 0 0 {name=X_62185_ }
C {devices/lab_pin.sym} 155300 -16930 0 0 {name=p154539 lab=_68801_/A }
C {devices/lab_pin.sym} 155380 -16930 0 1 {name=p154540 lab=_68802_/B }
C {sky130_stdcells/inv_2.sym} 155340 -16930 0 0 {name=X_68801_ }
C {devices/lab_pin.sym} 155300 -16810 0 0 {name=p154541 lab=clkbuf_9_158_0_CLK/X }
C {devices/lab_pin.sym} 155380 -16810 0 1 {name=p154542 lab=_85484_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 155340 -16810 0 0 {name=Xclkbuf_10_317_0_CLK }
C {devices/lab_pin.sym} 155300 -16690 0 0 {name=p154543 lab=_61135_/X }
C {devices/lab_pin.sym} 155380 -16690 0 1 {name=p154544 lab=_61238_/B }
C {sky130_stdcells/inv_2.sym} 155340 -16690 0 0 {name=X_61136_ }
C {devices/lab_pin.sym} 155260 -16600 0 0 {name=p154545 lab=_87555_/Q }
C {devices/lab_pin.sym} 155260 -16560 0 0 {name=p154546 lab=_69751_/X }
C {devices/lab_pin.sym} 155260 -16520 0 0 {name=p154547 lab=_69779_/X }
C {devices/lab_pin.sym} 155260 -16480 0 0 {name=p154548 lab=_69780_/Y }
C {devices/lab_pin.sym} 155420 -16540 0 1 {name=p154549 lab=_69781_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -16540 0 0 {name=X_69781_ }
C {devices/lab_pin.sym} 155260 -16410 0 0 {name=p154550 lab=_84088_/Q }
C {devices/lab_pin.sym} 155260 -16370 0 0 {name=p154551 lab=_66971_/X }
C {devices/lab_pin.sym} 155260 -16330 0 0 {name=p154552 lab=_66992_/X }
C {devices/lab_pin.sym} 155420 -16370 0 1 {name=p154553 lab=_66993_/X }
C {sky130_stdcells/a21bo_4.sym} 155340 -16370 0 0 {name=X_66993_ }
C {devices/lab_pin.sym} 155280 -16240 0 0 {name=p154554 lab=_78979_/A }
C {devices/lab_pin.sym} 155280 -16200 0 0 {name=p154555 lab=_78979_/B }
C {devices/lab_pin.sym} 155400 -16220 0 1 {name=p154556 lab=_78979_/X }
C {sky130_stdcells/or2_4.sym} 155340 -16220 0 0 {name=X_78979_ }
C {devices/lab_pin.sym} 155300 -16090 0 0 {name=p154557 lab=clkbuf_9_473_0_CLK/X }
C {devices/lab_pin.sym} 155380 -16090 0 1 {name=p154558 lab=_87826_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 155340 -16090 0 0 {name=Xclkbuf_10_947_0_CLK }
C {devices/lab_pin.sym} 155280 -15980 0 0 {name=p154559 lab=_68366_/X }
C {devices/lab_pin.sym} 155280 -15940 0 0 {name=p154560 lab=_68732_/B }
C {devices/lab_pin.sym} 155400 -15960 0 1 {name=p154561 lab=_68732_/Y }
C {sky130_stdcells/nor2_4.sym} 155340 -15960 0 0 {name=X_68732_ }
C {devices/lab_pin.sym} 155260 -15850 0 0 {name=p154562 lab=_65942_/Y }
C {devices/lab_pin.sym} 155260 -15810 0 0 {name=p154563 lab=_65915_/X }
C {devices/lab_pin.sym} 155260 -15770 0 0 {name=p154564 lab=_65943_/X }
C {devices/lab_pin.sym} 155420 -15810 0 1 {name=p154565 lab=_65944_/X }
C {sky130_stdcells/a21o_4.sym} 155340 -15810 0 0 {name=X_65944_ }
C {devices/lab_pin.sym} 155280 -15680 0 0 {name=p154566 lab=_60631_/D }
C {devices/lab_pin.sym} 155280 -15640 0 0 {name=p154567 lab=_61205_/B }
C {devices/lab_pin.sym} 155400 -15660 0 1 {name=p154568 lab=_61112_/A }
C {sky130_stdcells/and2_4.sym} 155340 -15660 0 0 {name=X_61067_ }
C {devices/lab_pin.sym} 155250 -15530 0 0 {name=p154569 lab=_81990_/CLK }
C {devices/lab_pin.sym} 155250 -15510 0 0 {name=p154570 lab=_82022_/Q }
C {devices/lab_pin.sym} 155430 -15530 0 1 {name=p154571 lab=_77023_/A }
C {sky130_stdcells/dfxtp_4.sym} 155340 -15520 0 0 {name=X_81990_ }
C {devices/lab_pin.sym} 155300 -15390 0 0 {name=p154572 lab=clkbuf_9_438_0_CLK/A }
C {devices/lab_pin.sym} 155380 -15390 0 1 {name=p154573 lab=clkbuf_9_438_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 155340 -15390 0 0 {name=Xclkbuf_9_438_0_CLK }
C {devices/lab_pin.sym} 155300 -15270 0 0 {name=p154574 lab=_62623_/A }
C {devices/lab_pin.sym} 155380 -15270 0 1 {name=p154575 lab=_62556_/A }
C {sky130_stdcells/buf_2.sym} 155340 -15270 0 0 {name=X_60018_ }
C {devices/lab_pin.sym} 155260 -15170 0 0 {name=p154576 lab=_58012_/B }
C {devices/lab_pin.sym} 155260 -15130 0 0 {name=p154577 lab=_49825_/X }
C {devices/lab_pin.sym} 155260 -15090 0 0 {name=p154578 lab=_49828_/Y }
C {devices/lab_pin.sym} 155420 -15130 0 1 {name=p154579 lab=_49829_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -15130 0 0 {name=X_49829_ }
C {devices/lab_pin.sym} 155250 -14990 0 0 {name=p154580 lab=_80813_/CLK }
C {devices/lab_pin.sym} 155250 -14970 0 0 {name=p154581 lab=_80985_/Q }
C {devices/lab_pin.sym} 155430 -14990 0 1 {name=p154582 lab=_80941_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -14980 0 0 {name=X_80941_ }
C {devices/lab_pin.sym} 155260 -14880 0 0 {name=p154583 lab=_68516_/X }
C {devices/lab_pin.sym} 155260 -14840 0 0 {name=p154584 lab=_68647_/Y }
C {devices/lab_pin.sym} 155260 -14800 0 0 {name=p154585 lab=_68649_/X }
C {devices/lab_pin.sym} 155260 -14760 0 0 {name=p154586 lab=_68662_/Y }
C {devices/lab_pin.sym} 155420 -14820 0 1 {name=p154587 lab=_68663_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -14820 0 0 {name=X_68663_ }
C {devices/lab_pin.sym} 155260 -14700 0 0 {name=p154588 lab=_65685_/X }
C {devices/lab_pin.sym} 155260 -14660 0 0 {name=p154589 lab=_86179_/Q }
C {devices/lab_pin.sym} 155260 -14620 0 0 {name=p154590 lab=_65701_/X }
C {devices/lab_pin.sym} 155260 -14580 0 0 {name=p154591 lab=_65874_/X }
C {devices/lab_pin.sym} 155420 -14640 0 1 {name=p154592 lab=_65875_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -14640 0 0 {name=X_65875_ }
C {devices/lab_pin.sym} 155260 -14520 0 0 {name=p154593 lab=_87975_/Q }
C {devices/lab_pin.sym} 155260 -14480 0 0 {name=p154594 lab=_67591_/X }
C {devices/lab_pin.sym} 155260 -14440 0 0 {name=p154595 lab=_67524_/X }
C {devices/lab_pin.sym} 155260 -14400 0 0 {name=p154596 lab=_67613_/X }
C {devices/lab_pin.sym} 155420 -14460 0 1 {name=p154597 lab=_67614_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -14460 0 0 {name=X_67614_ }
C {devices/lab_pin.sym} 155300 -14310 0 0 {name=p154598 lab=_52757_/A }
C {devices/lab_pin.sym} 155380 -14310 0 1 {name=p154599 lab=_52853_/A }
C {sky130_stdcells/buf_2.sym} 155340 -14310 0 0 {name=X_52840_ }
C {devices/lab_pin.sym} 155280 -14200 0 0 {name=p154600 lab=_64826_/A }
C {devices/lab_pin.sym} 155280 -14160 0 0 {name=p154601 lab=_64826_/B }
C {devices/lab_pin.sym} 155400 -14180 0 1 {name=p154602 lab=_64826_/X }
C {sky130_stdcells/and2_4.sym} 155340 -14180 0 0 {name=X_64826_ }
C {devices/lab_pin.sym} 155250 -14050 0 0 {name=p154603 lab=_83660_/CLK }
C {devices/lab_pin.sym} 155250 -14030 0 0 {name=p154604 lab=_70927_/Y }
C {devices/lab_pin.sym} 155430 -14050 0 1 {name=p154605 lab=_46886_/A }
C {sky130_stdcells/dfxtp_4.sym} 155340 -14040 0 0 {name=X_83660_ }
C {devices/lab_pin.sym} 155250 -13910 0 0 {name=p154606 lab=_80746_/CLK }
C {devices/lab_pin.sym} 155250 -13890 0 0 {name=p154607 lab=_75628_/B }
C {devices/lab_pin.sym} 155430 -13910 0 1 {name=p154608 lab=_80872_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -13900 0 0 {name=X_80872_ }
C {devices/lab_pin.sym} 155260 -13790 0 0 {name=p154609 lab=_68590_/X }
C {devices/lab_pin.sym} 155260 -13750 0 0 {name=p154610 lab=_68593_/X }
C {devices/lab_pin.sym} 155260 -13710 0 0 {name=p154611 lab=_68442_/X }
C {devices/lab_pin.sym} 155420 -13750 0 1 {name=p154612 lab=_68597_/A }
C {sky130_stdcells/a21o_4.sym} 155340 -13750 0 0 {name=X_68594_ }
C {devices/lab_pin.sym} 155250 -13610 0 0 {name=p154613 lab=_82610_/CLK }
C {devices/lab_pin.sym} 155250 -13590 0 0 {name=p154614 lab=_78965_/B }
C {devices/lab_pin.sym} 155430 -13610 0 1 {name=p154615 lab=_82611_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -13600 0 0 {name=X_82611_ }
C {devices/lab_pin.sym} 155280 -13480 0 0 {name=p154616 lab=_67497_/A }
C {devices/lab_pin.sym} 155280 -13440 0 0 {name=p154617 lab=_87722_/Q }
C {devices/lab_pin.sym} 155400 -13460 0 1 {name=p154618 lab=_67545_/X }
C {sky130_stdcells/and2_4.sym} 155340 -13460 0 0 {name=X_67545_ }
C {devices/lab_pin.sym} 155280 -13360 0 0 {name=p154619 lab=_52775_/A }
C {devices/lab_pin.sym} 155280 -13320 0 0 {name=p154620 lab=_52775_/B }
C {devices/lab_pin.sym} 155280 -13280 0 0 {name=p154621 lab=_52775_/C }
C {devices/lab_pin.sym} 155280 -13240 0 0 {name=p154622 lab=_52771_/D }
C {devices/lab_pin.sym} 155400 -13300 0 1 {name=p154623 lab=_52771_/X }
C {sky130_stdcells/and4_4.sym} 155340 -13300 0 0 {name=X_52771_ }
C {devices/lab_pin.sym} 155260 -13170 0 0 {name=p154624 lab=_64754_/X }
C {devices/lab_pin.sym} 155260 -13130 0 0 {name=p154625 lab=_64756_/X }
C {devices/lab_pin.sym} 155260 -13090 0 0 {name=p154626 lab=_64729_/X }
C {devices/lab_pin.sym} 155420 -13130 0 1 {name=p154627 lab=_64757_/X }
C {sky130_stdcells/a21o_4.sym} 155340 -13130 0 0 {name=X_64757_ }
C {devices/lab_pin.sym} 155250 -12990 0 0 {name=p154628 lab=_83589_/CLK }
C {devices/lab_pin.sym} 155250 -12970 0 0 {name=p154629 lab=_71148_/Y }
C {devices/lab_pin.sym} 155430 -12990 0 1 {name=p154630 lab=_48379_/A }
C {sky130_stdcells/dfxtp_4.sym} 155340 -12980 0 0 {name=X_83591_ }
C {devices/lab_pin.sym} 155300 -12850 0 0 {name=p154631 lab=_58338_/A }
C {devices/lab_pin.sym} 155380 -12850 0 1 {name=p154632 lab=_61969_/X }
C {sky130_stdcells/buf_2.sym} 155340 -12850 0 0 {name=X_61969_ }
C {devices/lab_pin.sym} 155260 -12750 0 0 {name=p154633 lab=_54506_/Y }
C {devices/lab_pin.sym} 155260 -12710 0 0 {name=p154634 lab=_54502_/X }
C {devices/lab_pin.sym} 155260 -12670 0 0 {name=p154635 lab=_54509_/X }
C {devices/lab_pin.sym} 155420 -12710 0 1 {name=p154636 lab=_54510_/Y }
C {sky130_stdcells/a21oi_4.sym} 155340 -12710 0 0 {name=X_54510_ }
C {devices/lab_pin.sym} 155250 -12570 0 0 {name=p154637 lab=_83550_/CLK }
C {devices/lab_pin.sym} 155250 -12550 0 0 {name=p154638 lab=_85330_/D }
C {devices/lab_pin.sym} 155430 -12570 0 1 {name=p154639 lab=_85330_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -12560 0 0 {name=X_85330_ }
C {devices/lab_pin.sym} 155280 -12460 0 0 {name=p154640 lab=_51709_/X }
C {devices/lab_pin.sym} 155280 -12420 0 0 {name=p154641 lab=_51721_/X }
C {devices/lab_pin.sym} 155280 -12380 0 0 {name=p154642 lab=_51715_/C }
C {devices/lab_pin.sym} 155280 -12340 0 0 {name=p154643 lab=_53244_/D }
C {devices/lab_pin.sym} 155400 -12400 0 1 {name=p154644 lab=_51722_/X }
C {sky130_stdcells/and4_4.sym} 155340 -12400 0 0 {name=X_51722_ }
C {devices/lab_pin.sym} 155280 -12280 0 0 {name=p154645 lab=_58370_/A }
C {devices/lab_pin.sym} 155280 -12240 0 0 {name=p154646 lab=_63416_/A }
C {devices/lab_pin.sym} 155280 -12200 0 0 {name=p154647 lab=_63443_/A }
C {devices/lab_pin.sym} 155280 -12160 0 0 {name=p154648 lab=_63699_/D }
C {devices/lab_pin.sym} 155400 -12220 0 1 {name=p154649 lab=_63708_/Y }
C {sky130_stdcells/nand4_4.sym} 155340 -12220 0 0 {name=X_63708_ }
C {devices/lab_pin.sym} 155250 -12070 0 0 {name=p154650 lab=_82553_/CLK }
C {devices/lab_pin.sym} 155250 -12050 0 0 {name=p154651 lab=_83862_/Q }
C {devices/lab_pin.sym} 155430 -12070 0 1 {name=p154652 lab=_82542_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -12060 0 0 {name=X_82542_ }
C {devices/lab_pin.sym} 155260 -11960 0 0 {name=p154653 lab=_82994_/Q }
C {devices/lab_pin.sym} 155260 -11920 0 0 {name=p154654 lab=_44063_/X }
C {devices/lab_pin.sym} 155260 -11880 0 0 {name=p154655 lab=_44097_/X }
C {devices/lab_pin.sym} 155260 -11840 0 0 {name=p154656 lab=_55489_/Y }
C {devices/lab_pin.sym} 155420 -11900 0 1 {name=p154657 lab=_55490_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -11900 0 0 {name=X_55490_ }
C {devices/lab_pin.sym} 155300 -11750 0 0 {name=p154658 lab=_67120_/X }
C {devices/lab_pin.sym} 155380 -11750 0 1 {name=p154659 lab=_67476_/X }
C {sky130_stdcells/buf_2.sym} 155340 -11750 0 0 {name=X_67476_ }
C {devices/lab_pin.sym} 155300 -11630 0 0 {name=p154660 lab=_84230_/Q }
C {devices/lab_pin.sym} 155380 -11630 0 1 {name=p154661 lab=_64688_/Y }
C {sky130_stdcells/inv_2.sym} 155340 -11630 0 0 {name=X_64688_ }
C {devices/lab_pin.sym} 155260 -11530 0 0 {name=p154662 lab=_81404_/D }
C {devices/lab_pin.sym} 155260 -11490 0 0 {name=p154663 lab=_69161_/X }
C {devices/lab_pin.sym} 155260 -11450 0 0 {name=p154664 lab=_69214_/X }
C {devices/lab_pin.sym} 155420 -11490 0 1 {name=p154665 lab=_83940_/D }
C {sky130_stdcells/a21bo_4.sym} 155340 -11490 0 0 {name=X_69215_ }
C {devices/lab_pin.sym} 155260 -11370 0 0 {name=p154666 lab=_54438_/Y }
C {devices/lab_pin.sym} 155260 -11330 0 0 {name=p154667 lab=_54422_/X }
C {devices/lab_pin.sym} 155260 -11290 0 0 {name=p154668 lab=_54440_/X }
C {devices/lab_pin.sym} 155420 -11330 0 1 {name=p154669 lab=_85442_/D }
C {sky130_stdcells/a21oi_4.sym} 155340 -11330 0 0 {name=X_54441_ }
C {devices/lab_pin.sym} 155260 -11210 0 0 {name=p154670 lab=_66366_/X }
C {devices/lab_pin.sym} 155260 -11170 0 0 {name=p154671 lab=_64926_/Y }
C {devices/lab_pin.sym} 155260 -11130 0 0 {name=p154672 lab=_66426_/Y }
C {devices/lab_pin.sym} 155420 -11170 0 1 {name=p154673 lab=_66427_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -11170 0 0 {name=X_66427_ }
C {devices/lab_pin.sym} 155250 -11030 0 0 {name=p154674 lab=_85257_/CLK }
C {devices/lab_pin.sym} 155250 -11010 0 0 {name=p154675 lab=_56247_/Y }
C {devices/lab_pin.sym} 155430 -11030 0 1 {name=p154676 lab=_56246_/C }
C {sky130_stdcells/dfxtp_4.sym} 155340 -11020 0 0 {name=X_85261_ }
C {devices/lab_pin.sym} 155280 -10900 0 0 {name=p154677 lab=_51671_/A }
C {devices/lab_pin.sym} 155280 -10860 0 0 {name=p154678 lab=_53179_/B }
C {devices/lab_pin.sym} 155400 -10880 0 1 {name=p154679 lab=_51653_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -10880 0 0 {name=X_51653_ }
C {devices/lab_pin.sym} 155260 -10790 0 0 {name=p154680 lab=_64473_/A }
C {devices/lab_pin.sym} 155260 -10750 0 0 {name=p154681 lab=_60732_/C }
C {devices/lab_pin.sym} 155260 -10710 0 0 {name=p154682 lab=_60739_/X }
C {devices/lab_pin.sym} 155260 -10670 0 0 {name=p154683 lab=_58498_/A }
C {devices/lab_pin.sym} 155260 -10630 0 0 {name=p154684 lab=_60704_/Y }
C {devices/lab_pin.sym} 155420 -10710 0 1 {name=p154685 lab=_63639_/Y }
C {sky130_stdcells/o32ai_4.sym} 155340 -10710 0 0 {name=X_63639_ }
C {devices/lab_pin.sym} 155250 -10550 0 0 {name=p154686 lab=_82671_/CLK }
C {devices/lab_pin.sym} 155250 -10530 0 0 {name=p154687 lab=_82473_/D }
C {devices/lab_pin.sym} 155430 -10550 0 1 {name=p154688 lab=_78303_/B }
C {sky130_stdcells/dfxtp_4.sym} 155340 -10540 0 0 {name=X_82473_ }
C {devices/lab_pin.sym} 155250 -10410 0 0 {name=p154689 lab=_82538_/CLK }
C {devices/lab_pin.sym} 155250 -10390 0 0 {name=p154690 lab=_87000_/D }
C {devices/lab_pin.sym} 155430 -10410 0 1 {name=p154691 lab=_44688_/A }
C {sky130_stdcells/dfxtp_4.sym} 155340 -10400 0 0 {name=X_87000_ }
C {devices/lab_pin.sym} 155250 -10270 0 0 {name=p154692 lab=_84210_/CLK }
C {devices/lab_pin.sym} 155250 -10250 0 0 {name=p154693 lab=_84212_/D }
C {devices/lab_pin.sym} 155430 -10270 0 1 {name=p154694 lab=_84212_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -10260 0 0 {name=X_84212_ }
C {devices/lab_pin.sym} 155260 -10150 0 0 {name=p154695 lab=_86169_/Q }
C {devices/lab_pin.sym} 155260 -10110 0 0 {name=p154696 lab=_50594_/X }
C {devices/lab_pin.sym} 155260 -10070 0 0 {name=p154697 lab=_50603_/Y }
C {devices/lab_pin.sym} 155420 -10110 0 1 {name=p154698 lab=_50604_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -10110 0 0 {name=X_50604_ }
C {devices/lab_pin.sym} 155260 -9990 0 0 {name=p154699 lab=_57158_/Y }
C {devices/lab_pin.sym} 155260 -9950 0 0 {name=p154700 lab=_57159_/Y }
C {devices/lab_pin.sym} 155260 -9910 0 0 {name=p154701 lab=_57105_/Y }
C {devices/lab_pin.sym} 155420 -9950 0 1 {name=p154702 lab=_57160_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -9950 0 0 {name=X_57160_ }
C {devices/lab_pin.sym} 155250 -9810 0 0 {name=p154703 lab=_81749_/CLK }
C {devices/lab_pin.sym} 155250 -9790 0 0 {name=p154704 lab=_81456_/Q }
C {devices/lab_pin.sym} 155430 -9810 0 1 {name=p154705 lab=_76036_/C }
C {sky130_stdcells/dfxtp_4.sym} 155340 -9800 0 0 {name=X_81424_ }
C {devices/lab_pin.sym} 155300 -9670 0 0 {name=p154706 lab=_69146_/A }
C {devices/lab_pin.sym} 155380 -9670 0 1 {name=p154707 lab=_69146_/X }
C {sky130_stdcells/buf_2.sym} 155340 -9670 0 0 {name=X_69146_ }
C {devices/lab_pin.sym} 155300 -9550 0 0 {name=p154708 lab=_54317_/A }
C {devices/lab_pin.sym} 155380 -9550 0 1 {name=p154709 lab=_54395_/C }
C {sky130_stdcells/buf_2.sym} 155340 -9550 0 0 {name=X_54372_ }
C {devices/lab_pin.sym} 155260 -9450 0 0 {name=p154710 lab=_66294_/X }
C {devices/lab_pin.sym} 155260 -9410 0 0 {name=p154711 lab=_66355_/Y }
C {devices/lab_pin.sym} 155260 -9370 0 0 {name=p154712 lab=_66357_/Y }
C {devices/lab_pin.sym} 155420 -9410 0 1 {name=p154713 lab=_66358_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -9410 0 0 {name=X_66358_ }
C {devices/lab_pin.sym} 155250 -9270 0 0 {name=p154714 lab=_85192_/CLK }
C {devices/lab_pin.sym} 155250 -9250 0 0 {name=p154715 lab=_85192_/D }
C {devices/lab_pin.sym} 155430 -9270 0 1 {name=p154716 lab=_56442_/C }
C {sky130_stdcells/dfxtp_4.sym} 155340 -9260 0 0 {name=X_85192_ }
C {devices/lab_pin.sym} 155300 -9130 0 0 {name=p154717 lab=_51584_/A }
C {devices/lab_pin.sym} 155380 -9130 0 1 {name=p154718 lab=_51639_/A }
C {sky130_stdcells/buf_2.sym} 155340 -9130 0 0 {name=X_51584_ }
C {devices/lab_pin.sym} 155260 -9030 0 0 {name=p154719 lab=_56082_/X }
C {devices/lab_pin.sym} 155260 -8990 0 0 {name=p154720 lab=_56109_/X }
C {devices/lab_pin.sym} 155260 -8950 0 0 {name=p154721 lab=_56110_/Y }
C {devices/lab_pin.sym} 155420 -8990 0 1 {name=p154722 lab=_56111_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -8990 0 0 {name=X_56111_ }
C {devices/lab_pin.sym} 155260 -8870 0 0 {name=p154723 lab=_53319_/Y }
C {devices/lab_pin.sym} 155260 -8830 0 0 {name=p154724 lab=_53301_/X }
C {devices/lab_pin.sym} 155260 -8790 0 0 {name=p154725 lab=_53322_/X }
C {devices/lab_pin.sym} 155420 -8830 0 1 {name=p154726 lab=_85655_/D }
C {sky130_stdcells/a21oi_4.sym} 155340 -8830 0 0 {name=X_53323_ }
C {devices/lab_pin.sym} 155300 -8690 0 0 {name=p154727 lab=_64772_/A }
C {devices/lab_pin.sym} 155380 -8690 0 1 {name=p154728 lab=_65309_/X }
C {sky130_stdcells/buf_2.sym} 155340 -8690 0 0 {name=X_65309_ }
C {devices/lab_pin.sym} 155250 -8570 0 0 {name=p154729 lab=_84231_/CLK }
C {devices/lab_pin.sym} 155250 -8550 0 0 {name=p154730 lab=_84143_/D }
C {devices/lab_pin.sym} 155430 -8570 0 1 {name=p154731 lab=_84143_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -8560 0 0 {name=X_84143_ }
C {devices/lab_pin.sym} 155280 -8440 0 0 {name=p154732 lab=_50541_/A }
C {devices/lab_pin.sym} 155280 -8400 0 0 {name=p154733 lab=_48851_/B }
C {devices/lab_pin.sym} 155400 -8420 0 1 {name=p154734 lab=_50535_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -8420 0 0 {name=X_50535_ }
C {devices/lab_pin.sym} 155250 -8290 0 0 {name=p154735 lab=_81322_/CLK }
C {devices/lab_pin.sym} 155250 -8270 0 0 {name=p154736 lab=_81355_/D }
C {devices/lab_pin.sym} 155430 -8290 0 1 {name=p154737 lab=_81355_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -8280 0 0 {name=X_81355_ }
C {devices/lab_pin.sym} 155300 -8150 0 0 {name=p154738 lab=_73227_/A }
C {devices/lab_pin.sym} 155380 -8150 0 1 {name=p154739 lab=_73198_/B }
C {sky130_stdcells/buf_2.sym} 155340 -8150 0 0 {name=X_57091_ }
C {devices/lab_pin.sym} 155260 -8060 0 0 {name=p154740 lab=_87990_/Q }
C {devices/lab_pin.sym} 155260 -8020 0 0 {name=p154741 lab=_69007_/X }
C {devices/lab_pin.sym} 155260 -7980 0 0 {name=p154742 lab=_69051_/X }
C {devices/lab_pin.sym} 155260 -7940 0 0 {name=p154743 lab=_69076_/X }
C {devices/lab_pin.sym} 155420 -8000 0 1 {name=p154744 lab=_69077_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -8000 0 0 {name=X_69077_ }
C {devices/lab_pin.sym} 155260 -7880 0 0 {name=p154745 lab=_57761_/X }
C {devices/lab_pin.sym} 155260 -7840 0 0 {name=p154746 lab=_84967_/Q }
C {devices/lab_pin.sym} 155260 -7800 0 0 {name=p154747 lab=_65309_/X }
C {devices/lab_pin.sym} 155260 -7760 0 0 {name=p154748 lab=_66288_/X }
C {devices/lab_pin.sym} 155420 -7820 0 1 {name=p154749 lab=_66289_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -7820 0 0 {name=X_66289_ }
C {devices/lab_pin.sym} 155300 -7670 0 0 {name=p154750 lab=_80319_/B }
C {devices/lab_pin.sym} 155380 -7670 0 1 {name=p154751 lab=_80306_/Y }
C {sky130_stdcells/inv_2.sym} 155340 -7670 0 0 {name=X_80306_ }
C {devices/lab_pin.sym} 155260 -7570 0 0 {name=p154752 lab=_56029_/X }
C {devices/lab_pin.sym} 155260 -7530 0 0 {name=p154753 lab=_56040_/X }
C {devices/lab_pin.sym} 155260 -7490 0 0 {name=p154754 lab=_56041_/Y }
C {devices/lab_pin.sym} 155420 -7530 0 1 {name=p154755 lab=_56042_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -7530 0 0 {name=X_56042_ }
C {devices/lab_pin.sym} 155280 -7400 0 0 {name=p154756 lab=_68028_/A }
C {devices/lab_pin.sym} 155280 -7360 0 0 {name=p154757 lab=_87702_/Q }
C {devices/lab_pin.sym} 155400 -7380 0 1 {name=p154758 lab=_68028_/X }
C {sky130_stdcells/and2_4.sym} 155340 -7380 0 0 {name=X_68028_ }
C {devices/lab_pin.sym} 155260 -7270 0 0 {name=p154759 lab=_53252_/Y }
C {devices/lab_pin.sym} 155260 -7230 0 0 {name=p154760 lab=_53242_/X }
C {devices/lab_pin.sym} 155260 -7190 0 0 {name=p154761 lab=_53253_/X }
C {devices/lab_pin.sym} 155420 -7230 0 1 {name=p154762 lab=_85668_/D }
C {sky130_stdcells/a21oi_4.sym} 155340 -7230 0 0 {name=X_53254_ }
C {devices/lab_pin.sym} 155250 -7090 0 0 {name=p154763 lab=_84074_/CLK }
C {devices/lab_pin.sym} 155250 -7070 0 0 {name=p154764 lab=_84074_/D }
C {devices/lab_pin.sym} 155430 -7090 0 1 {name=p154765 lab=_84074_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -7080 0 0 {name=X_84074_ }
C {devices/lab_pin.sym} 155280 -6960 0 0 {name=p154766 lab=_50465_/X }
C {devices/lab_pin.sym} 155280 -6920 0 0 {name=p154767 lab=_50466_/B }
C {devices/lab_pin.sym} 155400 -6940 0 1 {name=p154768 lab=_50466_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -6940 0 0 {name=X_50466_ }
C {devices/lab_pin.sym} 155250 -6810 0 0 {name=p154769 lab=_81603_/CLK }
C {devices/lab_pin.sym} 155250 -6790 0 0 {name=p154770 lab=_76974_/X }
C {devices/lab_pin.sym} 155430 -6810 0 1 {name=p154771 lab=_81286_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -6800 0 0 {name=X_81286_ }
C {devices/lab_pin.sym} 155300 -6670 0 0 {name=p154772 lab=clkbuf_4_8_1_CLK/X }
C {devices/lab_pin.sym} 155380 -6670 0 1 {name=p154773 lab=clkbuf_6_35_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 155340 -6670 0 0 {name=Xclkbuf_5_17_0_CLK }
C {devices/lab_pin.sym} 155260 -6570 0 0 {name=p154774 lab=_52202_/Y }
C {devices/lab_pin.sym} 155260 -6530 0 0 {name=p154775 lab=_52203_/X }
C {devices/lab_pin.sym} 155260 -6490 0 0 {name=p154776 lab=_52204_/X }
C {devices/lab_pin.sym} 155420 -6530 0 1 {name=p154777 lab=_85869_/D }
C {sky130_stdcells/a21oi_4.sym} 155340 -6530 0 0 {name=X_52205_ }
C {devices/lab_pin.sym} 155250 -6390 0 0 {name=p154778 lab=_83025_/CLK }
C {devices/lab_pin.sym} 155250 -6370 0 0 {name=p154779 lab=_83025_/D }
C {devices/lab_pin.sym} 155430 -6390 0 1 {name=p154780 lab=_83025_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -6380 0 0 {name=X_83025_ }
C {devices/lab_pin.sym} 155250 -6250 0 0 {name=p154781 lab=_87644_/CLK }
C {devices/lab_pin.sym} 155250 -6230 0 0 {name=p154782 lab=_87902_/D }
C {devices/lab_pin.sym} 155430 -6250 0 1 {name=p154783 lab=_87902_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -6240 0 0 {name=X_87902_ }
C {devices/lab_pin.sym} 155280 -6120 0 0 {name=p154784 lab=_80244_/B }
C {devices/lab_pin.sym} 155280 -6080 0 0 {name=p154785 lab=_80236_/Y }
C {devices/lab_pin.sym} 155400 -6100 0 1 {name=p154786 lab=_80237_/X }
C {sky130_stdcells/xor2_4.sym} 155340 -6100 0 0 {name=X_80237_ }
C {devices/lab_pin.sym} 155280 -6000 0 0 {name=p154787 lab=_53181_/A }
C {devices/lab_pin.sym} 155280 -5960 0 0 {name=p154788 lab=_53181_/B }
C {devices/lab_pin.sym} 155280 -5920 0 0 {name=p154789 lab=_53169_/X }
C {devices/lab_pin.sym} 155280 -5880 0 0 {name=p154790 lab=_53185_/D }
C {devices/lab_pin.sym} 155400 -5940 0 1 {name=p154791 lab=_53185_/X }
C {sky130_stdcells/and4_4.sym} 155340 -5940 0 0 {name=X_53185_ }
C {devices/lab_pin.sym} 155260 -5810 0 0 {name=p154792 lab=_50394_/Y }
C {devices/lab_pin.sym} 155260 -5770 0 0 {name=p154793 lab=_50395_/X }
C {devices/lab_pin.sym} 155260 -5730 0 0 {name=p154794 lab=_50396_/X }
C {devices/lab_pin.sym} 155420 -5770 0 1 {name=p154795 lab=_86209_/D }
C {sky130_stdcells/a21oi_4.sym} 155340 -5770 0 0 {name=X_50397_ }
C {devices/lab_pin.sym} 155300 -5630 0 0 {name=p154796 lab=_59801_/A }
C {devices/lab_pin.sym} 155380 -5630 0 1 {name=p154797 lab=_70009_/A }
C {sky130_stdcells/buf_2.sym} 155340 -5630 0 0 {name=X_59801_ }
C {devices/lab_pin.sym} 155260 -5530 0 0 {name=p154798 lab=_52133_/Y }
C {devices/lab_pin.sym} 155260 -5490 0 0 {name=p154799 lab=_52108_/X }
C {devices/lab_pin.sym} 155260 -5450 0 0 {name=p154800 lab=_52135_/X }
C {devices/lab_pin.sym} 155420 -5490 0 1 {name=p154801 lab=_52136_/Y }
C {sky130_stdcells/a21oi_4.sym} 155340 -5490 0 0 {name=X_52136_ }
C {devices/lab_pin.sym} 155250 -5350 0 0 {name=p154802 lab=_87834_/CLK }
C {devices/lab_pin.sym} 155250 -5330 0 0 {name=p154803 lab=_87833_/D }
C {devices/lab_pin.sym} 155430 -5350 0 1 {name=p154804 lab=_74164_/A }
C {sky130_stdcells/dfxtp_4.sym} 155340 -5340 0 0 {name=X_87833_ }
C {devices/lab_pin.sym} 155280 -5220 0 0 {name=p154805 lab=_80164_/Y }
C {devices/lab_pin.sym} 155280 -5180 0 0 {name=p154806 lab=_80167_/Y }
C {devices/lab_pin.sym} 155400 -5200 0 1 {name=p154807 lab=_80178_/B }
C {sky130_stdcells/xor2_4.sym} 155340 -5200 0 0 {name=X_80168_ }
C {devices/lab_pin.sym} 155300 -5070 0 0 {name=p154808 lab=_72417_/A }
C {devices/lab_pin.sym} 155380 -5070 0 1 {name=p154809 lab=_57993_/X }
C {sky130_stdcells/buf_2.sym} 155340 -5070 0 0 {name=X_57993_ }
C {devices/lab_pin.sym} 155260 -4980 0 0 {name=p154810 lab=_69574_/Y }
C {devices/lab_pin.sym} 155260 -4940 0 0 {name=p154811 lab=_69916_/X }
C {devices/lab_pin.sym} 155260 -4900 0 0 {name=p154812 lab=_69938_/X }
C {devices/lab_pin.sym} 155260 -4860 0 0 {name=p154813 lab=_69978_/Y }
C {devices/lab_pin.sym} 155420 -4920 0 1 {name=p154814 lab=_69979_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -4920 0 0 {name=X_69979_ }
C {devices/lab_pin.sym} 155300 -4770 0 0 {name=p154815 lab=_59649_/A }
C {devices/lab_pin.sym} 155380 -4770 0 1 {name=p154816 lab=_59754_/C }
C {sky130_stdcells/buf_2.sym} 155340 -4770 0 0 {name=X_59732_ }
C {devices/lab_pin.sym} 155300 -4650 0 0 {name=p154817 lab=_52431_/A }
C {devices/lab_pin.sym} 155380 -4650 0 1 {name=p154818 lab=_52083_/A }
C {sky130_stdcells/buf_2.sym} 155340 -4650 0 0 {name=X_52067_ }
C {devices/lab_pin.sym} 155260 -4560 0 0 {name=p154819 lab=_44214_/X }
C {devices/lab_pin.sym} 155260 -4520 0 0 {name=p154820 lab=_56571_/X }
C {devices/lab_pin.sym} 155260 -4480 0 0 {name=p154821 lab=_45409_/A }
C {devices/lab_pin.sym} 155260 -4440 0 0 {name=p154822 lab=_56943_/X }
C {devices/lab_pin.sym} 155420 -4500 0 1 {name=p154823 lab=_85120_/D }
C {sky130_stdcells/a2bb2o_4.sym} 155340 -4500 0 0 {name=X_56944_ }
C {devices/lab_pin.sym} 155250 -4350 0 0 {name=p154824 lab=_87766_/CLK }
C {devices/lab_pin.sym} 155250 -4330 0 0 {name=p154825 lab=_42698_/X }
C {devices/lab_pin.sym} 155430 -4350 0 1 {name=p154826 lab=_69553_/B }
C {sky130_stdcells/dfxtp_4.sym} 155340 -4340 0 0 {name=X_87764_ }
C {devices/lab_pin.sym} 155260 -4240 0 0 {name=p154827 lab=_72988_/X }
C {devices/lab_pin.sym} 155260 -4200 0 0 {name=p154828 lab=_85593_/Q }
C {devices/lab_pin.sym} 155260 -4160 0 0 {name=p154829 lab=_44272_/X }
C {devices/lab_pin.sym} 155260 -4120 0 0 {name=p154830 lab=_72989_/X }
C {devices/lab_pin.sym} 155420 -4180 0 1 {name=p154831 lab=_72990_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -4180 0 0 {name=X_72990_ }
C {devices/lab_pin.sym} 155250 -4030 0 0 {name=p154832 lab=_86576_/CLK }
C {devices/lab_pin.sym} 155250 -4010 0 0 {name=p154833 lab=_57577_/Y }
C {devices/lab_pin.sym} 155430 -4030 0 1 {name=p154834 lab=_84976_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -4020 0 0 {name=X_84976_ }
C {devices/lab_pin.sym} 155280 -3900 0 0 {name=p154835 lab=_84938_/Q }
C {devices/lab_pin.sym} 155280 -3860 0 0 {name=p154836 lab=_84186_/Q }
C {devices/lab_pin.sym} 155400 -3880 0 1 {name=p154837 lab=_80099_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -3880 0 0 {name=X_80099_ }
C {devices/lab_pin.sym} 155280 -3780 0 0 {name=p154838 lab=_51018_/A }
C {devices/lab_pin.sym} 155280 -3740 0 0 {name=p154839 lab=_51029_/B }
C {devices/lab_pin.sym} 155280 -3700 0 0 {name=p154840 lab=_51029_/C }
C {devices/lab_pin.sym} 155280 -3660 0 0 {name=p154841 lab=_52709_/D }
C {devices/lab_pin.sym} 155400 -3720 0 1 {name=p154842 lab=_51018_/X }
C {sky130_stdcells/and4_4.sym} 155340 -3720 0 0 {name=X_51018_ }
C {devices/lab_pin.sym} 155250 -3570 0 0 {name=p154843 lab=_86711_/CLK }
C {devices/lab_pin.sym} 155250 -3550 0 0 {name=p154844 lab=_86715_/D }
C {devices/lab_pin.sym} 155430 -3570 0 1 {name=p154845 lab=_58649_/A }
C {sky130_stdcells/dfxtp_4.sym} 155340 -3560 0 0 {name=X_86715_ }
C {devices/lab_pin.sym} 155260 -3450 0 0 {name=p154846 lab=_55681_/A }
C {devices/lab_pin.sym} 155260 -3410 0 0 {name=p154847 lab=_71939_/X }
C {devices/lab_pin.sym} 155260 -3370 0 0 {name=p154848 lab=_71940_/Y }
C {devices/lab_pin.sym} 155420 -3410 0 1 {name=p154849 lab=_71941_/Y }
C {sky130_stdcells/o21ai_4.sym} 155340 -3410 0 0 {name=X_71941_ }
C {devices/lab_pin.sym} 155250 -3270 0 0 {name=p154850 lab=_81473_/CLK }
C {devices/lab_pin.sym} 155250 -3250 0 0 {name=p154851 lab=_83927_/D }
C {devices/lab_pin.sym} 155430 -3270 0 1 {name=p154852 lab=_81391_/D }
C {sky130_stdcells/dfxtp_4.sym} 155340 -3260 0 0 {name=X_83927_ }
C {devices/lab_pin.sym} 155300 -3130 0 0 {name=p154853 lab=_59681_/A }
C {devices/lab_pin.sym} 155380 -3130 0 1 {name=p154854 lab=_59754_/D }
C {sky130_stdcells/inv_2.sym} 155340 -3130 0 0 {name=X_59663_ }
C {devices/lab_pin.sym} 155260 -3030 0 0 {name=p154855 lab=_56636_/X }
C {devices/lab_pin.sym} 155260 -2990 0 0 {name=p154856 lab=_56865_/Y }
C {devices/lab_pin.sym} 155260 -2950 0 0 {name=p154857 lab=_56874_/X }
C {devices/lab_pin.sym} 155420 -2990 0 1 {name=p154858 lab=_56875_/X }
C {sky130_stdcells/a21o_4.sym} 155340 -2990 0 0 {name=X_56875_ }
C {devices/lab_pin.sym} 155250 -2850 0 0 {name=p154859 lab=_87950_/CLK }
C {devices/lab_pin.sym} 155250 -2830 0 0 {name=p154860 lab=_42833_/X }
C {devices/lab_pin.sym} 155430 -2850 0 1 {name=p154861 lab=_87695_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -2840 0 0 {name=X_87695_ }
C {devices/lab_pin.sym} 155280 -2720 0 0 {name=p154862 lab=_86717_/Q }
C {devices/lab_pin.sym} 155280 -2680 0 0 {name=p154863 lab=_58614_/B }
C {devices/lab_pin.sym} 155400 -2700 0 1 {name=p154864 lab=_58614_/Y }
C {sky130_stdcells/nor2_4.sym} 155340 -2700 0 0 {name=X_58614_ }
C {devices/lab_pin.sym} 155300 -2570 0 0 {name=p154865 lab=_43840_/A }
C {devices/lab_pin.sym} 155380 -2570 0 1 {name=p154866 lab=_87239_/D }
C {sky130_stdcells/inv_2.sym} 155340 -2570 0 0 {name=X_43840_ }
C {devices/lab_pin.sym} 155280 -2460 0 0 {name=p154867 lab=_55826_/A }
C {devices/lab_pin.sym} 155280 -2420 0 0 {name=p154868 lab=_55826_/B }
C {devices/lab_pin.sym} 155400 -2440 0 1 {name=p154869 lab=_55826_/X }
C {sky130_stdcells/and2_4.sym} 155340 -2440 0 0 {name=X_55826_ }
C {devices/lab_pin.sym} 155250 -2310 0 0 {name=p154870 lab=_86008_/CLK }
C {devices/lab_pin.sym} 155250 -2290 0 0 {name=p154871 lab=_86646_/D }
C {devices/lab_pin.sym} 155430 -2310 0 1 {name=p154872 lab=_86646_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -2300 0 0 {name=X_86646_ }
C {devices/lab_pin.sym} 155280 -2180 0 0 {name=p154873 lab=_74642_/X }
C {devices/lab_pin.sym} 155280 -2140 0 0 {name=p154874 lab=_45654_/A }
C {devices/lab_pin.sym} 155400 -2160 0 1 {name=p154875 lab=_74660_/Y }
C {sky130_stdcells/nand2_4.sym} 155340 -2160 0 0 {name=X_74660_ }
C {devices/lab_pin.sym} 155300 -2030 0 0 {name=p154876 lab=_71783_/A }
C {devices/lab_pin.sym} 155380 -2030 0 1 {name=p154877 lab=_71883_/B }
C {sky130_stdcells/buf_2.sym} 155340 -2030 0 0 {name=X_71872_ }
C {devices/lab_pin.sym} 155300 -1910 0 0 {name=p154878 lab=_59593_/X }
C {devices/lab_pin.sym} 155380 -1910 0 1 {name=p154879 lab=_59622_/A }
C {sky130_stdcells/buf_2.sym} 155340 -1910 0 0 {name=X_59594_ }
C {devices/lab_pin.sym} 155250 -1790 0 0 {name=p154880 lab=_82536_/CLK }
C {devices/lab_pin.sym} 155250 -1770 0 0 {name=p154881 lab=_83858_/D }
C {devices/lab_pin.sym} 155430 -1790 0 1 {name=p154882 lab=_82538_/D }
C {sky130_stdcells/dfxtp_4.sym} 155340 -1780 0 0 {name=X_83858_ }
C {devices/lab_pin.sym} 155260 -1680 0 0 {name=p154883 lab=_73609_/X }
C {devices/lab_pin.sym} 155260 -1640 0 0 {name=p154884 lab=_85631_/Q }
C {devices/lab_pin.sym} 155260 -1600 0 0 {name=p154885 lab=_73472_/X }
C {devices/lab_pin.sym} 155260 -1560 0 0 {name=p154886 lab=_73610_/X }
C {devices/lab_pin.sym} 155420 -1620 0 1 {name=p154887 lab=_73611_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -1620 0 0 {name=X_73611_ }
C {devices/lab_pin.sym} 155260 -1490 0 0 {name=p154888 lab=_51222_/B }
C {devices/lab_pin.sym} 155260 -1450 0 0 {name=p154889 lab=_70802_/A }
C {devices/lab_pin.sym} 155260 -1410 0 0 {name=p154890 lab=_70822_/Y }
C {devices/lab_pin.sym} 155420 -1450 0 1 {name=p154891 lab=_83691_/D }
C {sky130_stdcells/o21ai_4.sym} 155340 -1450 0 0 {name=X_70823_ }
C {devices/lab_pin.sym} 155260 -1330 0 0 {name=p154892 lab=_58538_/X }
C {devices/lab_pin.sym} 155260 -1290 0 0 {name=p154893 lab=_83359_/Q }
C {devices/lab_pin.sym} 155260 -1250 0 0 {name=p154894 lab=_58544_/Y }
C {devices/lab_pin.sym} 155420 -1290 0 1 {name=p154895 lab=_58545_/X }
C {sky130_stdcells/o21a_4.sym} 155340 -1290 0 0 {name=X_58545_ }
C {devices/lab_pin.sym} 155250 -1150 0 0 {name=p154896 lab=_82743_/CLK }
C {devices/lab_pin.sym} 155250 -1130 0 0 {name=p154897 lab=_82841_/Q }
C {devices/lab_pin.sym} 155430 -1150 0 1 {name=p154898 lab=_82809_/Q }
C {sky130_stdcells/dfxtp_4.sym} 155340 -1140 0 0 {name=X_82809_ }
C {devices/lab_pin.sym} 155300 -1010 0 0 {name=p154899 lab=_43606_/A }
C {devices/lab_pin.sym} 155380 -1010 0 1 {name=p154900 lab=_43802_/A }
C {sky130_stdcells/buf_2.sym} 155340 -1010 0 0 {name=X_43771_ }
C {devices/lab_pin.sym} 155260 -920 0 0 {name=p154901 lab=_85255_/Q }
C {devices/lab_pin.sym} 155260 -880 0 0 {name=p154902 lab=_55190_/X }
C {devices/lab_pin.sym} 155260 -840 0 0 {name=p154903 lab=_44045_/X }
C {devices/lab_pin.sym} 155260 -800 0 0 {name=p154904 lab=_55756_/X }
C {devices/lab_pin.sym} 155420 -860 0 1 {name=p154905 lab=_55757_/X }
C {sky130_stdcells/a211o_4.sym} 155340 -860 0 0 {name=X_55757_ }
C {devices/lab_pin.sym} 155300 -710 0 0 {name=p154906 lab=_56863_/X }
C {devices/lab_pin.sym} 155380 -710 0 1 {name=p154907 lab=_74591_/X }
C {sky130_stdcells/buf_2.sym} 155340 -710 0 0 {name=X_74591_ }
C {devices/lab_pin.sym} 156170 -42150 0 0 {name=p154908 lab=_85630_/CLK }
C {devices/lab_pin.sym} 156170 -42130 0 0 {name=p154909 lab=_86577_/D }
C {devices/lab_pin.sym} 156350 -42150 0 1 {name=p154910 lab=_66143_/B }
C {sky130_stdcells/dfxtp_4.sym} 156260 -42140 0 0 {name=X_86577_ }
C {devices/lab_pin.sym} 156200 -42020 0 0 {name=p154911 lab=_52979_/A }
C {devices/lab_pin.sym} 156200 -41980 0 0 {name=p154912 lab=_52969_/B }
C {devices/lab_pin.sym} 156320 -42000 0 1 {name=p154913 lab=_52969_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -42000 0 0 {name=X_52969_ }
C {devices/lab_pin.sym} 156180 -41900 0 0 {name=p154914 lab=_40982_/X }
C {devices/lab_pin.sym} 156180 -41860 0 0 {name=p154915 lab=_40941_/X }
C {devices/lab_pin.sym} 156180 -41820 0 0 {name=p154916 lab=_69265_/B }
C {devices/lab_pin.sym} 156180 -41780 0 0 {name=p154917 lab=_40942_/X }
C {devices/lab_pin.sym} 156340 -41840 0 1 {name=p154918 lab=_88298_/D }
C {sky130_stdcells/a2bb2o_4.sym} 156260 -41840 0 0 {name=X_40983_ }
C {devices/lab_pin.sym} 156170 -41690 0 0 {name=p154919 lab=_81259_/CLK }
C {devices/lab_pin.sym} 156170 -41670 0 0 {name=p154920 lab=_70345_/X }
C {devices/lab_pin.sym} 156350 -41690 0 1 {name=p154921 lab=_74769_/A }
C {sky130_stdcells/dfxtp_4.sym} 156260 -41680 0 0 {name=X_83789_ }
C {devices/lab_pin.sym} 156200 -41560 0 0 {name=p154922 lab=_45510_/A }
C {devices/lab_pin.sym} 156200 -41520 0 0 {name=p154923 lab=_45590_/B }
C {devices/lab_pin.sym} 156320 -41540 0 1 {name=p154924 lab=_45510_/X }
C {sky130_stdcells/and2_4.sym} 156260 -41540 0 0 {name=X_45510_ }
C {devices/lab_pin.sym} 156220 -41410 0 0 {name=p154925 lab=_76330_/A }
C {devices/lab_pin.sym} 156300 -41410 0 1 {name=p154926 lab=_76330_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -41410 0 0 {name=X_76330_ }
C {devices/lab_pin.sym} 156170 -41290 0 0 {name=p154927 lab=_87063_/CLK }
C {devices/lab_pin.sym} 156170 -41270 0 0 {name=p154928 lab=_40891_/X }
C {devices/lab_pin.sym} 156350 -41290 0 1 {name=p154929 lab=_88316_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -41280 0 0 {name=X_88316_ }
C {devices/lab_pin.sym} 156180 -41170 0 0 {name=p154930 lab=_54706_/Y }
C {devices/lab_pin.sym} 156180 -41130 0 0 {name=p154931 lab=_54694_/X }
C {devices/lab_pin.sym} 156180 -41090 0 0 {name=p154932 lab=_54707_/X }
C {devices/lab_pin.sym} 156340 -41130 0 1 {name=p154933 lab=_54708_/Y }
C {sky130_stdcells/a21oi_4.sym} 156260 -41130 0 0 {name=X_54708_ }
C {devices/lab_pin.sym} 156220 -40990 0 0 {name=p154934 lab=_42429_/A }
C {devices/lab_pin.sym} 156300 -40990 0 1 {name=p154935 lab=_42723_/A }
C {sky130_stdcells/buf_2.sym} 156260 -40990 0 0 {name=X_42722_ }
C {devices/lab_pin.sym} 156200 -40880 0 0 {name=p154936 lab=_73542_/A }
C {devices/lab_pin.sym} 156200 -40840 0 0 {name=p154937 lab=_73542_/B }
C {devices/lab_pin.sym} 156320 -40860 0 1 {name=p154938 lab=_73543_/B }
C {sky130_stdcells/nand2_4.sym} 156260 -40860 0 0 {name=X_73542_ }
C {devices/lab_pin.sym} 156170 -40730 0 0 {name=p154939 lab=_85529_/CLK }
C {devices/lab_pin.sym} 156170 -40710 0 0 {name=p154940 lab=_85528_/D }
C {devices/lab_pin.sym} 156350 -40730 0 1 {name=p154941 lab=_85528_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -40720 0 0 {name=X_85528_ }
C {devices/lab_pin.sym} 156220 -40590 0 0 {name=p154942 lab=_52526_/B }
C {devices/lab_pin.sym} 156300 -40590 0 1 {name=p154943 lab=_50832_/B }
C {sky130_stdcells/buf_2.sym} 156260 -40590 0 0 {name=X_46490_ }
C {devices/lab_pin.sym} 156180 -40490 0 0 {name=p154944 lab=_53131_/B }
C {devices/lab_pin.sym} 156180 -40450 0 0 {name=p154945 lab=_70740_/A }
C {devices/lab_pin.sym} 156180 -40410 0 0 {name=p154946 lab=_70753_/Y }
C {devices/lab_pin.sym} 156340 -40450 0 1 {name=p154947 lab=_83707_/D }
C {sky130_stdcells/o21ai_4.sym} 156260 -40450 0 0 {name=X_70754_ }
C {devices/lab_pin.sym} 156220 -40310 0 0 {name=p154948 lab=_83415_/Q }
C {devices/lab_pin.sym} 156300 -40310 0 1 {name=p154949 lab=_58476_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -40310 0 0 {name=X_58476_ }
C {devices/lab_pin.sym} 156220 -40190 0 0 {name=p154950 lab=_56169_/A }
C {devices/lab_pin.sym} 156300 -40190 0 1 {name=p154951 lab=_55688_/X }
C {sky130_stdcells/buf_2.sym} 156260 -40190 0 0 {name=X_55688_ }
C {devices/lab_pin.sym} 156180 -40100 0 0 {name=p154952 lab=_45438_/Y }
C {devices/lab_pin.sym} 156180 -40060 0 0 {name=p154953 lab=_45439_/X }
C {devices/lab_pin.sym} 156180 -40020 0 0 {name=p154954 lab=_45390_/X }
C {devices/lab_pin.sym} 156180 -39980 0 0 {name=p154955 lab=_45440_/Y }
C {devices/lab_pin.sym} 156340 -40040 0 1 {name=p154956 lab=_45441_/X }
C {sky130_stdcells/a211o_4.sym} 156260 -40040 0 0 {name=X_45441_ }
C {devices/lab_pin.sym} 156200 -39910 0 0 {name=p154957 lab=_57427_/A }
C {devices/lab_pin.sym} 156200 -39870 0 0 {name=p154958 lab=_57445_/B }
C {devices/lab_pin.sym} 156200 -39830 0 0 {name=p154959 lab=_56750_/Y }
C {devices/lab_pin.sym} 156320 -39870 0 1 {name=p154960 lab=_57427_/Y }
C {sky130_stdcells/nand3_4.sym} 156260 -39870 0 0 {name=X_57427_ }
C {devices/lab_pin.sym} 156200 -39740 0 0 {name=p154961 lab=_81642_/Q }
C {devices/lab_pin.sym} 156200 -39700 0 0 {name=p154962 lab=_76260_/X }
C {devices/lab_pin.sym} 156320 -39720 0 1 {name=p154963 lab=_76261_/X }
C {sky130_stdcells/or2_4.sym} 156260 -39720 0 0 {name=X_76261_ }
C {devices/lab_pin.sym} 156170 -39590 0 0 {name=p154964 lab=_88247_/CLK }
C {devices/lab_pin.sym} 156170 -39570 0 0 {name=p154965 lab=_41269_/X }
C {devices/lab_pin.sym} 156350 -39590 0 1 {name=p154966 lab=_69048_/B }
C {sky130_stdcells/dfxtp_4.sym} 156260 -39580 0 0 {name=X_88247_ }
C {devices/lab_pin.sym} 156220 -39450 0 0 {name=p154967 lab=_42634_/A }
C {devices/lab_pin.sym} 156300 -39450 0 1 {name=p154968 lab=_42653_/X }
C {sky130_stdcells/buf_2.sym} 156260 -39450 0 0 {name=X_42653_ }
C {devices/lab_pin.sym} 156200 -39360 0 0 {name=p154969 lab=_54625_/A }
C {devices/lab_pin.sym} 156200 -39320 0 0 {name=p154970 lab=_54645_/B }
C {devices/lab_pin.sym} 156200 -39280 0 0 {name=p154971 lab=_54618_/X }
C {devices/lab_pin.sym} 156200 -39240 0 0 {name=p154972 lab=_47264_/A }
C {devices/lab_pin.sym} 156320 -39300 0 1 {name=p154973 lab=_54639_/X }
C {sky130_stdcells/and4_4.sym} 156260 -39300 0 0 {name=X_54639_ }
C {devices/lab_pin.sym} 156200 -39160 0 0 {name=p154974 lab=_73426_/A }
C {devices/lab_pin.sym} 156200 -39120 0 0 {name=p154975 lab=_86469_/Q }
C {devices/lab_pin.sym} 156320 -39140 0 1 {name=p154976 lab=_73473_/X }
C {sky130_stdcells/and2_4.sym} 156260 -39140 0 0 {name=X_73473_ }
C {devices/lab_pin.sym} 156170 -39010 0 0 {name=p154977 lab=_85459_/CLK }
C {devices/lab_pin.sym} 156170 -38990 0 0 {name=p154978 lab=_54348_/Y }
C {devices/lab_pin.sym} 156350 -39010 0 1 {name=p154979 lab=_85459_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -39000 0 0 {name=X_85459_ }
C {devices/lab_pin.sym} 156220 -38870 0 0 {name=p154980 lab=_70669_/A }
C {devices/lab_pin.sym} 156300 -38870 0 1 {name=p154981 lab=_70692_/C }
C {sky130_stdcells/buf_2.sym} 156260 -38870 0 0 {name=X_70685_ }
C {devices/lab_pin.sym} 156220 -38750 0 0 {name=p154982 lab=_78000_/A }
C {devices/lab_pin.sym} 156300 -38750 0 1 {name=p154983 lab=_78000_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -38750 0 0 {name=X_78000_ }
C {devices/lab_pin.sym} 156180 -38650 0 0 {name=p154984 lab=_80683_/Q }
C {devices/lab_pin.sym} 156180 -38610 0 0 {name=p154985 lab=_80983_/Q }
C {devices/lab_pin.sym} 156180 -38570 0 0 {name=p154986 lab=_75201_/Y }
C {devices/lab_pin.sym} 156340 -38610 0 1 {name=p154987 lab=_75212_/Y }
C {sky130_stdcells/a21boi_4.sym} 156260 -38610 0 0 {name=X_75212_ }
C {devices/lab_pin.sym} 156200 -38480 0 0 {name=p154988 lab=_41604_/A }
C {devices/lab_pin.sym} 156200 -38440 0 0 {name=p154989 lab=_82309_/Q }
C {devices/lab_pin.sym} 156320 -38460 0 1 {name=p154990 lab=_41604_/X }
C {sky130_stdcells/or2_4.sym} 156260 -38460 0 0 {name=X_41604_ }
C {devices/lab_pin.sym} 156200 -38340 0 0 {name=p154991 lab=_48801_/A }
C {devices/lab_pin.sym} 156200 -38300 0 0 {name=p154992 lab=_50391_/A }
C {devices/lab_pin.sym} 156320 -38320 0 1 {name=p154993 lab=_48160_/X }
C {sky130_stdcells/and2_4.sym} 156260 -38320 0 0 {name=X_48160_ }
C {devices/lab_pin.sym} 156180 -38210 0 0 {name=p154994 lab=_72352_/X }
C {devices/lab_pin.sym} 156180 -38170 0 0 {name=p154995 lab=_85960_/Q }
C {devices/lab_pin.sym} 156180 -38130 0 0 {name=p154996 lab=_72423_/X }
C {devices/lab_pin.sym} 156340 -38170 0 1 {name=p154997 lab=_72424_/Y }
C {sky130_stdcells/o21ai_4.sym} 156260 -38170 0 0 {name=X_72424_ }
C {devices/lab_pin.sym} 156200 -38040 0 0 {name=p154998 lab=_57358_/A }
C {devices/lab_pin.sym} 156200 -38000 0 0 {name=p154999 lab=_57068_/X }
C {devices/lab_pin.sym} 156320 -38020 0 1 {name=p155000 lab=_57358_/X }
C {sky130_stdcells/xor2_4.sym} 156260 -38020 0 0 {name=X_57358_ }
C {devices/lab_pin.sym} 156180 -37910 0 0 {name=p155001 lab=_45362_/X }
C {devices/lab_pin.sym} 156180 -37870 0 0 {name=p155002 lab=_45366_/Y }
C {devices/lab_pin.sym} 156180 -37830 0 0 {name=p155003 lab=_45371_/Y }
C {devices/lab_pin.sym} 156340 -37870 0 1 {name=p155004 lab=_45372_/Y }
C {sky130_stdcells/a21oi_4.sym} 156260 -37870 0 0 {name=X_45372_ }
C {devices/lab_pin.sym} 156180 -37750 0 0 {name=p155005 lab=_76188_/X }
C {devices/lab_pin.sym} 156180 -37710 0 0 {name=p155006 lab=_76193_/C }
C {devices/lab_pin.sym} 156180 -37670 0 0 {name=p155007 lab=_76193_/A }
C {devices/lab_pin.sym} 156340 -37710 0 1 {name=p155008 lab=_76192_/X }
C {sky130_stdcells/a21o_4.sym} 156260 -37710 0 0 {name=X_76192_ }
C {devices/lab_pin.sym} 156170 -37570 0 0 {name=p155009 lab=_82896_/CLK }
C {devices/lab_pin.sym} 156170 -37550 0 0 {name=p155010 lab=_88178_/D }
C {devices/lab_pin.sym} 156350 -37570 0 1 {name=p155011 lab=_67365_/B }
C {sky130_stdcells/dfxtp_4.sym} 156260 -37560 0 0 {name=X_88178_ }
C {devices/lab_pin.sym} 156180 -37470 0 0 {name=p155012 lab=_42568_/X }
C {devices/lab_pin.sym} 156180 -37430 0 0 {name=p155013 lab=_42569_/X }
C {devices/lab_pin.sym} 156180 -37390 0 0 {name=p155014 lab=_40845_/X }
C {devices/lab_pin.sym} 156180 -37350 0 0 {name=p155015 lab=_42583_/Y }
C {devices/lab_pin.sym} 156180 -37310 0 0 {name=p155016 lab=_42571_/X }
C {devices/lab_pin.sym} 156340 -37390 0 1 {name=p155017 lab=_42584_/Y }
C {sky130_stdcells/o32ai_4.sym} 156260 -37390 0 0 {name=X_42584_ }
C {devices/lab_pin.sym} 156220 -37230 0 0 {name=p155018 lab=_47111_/A }
C {devices/lab_pin.sym} 156300 -37230 0 1 {name=p155019 lab=_54553_/D }
C {sky130_stdcells/inv_2.sym} 156260 -37230 0 0 {name=X_47111_ }
C {devices/lab_pin.sym} 156200 -37130 0 0 {name=p155020 lab=_56309_/A }
C {devices/lab_pin.sym} 156200 -37090 0 0 {name=p155021 lab=_56298_/X }
C {devices/lab_pin.sym} 156200 -37050 0 0 {name=p155022 lab=_85241_/Q }
C {devices/lab_pin.sym} 156320 -37090 0 1 {name=p155023 lab=_56309_/Y }
C {sky130_stdcells/nand3_4.sym} 156260 -37090 0 0 {name=X_56309_ }
C {devices/lab_pin.sym} 156180 -36980 0 0 {name=p155024 lab=_41636_/X }
C {devices/lab_pin.sym} 156180 -36940 0 0 {name=p155025 lab=_40543_/X }
C {devices/lab_pin.sym} 156180 -36900 0 0 {name=p155026 lab=_87166_/Q }
C {devices/lab_pin.sym} 156180 -36860 0 0 {name=p155027 lab=_40544_/X }
C {devices/lab_pin.sym} 156340 -36920 0 1 {name=p155028 lab=_87166_/D }
C {sky130_stdcells/a2bb2o_4.sym} 156260 -36920 0 0 {name=X_44323_ }
C {devices/lab_pin.sym} 156200 -36780 0 0 {name=p155029 lab=_75143_/A }
C {devices/lab_pin.sym} 156200 -36740 0 0 {name=p155030 lab=_75127_/C }
C {devices/lab_pin.sym} 156320 -36760 0 1 {name=p155031 lab=_75143_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -36760 0 0 {name=X_75143_ }
C {devices/lab_pin.sym} 156170 -36630 0 0 {name=p155032 lab=_87436_/CLK }
C {devices/lab_pin.sym} 156170 -36610 0 0 {name=p155033 lab=_44398_/Y }
C {devices/lab_pin.sym} 156350 -36630 0 1 {name=p155034 lab=_87129_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -36620 0 0 {name=X_87129_ }
C {devices/lab_pin.sym} 156180 -36510 0 0 {name=p155035 lab=_41533_/X }
C {devices/lab_pin.sym} 156180 -36470 0 0 {name=p155036 lab=_82322_/Q }
C {devices/lab_pin.sym} 156180 -36430 0 0 {name=p155037 lab=_41534_/X }
C {devices/lab_pin.sym} 156340 -36470 0 1 {name=p155038 lab=_41535_/X }
C {sky130_stdcells/o21a_4.sym} 156260 -36470 0 0 {name=X_41535_ }
C {devices/lab_pin.sym} 156220 -36330 0 0 {name=p155039 lab=_57617_/B }
C {devices/lab_pin.sym} 156300 -36330 0 1 {name=p155040 lab=_50358_/B }
C {sky130_stdcells/buf_2.sym} 156260 -36330 0 0 {name=X_48091_ }
C {devices/lab_pin.sym} 156180 -36230 0 0 {name=p155041 lab=_72351_/Y }
C {devices/lab_pin.sym} 156180 -36190 0 0 {name=p155042 lab=_72354_/Y }
C {devices/lab_pin.sym} 156180 -36150 0 0 {name=p155043 lab=_72344_/X }
C {devices/lab_pin.sym} 156340 -36190 0 1 {name=p155044 lab=_72355_/X }
C {sky130_stdcells/a21o_4.sym} 156260 -36190 0 0 {name=X_72355_ }
C {devices/lab_pin.sym} 156200 -36080 0 0 {name=p155045 lab=_56842_/X }
C {devices/lab_pin.sym} 156200 -36040 0 0 {name=p155046 lab=_57289_/B }
C {devices/lab_pin.sym} 156200 -36000 0 0 {name=p155047 lab=_56848_/X }
C {devices/lab_pin.sym} 156200 -35960 0 0 {name=p155048 lab=_56849_/X }
C {devices/lab_pin.sym} 156320 -36020 0 1 {name=p155049 lab=_57290_/A }
C {sky130_stdcells/nor4_4.sym} 156260 -36020 0 0 {name=X_57289_ }
C {devices/lab_pin.sym} 156220 -35870 0 0 {name=p155050 lab=_53336_/B }
C {devices/lab_pin.sym} 156300 -35870 0 1 {name=p155051 lab=_51130_/B }
C {sky130_stdcells/buf_2.sym} 156260 -35870 0 0 {name=X_47042_ }
C {devices/lab_pin.sym} 156220 -35750 0 0 {name=p155052 lab=_58698_/A }
C {devices/lab_pin.sym} 156300 -35750 0 1 {name=p155053 lab=_59029_/A }
C {sky130_stdcells/buf_2.sym} 156260 -35750 0 0 {name=X_59028_ }
C {devices/lab_pin.sym} 156200 -35650 0 0 {name=p155054 lab=_71303_/A }
C {devices/lab_pin.sym} 156200 -35610 0 0 {name=p155055 lab=_71303_/B }
C {devices/lab_pin.sym} 156200 -35570 0 0 {name=p155056 lab=_71680_/C }
C {devices/lab_pin.sym} 156320 -35610 0 1 {name=p155057 lab=_71306_/Y }
C {sky130_stdcells/nand3_4.sym} 156260 -35610 0 0 {name=X_71306_ }
C {devices/lab_pin.sym} 156180 -35510 0 0 {name=p155058 lab=_58631_/A }
C {devices/lab_pin.sym} 156180 -35470 0 0 {name=p155059 lab=_57811_/A }
C {devices/lab_pin.sym} 156180 -35430 0 0 {name=p155060 lab=_72296_/A }
C {devices/lab_pin.sym} 156180 -35390 0 0 {name=p155061 lab=_44252_/X }
C {devices/lab_pin.sym} 156180 -35360 0 0 {name=p155062 lab=_44253_/X }
C {devices/lab_pin.sym} 156340 -35430 0 1 {name=p155063 lab=_44254_/X }
C {sky130_stdcells/a41o_4.sym} 156260 -35430 0 0 {name=X_44254_ }
C {devices/lab_pin.sym} 156200 -35280 0 0 {name=p155064 lab=_75072_/Y }
C {devices/lab_pin.sym} 156200 -35240 0 0 {name=p155065 lab=_75074_/B }
C {devices/lab_pin.sym} 156320 -35260 0 1 {name=p155066 lab=_75074_/X }
C {sky130_stdcells/and2_4.sym} 156260 -35260 0 0 {name=X_75074_ }
C {devices/lab_pin.sym} 156220 -35130 0 0 {name=p155067 lab=_79957_/A }
C {devices/lab_pin.sym} 156300 -35130 0 1 {name=p155068 lab=_79956_/A }
C {sky130_stdcells/inv_2.sym} 156260 -35130 0 0 {name=X_79951_ }
C {devices/lab_pin.sym} 156180 -35040 0 0 {name=p155069 lab=_41465_/X }
C {devices/lab_pin.sym} 156180 -35000 0 0 {name=p155070 lab=_41455_/X }
C {devices/lab_pin.sym} 156180 -34960 0 0 {name=p155071 lab=_88210_/Q }
C {devices/lab_pin.sym} 156180 -34920 0 0 {name=p155072 lab=_41457_/X }
C {devices/lab_pin.sym} 156340 -34980 0 1 {name=p155073 lab=_41466_/X }
C {sky130_stdcells/a2bb2o_4.sym} 156260 -34980 0 0 {name=X_41466_ }
C {devices/lab_pin.sym} 156220 -34830 0 0 {name=p155074 lab=_83267_/Q }
C {devices/lab_pin.sym} 156300 -34830 0 1 {name=p155075 lab=_72286_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -34830 0 0 {name=X_72286_ }
C {devices/lab_pin.sym} 156180 -34740 0 0 {name=p155076 lab=_40935_/X }
C {devices/lab_pin.sym} 156180 -34700 0 0 {name=p155077 lab=_43180_/X }
C {devices/lab_pin.sym} 156180 -34660 0 0 {name=p155078 lab=_87539_/Q }
C {devices/lab_pin.sym} 156180 -34620 0 0 {name=p155079 lab=_43185_/X }
C {devices/lab_pin.sym} 156340 -34680 0 1 {name=p155080 lab=_43205_/X }
C {sky130_stdcells/a2bb2o_4.sym} 156260 -34680 0 0 {name=X_43205_ }
C {devices/lab_pin.sym} 156200 -34540 0 0 {name=p155081 lab=_74025_/A }
C {devices/lab_pin.sym} 156200 -34500 0 0 {name=p155082 lab=_74025_/B }
C {devices/lab_pin.sym} 156320 -34520 0 1 {name=p155083 lab=_74026_/B }
C {sky130_stdcells/nand2_4.sym} 156260 -34520 0 0 {name=X_74025_ }
C {devices/lab_pin.sym} 156220 -34390 0 0 {name=p155084 lab=_82637_/Q }
C {devices/lab_pin.sym} 156300 -34390 0 1 {name=p155085 lab=_78902_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -34390 0 0 {name=X_78902_ }
C {devices/lab_pin.sym} 156180 -34290 0 0 {name=p155086 lab=_40325_/X }
C {devices/lab_pin.sym} 156180 -34250 0 0 {name=p155087 lab=_82328_/Q }
C {devices/lab_pin.sym} 156180 -34210 0 0 {name=p155088 lab=_40416_/X }
C {devices/lab_pin.sym} 156340 -34250 0 1 {name=p155089 lab=_40417_/Y }
C {sky130_stdcells/o21ai_4.sym} 156260 -34250 0 0 {name=X_40417_ }
C {devices/lab_pin.sym} 156200 -34140 0 0 {name=p155090 lab=_71136_/A }
C {devices/lab_pin.sym} 156200 -34100 0 0 {name=p155091 lab=_70758_/C }
C {devices/lab_pin.sym} 156200 -34060 0 0 {name=p155092 lab=_70758_/B }
C {devices/lab_pin.sym} 156200 -34020 0 0 {name=p155093 lab=_70627_/A }
C {devices/lab_pin.sym} 156320 -34080 0 1 {name=p155094 lab=_71238_/B }
C {sky130_stdcells/nand4_4.sym} 156260 -34080 0 0 {name=X_71237_ }
C {devices/lab_pin.sym} 156180 -33970 0 0 {name=p155095 lab=_44171_/X }
C {devices/lab_pin.sym} 156180 -33930 0 0 {name=p155096 lab=_44173_/X }
C {devices/lab_pin.sym} 156180 -33890 0 0 {name=p155097 lab=_44177_/X }
C {devices/lab_pin.sym} 156180 -33850 0 0 {name=p155098 lab=_72461_/A }
C {devices/lab_pin.sym} 156180 -33820 0 0 {name=p155099 lab=_44184_/X }
C {devices/lab_pin.sym} 156340 -33890 0 1 {name=p155100 lab=_44185_/X }
C {sky130_stdcells/a41o_4.sym} 156260 -33890 0 0 {name=X_44185_ }
C {devices/lab_pin.sym} 156200 -33740 0 0 {name=p155101 lab=_79882_/A }
C {devices/lab_pin.sym} 156200 -33700 0 0 {name=p155102 lab=_79881_/X }
C {devices/lab_pin.sym} 156320 -33720 0 1 {name=p155103 lab=_79890_/A }
C {sky130_stdcells/nand2_4.sym} 156260 -33720 0 0 {name=X_79882_ }
C {devices/lab_pin.sym} 156220 -33590 0 0 {name=p155104 lab=_41397_/A }
C {devices/lab_pin.sym} 156300 -33590 0 1 {name=p155105 lab=_41397_/X }
C {sky130_stdcells/buf_2.sym} 156260 -33590 0 0 {name=X_41397_ }
C {devices/lab_pin.sym} 156220 -33470 0 0 {name=p155106 lab=clkbuf_6_50_0_CLK/X }
C {devices/lab_pin.sym} 156300 -33470 0 1 {name=p155107 lab=clkbuf_8_201_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 156260 -33470 0 0 {name=Xclkbuf_7_100_0_CLK }
C {devices/lab_pin.sym} 156180 -33390 0 0 {name=p155108 lab=_43129_/X }
C {devices/lab_pin.sym} 156180 -33350 0 0 {name=p155109 lab=_43130_/X }
C {devices/lab_pin.sym} 156180 -33310 0 0 {name=p155110 lab=_40806_/X }
C {devices/lab_pin.sym} 156180 -33270 0 0 {name=p155111 lab=_43135_/Y }
C {devices/lab_pin.sym} 156180 -33230 0 0 {name=p155112 lab=_43127_/X }
C {devices/lab_pin.sym} 156340 -33310 0 1 {name=p155113 lab=_43136_/Y }
C {sky130_stdcells/o32ai_4.sym} 156260 -33310 0 0 {name=X_43136_ }
C {devices/lab_pin.sym} 156200 -33160 0 0 {name=p155114 lab=_82837_/Q }
C {devices/lab_pin.sym} 156200 -33120 0 0 {name=p155115 lab=_78833_/B }
C {devices/lab_pin.sym} 156320 -33140 0 1 {name=p155116 lab=_78833_/Y }
C {sky130_stdcells/xnor2_4.sym} 156260 -33140 0 0 {name=X_78833_ }
C {devices/lab_pin.sym} 156220 -33010 0 0 {name=p155117 lab=_46450_/A }
C {devices/lab_pin.sym} 156300 -33010 0 1 {name=p155118 lab=_74458_/A }
C {sky130_stdcells/buf_2.sym} 156260 -33010 0 0 {name=X_40348_ }
C {devices/lab_pin.sym} 156200 -32920 0 0 {name=p155119 lab=_71168_/A }
C {devices/lab_pin.sym} 156200 -32880 0 0 {name=p155120 lab=_71173_/B }
C {devices/lab_pin.sym} 156200 -32840 0 0 {name=p155121 lab=_74531_/B }
C {devices/lab_pin.sym} 156200 -32800 0 0 {name=p155122 lab=_71178_/D }
C {devices/lab_pin.sym} 156320 -32860 0 1 {name=p155123 lab=_71168_/Y }
C {sky130_stdcells/nand4_4.sym} 156260 -32860 0 0 {name=X_71168_ }
C {devices/lab_pin.sym} 156200 -32720 0 0 {name=p155124 lab=_48964_/A }
C {devices/lab_pin.sym} 156200 -32680 0 0 {name=p155125 lab=_48992_/X }
C {devices/lab_pin.sym} 156320 -32700 0 1 {name=p155126 lab=_48993_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -32700 0 0 {name=X_48993_ }
C {devices/lab_pin.sym} 156220 -32570 0 0 {name=p155127 lab=clkbuf_9_35_0_CLK/X }
C {devices/lab_pin.sym} 156300 -32570 0 1 {name=p155128 lab=_80672_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 156260 -32570 0 0 {name=Xclkbuf_10_70_0_CLK }
C {devices/lab_pin.sym} 156180 -32480 0 0 {name=p155129 lab=_83525_/Q }
C {devices/lab_pin.sym} 156180 -32440 0 0 {name=p155130 lab=_83173_/Q }
C {devices/lab_pin.sym} 156180 -32400 0 0 {name=p155131 lab=_83500_/Q }
C {devices/lab_pin.sym} 156180 -32360 0 0 {name=p155132 lab=_83148_/Q }
C {devices/lab_pin.sym} 156340 -32420 0 1 {name=p155133 lab=_70119_/Y }
C {sky130_stdcells/a22oi_4.sym} 156260 -32420 0 0 {name=X_70119_ }
C {devices/lab_pin.sym} 156180 -32290 0 0 {name=p155134 lab=_46301_/X }
C {devices/lab_pin.sym} 156180 -32250 0 0 {name=p155135 lab=_82359_/Q }
C {devices/lab_pin.sym} 156180 -32210 0 0 {name=p155136 lab=_47943_/X }
C {devices/lab_pin.sym} 156340 -32250 0 1 {name=p155137 lab=_51988_/A }
C {sky130_stdcells/o21ai_4.sym} 156260 -32250 0 0 {name=X_47944_ }
C {devices/lab_pin.sym} 156220 -32110 0 0 {name=p155138 lab=_43066_/Y }
C {devices/lab_pin.sym} 156300 -32110 0 1 {name=p155139 lab=_87589_/D }
C {sky130_stdcells/inv_2.sym} 156260 -32110 0 0 {name=X_43067_ }
C {devices/lab_pin.sym} 156200 -32000 0 0 {name=p155140 lab=_78764_/A }
C {devices/lab_pin.sym} 156200 -31960 0 0 {name=p155141 lab=_78759_/X }
C {devices/lab_pin.sym} 156320 -31980 0 1 {name=p155142 lab=_78764_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -31980 0 0 {name=X_78764_ }
C {devices/lab_pin.sym} 156200 -31880 0 0 {name=p155143 lab=_61510_/X }
C {devices/lab_pin.sym} 156200 -31840 0 0 {name=p155144 lab=_64052_/B }
C {devices/lab_pin.sym} 156200 -31800 0 0 {name=p155145 lab=_64003_/C }
C {devices/lab_pin.sym} 156200 -31760 0 0 {name=p155146 lab=_64052_/D }
C {devices/lab_pin.sym} 156320 -31820 0 1 {name=p155147 lab=_63990_/Y }
C {sky130_stdcells/nand4_4.sym} 156260 -31820 0 0 {name=X_63990_ }
C {devices/lab_pin.sym} 156200 -31690 0 0 {name=p155148 lab=_71088_/A }
C {devices/lab_pin.sym} 156200 -31650 0 0 {name=p155149 lab=_71076_/B }
C {devices/lab_pin.sym} 156200 -31610 0 0 {name=p155150 lab=_71099_/C }
C {devices/lab_pin.sym} 156320 -31650 0 1 {name=p155151 lab=_71099_/Y }
C {sky130_stdcells/nand3_4.sym} 156260 -31650 0 0 {name=X_71099_ }
C {devices/lab_pin.sym} 156200 -31520 0 0 {name=p155152 lab=_75976_/A }
C {devices/lab_pin.sym} 156200 -31480 0 0 {name=p155153 lab=_75976_/B }
C {devices/lab_pin.sym} 156320 -31500 0 1 {name=p155154 lab=_75977_/B }
C {sky130_stdcells/nor2_4.sym} 156260 -31500 0 0 {name=X_75976_ }
C {devices/lab_pin.sym} 156180 -31410 0 0 {name=p155155 lab=_42013_/X }
C {devices/lab_pin.sym} 156180 -31370 0 0 {name=p155156 lab=_42006_/X }
C {devices/lab_pin.sym} 156180 -31330 0 0 {name=p155157 lab=_40839_/X }
C {devices/lab_pin.sym} 156180 -31290 0 0 {name=p155158 lab=_73124_/A }
C {devices/lab_pin.sym} 156180 -31250 0 0 {name=p155159 lab=_42007_/X }
C {devices/lab_pin.sym} 156340 -31330 0 1 {name=p155160 lab=_42018_/Y }
C {sky130_stdcells/o32ai_4.sym} 156260 -31330 0 0 {name=X_42018_ }
C {devices/lab_pin.sym} 156200 -31180 0 0 {name=p155161 lab=_77715_/A }
C {devices/lab_pin.sym} 156200 -31140 0 0 {name=p155162 lab=_77715_/B }
C {devices/lab_pin.sym} 156320 -31160 0 1 {name=p155163 lab=_77716_/B }
C {sky130_stdcells/xnor2_4.sym} 156260 -31160 0 0 {name=X_77715_ }
C {devices/lab_pin.sym} 156200 -31040 0 0 {name=p155164 lab=_80941_/Q }
C {devices/lab_pin.sym} 156200 -31000 0 0 {name=p155165 lab=_74927_/B }
C {devices/lab_pin.sym} 156320 -31020 0 1 {name=p155166 lab=_74927_/X }
C {sky130_stdcells/xor2_4.sym} 156260 -31020 0 0 {name=X_74927_ }
C {devices/lab_pin.sym} 156180 -30930 0 0 {name=p155167 lab=_62934_/Y }
C {devices/lab_pin.sym} 156180 -30890 0 0 {name=p155168 lab=_62886_/X }
C {devices/lab_pin.sym} 156180 -30850 0 0 {name=p155169 lab=_62935_/Y }
C {devices/lab_pin.sym} 156180 -30810 0 0 {name=p155170 lab=_62938_/Y }
C {devices/lab_pin.sym} 156180 -30780 0 0 {name=p155171 lab=_62940_/X }
C {devices/lab_pin.sym} 156340 -30850 0 1 {name=p155172 lab=_62941_/X }
C {sky130_stdcells/a41o_4.sym} 156260 -30850 0 0 {name=X_62941_ }
C {devices/lab_pin.sym} 156220 -30690 0 0 {name=p155173 lab=clkbuf_6_57_0_CLK/X }
C {devices/lab_pin.sym} 156300 -30690 0 1 {name=p155174 lab=clkbuf_8_231_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 156260 -30690 0 0 {name=Xclkbuf_7_115_0_CLK }
C {devices/lab_pin.sym} 156220 -30570 0 0 {name=p155175 lab=_51340_/A }
C {devices/lab_pin.sym} 156300 -30570 0 1 {name=p155176 lab=_47918_/A }
C {sky130_stdcells/buf_2.sym} 156260 -30570 0 0 {name=X_47875_ }
C {devices/lab_pin.sym} 156180 -30470 0 0 {name=p155177 lab=_78682_/A }
C {devices/lab_pin.sym} 156180 -30430 0 0 {name=p155178 lab=_78682_/B }
C {devices/lab_pin.sym} 156180 -30390 0 0 {name=p155179 lab=_78680_/Y }
C {devices/lab_pin.sym} 156340 -30430 0 1 {name=p155180 lab=_78695_/X }
C {sky130_stdcells/o21a_4.sym} 156260 -30430 0 0 {name=X_78695_ }
C {devices/lab_pin.sym} 156220 -30290 0 0 {name=p155181 lab=_49614_/A }
C {devices/lab_pin.sym} 156300 -30290 0 1 {name=p155182 lab=_49614_/X }
C {sky130_stdcells/buf_2.sym} 156260 -30290 0 0 {name=X_49614_ }
C {devices/lab_pin.sym} 156200 -30180 0 0 {name=p155183 lab=_46817_/A }
C {devices/lab_pin.sym} 156200 -30140 0 0 {name=p155184 lab=_51003_/B }
C {devices/lab_pin.sym} 156320 -30160 0 1 {name=p155185 lab=_46826_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -30160 0 0 {name=X_46826_ }
C {devices/lab_pin.sym} 156220 -30030 0 0 {name=p155186 lab=_65660_/A }
C {devices/lab_pin.sym} 156300 -30030 0 1 {name=p155187 lab=_65660_/X }
C {sky130_stdcells/buf_2.sym} 156260 -30030 0 0 {name=X_65660_ }
C {devices/lab_pin.sym} 156200 -29920 0 0 {name=p155188 lab=_77643_/B }
C {devices/lab_pin.sym} 156200 -29880 0 0 {name=p155189 lab=_77643_/A }
C {devices/lab_pin.sym} 156320 -29900 0 1 {name=p155190 lab=_77648_/C }
C {sky130_stdcells/nand2_4.sym} 156260 -29900 0 0 {name=X_77646_ }
C {devices/lab_pin.sym} 156180 -29810 0 0 {name=p155191 lab=_62867_/X }
C {devices/lab_pin.sym} 156180 -29770 0 0 {name=p155192 lab=_62831_/X }
C {devices/lab_pin.sym} 156180 -29730 0 0 {name=p155193 lab=_62869_/Y }
C {devices/lab_pin.sym} 156180 -29690 0 0 {name=p155194 lab=_62870_/Y }
C {devices/lab_pin.sym} 156180 -29660 0 0 {name=p155195 lab=_62871_/X }
C {devices/lab_pin.sym} 156340 -29730 0 1 {name=p155196 lab=_62872_/X }
C {sky130_stdcells/a41o_4.sym} 156260 -29730 0 0 {name=X_62872_ }
C {devices/lab_pin.sym} 156200 -29580 0 0 {name=p155197 lab=_81123_/D }
C {devices/lab_pin.sym} 156200 -29540 0 0 {name=p155198 lab=_80835_/Q }
C {devices/lab_pin.sym} 156320 -29560 0 1 {name=p155199 lab=_74858_/Y }
C {sky130_stdcells/nor2_4.sym} 156260 -29560 0 0 {name=X_74858_ }
C {devices/lab_pin.sym} 156220 -29430 0 0 {name=p155200 lab=clkbuf_9_42_0_CLK/X }
C {devices/lab_pin.sym} 156300 -29430 0 1 {name=p155201 lab=_83246_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 156260 -29430 0 0 {name=Xclkbuf_10_85_0_CLK }
C {devices/lab_pin.sym} 156200 -29320 0 0 {name=p155202 lab=_64611_/A }
C {devices/lab_pin.sym} 156200 -29280 0 0 {name=p155203 lab=_85824_/Q }
C {devices/lab_pin.sym} 156320 -29300 0 1 {name=p155204 lab=_64611_/X }
C {sky130_stdcells/and2_4.sym} 156260 -29300 0 0 {name=X_64611_ }
C {devices/lab_pin.sym} 156180 -29190 0 0 {name=p155205 lab=_49540_/Y }
C {devices/lab_pin.sym} 156180 -29150 0 0 {name=p155206 lab=_49541_/X }
C {devices/lab_pin.sym} 156180 -29110 0 0 {name=p155207 lab=_49544_/X }
C {devices/lab_pin.sym} 156340 -29150 0 1 {name=p155208 lab=_49545_/Y }
C {sky130_stdcells/a21oi_4.sym} 156260 -29150 0 0 {name=X_49545_ }
C {devices/lab_pin.sym} 156200 -29040 0 0 {name=p155209 lab=_61823_/A }
C {devices/lab_pin.sym} 156200 -29000 0 0 {name=p155210 lab=_61823_/B }
C {devices/lab_pin.sym} 156200 -28960 0 0 {name=p155211 lab=_59501_/X }
C {devices/lab_pin.sym} 156200 -28920 0 0 {name=p155212 lab=_61788_/X }
C {devices/lab_pin.sym} 156320 -28980 0 1 {name=p155213 lab=_61823_/X }
C {sky130_stdcells/and4_4.sym} 156260 -28980 0 0 {name=X_61823_ }
C {devices/lab_pin.sym} 156180 -28850 0 0 {name=p155214 lab=_73806_/X }
C {devices/lab_pin.sym} 156180 -28810 0 0 {name=p155215 lab=_73808_/X }
C {devices/lab_pin.sym} 156180 -28770 0 0 {name=p155216 lab=_73738_/X }
C {devices/lab_pin.sym} 156340 -28810 0 1 {name=p155217 lab=_73812_/A }
C {sky130_stdcells/a21o_4.sym} 156260 -28810 0 0 {name=X_73809_ }
C {devices/lab_pin.sym} 156220 -28670 0 0 {name=p155218 lab=_83674_/Q }
C {devices/lab_pin.sym} 156300 -28670 0 1 {name=p155219 lab=_52658_/B }
C {sky130_stdcells/inv_2.sym} 156260 -28670 0 0 {name=X_46757_ }
C {devices/lab_pin.sym} 156180 -28580 0 0 {name=p155220 lab=_65484_/X }
C {devices/lab_pin.sym} 156180 -28540 0 0 {name=p155221 lab=_86198_/Q }
C {devices/lab_pin.sym} 156180 -28500 0 0 {name=p155222 lab=_65534_/X }
C {devices/lab_pin.sym} 156180 -28460 0 0 {name=p155223 lab=_65590_/X }
C {devices/lab_pin.sym} 156340 -28520 0 1 {name=p155224 lab=_65591_/X }
C {sky130_stdcells/a211o_4.sym} 156260 -28520 0 0 {name=X_65591_ }
C {devices/lab_pin.sym} 156220 -28370 0 0 {name=p155225 lab=clkbuf_8_231_0_CLK/A }
C {devices/lab_pin.sym} 156300 -28370 0 1 {name=p155226 lab=clkbuf_8_231_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 156260 -28370 0 0 {name=Xclkbuf_8_231_0_CLK }
C {devices/lab_pin.sym} 156180 -28270 0 0 {name=p155227 lab=_77560_/Y }
C {devices/lab_pin.sym} 156180 -28230 0 0 {name=p155228 lab=_77564_/B }
C {devices/lab_pin.sym} 156180 -28190 0 0 {name=p155229 lab=_77559_/B }
C {devices/lab_pin.sym} 156340 -28230 0 1 {name=p155230 lab=_77577_/Y }
C {sky130_stdcells/o21ai_4.sym} 156260 -28230 0 0 {name=X_77577_ }
C {devices/lab_pin.sym} 156200 -28100 0 0 {name=p155231 lab=_43969_/A }
C {devices/lab_pin.sym} 156200 -28060 0 0 {name=p155232 lab=_43969_/B }
C {devices/lab_pin.sym} 156320 -28080 0 1 {name=p155233 lab=_43970_/A }
C {sky130_stdcells/and2_4.sym} 156260 -28080 0 0 {name=X_43969_ }
C {devices/lab_pin.sym} 156200 -27980 0 0 {name=p155234 lab=_71735_/A }
C {devices/lab_pin.sym} 156200 -27940 0 0 {name=p155235 lab=_70630_/B }
C {devices/lab_pin.sym} 156200 -27900 0 0 {name=p155236 lab=_74789_/C }
C {devices/lab_pin.sym} 156200 -27860 0 0 {name=p155237 lab=_71010_/X }
C {devices/lab_pin.sym} 156320 -27920 0 1 {name=p155238 lab=_74789_/X }
C {sky130_stdcells/and4_4.sym} 156260 -27920 0 0 {name=X_74789_ }
C {devices/lab_pin.sym} 156220 -27770 0 0 {name=p155239 lab=_68461_/A }
C {devices/lab_pin.sym} 156300 -27770 0 1 {name=p155240 lab=_67806_/A }
C {sky130_stdcells/buf_2.sym} 156260 -27770 0 0 {name=X_67330_ }
C {devices/lab_pin.sym} 156180 -27670 0 0 {name=p155241 lab=_79313_/Y }
C {devices/lab_pin.sym} 156180 -27630 0 0 {name=p155242 lab=_79296_/Y }
C {devices/lab_pin.sym} 156180 -27590 0 0 {name=p155243 lab=_79315_/X }
C {devices/lab_pin.sym} 156340 -27630 0 1 {name=p155244 lab=_79316_/Y }
C {sky130_stdcells/o21ai_4.sym} 156260 -27630 0 0 {name=X_79316_ }
C {devices/lab_pin.sym} 156180 -27510 0 0 {name=p155245 lab=_45704_/X }
C {devices/lab_pin.sym} 156180 -27470 0 0 {name=p155246 lab=_45707_/Y }
C {devices/lab_pin.sym} 156180 -27430 0 0 {name=p155247 lab=_45678_/X }
C {devices/lab_pin.sym} 156340 -27470 0 1 {name=p155248 lab=_45708_/X }
C {sky130_stdcells/a21o_4.sym} 156260 -27470 0 0 {name=X_45708_ }
C {devices/lab_pin.sym} 156180 -27350 0 0 {name=p155249 lab=_76516_/Y }
C {devices/lab_pin.sym} 156180 -27310 0 0 {name=p155250 lab=_76509_/X }
C {devices/lab_pin.sym} 156180 -27270 0 0 {name=p155251 lab=_76511_/B }
C {devices/lab_pin.sym} 156340 -27310 0 1 {name=p155252 lab=_76529_/B }
C {sky130_stdcells/a21boi_4.sym} 156260 -27310 0 0 {name=X_76528_ }
C {devices/lab_pin.sym} 156220 -27170 0 0 {name=p155253 lab=_64542_/A }
C {devices/lab_pin.sym} 156300 -27170 0 1 {name=p155254 lab=_64542_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -27170 0 0 {name=X_64542_ }
C {devices/lab_pin.sym} 156200 -27060 0 0 {name=p155255 lab=_49481_/A }
C {devices/lab_pin.sym} 156200 -27020 0 0 {name=p155256 lab=_50998_/B }
C {devices/lab_pin.sym} 156320 -27040 0 1 {name=p155257 lab=_49476_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -27040 0 0 {name=X_49476_ }
C {devices/lab_pin.sym} 156200 -26940 0 0 {name=p155258 lab=_61770_/A }
C {devices/lab_pin.sym} 156200 -26900 0 0 {name=p155259 lab=_61770_/B }
C {devices/lab_pin.sym} 156200 -26860 0 0 {name=p155260 lab=_63384_/B }
C {devices/lab_pin.sym} 156200 -26820 0 0 {name=p155261 lab=_61770_/D }
C {devices/lab_pin.sym} 156320 -26880 0 1 {name=p155262 lab=_61754_/X }
C {sky130_stdcells/and4_4.sym} 156260 -26880 0 0 {name=X_61754_ }
C {devices/lab_pin.sym} 156220 -26730 0 0 {name=p155263 lab=_82970_/Q }
C {devices/lab_pin.sym} 156300 -26730 0 1 {name=p155264 lab=_46688_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -26730 0 0 {name=X_46688_ }
C {devices/lab_pin.sym} 156200 -26620 0 0 {name=p155265 lab=_48426_/Y }
C {devices/lab_pin.sym} 156200 -26580 0 0 {name=p155266 lab=_48449_/B }
C {devices/lab_pin.sym} 156320 -26600 0 1 {name=p155267 lab=_48427_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -26600 0 0 {name=X_48427_ }
C {devices/lab_pin.sym} 156200 -26490 0 0 {name=p155268 lab=_60700_/A }
C {devices/lab_pin.sym} 156200 -26450 0 0 {name=p155269 lab=_60612_/B }
C {devices/lab_pin.sym} 156200 -26410 0 0 {name=p155270 lab=_84582_/Q }
C {devices/lab_pin.sym} 156320 -26450 0 1 {name=p155271 lab=_60705_/Y }
C {sky130_stdcells/nor3_4.sym} 156260 -26450 0 0 {name=X_60705_ }
C {devices/lab_pin.sym} 156220 -26310 0 0 {name=p155272 lab=_67144_/A }
C {devices/lab_pin.sym} 156300 -26310 0 1 {name=p155273 lab=_67308_/A }
C {sky130_stdcells/buf_2.sym} 156260 -26310 0 0 {name=X_67261_ }
C {devices/lab_pin.sym} 156180 -26210 0 0 {name=p155274 lab=_79229_/Y }
C {devices/lab_pin.sym} 156180 -26170 0 0 {name=p155275 lab=_79248_/C }
C {devices/lab_pin.sym} 156180 -26130 0 0 {name=p155276 lab=_79246_/Y }
C {devices/lab_pin.sym} 156340 -26170 0 1 {name=p155277 lab=_79247_/X }
C {sky130_stdcells/a21o_4.sym} 156260 -26170 0 0 {name=X_79247_ }
C {devices/lab_pin.sym} 156180 -26050 0 0 {name=p155278 lab=_45636_/X }
C {devices/lab_pin.sym} 156180 -26010 0 0 {name=p155279 lab=_45638_/Y }
C {devices/lab_pin.sym} 156180 -25970 0 0 {name=p155280 lab=_45561_/X }
C {devices/lab_pin.sym} 156340 -26010 0 1 {name=p155281 lab=_45639_/Y }
C {sky130_stdcells/a21oi_4.sym} 156260 -26010 0 0 {name=X_45639_ }
C {devices/lab_pin.sym} 156200 -25880 0 0 {name=p155282 lab=_64473_/A }
C {devices/lab_pin.sym} 156200 -25840 0 0 {name=p155283 lab=_64454_/B }
C {devices/lab_pin.sym} 156320 -25860 0 1 {name=p155284 lab=_64473_/Y }
C {sky130_stdcells/nor2_4.sym} 156260 -25860 0 0 {name=X_64473_ }
C {devices/lab_pin.sym} 156200 -25740 0 0 {name=p155285 lab=_76459_/A }
C {devices/lab_pin.sym} 156200 -25700 0 0 {name=p155286 lab=_81526_/D }
C {devices/lab_pin.sym} 156320 -25720 0 1 {name=p155287 lab=_76459_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -25720 0 0 {name=X_76459_ }
C {devices/lab_pin.sym} 156200 -25620 0 0 {name=p155288 lab=_61685_/A }
C {devices/lab_pin.sym} 156200 -25580 0 0 {name=p155289 lab=_61653_/X }
C {devices/lab_pin.sym} 156200 -25540 0 0 {name=p155290 lab=_61654_/X }
C {devices/lab_pin.sym} 156200 -25500 0 0 {name=p155291 lab=_61639_/X }
C {devices/lab_pin.sym} 156320 -25560 0 1 {name=p155292 lab=_61685_/Y }
C {sky130_stdcells/nand4_4.sym} 156260 -25560 0 0 {name=X_61685_ }
C {devices/lab_pin.sym} 156180 -25440 0 0 {name=p155293 lab=_87577_/Q }
C {devices/lab_pin.sym} 156180 -25400 0 0 {name=p155294 lab=_66538_/X }
C {devices/lab_pin.sym} 156180 -25360 0 0 {name=p155295 lab=_66540_/X }
C {devices/lab_pin.sym} 156180 -25320 0 0 {name=p155296 lab=_68999_/X }
C {devices/lab_pin.sym} 156340 -25380 0 1 {name=p155297 lab=_69000_/X }
C {sky130_stdcells/a211o_4.sym} 156260 -25380 0 0 {name=X_69000_ }
C {devices/lab_pin.sym} 156180 -25260 0 0 {name=p155298 lab=_57947_/A }
C {devices/lab_pin.sym} 156180 -25220 0 0 {name=p155299 lab=_85612_/Q }
C {devices/lab_pin.sym} 156180 -25180 0 0 {name=p155300 lab=_65301_/X }
C {devices/lab_pin.sym} 156180 -25140 0 0 {name=p155301 lab=_66211_/X }
C {devices/lab_pin.sym} 156340 -25200 0 1 {name=p155302 lab=_66212_/X }
C {sky130_stdcells/a211o_4.sym} 156260 -25200 0 0 {name=X_66212_ }
C {devices/lab_pin.sym} 156200 -25080 0 0 {name=p155303 lab=_63448_/A }
C {devices/lab_pin.sym} 156200 -25040 0 0 {name=p155304 lab=_63424_/B }
C {devices/lab_pin.sym} 156200 -25000 0 0 {name=p155305 lab=_63410_/C }
C {devices/lab_pin.sym} 156200 -24960 0 0 {name=p155306 lab=_63410_/D }
C {devices/lab_pin.sym} 156320 -25020 0 1 {name=p155307 lab=_63424_/X }
C {sky130_stdcells/and4_4.sym} 156260 -25020 0 0 {name=X_63424_ }
C {devices/lab_pin.sym} 156220 -24870 0 0 {name=p155308 lab=clkbuf_8_247_0_CLK/A }
C {devices/lab_pin.sym} 156300 -24870 0 1 {name=p155309 lab=clkbuf_9_493_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 156260 -24870 0 0 {name=Xclkbuf_8_246_0_CLK }
C {devices/lab_pin.sym} 156200 -24780 0 0 {name=p155310 lab=_61276_/B }
C {devices/lab_pin.sym} 156200 -24740 0 0 {name=p155311 lab=_60636_/B }
C {devices/lab_pin.sym} 156200 -24700 0 0 {name=p155312 lab=_59657_/A }
C {devices/lab_pin.sym} 156200 -24660 0 0 {name=p155313 lab=_60407_/C }
C {devices/lab_pin.sym} 156320 -24720 0 1 {name=p155314 lab=_60637_/A }
C {sky130_stdcells/and4_4.sym} 156260 -24720 0 0 {name=X_60636_ }
C {devices/lab_pin.sym} 156220 -24570 0 0 {name=p155315 lab=_48357_/Y }
C {devices/lab_pin.sym} 156300 -24570 0 1 {name=p155316 lab=_48358_/X }
C {sky130_stdcells/buf_2.sym} 156260 -24570 0 0 {name=X_48358_ }
C {devices/lab_pin.sym} 156180 -24470 0 0 {name=p155317 lab=_67189_/X }
C {devices/lab_pin.sym} 156180 -24430 0 0 {name=p155318 lab=_67191_/X }
C {devices/lab_pin.sym} 156180 -24390 0 0 {name=p155319 lab=_67147_/X }
C {devices/lab_pin.sym} 156340 -24430 0 1 {name=p155320 lab=_67197_/A }
C {sky130_stdcells/a21o_4.sym} 156260 -24430 0 0 {name=X_67192_ }
C {devices/lab_pin.sym} 156200 -24300 0 0 {name=p155321 lab=_79164_/Y }
C {devices/lab_pin.sym} 156200 -24260 0 0 {name=p155322 lab=_79523_/B }
C {devices/lab_pin.sym} 156320 -24280 0 1 {name=p155323 lab=_79178_/Y }
C {sky130_stdcells/nor2_4.sym} 156260 -24280 0 0 {name=X_79178_ }
C {devices/lab_pin.sym} 156220 -24150 0 0 {name=p155324 lab=clkbuf_9_120_0_CLK/X }
C {devices/lab_pin.sym} 156300 -24150 0 1 {name=p155325 lab=_84562_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 156260 -24150 0 0 {name=Xclkbuf_10_241_0_CLK }
C {devices/lab_pin.sym} 156220 -24030 0 0 {name=p155326 lab=_81816_/Q }
C {devices/lab_pin.sym} 156300 -24030 0 1 {name=p155327 lab=_47310_/A }
C {sky130_stdcells/inv_2.sym} 156260 -24030 0 0 {name=X_47309_ }
C {devices/lab_pin.sym} 156220 -23910 0 0 {name=p155328 lab=clkbuf_9_435_0_CLK/X }
C {devices/lab_pin.sym} 156300 -23910 0 1 {name=p155329 lab=_86736_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 156260 -23910 0 0 {name=Xclkbuf_10_871_0_CLK }
C {devices/lab_pin.sym} 156200 -23800 0 0 {name=p155330 lab=_65934_/X }
C {devices/lab_pin.sym} 156200 -23760 0 0 {name=p155331 lab=_66143_/B }
C {devices/lab_pin.sym} 156320 -23780 0 1 {name=p155332 lab=_66143_/X }
C {sky130_stdcells/and2_4.sym} 156260 -23780 0 0 {name=X_66143_ }
C {devices/lab_pin.sym} 156200 -23660 0 0 {name=p155333 lab=_82570_/Q }
C {devices/lab_pin.sym} 156200 -23620 0 0 {name=p155334 lab=_82858_/D }
C {devices/lab_pin.sym} 156320 -23640 0 1 {name=p155335 lab=_78129_/X }
C {sky130_stdcells/xor2_4.sym} 156260 -23640 0 0 {name=X_78129_ }
C {devices/lab_pin.sym} 156200 -23540 0 0 {name=p155336 lab=_63355_/A }
C {devices/lab_pin.sym} 156200 -23500 0 0 {name=p155337 lab=_60642_/A }
C {devices/lab_pin.sym} 156200 -23460 0 0 {name=p155338 lab=_60638_/Y }
C {devices/lab_pin.sym} 156200 -23420 0 0 {name=p155339 lab=_60642_/C }
C {devices/lab_pin.sym} 156320 -23480 0 1 {name=p155340 lab=_63355_/Y }
C {sky130_stdcells/nand4_4.sym} 156260 -23480 0 0 {name=X_63355_ }
C {devices/lab_pin.sym} 156200 -23340 0 0 {name=p155341 lab=_48264_/X }
C {devices/lab_pin.sym} 156200 -23300 0 0 {name=p155342 lab=_52036_/B }
C {devices/lab_pin.sym} 156320 -23320 0 1 {name=p155343 lab=_48289_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -23320 0 0 {name=X_48289_ }
C {devices/lab_pin.sym} 156220 -23190 0 0 {name=p155344 lab=_60566_/X }
C {devices/lab_pin.sym} 156300 -23190 0 1 {name=p155345 lab=_60567_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -23190 0 0 {name=X_60567_ }
C {devices/lab_pin.sym} 156220 -23070 0 0 {name=p155346 lab=clkbuf_9_11_0_CLK/X }
C {devices/lab_pin.sym} 156300 -23070 0 1 {name=p155347 lab=_85190_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 156260 -23070 0 0 {name=Xclkbuf_10_23_0_CLK }
C {devices/lab_pin.sym} 156220 -22950 0 0 {name=p155348 lab=_50638_/A }
C {devices/lab_pin.sym} 156300 -22950 0 1 {name=p155349 lab=_50572_/A }
C {sky130_stdcells/buf_2.sym} 156260 -22950 0 0 {name=X_50320_ }
C {devices/lab_pin.sym} 156180 -22850 0 0 {name=p155350 lab=_62196_/X }
C {devices/lab_pin.sym} 156180 -22810 0 0 {name=p155351 lab=_61831_/X }
C {devices/lab_pin.sym} 156180 -22770 0 0 {name=p155352 lab=_62305_/X }
C {devices/lab_pin.sym} 156340 -22810 0 1 {name=p155353 lab=_62306_/X }
C {sky130_stdcells/a21o_4.sym} 156260 -22810 0 0 {name=X_62306_ }
C {devices/lab_pin.sym} 156170 -22670 0 0 {name=p155354 lab=_81197_/CLK }
C {devices/lab_pin.sym} 156170 -22650 0 0 {name=p155355 lab=_81140_/D }
C {devices/lab_pin.sym} 156350 -22670 0 1 {name=p155356 lab=_40659_/A }
C {sky130_stdcells/dfxtp_4.sym} 156260 -22660 0 0 {name=X_81140_ }
C {devices/lab_pin.sym} 156200 -22540 0 0 {name=p155357 lab=_57770_/A }
C {devices/lab_pin.sym} 156200 -22500 0 0 {name=p155358 lab=_73833_/B }
C {devices/lab_pin.sym} 156320 -22520 0 1 {name=p155359 lab=_66074_/X }
C {sky130_stdcells/and2_4.sym} 156260 -22520 0 0 {name=X_66074_ }
C {devices/lab_pin.sym} 156220 -22390 0 0 {name=p155360 lab=clkbuf_9_363_0_CLK/A }
C {devices/lab_pin.sym} 156300 -22390 0 1 {name=p155361 lab=clkbuf_9_362_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 156260 -22390 0 0 {name=Xclkbuf_9_362_0_CLK }
C {devices/lab_pin.sym} 156180 -22290 0 0 {name=p155362 lab=_63283_/X }
C {devices/lab_pin.sym} 156180 -22250 0 0 {name=p155363 lab=_63284_/X }
C {devices/lab_pin.sym} 156180 -22210 0 0 {name=p155364 lab=_63285_/Y }
C {devices/lab_pin.sym} 156340 -22250 0 1 {name=p155365 lab=_63286_/Y }
C {sky130_stdcells/a21oi_4.sym} 156260 -22250 0 0 {name=X_63286_ }
C {devices/lab_pin.sym} 156180 -22150 0 0 {name=p155366 lab=_60435_/A }
C {devices/lab_pin.sym} 156180 -22110 0 0 {name=p155367 lab=_60493_/X }
C {devices/lab_pin.sym} 156180 -22070 0 0 {name=p155368 lab=_60495_/X }
C {devices/lab_pin.sym} 156180 -22030 0 0 {name=p155369 lab=_60572_/C }
C {devices/lab_pin.sym} 156180 -22000 0 0 {name=p155370 lab=_60497_/Y }
C {devices/lab_pin.sym} 156340 -22070 0 1 {name=p155371 lab=_60498_/Y }
C {sky130_stdcells/a41oi_4.sym} 156260 -22070 0 0 {name=X_60498_ }
C {devices/lab_pin.sym} 156200 -21920 0 0 {name=p155372 lab=_64948_/A }
C {devices/lab_pin.sym} 156200 -21880 0 0 {name=p155373 lab=_65025_/B }
C {devices/lab_pin.sym} 156320 -21900 0 1 {name=p155374 lab=_65025_/X }
C {sky130_stdcells/and2_4.sym} 156260 -21900 0 0 {name=X_65025_ }
C {devices/lab_pin.sym} 156200 -21780 0 0 {name=p155375 lab=_69902_/A }
C {devices/lab_pin.sym} 156200 -21740 0 0 {name=p155376 lab=_69902_/B }
C {devices/lab_pin.sym} 156320 -21760 0 1 {name=p155377 lab=_69902_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -21760 0 0 {name=X_69902_ }
C {devices/lab_pin.sym} 156220 -21630 0 0 {name=p155378 lab=_50222_/X }
C {devices/lab_pin.sym} 156300 -21630 0 1 {name=p155379 lab=_50251_/X }
C {sky130_stdcells/buf_2.sym} 156260 -21630 0 0 {name=X_50251_ }
C {devices/lab_pin.sym} 156220 -21510 0 0 {name=p155380 lab=_62237_/A }
C {devices/lab_pin.sym} 156300 -21510 0 1 {name=p155381 lab=_62237_/X }
C {sky130_stdcells/buf_2.sym} 156260 -21510 0 0 {name=X_62237_ }
C {devices/lab_pin.sym} 156170 -21390 0 0 {name=p155382 lab=_80817_/CLK }
C {devices/lab_pin.sym} 156170 -21370 0 0 {name=p155383 lab=_75839_/A }
C {devices/lab_pin.sym} 156350 -21390 0 1 {name=p155384 lab=_75254_/A }
C {sky130_stdcells/dfxtp_4.sym} 156260 -21380 0 0 {name=X_81071_ }
C {devices/lab_pin.sym} 156220 -21250 0 0 {name=p155385 lab=clkbuf_9_128_0_CLK/X }
C {devices/lab_pin.sym} 156300 -21250 0 1 {name=p155386 lab=_84344_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 156260 -21250 0 0 {name=Xclkbuf_10_256_0_CLK }
C {devices/lab_pin.sym} 156220 -21130 0 0 {name=p155387 lab=clkbuf_9_443_0_CLK/X }
C {devices/lab_pin.sym} 156300 -21130 0 1 {name=p155388 lab=_86030_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 156260 -21130 0 0 {name=Xclkbuf_10_886_0_CLK }
C {devices/lab_pin.sym} 156180 -21030 0 0 {name=p155389 lab=_80013_/Y }
C {devices/lab_pin.sym} 156180 -20990 0 0 {name=p155390 lab=_80008_/X }
C {devices/lab_pin.sym} 156180 -20950 0 0 {name=p155391 lab=_80021_/X }
C {devices/lab_pin.sym} 156340 -20990 0 1 {name=p155392 lab=_80023_/B }
C {sky130_stdcells/a21boi_4.sym} 156260 -20990 0 0 {name=X_80022_ }
C {devices/lab_pin.sym} 156220 -20850 0 0 {name=p155393 lab=_69747_/A }
C {devices/lab_pin.sym} 156300 -20850 0 1 {name=p155394 lab=_69833_/X }
C {sky130_stdcells/buf_2.sym} 156260 -20850 0 0 {name=X_69833_ }
C {devices/lab_pin.sym} 156180 -20750 0 0 {name=p155395 lab=_65285_/B }
C {devices/lab_pin.sym} 156180 -20710 0 0 {name=p155396 lab=_50162_/X }
C {devices/lab_pin.sym} 156180 -20670 0 0 {name=p155397 lab=_50181_/Y }
C {devices/lab_pin.sym} 156340 -20710 0 1 {name=p155398 lab=_50182_/Y }
C {sky130_stdcells/o21ai_4.sym} 156260 -20710 0 0 {name=X_50182_ }
C {devices/lab_pin.sym} 156180 -20590 0 0 {name=p155399 lab=_62165_/Y }
C {devices/lab_pin.sym} 156180 -20550 0 0 {name=p155400 lab=_62166_/X }
C {devices/lab_pin.sym} 156180 -20510 0 0 {name=p155401 lab=_62167_/Y }
C {devices/lab_pin.sym} 156340 -20550 0 1 {name=p155402 lab=_84428_/D }
C {sky130_stdcells/a21oi_4.sym} 156260 -20550 0 0 {name=X_62168_ }
C {devices/lab_pin.sym} 156220 -20410 0 0 {name=p155403 lab=clkbuf_9_19_0_CLK/X }
C {devices/lab_pin.sym} 156300 -20410 0 1 {name=p155404 lab=_85083_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 156260 -20410 0 0 {name=Xclkbuf_10_38_0_CLK }
C {devices/lab_pin.sym} 156220 -20290 0 0 {name=p155405 lab=clkbuf_8_188_0_CLK/X }
C {devices/lab_pin.sym} 156300 -20290 0 1 {name=p155406 lab=clkbuf_9_377_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 156260 -20290 0 0 {name=Xclkbuf_9_377_0_CLK }
C {devices/lab_pin.sym} 156220 -20170 0 0 {name=p155407 lab=_64546_/A }
C {devices/lab_pin.sym} 156300 -20170 0 1 {name=p155408 lab=_61125_/A }
C {sky130_stdcells/inv_2.sym} 156260 -20170 0 0 {name=X_61119_ }
C {devices/lab_pin.sym} 156170 -20050 0 0 {name=p155409 lab=_84714_/CLK }
C {devices/lab_pin.sym} 156170 -20030 0 0 {name=p155410 lab=_58516_/Y }
C {devices/lab_pin.sym} 156350 -20050 0 1 {name=p155411 lab=_84830_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -20040 0 0 {name=X_84830_ }
C {devices/lab_pin.sym} 156200 -19920 0 0 {name=p155412 lab=_69086_/A }
C {devices/lab_pin.sym} 156200 -19880 0 0 {name=p155413 lab=_73149_/A }
C {devices/lab_pin.sym} 156320 -19900 0 1 {name=p155414 lab=_69764_/X }
C {sky130_stdcells/and2_4.sym} 156260 -19900 0 0 {name=X_69764_ }
C {devices/lab_pin.sym} 156180 -19790 0 0 {name=p155415 lab=_85339_/Q }
C {devices/lab_pin.sym} 156180 -19750 0 0 {name=p155416 lab=_54967_/X }
C {devices/lab_pin.sym} 156180 -19710 0 0 {name=p155417 lab=_54989_/Y }
C {devices/lab_pin.sym} 156340 -19750 0 1 {name=p155418 lab=_54990_/Y }
C {sky130_stdcells/o21ai_4.sym} 156260 -19750 0 0 {name=X_54990_ }
C {devices/lab_pin.sym} 156180 -19640 0 0 {name=p155419 lab=_87362_/Q }
C {devices/lab_pin.sym} 156180 -19600 0 0 {name=p155420 lab=_66878_/X }
C {devices/lab_pin.sym} 156180 -19560 0 0 {name=p155421 lab=_66879_/X }
C {devices/lab_pin.sym} 156180 -19520 0 0 {name=p155422 lab=_66975_/X }
C {devices/lab_pin.sym} 156340 -19580 0 1 {name=p155423 lab=_66976_/X }
C {sky130_stdcells/a211o_4.sym} 156260 -19580 0 0 {name=X_66976_ }
C {devices/lab_pin.sym} 156200 -19460 0 0 {name=p155424 lab=_59794_/X }
C {devices/lab_pin.sym} 156200 -19420 0 0 {name=p155425 lab=_62088_/B }
C {devices/lab_pin.sym} 156200 -19380 0 0 {name=p155426 lab=_62096_/Y }
C {devices/lab_pin.sym} 156200 -19340 0 0 {name=p155427 lab=_62099_/D }
C {devices/lab_pin.sym} 156320 -19400 0 1 {name=p155428 lab=_62099_/Y }
C {sky130_stdcells/nand4_4.sym} 156260 -19400 0 0 {name=X_62099_ }
C {devices/lab_pin.sym} 156220 -19250 0 0 {name=p155429 lab=_69958_/A }
C {devices/lab_pin.sym} 156300 -19250 0 1 {name=p155430 lab=_68715_/X }
C {sky130_stdcells/buf_2.sym} 156260 -19250 0 0 {name=X_68715_ }
C {devices/lab_pin.sym} 156220 -19130 0 0 {name=p155431 lab=_54295_/A }
C {devices/lab_pin.sym} 156300 -19130 0 1 {name=p155432 lab=_53942_/A }
C {sky130_stdcells/buf_2.sym} 156260 -19130 0 0 {name=X_53941_ }
C {devices/lab_pin.sym} 156200 -19030 0 0 {name=p155433 lab=_65923_/X }
C {devices/lab_pin.sym} 156200 -18990 0 0 {name=p155434 lab=_65741_/B }
C {devices/lab_pin.sym} 156200 -18950 0 0 {name=p155435 lab=_65927_/C }
C {devices/lab_pin.sym} 156320 -18990 0 1 {name=p155436 lab=_65927_/Y }
C {sky130_stdcells/nand3_4.sym} 156260 -18990 0 0 {name=X_65927_ }
C {devices/lab_pin.sym} 156170 -18850 0 0 {name=p155437 lab=_84766_/CLK }
C {devices/lab_pin.sym} 156170 -18830 0 0 {name=p155438 lab=_84761_/D }
C {devices/lab_pin.sym} 156350 -18850 0 1 {name=p155439 lab=_84761_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -18840 0 0 {name=X_84761_ }
C {devices/lab_pin.sym} 156170 -18710 0 0 {name=p155440 lab=_82116_/CLK }
C {devices/lab_pin.sym} 156170 -18690 0 0 {name=p155441 lab=_83901_/Q }
C {devices/lab_pin.sym} 156350 -18710 0 1 {name=p155442 lab=_81973_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -18700 0 0 {name=X_81973_ }
C {devices/lab_pin.sym} 156180 -18590 0 0 {name=p155443 lab=_81976_/D }
C {devices/lab_pin.sym} 156180 -18550 0 0 {name=p155444 lab=_69632_/X }
C {devices/lab_pin.sym} 156180 -18510 0 0 {name=p155445 lab=_69694_/X }
C {devices/lab_pin.sym} 156340 -18550 0 1 {name=p155446 lab=_83904_/D }
C {sky130_stdcells/a21bo_4.sym} 156260 -18550 0 0 {name=X_69695_ }
C {devices/lab_pin.sym} 156170 -18410 0 0 {name=p155447 lab=_86500_/CLK }
C {devices/lab_pin.sym} 156170 -18390 0 0 {name=p155448 lab=_48692_/Y }
C {devices/lab_pin.sym} 156350 -18410 0 1 {name=p155449 lab=_86500_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -18400 0 0 {name=X_86500_ }
C {devices/lab_pin.sym} 156170 -18270 0 0 {name=p155450 lab=_86303_/CLK }
C {devices/lab_pin.sym} 156170 -18250 0 0 {name=p155451 lab=_83712_/D }
C {devices/lab_pin.sym} 156350 -18270 0 1 {name=p155452 lab=_47535_/A }
C {sky130_stdcells/dfxtp_4.sym} 156260 -18260 0 0 {name=X_83712_ }
C {devices/lab_pin.sym} 156200 -18150 0 0 {name=p155453 lab=_56660_/A }
C {devices/lab_pin.sym} 156200 -18110 0 0 {name=p155454 lab=_56659_/Y }
C {devices/lab_pin.sym} 156200 -18070 0 0 {name=p155455 lab=_83333_/Q }
C {devices/lab_pin.sym} 156320 -18110 0 1 {name=p155456 lab=_56661_/C }
C {sky130_stdcells/nand3_4.sym} 156260 -18110 0 0 {name=X_56660_ }
C {devices/lab_pin.sym} 156170 -17970 0 0 {name=p155457 lab=_80928_/CLK }
C {devices/lab_pin.sym} 156170 -17950 0 0 {name=p155458 lab=_84100_/Q }
C {devices/lab_pin.sym} 156350 -17970 0 1 {name=p155459 lab=_75807_/A }
C {sky130_stdcells/dfxtp_4.sym} 156260 -17960 0 0 {name=X_80924_ }
C {devices/lab_pin.sym} 156180 -17860 0 0 {name=p155460 lab=_44697_/A }
C {devices/lab_pin.sym} 156180 -17820 0 0 {name=p155461 lab=_68570_/X }
C {devices/lab_pin.sym} 156180 -17780 0 0 {name=p155462 lab=_68571_/X }
C {devices/lab_pin.sym} 156180 -17740 0 0 {name=p155463 lab=_68645_/X }
C {devices/lab_pin.sym} 156340 -17800 0 1 {name=p155464 lab=_68646_/X }
C {sky130_stdcells/a211o_4.sym} 156260 -17800 0 0 {name=X_68646_ }
C {devices/lab_pin.sym} 156170 -17650 0 0 {name=p155465 lab=_87993_/CLK }
C {devices/lab_pin.sym} 156170 -17630 0 0 {name=p155466 lab=_87480_/D }
C {devices/lab_pin.sym} 156350 -17650 0 1 {name=p155467 lab=_87480_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -17640 0 0 {name=X_87480_ }
C {devices/lab_pin.sym} 156200 -17520 0 0 {name=p155468 lab=_53871_/X }
C {devices/lab_pin.sym} 156200 -17480 0 0 {name=p155469 lab=_49064_/A }
C {devices/lab_pin.sym} 156320 -17500 0 1 {name=p155470 lab=_53872_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -17500 0 0 {name=X_53872_ }
C {devices/lab_pin.sym} 156220 -17370 0 0 {name=p155471 lab=clkbuf_8_150_0_CLK/X }
C {devices/lab_pin.sym} 156300 -17370 0 1 {name=p155472 lab=clkbuf_9_300_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 156260 -17370 0 0 {name=Xclkbuf_9_300_0_CLK }
C {devices/lab_pin.sym} 156180 -17280 0 0 {name=p155473 lab=_65845_/X }
C {devices/lab_pin.sym} 156180 -17240 0 0 {name=p155474 lab=_86180_/Q }
C {devices/lab_pin.sym} 156180 -17200 0 0 {name=p155475 lab=_65790_/X }
C {devices/lab_pin.sym} 156180 -17160 0 0 {name=p155476 lab=_65857_/X }
C {devices/lab_pin.sym} 156340 -17220 0 1 {name=p155477 lab=_65858_/X }
C {sky130_stdcells/a211o_4.sym} 156260 -17220 0 0 {name=X_65858_ }
C {devices/lab_pin.sym} 156170 -17070 0 0 {name=p155478 lab=_83227_/CLK }
C {devices/lab_pin.sym} 156170 -17050 0 0 {name=p155479 lab=_59835_/X }
C {devices/lab_pin.sym} 156350 -17070 0 1 {name=p155480 lab=_80400_/A }
C {sky130_stdcells/dfxtp_4.sym} 156260 -17060 0 0 {name=X_84692_ }
C {devices/lab_pin.sym} 156220 -16930 0 0 {name=p155481 lab=_55610_/X }
C {devices/lab_pin.sym} 156300 -16930 0 1 {name=p155482 lab=_55611_/X }
C {sky130_stdcells/buf_2.sym} 156260 -16930 0 0 {name=X_55611_ }
C {devices/lab_pin.sym} 156170 -16810 0 0 {name=p155483 lab=_85536_/CLK }
C {devices/lab_pin.sym} 156170 -16790 0 0 {name=p155484 lab=_86431_/D }
C {devices/lab_pin.sym} 156350 -16810 0 1 {name=p155485 lab=_64647_/B }
C {sky130_stdcells/dfxtp_4.sym} 156260 -16800 0 0 {name=X_86431_ }
C {devices/lab_pin.sym} 156200 -16680 0 0 {name=p155486 lab=_52843_/A }
C {devices/lab_pin.sym} 156200 -16640 0 0 {name=p155487 lab=_51130_/B }
C {devices/lab_pin.sym} 156320 -16660 0 1 {name=p155488 lab=_52823_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -16660 0 0 {name=X_52823_ }
C {devices/lab_pin.sym} 156220 -16530 0 0 {name=p155489 lab=_64809_/A }
C {devices/lab_pin.sym} 156300 -16530 0 1 {name=p155490 lab=_64809_/X }
C {sky130_stdcells/buf_2.sym} 156260 -16530 0 0 {name=X_64809_ }
C {devices/lab_pin.sym} 156170 -16410 0 0 {name=p155491 lab=_86422_/CLK }
C {devices/lab_pin.sym} 156170 -16390 0 0 {name=p155492 lab=_70977_/Y }
C {devices/lab_pin.sym} 156350 -16410 0 1 {name=p155493 lab=_46410_/A }
C {sky130_stdcells/dfxtp_4.sym} 156260 -16400 0 0 {name=X_83643_ }
C {devices/lab_pin.sym} 156180 -16300 0 0 {name=p155494 lab=_56587_/X }
C {devices/lab_pin.sym} 156180 -16260 0 0 {name=p155495 lab=_56589_/X }
C {devices/lab_pin.sym} 156180 -16220 0 0 {name=p155496 lab=_85148_/Q }
C {devices/lab_pin.sym} 156180 -16180 0 0 {name=p155497 lab=_56590_/X }
C {devices/lab_pin.sym} 156340 -16240 0 1 {name=p155498 lab=_85148_/D }
C {sky130_stdcells/a2bb2o_4.sym} 156260 -16240 0 0 {name=X_56591_ }
C {devices/lab_pin.sym} 156170 -16090 0 0 {name=p155499 lab=_80854_/CLK }
C {devices/lab_pin.sym} 156170 -16070 0 0 {name=p155500 lab=_80887_/Q }
C {devices/lab_pin.sym} 156350 -16090 0 1 {name=p155501 lab=_75003_/B }
C {sky130_stdcells/dfxtp_4.sym} 156260 -16080 0 0 {name=X_80855_ }
C {devices/lab_pin.sym} 156200 -15960 0 0 {name=p155502 lab=_68452_/A }
C {devices/lab_pin.sym} 156200 -15920 0 0 {name=p155503 lab=_87243_/Q }
C {devices/lab_pin.sym} 156320 -15940 0 1 {name=p155504 lab=_68577_/X }
C {sky130_stdcells/and2_4.sym} 156260 -15940 0 0 {name=X_68577_ }
C {devices/lab_pin.sym} 156220 -15810 0 0 {name=p155505 lab=_65516_/A }
C {devices/lab_pin.sym} 156300 -15810 0 1 {name=p155506 lab=_65789_/X }
C {sky130_stdcells/buf_2.sym} 156260 -15810 0 0 {name=X_65789_ }
C {devices/lab_pin.sym} 156220 -15690 0 0 {name=p155507 lab=_58408_/A }
C {devices/lab_pin.sym} 156300 -15690 0 1 {name=p155508 lab=_58364_/B }
C {sky130_stdcells/buf_2.sym} 156260 -15690 0 0 {name=X_58330_ }
C {devices/lab_pin.sym} 156220 -15570 0 0 {name=p155509 lab=clkbuf_9_412_0_CLK/X }
C {devices/lab_pin.sym} 156300 -15570 0 1 {name=p155510 lab=_82879_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 156260 -15570 0 0 {name=Xclkbuf_10_824_0_CLK }
C {devices/lab_pin.sym} 156200 -15460 0 0 {name=p155511 lab=_55462_/X }
C {devices/lab_pin.sym} 156200 -15420 0 0 {name=p155512 lab=_45515_/Y }
C {devices/lab_pin.sym} 156320 -15440 0 1 {name=p155513 lab=_55542_/Y }
C {sky130_stdcells/nor2_4.sym} 156260 -15440 0 0 {name=X_55542_ }
C {devices/lab_pin.sym} 156180 -15340 0 0 {name=p155514 lab=_87467_/Q }
C {devices/lab_pin.sym} 156180 -15300 0 0 {name=p155515 lab=_67476_/X }
C {devices/lab_pin.sym} 156180 -15260 0 0 {name=p155516 lab=_67477_/X }
C {devices/lab_pin.sym} 156180 -15220 0 0 {name=p155517 lab=_67527_/X }
C {devices/lab_pin.sym} 156340 -15280 0 1 {name=p155518 lab=_67528_/X }
C {sky130_stdcells/a211o_4.sym} 156260 -15280 0 0 {name=X_67528_ }
C {devices/lab_pin.sym} 156170 -15130 0 0 {name=p155519 lab=_83049_/CLK }
C {devices/lab_pin.sym} 156170 -15110 0 0 {name=p155520 lab=_49578_/Y }
C {devices/lab_pin.sym} 156350 -15130 0 1 {name=p155521 lab=_86362_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -15120 0 0 {name=X_86362_ }
C {devices/lab_pin.sym} 156220 -14990 0 0 {name=p155522 lab=_52754_/A }
C {devices/lab_pin.sym} 156300 -14990 0 1 {name=p155523 lab=_52783_/A }
C {sky130_stdcells/buf_2.sym} 156260 -14990 0 0 {name=X_52754_ }
C {devices/lab_pin.sym} 156170 -14870 0 0 {name=p155524 lab=_86505_/CLK }
C {devices/lab_pin.sym} 156170 -14850 0 0 {name=p155525 lab=_83574_/D }
C {devices/lab_pin.sym} 156350 -14870 0 1 {name=p155526 lab=_48571_/A }
C {sky130_stdcells/dfxtp_4.sym} 156260 -14860 0 0 {name=X_83574_ }
C {devices/lab_pin.sym} 156170 -14730 0 0 {name=p155527 lab=_80754_/CLK }
C {devices/lab_pin.sym} 156170 -14710 0 0 {name=p155528 lab=_80786_/D }
C {devices/lab_pin.sym} 156350 -14730 0 1 {name=p155529 lab=_80786_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -14720 0 0 {name=X_80786_ }
C {devices/lab_pin.sym} 156170 -14590 0 0 {name=p155530 lab=_88097_/CLK }
C {devices/lab_pin.sym} 156170 -14570 0 0 {name=p155531 lab=_41934_/Y }
C {devices/lab_pin.sym} 156350 -14590 0 1 {name=p155532 lab=_73892_/A }
C {sky130_stdcells/dfxtp_4.sym} 156260 -14580 0 0 {name=X_88101_ }
C {devices/lab_pin.sym} 156170 -14450 0 0 {name=p155533 lab=_85138_/CLK }
C {devices/lab_pin.sym} 156170 -14430 0 0 {name=p155534 lab=_55991_/Y }
C {devices/lab_pin.sym} 156350 -14450 0 1 {name=p155535 lab=_55990_/C }
C {sky130_stdcells/dfxtp_4.sym} 156260 -14440 0 0 {name=X_85313_ }
C {devices/lab_pin.sym} 156200 -14340 0 0 {name=p155536 lab=_51695_/A }
C {devices/lab_pin.sym} 156200 -14300 0 0 {name=p155537 lab=_51715_/B }
C {devices/lab_pin.sym} 156200 -14260 0 0 {name=p155538 lab=_51695_/C }
C {devices/lab_pin.sym} 156200 -14220 0 0 {name=p155539 lab=_53230_/D }
C {devices/lab_pin.sym} 156320 -14280 0 1 {name=p155540 lab=_51705_/X }
C {sky130_stdcells/and4_4.sym} 156260 -14280 0 0 {name=X_51705_ }
C {devices/lab_pin.sym} 156220 -14130 0 0 {name=p155541 lab=clkbuf_9_315_0_CLK/A }
C {devices/lab_pin.sym} 156300 -14130 0 1 {name=p155542 lab=clkbuf_9_315_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 156260 -14130 0 0 {name=Xclkbuf_9_315_0_CLK }
C {devices/lab_pin.sym} 156220 -14010 0 0 {name=p155543 lab=_62027_/A }
C {devices/lab_pin.sym} 156300 -14010 0 1 {name=p155544 lab=_58261_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -14010 0 0 {name=X_58261_ }
C {devices/lab_pin.sym} 156170 -13890 0 0 {name=p155545 lab=_82503_/CLK }
C {devices/lab_pin.sym} 156170 -13870 0 0 {name=p155546 lab=_82525_/D }
C {devices/lab_pin.sym} 156350 -13890 0 1 {name=p155547 lab=_78727_/A }
C {sky130_stdcells/dfxtp_4.sym} 156260 -13880 0 0 {name=X_82525_ }
C {devices/lab_pin.sym} 156180 -13780 0 0 {name=p155548 lab=_45617_/A }
C {devices/lab_pin.sym} 156180 -13740 0 0 {name=p155549 lab=_55468_/X }
C {devices/lab_pin.sym} 156180 -13700 0 0 {name=p155550 lab=_55458_/X }
C {devices/lab_pin.sym} 156180 -13660 0 0 {name=p155551 lab=_55472_/Y }
C {devices/lab_pin.sym} 156340 -13720 0 1 {name=p155552 lab=_55473_/X }
C {sky130_stdcells/a211o_4.sym} 156260 -13720 0 0 {name=X_55473_ }
C {devices/lab_pin.sym} 156220 -13570 0 0 {name=p155553 lab=_67222_/A }
C {devices/lab_pin.sym} 156300 -13570 0 1 {name=p155554 lab=_67460_/A }
C {sky130_stdcells/buf_2.sym} 156260 -13570 0 0 {name=X_67459_ }
C {devices/lab_pin.sym} 156170 -13450 0 0 {name=p155555 lab=_86611_/CLK }
C {devices/lab_pin.sym} 156170 -13430 0 0 {name=p155556 lab=_86293_/D }
C {devices/lab_pin.sym} 156350 -13450 0 1 {name=p155557 lab=_86293_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -13440 0 0 {name=X_86293_ }
C {devices/lab_pin.sym} 156220 -13310 0 0 {name=p155558 lab=_52657_/A }
C {devices/lab_pin.sym} 156300 -13310 0 1 {name=p155559 lab=_52706_/A }
C {sky130_stdcells/buf_2.sym} 156260 -13310 0 0 {name=X_52685_ }
C {devices/lab_pin.sym} 156220 -13190 0 0 {name=p155560 lab=_57212_/A }
C {devices/lab_pin.sym} 156300 -13190 0 1 {name=p155561 lab=_57212_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -13190 0 0 {name=X_57212_ }
C {devices/lab_pin.sym} 156170 -13070 0 0 {name=p155562 lab=_88036_/CLK }
C {devices/lab_pin.sym} 156170 -13050 0 0 {name=p155563 lab=_42109_/Y }
C {devices/lab_pin.sym} 156350 -13070 0 1 {name=p155564 lab=_88032_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -13060 0 0 {name=X_88032_ }
C {devices/lab_pin.sym} 156180 -12950 0 0 {name=p155565 lab=_54420_/Y }
C {devices/lab_pin.sym} 156180 -12910 0 0 {name=p155566 lab=_54422_/X }
C {devices/lab_pin.sym} 156180 -12870 0 0 {name=p155567 lab=_54423_/X }
C {devices/lab_pin.sym} 156340 -12910 0 1 {name=p155568 lab=_54424_/Y }
C {sky130_stdcells/a21oi_4.sym} 156260 -12910 0 0 {name=X_54424_ }
C {devices/lab_pin.sym} 156220 -12770 0 0 {name=p155569 lab=clkbuf_9_104_0_CLK/X }
C {devices/lab_pin.sym} 156300 -12770 0 1 {name=p155570 lab=_84498_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 156260 -12770 0 0 {name=Xclkbuf_10_209_0_CLK }
C {devices/lab_pin.sym} 156170 -12650 0 0 {name=p155571 lab=_85244_/CLK }
C {devices/lab_pin.sym} 156170 -12630 0 0 {name=p155572 lab=_56302_/Y }
C {devices/lab_pin.sym} 156350 -12650 0 1 {name=p155573 lab=_85244_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -12640 0 0 {name=X_85244_ }
C {devices/lab_pin.sym} 156180 -12530 0 0 {name=p155574 lab=_51633_/Y }
C {devices/lab_pin.sym} 156180 -12490 0 0 {name=p155575 lab=_51613_/X }
C {devices/lab_pin.sym} 156180 -12450 0 0 {name=p155576 lab=_51635_/X }
C {devices/lab_pin.sym} 156340 -12490 0 1 {name=p155577 lab=_85974_/D }
C {sky130_stdcells/a21oi_4.sym} 156260 -12490 0 0 {name=X_51636_ }
C {devices/lab_pin.sym} 156220 -12350 0 0 {name=p155578 lab=_83375_/Q }
C {devices/lab_pin.sym} 156300 -12350 0 1 {name=p155579 lab=_58192_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -12350 0 0 {name=X_58192_ }
C {devices/lab_pin.sym} 156200 -12250 0 0 {name=p155580 lab=_71706_/A }
C {devices/lab_pin.sym} 156200 -12210 0 0 {name=p155581 lab=_71366_/A }
C {devices/lab_pin.sym} 156200 -12170 0 0 {name=p155582 lab=_71424_/C }
C {devices/lab_pin.sym} 156320 -12210 0 1 {name=p155583 lab=_70470_/X }
C {sky130_stdcells/and3_4.sym} 156260 -12210 0 0 {name=X_70470_ }
C {devices/lab_pin.sym} 156170 -12070 0 0 {name=p155584 lab=_84177_/CLK }
C {devices/lab_pin.sym} 156170 -12050 0 0 {name=p155585 lab=_82456_/D }
C {devices/lab_pin.sym} 156350 -12070 0 1 {name=p155586 lab=_82456_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -12060 0 0 {name=X_82456_ }
C {devices/lab_pin.sym} 156220 -11930 0 0 {name=p155587 lab=clkbuf_9_419_0_CLK/X }
C {devices/lab_pin.sym} 156300 -11930 0 1 {name=p155588 lab=_83783_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 156260 -11930 0 0 {name=Xclkbuf_10_839_0_CLK }
C {devices/lab_pin.sym} 156220 -11810 0 0 {name=p155589 lab=clkbuf_4_0_1_CLK/X }
C {devices/lab_pin.sym} 156300 -11810 0 1 {name=p155590 lab=clkbuf_6_1_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 156260 -11810 0 0 {name=Xclkbuf_5_0_0_CLK }
C {devices/lab_pin.sym} 156170 -11690 0 0 {name=p155591 lab=_83940_/CLK }
C {devices/lab_pin.sym} 156170 -11670 0 0 {name=p155592 lab=_83943_/Q }
C {devices/lab_pin.sym} 156350 -11690 0 1 {name=p155593 lab=_76766_/B }
C {sky130_stdcells/dfxtp_4.sym} 156260 -11680 0 0 {name=X_81407_ }
C {devices/lab_pin.sym} 156180 -11590 0 0 {name=p155594 lab=_56729_/X }
C {devices/lab_pin.sym} 156180 -11550 0 0 {name=p155595 lab=_57023_/X }
C {devices/lab_pin.sym} 156180 -11510 0 0 {name=p155596 lab=_57129_/Y }
C {devices/lab_pin.sym} 156180 -11470 0 0 {name=p155597 lab=_56816_/A }
C {devices/lab_pin.sym} 156180 -11440 0 0 {name=p155598 lab=_57270_/A }
C {devices/lab_pin.sym} 156340 -11510 0 1 {name=p155599 lab=_57143_/X }
C {sky130_stdcells/a41o_4.sym} 156260 -11510 0 0 {name=X_57143_ }
C {devices/lab_pin.sym} 156200 -11360 0 0 {name=p155600 lab=_69128_/X }
C {devices/lab_pin.sym} 156200 -11320 0 0 {name=p155601 lab=_69129_/B }
C {devices/lab_pin.sym} 156320 -11340 0 1 {name=p155602 lab=_69129_/X }
C {sky130_stdcells/and2_4.sym} 156260 -11340 0 0 {name=X_69129_ }
C {devices/lab_pin.sym} 156200 -11220 0 0 {name=p155603 lab=_54355_/A }
C {devices/lab_pin.sym} 156200 -11180 0 0 {name=p155604 lab=_52663_/B }
C {devices/lab_pin.sym} 156320 -11200 0 1 {name=p155605 lab=_54355_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -11200 0 0 {name=X_54355_ }
C {devices/lab_pin.sym} 156170 -11070 0 0 {name=p155606 lab=_85270_/CLK }
C {devices/lab_pin.sym} 156170 -11050 0 0 {name=p155607 lab=_85175_/D }
C {devices/lab_pin.sym} 156350 -11070 0 1 {name=p155608 lab=_55896_/B }
C {sky130_stdcells/dfxtp_4.sym} 156260 -11060 0 0 {name=X_85175_ }
C {devices/lab_pin.sym} 156220 -10930 0 0 {name=p155609 lab=_51622_/A }
C {devices/lab_pin.sym} 156300 -10930 0 1 {name=p155610 lab=_51590_/A }
C {sky130_stdcells/buf_2.sym} 156260 -10930 0 0 {name=X_51567_ }
C {devices/lab_pin.sym} 156170 -10810 0 0 {name=p155611 lab=_85491_/CLK }
C {devices/lab_pin.sym} 156170 -10790 0 0 {name=p155612 lab=_82387_/D }
C {devices/lab_pin.sym} 156350 -10810 0 1 {name=p155613 lab=_82387_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -10800 0 0 {name=X_82387_ }
C {devices/lab_pin.sym} 156180 -10690 0 0 {name=p155614 lab=_41042_/X }
C {devices/lab_pin.sym} 156180 -10650 0 0 {name=p155615 lab=_81754_/Q }
C {devices/lab_pin.sym} 156180 -10610 0 0 {name=p155616 lab=_41319_/X }
C {devices/lab_pin.sym} 156340 -10650 0 1 {name=p155617 lab=_41320_/X }
C {sky130_stdcells/o21a_4.sym} 156260 -10650 0 0 {name=X_41320_ }
C {devices/lab_pin.sym} 156180 -10530 0 0 {name=p155618 lab=_85658_/Q }
C {devices/lab_pin.sym} 156180 -10490 0 0 {name=p155619 lab=_53295_/X }
C {devices/lab_pin.sym} 156180 -10450 0 0 {name=p155620 lab=_53305_/Y }
C {devices/lab_pin.sym} 156340 -10490 0 1 {name=p155621 lab=_53306_/Y }
C {sky130_stdcells/o21ai_4.sym} 156260 -10490 0 0 {name=X_53306_ }
C {devices/lab_pin.sym} 156200 -10360 0 0 {name=p155622 lab=_86623_/Q }
C {devices/lab_pin.sym} 156200 -10320 0 0 {name=p155623 lab=_72193_/B }
C {devices/lab_pin.sym} 156320 -10340 0 1 {name=p155624 lab=_72140_/Y }
C {sky130_stdcells/nor2_4.sym} 156260 -10340 0 0 {name=X_72140_ }
C {devices/lab_pin.sym} 156170 -10210 0 0 {name=p155625 lab=_82152_/CLK }
C {devices/lab_pin.sym} 156170 -10190 0 0 {name=p155626 lab=_66425_/X }
C {devices/lab_pin.sym} 156350 -10210 0 1 {name=p155627 lab=_84126_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -10200 0 0 {name=X_84126_ }
C {devices/lab_pin.sym} 156180 -10090 0 0 {name=p155628 lab=_86185_/Q }
C {devices/lab_pin.sym} 156180 -10050 0 0 {name=p155629 lab=_50506_/X }
C {devices/lab_pin.sym} 156180 -10010 0 0 {name=p155630 lab=_50517_/Y }
C {devices/lab_pin.sym} 156340 -10050 0 1 {name=p155631 lab=_50518_/Y }
C {sky130_stdcells/o21ai_4.sym} 156260 -10050 0 0 {name=X_50518_ }
C {devices/lab_pin.sym} 156180 -9950 0 0 {name=p155632 lab=_44290_/X }
C {devices/lab_pin.sym} 156180 -9910 0 0 {name=p155633 lab=_45891_/X }
C {devices/lab_pin.sym} 156180 -9870 0 0 {name=p155634 lab=_56275_/X }
C {devices/lab_pin.sym} 156180 -9830 0 0 {name=p155635 lab=_57223_/D }
C {devices/lab_pin.sym} 156180 -9800 0 0 {name=p155636 lab=_56914_/Y }
C {devices/lab_pin.sym} 156340 -9870 0 1 {name=p155637 lab=_57075_/A }
C {sky130_stdcells/a41oi_4.sym} 156260 -9870 0 0 {name=X_57074_ }
C {devices/lab_pin.sym} 156170 -9710 0 0 {name=p155638 lab=_82053_/CLK }
C {devices/lab_pin.sym} 156170 -9690 0 0 {name=p155639 lab=_76518_/X }
C {devices/lab_pin.sym} 156350 -9710 0 1 {name=p155640 lab=_81714_/D }
C {sky130_stdcells/dfxtp_4.sym} 156260 -9700 0 0 {name=X_81338_ }
C {devices/lab_pin.sym} 156200 -9600 0 0 {name=p155641 lab=_54286_/A }
C {devices/lab_pin.sym} 156200 -9560 0 0 {name=p155642 lab=_54298_/B }
C {devices/lab_pin.sym} 156200 -9520 0 0 {name=p155643 lab=_54286_/C }
C {devices/lab_pin.sym} 156200 -9480 0 0 {name=p155644 lab=_54286_/D }
C {devices/lab_pin.sym} 156320 -9540 0 1 {name=p155645 lab=_54286_/X }
C {sky130_stdcells/and4_4.sym} 156260 -9540 0 0 {name=X_54286_ }
C {devices/lab_pin.sym} 156220 -9390 0 0 {name=p155646 lab=_51552_/A }
C {devices/lab_pin.sym} 156300 -9390 0 1 {name=p155647 lab=_51522_/C }
C {sky130_stdcells/buf_2.sym} 156260 -9390 0 0 {name=X_51498_ }
C {devices/lab_pin.sym} 156200 -9280 0 0 {name=p155648 lab=_56003_/B }
C {devices/lab_pin.sym} 156200 -9240 0 0 {name=p155649 lab=_56002_/A }
C {devices/lab_pin.sym} 156320 -9260 0 1 {name=p155650 lab=_56025_/X }
C {sky130_stdcells/xor2_4.sym} 156260 -9260 0 0 {name=X_56025_ }
C {devices/lab_pin.sym} 156220 -9130 0 0 {name=p155651 lab=_41181_/A }
C {devices/lab_pin.sym} 156300 -9130 0 1 {name=p155652 lab=_41251_/X }
C {sky130_stdcells/buf_2.sym} 156260 -9130 0 0 {name=X_41251_ }
C {devices/lab_pin.sym} 156180 -9030 0 0 {name=p155653 lab=_85671_/Q }
C {devices/lab_pin.sym} 156180 -8990 0 0 {name=p155654 lab=_53225_/X }
C {devices/lab_pin.sym} 156180 -8950 0 0 {name=p155655 lab=_53236_/Y }
C {devices/lab_pin.sym} 156340 -8990 0 1 {name=p155656 lab=_53237_/Y }
C {sky130_stdcells/o21ai_4.sym} 156260 -8990 0 0 {name=X_53237_ }
C {devices/lab_pin.sym} 156180 -8870 0 0 {name=p155657 lab=_72069_/Y }
C {devices/lab_pin.sym} 156180 -8830 0 0 {name=p155658 lab=_72059_/X }
C {devices/lab_pin.sym} 156180 -8790 0 0 {name=p155659 lab=_72070_/X }
C {devices/lab_pin.sym} 156340 -8830 0 1 {name=p155660 lab=_72071_/Y }
C {sky130_stdcells/a21oi_4.sym} 156260 -8830 0 0 {name=X_72071_ }
C {devices/lab_pin.sym} 156170 -8690 0 0 {name=p155661 lab=_81492_/CLK }
C {devices/lab_pin.sym} 156170 -8670 0 0 {name=p155662 lab=_67736_/X }
C {devices/lab_pin.sym} 156350 -8690 0 1 {name=p155663 lab=_84057_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -8680 0 0 {name=X_84057_ }
C {devices/lab_pin.sym} 156200 -8560 0 0 {name=p155664 lab=_50439_/X }
C {devices/lab_pin.sym} 156200 -8520 0 0 {name=p155665 lab=_48482_/B }
C {devices/lab_pin.sym} 156320 -8540 0 1 {name=p155666 lab=_50449_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -8540 0 0 {name=X_50449_ }
C {devices/lab_pin.sym} 156170 -8410 0 0 {name=p155667 lab=_81269_/CLK }
C {devices/lab_pin.sym} 156170 -8390 0 0 {name=p155668 lab=_81301_/Q }
C {devices/lab_pin.sym} 156350 -8410 0 1 {name=p155669 lab=_81269_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -8400 0 0 {name=X_81269_ }
C {devices/lab_pin.sym} 156180 -8290 0 0 {name=p155670 lab=_53148_/B }
C {devices/lab_pin.sym} 156180 -8250 0 0 {name=p155671 lab=_71013_/X }
C {devices/lab_pin.sym} 156180 -8210 0 0 {name=p155672 lab=_71021_/Y }
C {devices/lab_pin.sym} 156340 -8250 0 1 {name=p155673 lab=_83632_/D }
C {sky130_stdcells/o21ai_4.sym} 156260 -8250 0 0 {name=X_71022_ }
C {devices/lab_pin.sym} 156170 -8110 0 0 {name=p155674 lab=_83008_/CLK }
C {devices/lab_pin.sym} 156170 -8090 0 0 {name=p155675 lab=_83008_/D }
C {devices/lab_pin.sym} 156350 -8110 0 1 {name=p155676 lab=_45416_/A }
C {sky130_stdcells/dfxtp_4.sym} 156260 -8100 0 0 {name=X_83008_ }
C {devices/lab_pin.sym} 156220 -7970 0 0 {name=p155677 lab=_40989_/A }
C {devices/lab_pin.sym} 156300 -7970 0 1 {name=p155678 lab=_41182_/X }
C {sky130_stdcells/buf_2.sym} 156260 -7970 0 0 {name=X_41182_ }
C {devices/lab_pin.sym} 156180 -7870 0 0 {name=p155679 lab=_85684_/Q }
C {devices/lab_pin.sym} 156180 -7830 0 0 {name=p155680 lab=_53146_/X }
C {devices/lab_pin.sym} 156180 -7790 0 0 {name=p155681 lab=_53167_/Y }
C {devices/lab_pin.sym} 156340 -7830 0 1 {name=p155682 lab=_53168_/Y }
C {sky130_stdcells/o21ai_4.sym} 156260 -7830 0 0 {name=X_53168_ }
C {devices/lab_pin.sym} 156200 -7700 0 0 {name=p155683 lab=_52188_/A }
C {devices/lab_pin.sym} 156200 -7660 0 0 {name=p155684 lab=_52119_/B }
C {devices/lab_pin.sym} 156320 -7680 0 1 {name=p155685 lab=_52119_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -7680 0 0 {name=X_52119_ }
C {devices/lab_pin.sym} 156200 -7560 0 0 {name=p155686 lab=_75830_/A }
C {devices/lab_pin.sym} 156200 -7520 0 0 {name=p155687 lab=_75830_/B }
C {devices/lab_pin.sym} 156320 -7540 0 1 {name=p155688 lab=_75831_/A }
C {sky130_stdcells/xor2_4.sym} 156260 -7540 0 0 {name=X_75830_ }
C {devices/lab_pin.sym} 156170 -7410 0 0 {name=p155689 lab=_87820_/CLK }
C {devices/lab_pin.sym} 156170 -7390 0 0 {name=p155690 lab=_42572_/Y }
C {devices/lab_pin.sym} 156350 -7410 0 1 {name=p155691 lab=_87816_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -7400 0 0 {name=X_87816_ }
C {devices/lab_pin.sym} 156180 -7310 0 0 {name=p155692 lab=_45980_/X }
C {devices/lab_pin.sym} 156180 -7270 0 0 {name=p155693 lab=_45987_/X }
C {devices/lab_pin.sym} 156180 -7230 0 0 {name=p155694 lab=_40445_/X }
C {devices/lab_pin.sym} 156180 -7190 0 0 {name=p155695 lab=_86825_/Q }
C {devices/lab_pin.sym} 156180 -7150 0 0 {name=p155696 lab=_45982_/X }
C {devices/lab_pin.sym} 156340 -7230 0 1 {name=p155697 lab=_45991_/A }
C {sky130_stdcells/o32ai_4.sym} 156260 -7230 0 0 {name=X_45990_ }
C {devices/lab_pin.sym} 156200 -7100 0 0 {name=p155698 lab=_53107_/A }
C {devices/lab_pin.sym} 156200 -7060 0 0 {name=p155699 lab=_53113_/B }
C {devices/lab_pin.sym} 156200 -7020 0 0 {name=p155700 lab=_53107_/C }
C {devices/lab_pin.sym} 156200 -6980 0 0 {name=p155701 lab=_53099_/D }
C {devices/lab_pin.sym} 156320 -7040 0 1 {name=p155702 lab=_53099_/X }
C {sky130_stdcells/and4_4.sym} 156260 -7040 0 0 {name=X_53099_ }
C {devices/lab_pin.sym} 156180 -6910 0 0 {name=p155703 lab=_57966_/X }
C {devices/lab_pin.sym} 156180 -6870 0 0 {name=p155704 lab=_85711_/Q }
C {devices/lab_pin.sym} 156180 -6830 0 0 {name=p155705 lab=_57878_/X }
C {devices/lab_pin.sym} 156340 -6870 0 1 {name=p155706 lab=_57976_/X }
C {sky130_stdcells/o21a_4.sym} 156260 -6870 0 0 {name=X_57976_ }
C {devices/lab_pin.sym} 156220 -6730 0 0 {name=p155707 lab=_57689_/A }
C {devices/lab_pin.sym} 156300 -6730 0 1 {name=p155708 lab=_60132_/A }
C {sky130_stdcells/buf_2.sym} 156260 -6730 0 0 {name=X_59715_ }
C {devices/lab_pin.sym} 156180 -6630 0 0 {name=p155709 lab=_44905_/X }
C {devices/lab_pin.sym} 156180 -6590 0 0 {name=p155710 lab=_61354_/B }
C {devices/lab_pin.sym} 156180 -6550 0 0 {name=p155711 lab=_44907_/X }
C {devices/lab_pin.sym} 156340 -6590 0 1 {name=p155712 lab=_44941_/Y }
C {sky130_stdcells/o21ai_4.sym} 156260 -6590 0 0 {name=X_44941_ }
C {devices/lab_pin.sym} 156200 -6470 0 0 {name=p155713 lab=_56927_/A }
C {devices/lab_pin.sym} 156200 -6430 0 0 {name=p155714 lab=_56774_/C }
C {devices/lab_pin.sym} 156200 -6390 0 0 {name=p155715 lab=_56927_/C }
C {devices/lab_pin.sym} 156320 -6430 0 1 {name=p155716 lab=_56927_/Y }
C {sky130_stdcells/nand3_4.sym} 156260 -6430 0 0 {name=X_56927_ }
C {devices/lab_pin.sym} 156220 -6290 0 0 {name=p155717 lab=_80919_/Q }
C {devices/lab_pin.sym} 156300 -6290 0 1 {name=p155718 lab=_75761_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -6290 0 0 {name=X_75761_ }
C {devices/lab_pin.sym} 156170 -6170 0 0 {name=p155719 lab=_87749_/CLK }
C {devices/lab_pin.sym} 156170 -6150 0 0 {name=p155720 lab=_42730_/X }
C {devices/lab_pin.sym} 156350 -6170 0 1 {name=p155721 lab=_68768_/B }
C {sky130_stdcells/dfxtp_4.sym} 156260 -6160 0 0 {name=X_87747_ }
C {devices/lab_pin.sym} 156200 -6040 0 0 {name=p155722 lab=_72973_/A }
C {devices/lab_pin.sym} 156200 -6000 0 0 {name=p155723 lab=_72973_/B }
C {devices/lab_pin.sym} 156320 -6020 0 1 {name=p155724 lab=_72973_/Y }
C {sky130_stdcells/nor2_4.sym} 156260 -6020 0 0 {name=X_72973_ }
C {devices/lab_pin.sym} 156170 -5890 0 0 {name=p155725 lab=_84869_/CLK }
C {devices/lab_pin.sym} 156170 -5870 0 0 {name=p155726 lab=_84959_/D }
C {devices/lab_pin.sym} 156350 -5890 0 1 {name=p155727 lab=_84959_/Q }
C {sky130_stdcells/dfxtp_4.sym} 156260 -5880 0 0 {name=X_84959_ }
C {devices/lab_pin.sym} 156180 -5770 0 0 {name=p155728 lab=_77499_/X }
C {devices/lab_pin.sym} 156180 -5730 0 0 {name=p155729 lab=_77478_/X }
C {devices/lab_pin.sym} 156180 -5690 0 0 {name=p155730 lab=_77479_/X }
C {devices/lab_pin.sym} 156340 -5730 0 1 {name=p155731 lab=_77500_/Y }
C {sky130_stdcells/a21oi_4.sym} 156260 -5730 0 0 {name=X_77500_ }
C {devices/lab_pin.sym} 156220 -5590 0 0 {name=p155732 lab=_74711_/A }
C {devices/lab_pin.sym} 156300 -5590 0 1 {name=p155733 lab=_74712_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -5590 0 0 {name=X_74712_ }
C {devices/lab_pin.sym} 156180 -5490 0 0 {name=p155734 lab=_72295_/A }
C {devices/lab_pin.sym} 156180 -5450 0 0 {name=p155735 lab=_47619_/X }
C {devices/lab_pin.sym} 156180 -5410 0 0 {name=p155736 lab=_47659_/Y }
C {devices/lab_pin.sym} 156340 -5450 0 1 {name=p155737 lab=_47660_/Y }
C {sky130_stdcells/o21ai_4.sym} 156260 -5450 0 0 {name=X_47660_ }
C {devices/lab_pin.sym} 156180 -5330 0 0 {name=p155738 lab=_71920_/Y }
C {devices/lab_pin.sym} 156180 -5290 0 0 {name=p155739 lab=_56727_/X }
C {devices/lab_pin.sym} 156180 -5250 0 0 {name=p155740 lab=_71923_/Y }
C {devices/lab_pin.sym} 156340 -5290 0 1 {name=p155741 lab=_83327_/D }
C {sky130_stdcells/a21o_4.sym} 156260 -5290 0 0 {name=X_71924_ }
C {devices/lab_pin.sym} 156220 -5150 0 0 {name=p155742 lab=_59664_/C }
C {devices/lab_pin.sym} 156300 -5150 0 1 {name=p155743 lab=_59824_/B }
C {sky130_stdcells/buf_2.sym} 156260 -5150 0 0 {name=X_59646_ }
C {devices/lab_pin.sym} 156180 -5050 0 0 {name=p155744 lab=_78466_/X }
C {devices/lab_pin.sym} 156180 -5010 0 0 {name=p155745 lab=_78478_/Y }
C {devices/lab_pin.sym} 156180 -4970 0 0 {name=p155746 lab=_78479_/Y }
C {devices/lab_pin.sym} 156340 -5010 0 1 {name=p155747 lab=_78480_/X }
C {sky130_stdcells/a21o_4.sym} 156260 -5010 0 0 {name=X_78480_ }
C {devices/lab_pin.sym} 156220 -4870 0 0 {name=p155748 lab=_80670_/Q }
C {devices/lab_pin.sym} 156300 -4870 0 1 {name=p155749 lab=_45193_/A }
C {sky130_stdcells/buf_2.sym} 156260 -4870 0 0 {name=X_44872_ }
C {devices/lab_pin.sym} 156220 -4750 0 0 {name=p155750 lab=_83334_/Q }
C {devices/lab_pin.sym} 156300 -4750 0 1 {name=p155751 lab=_57346_/C }
C {sky130_stdcells/buf_2.sym} 156260 -4750 0 0 {name=X_56858_ }
C {devices/lab_pin.sym} 156200 -4640 0 0 {name=p155752 lab=_75692_/A }
C {devices/lab_pin.sym} 156200 -4600 0 0 {name=p155753 lab=_75692_/B }
C {devices/lab_pin.sym} 156320 -4620 0 1 {name=p155754 lab=_75693_/B }
C {sky130_stdcells/xnor2_4.sym} 156260 -4620 0 0 {name=X_75692_ }
C {devices/lab_pin.sym} 156170 -4490 0 0 {name=p155755 lab=_82886_/CLK }
C {devices/lab_pin.sym} 156170 -4470 0 0 {name=p155756 lab=_87678_/D }
C {devices/lab_pin.sym} 156350 -4490 0 1 {name=p155757 lab=_67079_/B }
C {sky130_stdcells/dfxtp_4.sym} 156260 -4480 0 0 {name=X_87678_ }
C {devices/lab_pin.sym} 156220 -4350 0 0 {name=p155758 lab=_74509_/B }
C {devices/lab_pin.sym} 156300 -4350 0 1 {name=p155759 lab=_46620_/A }
C {sky130_stdcells/buf_2.sym} 156260 -4350 0 0 {name=X_46611_ }
C {devices/lab_pin.sym} 156200 -4250 0 0 {name=p155760 lab=_77426_/X }
C {devices/lab_pin.sym} 156200 -4210 0 0 {name=p155761 lab=_77431_/B }
C {devices/lab_pin.sym} 156200 -4170 0 0 {name=p155762 lab=_77427_/Y }
C {devices/lab_pin.sym} 156320 -4210 0 1 {name=p155763 lab=_77431_/Y }
C {sky130_stdcells/nand3_4.sym} 156260 -4210 0 0 {name=X_77431_ }
C {devices/lab_pin.sym} 156180 -4100 0 0 {name=p155764 lab=_45215_/A }
C {devices/lab_pin.sym} 156180 -4060 0 0 {name=p155765 lab=_55492_/X }
C {devices/lab_pin.sym} 156180 -4020 0 0 {name=p155766 lab=_44096_/X }
C {devices/lab_pin.sym} 156180 -3980 0 0 {name=p155767 lab=_55808_/X }
C {devices/lab_pin.sym} 156340 -4040 0 1 {name=p155768 lab=_55809_/X }
C {sky130_stdcells/a211o_4.sym} 156260 -4040 0 0 {name=X_55809_ }
C {devices/lab_pin.sym} 156220 -3890 0 0 {name=p155769 lab=_43166_/A }
C {devices/lab_pin.sym} 156300 -3890 0 1 {name=p155770 lab=_43854_/A }
C {sky130_stdcells/buf_2.sym} 156260 -3890 0 0 {name=X_43823_ }
C {devices/lab_pin.sym} 156200 -3780 0 0 {name=p155771 lab=_74642_/X }
C {devices/lab_pin.sym} 156200 -3740 0 0 {name=p155772 lab=_45495_/A }
C {devices/lab_pin.sym} 156320 -3760 0 1 {name=p155773 lab=_74643_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -3760 0 0 {name=X_74643_ }
C {devices/lab_pin.sym} 156170 -3630 0 0 {name=p155774 lab=_85990_/CLK }
C {devices/lab_pin.sym} 156170 -3610 0 0 {name=p155775 lab=_47496_/Y }
C {devices/lab_pin.sym} 156350 -3630 0 1 {name=p155776 lab=_58097_/A }
C {sky130_stdcells/dfxtp_4.sym} 156260 -3620 0 0 {name=X_86629_ }
C {devices/lab_pin.sym} 156200 -3500 0 0 {name=p155777 lab=_47574_/A }
C {devices/lab_pin.sym} 156200 -3460 0 0 {name=p155778 lab=_53135_/B }
C {devices/lab_pin.sym} 156320 -3480 0 1 {name=p155779 lab=_47591_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -3480 0 0 {name=X_47591_ }
C {devices/lab_pin.sym} 156200 -3380 0 0 {name=p155780 lab=_70543_/Y }
C {devices/lab_pin.sym} 156200 -3340 0 0 {name=p155781 lab=_71857_/B }
C {devices/lab_pin.sym} 156200 -3300 0 0 {name=p155782 lab=_71851_/X }
C {devices/lab_pin.sym} 156200 -3260 0 0 {name=p155783 lab=_71857_/D }
C {devices/lab_pin.sym} 156320 -3320 0 1 {name=p155784 lab=_71855_/Y }
C {sky130_stdcells/nor4_4.sym} 156260 -3320 0 0 {name=X_71855_ }
C {devices/lab_pin.sym} 156200 -3200 0 0 {name=p155785 lab=_59571_/B }
C {devices/lab_pin.sym} 156200 -3160 0 0 {name=p155786 lab=_59876_/B }
C {devices/lab_pin.sym} 156200 -3120 0 0 {name=p155787 lab=_59560_/A }
C {devices/lab_pin.sym} 156200 -3080 0 0 {name=p155788 lab=_43995_/A }
C {devices/lab_pin.sym} 156320 -3140 0 1 {name=p155789 lab=_59577_/X }
C {sky130_stdcells/and4_4.sym} 156260 -3140 0 0 {name=X_59577_ }
C {devices/lab_pin.sym} 156220 -2990 0 0 {name=p155790 lab=_56783_/X }
C {devices/lab_pin.sym} 156300 -2990 0 1 {name=p155791 lab=_57170_/A }
C {sky130_stdcells/buf_2.sym} 156260 -2990 0 0 {name=X_56789_ }
C {devices/lab_pin.sym} 156200 -2880 0 0 {name=p155792 lab=_49287_/A }
C {devices/lab_pin.sym} 156200 -2840 0 0 {name=p155793 lab=_50852_/B }
C {devices/lab_pin.sym} 156320 -2860 0 1 {name=p155794 lab=_49330_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -2860 0 0 {name=X_49330_ }
C {devices/lab_pin.sym} 156220 -2730 0 0 {name=p155795 lab=_46249_/A }
C {devices/lab_pin.sym} 156300 -2730 0 1 {name=p155796 lab=_46542_/X }
C {sky130_stdcells/buf_2.sym} 156260 -2730 0 0 {name=X_46542_ }
C {devices/lab_pin.sym} 156220 -2610 0 0 {name=p155797 lab=_74531_/C }
C {devices/lab_pin.sym} 156300 -2610 0 1 {name=p155798 lab=_70810_/C }
C {sky130_stdcells/buf_2.sym} 156260 -2610 0 0 {name=X_70806_ }
C {devices/lab_pin.sym} 156200 -2500 0 0 {name=p155799 lab=_58528_/A }
C {devices/lab_pin.sym} 156200 -2460 0 0 {name=p155800 lab=_58510_/X }
C {devices/lab_pin.sym} 156320 -2480 0 1 {name=p155801 lab=_58528_/Y }
C {sky130_stdcells/nor2_4.sym} 156260 -2480 0 0 {name=X_58528_ }
C {devices/lab_pin.sym} 156200 -2360 0 0 {name=p155802 lab=_77371_/A }
C {devices/lab_pin.sym} 156200 -2320 0 0 {name=p155803 lab=_77361_/Y }
C {devices/lab_pin.sym} 156320 -2340 0 1 {name=p155804 lab=_77362_/X }
C {sky130_stdcells/or2_4.sym} 156260 -2340 0 0 {name=X_77362_ }
C {devices/lab_pin.sym} 156180 -2240 0 0 {name=p155805 lab=_40939_/X }
C {devices/lab_pin.sym} 156180 -2200 0 0 {name=p155806 lab=_43752_/X }
C {devices/lab_pin.sym} 156180 -2160 0 0 {name=p155807 lab=_87282_/Q }
C {devices/lab_pin.sym} 156180 -2120 0 0 {name=p155808 lab=_43753_/X }
C {devices/lab_pin.sym} 156340 -2180 0 1 {name=p155809 lab=_87282_/D }
C {sky130_stdcells/a2bb2o_4.sym} 156260 -2180 0 0 {name=X_43754_ }
C {devices/lab_pin.sym} 156180 -2050 0 0 {name=p155810 lab=_45082_/A }
C {devices/lab_pin.sym} 156180 -2010 0 0 {name=p155811 lab=_74568_/X }
C {devices/lab_pin.sym} 156180 -1970 0 0 {name=p155812 lab=_74573_/X }
C {devices/lab_pin.sym} 156340 -2010 0 1 {name=p155813 lab=_83030_/D }
C {sky130_stdcells/o21ai_4.sym} 156260 -2010 0 0 {name=X_74574_ }
C {devices/lab_pin.sym} 156200 -1880 0 0 {name=p155814 lab=_82299_/Q }
C {devices/lab_pin.sym} 156200 -1840 0 0 {name=p155815 lab=_40932_/X }
C {devices/lab_pin.sym} 156320 -1860 0 1 {name=p155816 lab=_40966_/X }
C {sky130_stdcells/or2_4.sym} 156260 -1860 0 0 {name=X_40966_ }
C {devices/lab_pin.sym} 156200 -1750 0 0 {name=p155817 lab=_71235_/A }
C {devices/lab_pin.sym} 156200 -1710 0 0 {name=p155818 lab=_71672_/C }
C {devices/lab_pin.sym} 156200 -1670 0 0 {name=p155819 lab=_71785_/X }
C {devices/lab_pin.sym} 156320 -1710 0 1 {name=p155820 lab=_71786_/Y }
C {sky130_stdcells/nand3_4.sym} 156260 -1710 0 0 {name=X_71786_ }
C {devices/lab_pin.sym} 156220 -1570 0 0 {name=p155821 lab=_79086_/B }
C {devices/lab_pin.sym} 156300 -1570 0 1 {name=p155822 lab=_79101_/Y }
C {sky130_stdcells/inv_2.sym} 156260 -1570 0 0 {name=X_79101_ }
C {devices/lab_pin.sym} 156180 -1470 0 0 {name=p155823 lab=_76300_/Y }
C {devices/lab_pin.sym} 156180 -1430 0 0 {name=p155824 lab=_76301_/Y }
C {devices/lab_pin.sym} 156180 -1390 0 0 {name=p155825 lab=_76302_/Y }
C {devices/lab_pin.sym} 156340 -1430 0 1 {name=p155826 lab=_76313_/X }
C {sky130_stdcells/o21a_4.sym} 156260 -1430 0 0 {name=X_76313_ }
C {devices/lab_pin.sym} 156220 -1290 0 0 {name=p155827 lab=_42704_/Y }
C {devices/lab_pin.sym} 156300 -1290 0 1 {name=p155828 lab=_87761_/D }
C {sky130_stdcells/inv_2.sym} 156260 -1290 0 0 {name=X_42705_ }
C {devices/lab_pin.sym} 156200 -1180 0 0 {name=p155829 lab=_49261_/A }
C {devices/lab_pin.sym} 156200 -1140 0 0 {name=p155830 lab=_50781_/B }
C {devices/lab_pin.sym} 156320 -1160 0 1 {name=p155831 lab=_49261_/Y }
C {sky130_stdcells/nand2_4.sym} 156260 -1160 0 0 {name=X_49261_ }
C {devices/lab_pin.sym} 156180 -1050 0 0 {name=p155832 lab=_73523_/X }
C {devices/lab_pin.sym} 156180 -1010 0 0 {name=p155833 lab=_73524_/Y }
C {devices/lab_pin.sym} 156180 -970 0 0 {name=p155834 lab=_73367_/X }
C {devices/lab_pin.sym} 156340 -1010 0 1 {name=p155835 lab=_73525_/Y }
C {sky130_stdcells/a21oi_4.sym} 156260 -1010 0 0 {name=X_73525_ }
C {devices/lab_pin.sym} 156180 -890 0 0 {name=p155836 lab=_46467_/Y }
C {devices/lab_pin.sym} 156180 -850 0 0 {name=p155837 lab=_46445_/X }
C {devices/lab_pin.sym} 156180 -810 0 0 {name=p155838 lab=_46472_/X }
C {devices/lab_pin.sym} 156340 -850 0 1 {name=p155839 lab=_86734_/D }
C {sky130_stdcells/a21oi_4.sym} 156260 -850 0 0 {name=X_46473_ }
C {devices/lab_pin.sym} 156220 -710 0 0 {name=p155840 lab=_70736_/Y }
C {devices/lab_pin.sym} 156300 -710 0 1 {name=p155841 lab=_70755_/A }
C {sky130_stdcells/inv_2.sym} 156260 -710 0 0 {name=X_70737_ }
C {devices/lab_pin.sym} 157140 -42150 0 0 {name=p155842 lab=_84843_/Q }
C {devices/lab_pin.sym} 157220 -42150 0 1 {name=p155843 lab=_58459_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -42150 0 0 {name=X_58459_ }
C {devices/lab_pin.sym} 157140 -42030 0 0 {name=p155844 lab=_77292_/Y }
C {devices/lab_pin.sym} 157220 -42030 0 1 {name=p155845 lab=_77296_/A }
C {sky130_stdcells/inv_2.sym} 157180 -42030 0 0 {name=X_77293_ }
C {devices/lab_pin.sym} 157140 -41910 0 0 {name=p155846 lab=_43685_/A }
C {devices/lab_pin.sym} 157220 -41910 0 1 {name=p155847 lab=_43685_/X }
C {sky130_stdcells/buf_2.sym} 157180 -41910 0 0 {name=X_43685_ }
C {devices/lab_pin.sym} 157120 -41800 0 0 {name=p155848 lab=_40897_/A }
C {devices/lab_pin.sym} 157120 -41760 0 0 {name=p155849 lab=_40842_/X }
C {devices/lab_pin.sym} 157240 -41780 0 1 {name=p155850 lab=_40897_/X }
C {sky130_stdcells/or2_4.sym} 157180 -41780 0 0 {name=X_40897_ }
C {devices/lab_pin.sym} 157140 -41650 0 0 {name=p155851 lab=_48212_/A }
C {devices/lab_pin.sym} 157220 -41650 0 1 {name=p155852 lab=_53488_/B }
C {sky130_stdcells/buf_2.sym} 157180 -41650 0 0 {name=X_48212_ }
C {devices/lab_pin.sym} 157120 -41540 0 0 {name=p155853 lab=_79021_/B }
C {devices/lab_pin.sym} 157120 -41500 0 0 {name=p155854 lab=_79021_/A }
C {devices/lab_pin.sym} 157240 -41520 0 1 {name=p155855 lab=_79032_/X }
C {sky130_stdcells/and2_4.sym} 157180 -41520 0 0 {name=X_79032_ }
C {devices/lab_pin.sym} 157100 -41420 0 0 {name=p155856 lab=_45422_/Y }
C {devices/lab_pin.sym} 157100 -41380 0 0 {name=p155857 lab=_45388_/X }
C {devices/lab_pin.sym} 157100 -41340 0 0 {name=p155858 lab=_45390_/X }
C {devices/lab_pin.sym} 157100 -41300 0 0 {name=p155859 lab=_45423_/Y }
C {devices/lab_pin.sym} 157260 -41360 0 1 {name=p155860 lab=_45424_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -41360 0 0 {name=X_45424_ }
C {devices/lab_pin.sym} 157120 -41220 0 0 {name=p155861 lab=_81352_/Q }
C {devices/lab_pin.sym} 157120 -41180 0 0 {name=p155862 lab=_81608_/D }
C {devices/lab_pin.sym} 157240 -41200 0 1 {name=p155863 lab=_81320_/D }
C {sky130_stdcells/xor2_4.sym} 157180 -41200 0 0 {name=X_76244_ }
C {devices/lab_pin.sym} 157100 -41100 0 0 {name=p155864 lab=_40939_/X }
C {devices/lab_pin.sym} 157100 -41060 0 0 {name=p155865 lab=_42631_/X }
C {devices/lab_pin.sym} 157100 -41020 0 0 {name=p155866 lab=_69147_/B }
C {devices/lab_pin.sym} 157100 -40980 0 0 {name=p155867 lab=_42634_/X }
C {devices/lab_pin.sym} 157260 -41040 0 1 {name=p155868 lab=_87794_/D }
C {sky130_stdcells/a2bb2o_4.sym} 157180 -41040 0 0 {name=X_42636_ }
C {devices/lab_pin.sym} 157140 -40890 0 0 {name=p155869 lab=_49192_/A }
C {devices/lab_pin.sym} 157220 -40890 0 1 {name=p155870 lab=_50719_/B }
C {sky130_stdcells/buf_2.sym} 157180 -40890 0 0 {name=X_49192_ }
C {devices/lab_pin.sym} 157140 -40770 0 0 {name=p155871 lab=_61317_/A }
C {devices/lab_pin.sym} 157220 -40770 0 1 {name=p155872 lab=_61484_/C }
C {sky130_stdcells/buf_2.sym} 157180 -40770 0 0 {name=X_61470_ }
C {devices/lab_pin.sym} 157100 -40680 0 0 {name=p155873 lab=_73163_/X }
C {devices/lab_pin.sym} 157100 -40640 0 0 {name=p155874 lab=_83054_/Q }
C {devices/lab_pin.sym} 157100 -40600 0 0 {name=p155875 lab=_73385_/X }
C {devices/lab_pin.sym} 157100 -40560 0 0 {name=p155876 lab=_73455_/X }
C {devices/lab_pin.sym} 157260 -40620 0 1 {name=p155877 lab=_73456_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -40620 0 0 {name=X_73456_ }
C {devices/lab_pin.sym} 157120 -40500 0 0 {name=p155878 lab=_70758_/A }
C {devices/lab_pin.sym} 157120 -40460 0 0 {name=p155879 lab=_70579_/Y }
C {devices/lab_pin.sym} 157120 -40420 0 0 {name=p155880 lab=_70827_/B }
C {devices/lab_pin.sym} 157120 -40380 0 0 {name=p155881 lab=_70668_/D }
C {devices/lab_pin.sym} 157240 -40440 0 1 {name=p155882 lab=_70669_/A }
C {sky130_stdcells/nand4_4.sym} 157180 -40440 0 0 {name=X_70668_ }
C {devices/lab_pin.sym} 157100 -40310 0 0 {name=p155883 lab=_86563_/Q }
C {devices/lab_pin.sym} 157100 -40270 0 0 {name=p155884 lab=_48103_/X }
C {devices/lab_pin.sym} 157100 -40230 0 0 {name=p155885 lab=_48142_/Y }
C {devices/lab_pin.sym} 157260 -40270 0 1 {name=p155886 lab=_48143_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -40270 0 0 {name=X_48143_ }
C {devices/lab_pin.sym} 157120 -40160 0 0 {name=p155887 lab=_60515_/B }
C {devices/lab_pin.sym} 157120 -40120 0 0 {name=p155888 lab=_60421_/B }
C {devices/lab_pin.sym} 157120 -40080 0 0 {name=p155889 lab=_60570_/A }
C {devices/lab_pin.sym} 157120 -40040 0 0 {name=p155890 lab=_60515_/C }
C {devices/lab_pin.sym} 157240 -40100 0 1 {name=p155891 lab=_60532_/A }
C {sky130_stdcells/and4_4.sym} 157180 -40100 0 0 {name=X_60421_ }
C {devices/lab_pin.sym} 157100 -39970 0 0 {name=p155892 lab=_72339_/X }
C {devices/lab_pin.sym} 157100 -39930 0 0 {name=p155893 lab=_85321_/Q }
C {devices/lab_pin.sym} 157100 -39890 0 0 {name=p155894 lab=_72386_/X }
C {devices/lab_pin.sym} 157260 -39930 0 1 {name=p155895 lab=_72407_/X }
C {sky130_stdcells/o21a_4.sym} 157180 -39930 0 0 {name=X_72407_ }
C {devices/lab_pin.sym} 157100 -39810 0 0 {name=p155896 lab=_55713_/B }
C {devices/lab_pin.sym} 157100 -39770 0 0 {name=p155897 lab=_45354_/X }
C {devices/lab_pin.sym} 157100 -39730 0 0 {name=p155898 lab=_45311_/X }
C {devices/lab_pin.sym} 157260 -39770 0 1 {name=p155899 lab=_45355_/X }
C {sky130_stdcells/o21a_4.sym} 157180 -39770 0 0 {name=X_45355_ }
C {devices/lab_pin.sym} 157140 -39630 0 0 {name=p155900 lab=_76175_/A }
C {devices/lab_pin.sym} 157220 -39630 0 1 {name=p155901 lab=_76175_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -39630 0 0 {name=X_76175_ }
C {devices/lab_pin.sym} 157140 -39510 0 0 {name=p155902 lab=_42566_/Y }
C {devices/lab_pin.sym} 157220 -39510 0 1 {name=p155903 lab=_42567_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -39510 0 0 {name=X_42567_ }
C {devices/lab_pin.sym} 157100 -39420 0 0 {name=p155904 lab=_73163_/X }
C {devices/lab_pin.sym} 157100 -39380 0 0 {name=p155905 lab=_83057_/Q }
C {devices/lab_pin.sym} 157100 -39340 0 0 {name=p155906 lab=_73385_/X }
C {devices/lab_pin.sym} 157100 -39300 0 0 {name=p155907 lab=_73386_/X }
C {devices/lab_pin.sym} 157260 -39360 0 1 {name=p155908 lab=_73387_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -39360 0 0 {name=X_73387_ }
C {devices/lab_pin.sym} 157120 -39240 0 0 {name=p155909 lab=_70710_/A }
C {devices/lab_pin.sym} 157120 -39200 0 0 {name=p155910 lab=_70613_/B }
C {devices/lab_pin.sym} 157120 -39160 0 0 {name=p155911 lab=_74533_/D }
C {devices/lab_pin.sym} 157120 -39120 0 0 {name=p155912 lab=_70594_/X }
C {devices/lab_pin.sym} 157240 -39180 0 1 {name=p155913 lab=_70599_/Y }
C {sky130_stdcells/nand4_4.sym} 157180 -39180 0 0 {name=X_70599_ }
C {devices/lab_pin.sym} 157140 -39030 0 0 {name=p155914 lab=clkbuf_7_93_0_CLK/A }
C {devices/lab_pin.sym} 157220 -39030 0 1 {name=p155915 lab=clkbuf_7_92_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 157180 -39030 0 0 {name=Xclkbuf_7_92_0_CLK }
C {devices/lab_pin.sym} 157140 -38910 0 0 {name=p155916 lab=_44305_/X }
C {devices/lab_pin.sym} 157220 -38910 0 1 {name=p155917 lab=_74095_/B }
C {sky130_stdcells/buf_2.sym} 157180 -38910 0 0 {name=X_44306_ }
C {devices/lab_pin.sym} 157100 -38810 0 0 {name=p155918 lab=_63138_/Y }
C {devices/lab_pin.sym} 157100 -38770 0 0 {name=p155919 lab=_63139_/X }
C {devices/lab_pin.sym} 157100 -38730 0 0 {name=p155920 lab=_63114_/X }
C {devices/lab_pin.sym} 157260 -38770 0 1 {name=p155921 lab=_63140_/Y }
C {sky130_stdcells/a21oi_4.sym} 157180 -38770 0 0 {name=X_63140_ }
C {devices/lab_pin.sym} 157100 -38650 0 0 {name=p155922 lab=_75124_/X }
C {devices/lab_pin.sym} 157100 -38610 0 0 {name=p155923 lab=_75127_/C }
C {devices/lab_pin.sym} 157100 -38570 0 0 {name=p155924 lab=_81062_/Q }
C {devices/lab_pin.sym} 157260 -38610 0 1 {name=p155925 lab=_75126_/X }
C {sky130_stdcells/a21o_4.sym} 157180 -38610 0 0 {name=X_75126_ }
C {devices/lab_pin.sym} 157120 -38480 0 0 {name=p155926 lab=_81173_/Q }
C {devices/lab_pin.sym} 157120 -38440 0 0 {name=p155927 lab=_41471_/B }
C {devices/lab_pin.sym} 157240 -38460 0 1 {name=p155928 lab=_41518_/X }
C {sky130_stdcells/or2_4.sym} 157180 -38460 0 0 {name=X_41518_ }
C {devices/lab_pin.sym} 157100 -38350 0 0 {name=p155929 lab=_79629_/A }
C {devices/lab_pin.sym} 157100 -38310 0 0 {name=p155930 lab=_60349_/X }
C {devices/lab_pin.sym} 157100 -38270 0 0 {name=p155931 lab=_60351_/X }
C {devices/lab_pin.sym} 157260 -38310 0 1 {name=p155932 lab=_60352_/X }
C {sky130_stdcells/o21a_4.sym} 157180 -38310 0 0 {name=X_60352_ }
C {devices/lab_pin.sym} 157100 -38210 0 0 {name=p155933 lab=_72299_/X }
C {devices/lab_pin.sym} 157100 -38170 0 0 {name=p155934 lab=_72335_/Y }
C {devices/lab_pin.sym} 157100 -38130 0 0 {name=p155935 lab=_72336_/Y }
C {devices/lab_pin.sym} 157100 -38090 0 0 {name=p155936 lab=_72337_/X }
C {devices/lab_pin.sym} 157100 -38050 0 0 {name=p155937 lab=_72303_/X }
C {devices/lab_pin.sym} 157260 -38130 0 1 {name=p155938 lab=_72338_/X }
C {sky130_stdcells/o32a_4.sym} 157180 -38130 0 0 {name=X_72338_ }
C {devices/lab_pin.sym} 157100 -37990 0 0 {name=p155939 lab=_66238_/B }
C {devices/lab_pin.sym} 157100 -37950 0 0 {name=p155940 lab=_48049_/X }
C {devices/lab_pin.sym} 157100 -37910 0 0 {name=p155941 lab=_48073_/Y }
C {devices/lab_pin.sym} 157260 -37950 0 1 {name=p155942 lab=_48074_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -37950 0 0 {name=X_48074_ }
C {devices/lab_pin.sym} 157100 -37830 0 0 {name=p155943 lab=_56442_/C }
C {devices/lab_pin.sym} 157100 -37790 0 0 {name=p155944 lab=_45252_/X }
C {devices/lab_pin.sym} 157100 -37750 0 0 {name=p155945 lab=_45285_/X }
C {devices/lab_pin.sym} 157260 -37790 0 1 {name=p155946 lab=_45286_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -37790 0 0 {name=X_45286_ }
C {devices/lab_pin.sym} 157140 -37650 0 0 {name=p155947 lab=_42498_/A }
C {devices/lab_pin.sym} 157220 -37650 0 1 {name=p155948 lab=_87845_/D }
C {sky130_stdcells/inv_2.sym} 157180 -37650 0 0 {name=X_42498_ }
C {devices/lab_pin.sym} 157120 -37540 0 0 {name=p155949 lab=_47008_/A }
C {devices/lab_pin.sym} 157120 -37500 0 0 {name=p155950 lab=_52807_/B }
C {devices/lab_pin.sym} 157240 -37520 0 1 {name=p155951 lab=_47025_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -37520 0 0 {name=X_47025_ }
C {devices/lab_pin.sym} 157140 -37390 0 0 {name=p155952 lab=_44236_/X }
C {devices/lab_pin.sym} 157220 -37390 0 1 {name=p155953 lab=_57126_/A }
C {sky130_stdcells/buf_2.sym} 157180 -37390 0 0 {name=X_44237_ }
C {devices/lab_pin.sym} 157100 -37290 0 0 {name=p155954 lab=_79456_/A }
C {devices/lab_pin.sym} 157100 -37250 0 0 {name=p155955 lab=_63008_/X }
C {devices/lab_pin.sym} 157100 -37210 0 0 {name=p155956 lab=_63070_/Y }
C {devices/lab_pin.sym} 157260 -37250 0 1 {name=p155957 lab=_84356_/D }
C {sky130_stdcells/a21o_4.sym} 157180 -37250 0 0 {name=X_63071_ }
C {devices/lab_pin.sym} 157120 -37120 0 0 {name=p155958 lab=_81150_/D }
C {devices/lab_pin.sym} 157120 -37080 0 0 {name=p155959 lab=_75046_/B }
C {devices/lab_pin.sym} 157240 -37100 0 1 {name=p155960 lab=_75057_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -37100 0 0 {name=X_75057_ }
C {devices/lab_pin.sym} 157140 -36970 0 0 {name=p155961 lab=_79934_/A }
C {devices/lab_pin.sym} 157220 -36970 0 1 {name=p155962 lab=_79944_/A }
C {sky130_stdcells/inv_2.sym} 157180 -36970 0 0 {name=X_79934_ }
C {devices/lab_pin.sym} 157140 -36850 0 0 {name=p155963 lab=_41411_/X }
C {devices/lab_pin.sym} 157220 -36850 0 1 {name=p155964 lab=_41449_/X }
C {sky130_stdcells/buf_2.sym} 157180 -36850 0 0 {name=X_41449_ }
C {devices/lab_pin.sym} 157120 -36750 0 0 {name=p155965 lab=_60233_/Y }
C {devices/lab_pin.sym} 157120 -36710 0 0 {name=p155966 lab=_60159_/A }
C {devices/lab_pin.sym} 157120 -36670 0 0 {name=p155967 lab=_60218_/A }
C {devices/lab_pin.sym} 157240 -36710 0 1 {name=p155968 lab=_60300_/C }
C {sky130_stdcells/nand3_4.sym} 157180 -36710 0 0 {name=X_60283_ }
C {devices/lab_pin.sym} 157100 -36590 0 0 {name=p155969 lab=_72266_/Y }
C {devices/lab_pin.sym} 157100 -36550 0 0 {name=p155970 lab=_72268_/Y }
C {devices/lab_pin.sym} 157100 -36510 0 0 {name=p155971 lab=_72185_/X }
C {devices/lab_pin.sym} 157260 -36550 0 1 {name=p155972 lab=_72269_/X }
C {sky130_stdcells/a21o_4.sym} 157180 -36550 0 0 {name=X_72269_ }
C {devices/lab_pin.sym} 157140 -36410 0 0 {name=p155973 lab=_62022_/A }
C {devices/lab_pin.sym} 157220 -36410 0 1 {name=p155974 lab=_63598_/A }
C {sky130_stdcells/inv_2.sym} 157180 -36410 0 0 {name=X_62022_ }
C {devices/lab_pin.sym} 157100 -36320 0 0 {name=p155975 lab=_43078_/Y }
C {devices/lab_pin.sym} 157100 -36280 0 0 {name=p155976 lab=_72900_/X }
C {devices/lab_pin.sym} 157100 -36240 0 0 {name=p155977 lab=_73894_/X }
C {devices/lab_pin.sym} 157100 -36200 0 0 {name=p155978 lab=_74007_/Y }
C {devices/lab_pin.sym} 157260 -36260 0 1 {name=p155979 lab=_74008_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -36260 0 0 {name=X_74008_ }
C {devices/lab_pin.sym} 157140 -36110 0 0 {name=p155980 lab=_44012_/A }
C {devices/lab_pin.sym} 157220 -36110 0 1 {name=p155981 lab=_44244_/A }
C {sky130_stdcells/inv_2.sym} 157180 -36110 0 0 {name=X_44168_ }
C {devices/lab_pin.sym} 157120 -36000 0 0 {name=p155982 lab=_79861_/X }
C {devices/lab_pin.sym} 157120 -35960 0 0 {name=p155983 lab=_79865_/B }
C {devices/lab_pin.sym} 157240 -35980 0 1 {name=p155984 lab=_79875_/B }
C {sky130_stdcells/xor2_4.sym} 157180 -35980 0 0 {name=X_79865_ }
C {devices/lab_pin.sym} 157140 -35850 0 0 {name=p155985 lab=_87568_/Q }
C {devices/lab_pin.sym} 157220 -35850 0 1 {name=p155986 lab=_43119_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -35850 0 0 {name=X_43119_ }
C {devices/lab_pin.sym} 157120 -35740 0 0 {name=p155987 lab=_66785_/A }
C {devices/lab_pin.sym} 157120 -35700 0 0 {name=p155988 lab=_66830_/B }
C {devices/lab_pin.sym} 157240 -35720 0 1 {name=p155989 lab=_66830_/X }
C {sky130_stdcells/and2_4.sym} 157180 -35720 0 0 {name=X_66830_ }
C {devices/lab_pin.sym} 157100 -35610 0 0 {name=p155990 lab=_79122_/A }
C {devices/lab_pin.sym} 157100 -35570 0 0 {name=p155991 lab=_79122_/B }
C {devices/lab_pin.sym} 157100 -35530 0 0 {name=p155992 lab=_78818_/C }
C {devices/lab_pin.sym} 157260 -35570 0 1 {name=p155993 lab=_78816_/Y }
C {sky130_stdcells/a21oi_4.sym} 157180 -35570 0 0 {name=X_78816_ }
C {devices/lab_pin.sym} 157120 -35440 0 0 {name=p155994 lab=_48976_/A }
C {devices/lab_pin.sym} 157120 -35400 0 0 {name=p155995 lab=_48976_/B }
C {devices/lab_pin.sym} 157240 -35420 0 1 {name=p155996 lab=_48976_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -35420 0 0 {name=X_48976_ }
C {devices/lab_pin.sym} 157140 -35290 0 0 {name=p155997 lab=_44098_/X }
C {devices/lab_pin.sym} 157220 -35290 0 1 {name=p155998 lab=_44099_/X }
C {sky130_stdcells/buf_2.sym} 157180 -35290 0 0 {name=X_44099_ }
C {devices/lab_pin.sym} 157120 -35180 0 0 {name=p155999 lab=_84225_/Q }
C {devices/lab_pin.sym} 157120 -35140 0 0 {name=p156000 lab=_72214_/A }
C {devices/lab_pin.sym} 157240 -35160 0 1 {name=p156001 lab=_79796_/X }
C {sky130_stdcells/xor2_4.sym} 157180 -35160 0 0 {name=X_79796_ }
C {devices/lab_pin.sym} 157100 -35050 0 0 {name=p156002 lab=_47904_/X }
C {devices/lab_pin.sym} 157100 -35010 0 0 {name=p156003 lab=_46350_/A }
C {devices/lab_pin.sym} 157100 -34970 0 0 {name=p156004 lab=_47926_/X }
C {devices/lab_pin.sym} 157260 -35010 0 1 {name=p156005 lab=_48221_/A }
C {sky130_stdcells/o21ai_4.sym} 157180 -35010 0 0 {name=X_47927_ }
C {devices/lab_pin.sym} 157100 -34900 0 0 {name=p156006 lab=_87947_/Q }
C {devices/lab_pin.sym} 157100 -34860 0 0 {name=p156007 lab=_66759_/X }
C {devices/lab_pin.sym} 157100 -34820 0 0 {name=p156008 lab=_66688_/X }
C {devices/lab_pin.sym} 157100 -34780 0 0 {name=p156009 lab=_66760_/X }
C {devices/lab_pin.sym} 157260 -34840 0 1 {name=p156010 lab=_66761_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -34840 0 0 {name=X_66761_ }
C {devices/lab_pin.sym} 157120 -34700 0 0 {name=p156011 lab=_78747_/A }
C {devices/lab_pin.sym} 157120 -34660 0 0 {name=p156012 lab=_78746_/Y }
C {devices/lab_pin.sym} 157240 -34680 0 1 {name=p156013 lab=_82782_/D }
C {sky130_stdcells/xor2_4.sym} 157180 -34680 0 0 {name=X_78747_ }
C {devices/lab_pin.sym} 157120 -34580 0 0 {name=p156014 lab=_61500_/X }
C {devices/lab_pin.sym} 157120 -34540 0 0 {name=p156015 lab=_63908_/B }
C {devices/lab_pin.sym} 157120 -34500 0 0 {name=p156016 lab=_64003_/C }
C {devices/lab_pin.sym} 157120 -34460 0 0 {name=p156017 lab=_63908_/D }
C {devices/lab_pin.sym} 157240 -34520 0 1 {name=p156018 lab=_63973_/Y }
C {sky130_stdcells/nand4_4.sym} 157180 -34520 0 0 {name=X_63973_ }
C {devices/lab_pin.sym} 157100 -34390 0 0 {name=p156019 lab=_75952_/Y }
C {devices/lab_pin.sym} 157100 -34350 0 0 {name=p156020 lab=_75957_/Y }
C {devices/lab_pin.sym} 157100 -34310 0 0 {name=p156021 lab=_75958_/Y }
C {devices/lab_pin.sym} 157260 -34350 0 1 {name=p156022 lab=_75963_/C }
C {sky130_stdcells/a21o_4.sym} 157180 -34350 0 0 {name=X_75959_ }
C {devices/lab_pin.sym} 157100 -34230 0 0 {name=p156023 lab=_68497_/X }
C {devices/lab_pin.sym} 157100 -34190 0 0 {name=p156024 lab=_68499_/X }
C {devices/lab_pin.sym} 157100 -34150 0 0 {name=p156025 lab=_68477_/X }
C {devices/lab_pin.sym} 157260 -34190 0 1 {name=p156026 lab=_68500_/Y }
C {sky130_stdcells/a21oi_4.sym} 157180 -34190 0 0 {name=X_68500_ }
C {devices/lab_pin.sym} 157140 -34050 0 0 {name=p156027 lab=clkbuf_7_31_0_CLK/A }
C {devices/lab_pin.sym} 157220 -34050 0 1 {name=p156028 lab=clkbuf_8_61_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 157180 -34050 0 0 {name=Xclkbuf_7_30_0_CLK }
C {devices/lab_pin.sym} 157100 -33950 0 0 {name=p156029 lab=_65700_/X }
C {devices/lab_pin.sym} 157100 -33910 0 0 {name=p156030 lab=_65710_/Y }
C {devices/lab_pin.sym} 157100 -33870 0 0 {name=p156031 lab=_65711_/Y }
C {devices/lab_pin.sym} 157260 -33910 0 1 {name=p156032 lab=_65712_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -33910 0 0 {name=X_65712_ }
C {devices/lab_pin.sym} 157120 -33800 0 0 {name=p156033 lab=_62644_/X }
C {devices/lab_pin.sym} 157120 -33760 0 0 {name=p156034 lab=_58184_/A }
C {devices/lab_pin.sym} 157120 -33720 0 0 {name=p156035 lab=_62924_/C }
C {devices/lab_pin.sym} 157120 -33680 0 0 {name=p156036 lab=_60220_/A }
C {devices/lab_pin.sym} 157240 -33740 0 1 {name=p156037 lab=_62924_/X }
C {sky130_stdcells/and4_4.sym} 157180 -33740 0 0 {name=X_62924_ }
C {devices/lab_pin.sym} 157120 -33600 0 0 {name=p156038 lab=_69605_/A }
C {devices/lab_pin.sym} 157120 -33560 0 0 {name=p156039 lab=_69480_/B }
C {devices/lab_pin.sym} 157240 -33580 0 1 {name=p156040 lab=_69480_/X }
C {sky130_stdcells/and2_4.sym} 157180 -33580 0 0 {name=X_69480_ }
C {devices/lab_pin.sym} 157140 -33450 0 0 {name=p156041 lab=_47857_/X }
C {devices/lab_pin.sym} 157220 -33450 0 1 {name=p156042 lab=_47887_/A }
C {sky130_stdcells/buf_2.sym} 157180 -33450 0 0 {name=X_47858_ }
C {devices/lab_pin.sym} 157140 -33330 0 0 {name=p156043 lab=_82811_/Q }
C {devices/lab_pin.sym} 157220 -33330 0 1 {name=p156044 lab=_78682_/A }
C {sky130_stdcells/inv_2.sym} 157180 -33330 0 0 {name=X_78678_ }
C {devices/lab_pin.sym} 157100 -33240 0 0 {name=p156045 lab=_87438_/Q }
C {devices/lab_pin.sym} 157100 -33200 0 0 {name=p156046 lab=_66642_/X }
C {devices/lab_pin.sym} 157100 -33160 0 0 {name=p156047 lab=_66643_/X }
C {devices/lab_pin.sym} 157100 -33120 0 0 {name=p156048 lab=_66691_/X }
C {devices/lab_pin.sym} 157260 -33180 0 1 {name=p156049 lab=_66692_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -33180 0 0 {name=X_66692_ }
C {devices/lab_pin.sym} 157140 -33030 0 0 {name=p156050 lab=clkbuf_7_85_0_CLK/X }
C {devices/lab_pin.sym} 157220 -33030 0 1 {name=p156051 lab=clkbuf_9_341_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 157180 -33030 0 0 {name=Xclkbuf_8_170_0_CLK }
C {devices/lab_pin.sym} 157120 -32920 0 0 {name=p156052 lab=_68409_/A }
C {devices/lab_pin.sym} 157120 -32880 0 0 {name=p156053 lab=_88273_/Q }
C {devices/lab_pin.sym} 157240 -32900 0 1 {name=p156054 lab=_68431_/X }
C {sky130_stdcells/and2_4.sym} 157180 -32900 0 0 {name=X_68431_ }
C {devices/lab_pin.sym} 157140 -32770 0 0 {name=p156055 lab=_82957_/Q }
C {devices/lab_pin.sym} 157220 -32770 0 1 {name=p156056 lab=_46809_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -32770 0 0 {name=X_46809_ }
C {devices/lab_pin.sym} 157100 -32670 0 0 {name=p156057 lab=_65637_/X }
C {devices/lab_pin.sym} 157100 -32630 0 0 {name=p156058 lab=_65641_/X }
C {devices/lab_pin.sym} 157100 -32590 0 0 {name=p156059 lab=_65642_/X }
C {devices/lab_pin.sym} 157260 -32630 0 1 {name=p156060 lab=_65646_/A }
C {sky130_stdcells/a21o_4.sym} 157180 -32630 0 0 {name=X_65643_ }
C {devices/lab_pin.sym} 157140 -32490 0 0 {name=p156061 lab=_82237_/Q }
C {devices/lab_pin.sym} 157220 -32490 0 1 {name=p156062 lab=_77629_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -32490 0 0 {name=X_77629_ }
C {devices/lab_pin.sym} 157120 -32400 0 0 {name=p156063 lab=_58474_/A }
C {devices/lab_pin.sym} 157120 -32360 0 0 {name=p156064 lab=_62841_/X }
C {devices/lab_pin.sym} 157120 -32320 0 0 {name=p156065 lab=_60309_/C }
C {devices/lab_pin.sym} 157120 -32280 0 0 {name=p156066 lab=_60254_/B }
C {devices/lab_pin.sym} 157240 -32340 0 1 {name=p156067 lab=_62855_/Y }
C {sky130_stdcells/nand4_4.sym} 157180 -32340 0 0 {name=X_62855_ }
C {devices/lab_pin.sym} 157120 -32200 0 0 {name=p156068 lab=_47799_/A }
C {devices/lab_pin.sym} 157120 -32160 0 0 {name=p156069 lab=_53246_/B }
C {devices/lab_pin.sym} 157240 -32180 0 1 {name=p156070 lab=_47789_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -32180 0 0 {name=X_47789_ }
C {devices/lab_pin.sym} 157120 -32080 0 0 {name=p156071 lab=_49537_/A }
C {devices/lab_pin.sym} 157120 -32040 0 0 {name=p156072 lab=_49516_/B }
C {devices/lab_pin.sym} 157120 -32000 0 0 {name=p156073 lab=_49522_/C }
C {devices/lab_pin.sym} 157120 -31960 0 0 {name=p156074 lab=_52742_/D }
C {devices/lab_pin.sym} 157240 -32020 0 1 {name=p156075 lab=_49528_/X }
C {sky130_stdcells/and4_4.sym} 157180 -32020 0 0 {name=X_49528_ }
C {devices/lab_pin.sym} 157120 -31900 0 0 {name=p156076 lab=_61839_/A }
C {devices/lab_pin.sym} 157120 -31860 0 0 {name=p156077 lab=_61791_/B }
C {devices/lab_pin.sym} 157120 -31820 0 0 {name=p156078 lab=_61732_/X }
C {devices/lab_pin.sym} 157120 -31780 0 0 {name=p156079 lab=_63066_/B }
C {devices/lab_pin.sym} 157240 -31840 0 1 {name=p156080 lab=_61806_/X }
C {sky130_stdcells/and4_4.sym} 157180 -31840 0 0 {name=X_61806_ }
C {devices/lab_pin.sym} 157240 -31700 0 1 {name=p156081 lab=THREAD_COUNT[2] }
C {devices/lab_pin.sym} 157240 -31660 0 1 {name=p156082 lab=_80640_/LO }
C {sky130_stdcells/conb_1.sym} 157180 -31680 0 0 {name=X_80640_ }
C {devices/lab_pin.sym} 157120 -31560 0 0 {name=p156083 lab=_68360_/X }
C {devices/lab_pin.sym} 157120 -31520 0 0 {name=p156084 lab=_68361_/Y }
C {devices/lab_pin.sym} 157240 -31540 0 1 {name=p156085 lab=_68362_/Y }
C {sky130_stdcells/nor2_4.sym} 157180 -31540 0 0 {name=X_68362_ }
C {devices/lab_pin.sym} 157100 -31430 0 0 {name=p156086 lab=_65572_/Y }
C {devices/lab_pin.sym} 157100 -31390 0 0 {name=p156087 lab=_65529_/X }
C {devices/lab_pin.sym} 157100 -31350 0 0 {name=p156088 lab=_65573_/X }
C {devices/lab_pin.sym} 157260 -31390 0 1 {name=p156089 lab=_84192_/D }
C {sky130_stdcells/a21o_4.sym} 157180 -31390 0 0 {name=X_65574_ }
C {devices/lab_pin.sym} 157140 -31250 0 0 {name=p156090 lab=_60274_/X }
C {devices/lab_pin.sym} 157220 -31250 0 1 {name=p156091 lab=_62834_/D }
C {sky130_stdcells/buf_2.sym} 157180 -31250 0 0 {name=X_62786_ }
C {devices/lab_pin.sym} 157140 -31130 0 0 {name=p156092 lab=clkbuf_6_22_0_CLK/X }
C {devices/lab_pin.sym} 157220 -31130 0 1 {name=p156093 lab=clkbuf_8_91_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 157180 -31130 0 0 {name=Xclkbuf_7_45_0_CLK }
C {devices/lab_pin.sym} 157140 -31010 0 0 {name=p156094 lab=_67312_/X }
C {devices/lab_pin.sym} 157220 -31010 0 1 {name=p156095 lab=_67313_/X }
C {sky130_stdcells/buf_2.sym} 157180 -31010 0 0 {name=X_67313_ }
C {devices/lab_pin.sym} 157120 -30910 0 0 {name=p156096 lab=_64474_/X }
C {devices/lab_pin.sym} 157120 -30870 0 0 {name=p156097 lab=_64525_/B }
C {devices/lab_pin.sym} 157120 -30830 0 0 {name=p156098 lab=_64525_/C }
C {devices/lab_pin.sym} 157240 -30870 0 1 {name=p156099 lab=_64525_/X }
C {sky130_stdcells/and3_4.sym} 157180 -30870 0 0 {name=X_64525_ }
C {devices/lab_pin.sym} 157120 -30760 0 0 {name=p156100 lab=_61330_/X }
C {devices/lab_pin.sym} 157120 -30720 0 0 {name=p156101 lab=_62183_/A }
C {devices/lab_pin.sym} 157120 -30680 0 0 {name=p156102 lab=_59810_/A }
C {devices/lab_pin.sym} 157120 -30640 0 0 {name=p156103 lab=_59754_/A }
C {devices/lab_pin.sym} 157240 -30700 0 1 {name=p156104 lab=_61750_/B }
C {sky130_stdcells/nand4_4.sym} 157180 -30700 0 0 {name=X_61737_ }
C {devices/lab_pin.sym} 157100 -30570 0 0 {name=p156105 lab=_58800_/B }
C {devices/lab_pin.sym} 157100 -30530 0 0 {name=p156106 lab=_49443_/X }
C {devices/lab_pin.sym} 157100 -30490 0 0 {name=p156107 lab=_49458_/Y }
C {devices/lab_pin.sym} 157260 -30530 0 1 {name=p156108 lab=_49459_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -30530 0 0 {name=X_49459_ }
C {devices/lab_pin.sym} 157120 -30400 0 0 {name=p156109 lab=_80562_/B }
C {devices/lab_pin.sym} 157120 -30360 0 0 {name=p156110 lab=_80561_/X }
C {devices/lab_pin.sym} 157240 -30380 0 1 {name=p156111 lab=_80571_/X }
C {sky130_stdcells/and2_4.sym} 157180 -30380 0 0 {name=X_80571_ }
C {devices/lab_pin.sym} 157140 -30250 0 0 {name=p156112 lab=clkbuf_7_92_0_CLK/X }
C {devices/lab_pin.sym} 157220 -30250 0 1 {name=p156113 lab=clkbuf_9_370_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 157180 -30250 0 0 {name=Xclkbuf_8_185_0_CLK }
C {devices/lab_pin.sym} 157100 -30150 0 0 {name=p156114 lab=_82638_/D }
C {devices/lab_pin.sym} 157100 -30110 0 0 {name=p156115 lab=_68279_/X }
C {devices/lab_pin.sym} 157100 -30070 0 0 {name=p156116 lab=_68292_/X }
C {devices/lab_pin.sym} 157260 -30110 0 1 {name=p156117 lab=_83990_/D }
C {sky130_stdcells/a21bo_4.sym} 157180 -30110 0 0 {name=X_68293_ }
C {devices/lab_pin.sym} 157140 -29970 0 0 {name=p156118 lab=clkbuf_9_90_0_CLK/X }
C {devices/lab_pin.sym} 157220 -29970 0 1 {name=p156119 lab=_83333_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 157180 -29970 0 0 {name=Xclkbuf_10_180_0_CLK }
C {devices/lab_pin.sym} 157090 -29850 0 0 {name=p156120 lab=_80835_/CLK }
C {devices/lab_pin.sym} 157090 -29830 0 0 {name=p156121 lab=_77028_/B }
C {devices/lab_pin.sym} 157270 -29850 0 1 {name=p156122 lab=_82310_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -29840 0 0 {name=X_82310_ }
C {devices/lab_pin.sym} 157140 -29710 0 0 {name=p156123 lab=_67126_/X }
C {devices/lab_pin.sym} 157220 -29710 0 1 {name=p156124 lab=_67266_/A }
C {sky130_stdcells/buf_2.sym} 157180 -29710 0 0 {name=X_67244_ }
C {devices/lab_pin.sym} 157140 -29590 0 0 {name=p156125 lab=_52438_/A }
C {devices/lab_pin.sym} 157220 -29590 0 1 {name=p156126 lab=_52470_/X }
C {sky130_stdcells/buf_2.sym} 157180 -29590 0 0 {name=X_52470_ }
C {devices/lab_pin.sym} 157120 -29490 0 0 {name=p156127 lab=_64455_/X }
C {devices/lab_pin.sym} 157120 -29450 0 0 {name=p156128 lab=_84892_/Q }
C {devices/lab_pin.sym} 157120 -29410 0 0 {name=p156129 lab=_64456_/C }
C {devices/lab_pin.sym} 157240 -29450 0 1 {name=p156130 lab=_64456_/Y }
C {sky130_stdcells/nand3_4.sym} 157180 -29450 0 0 {name=X_64456_ }
C {devices/lab_pin.sym} 157090 -29310 0 0 {name=p156131 lab=_85536_/CLK }
C {devices/lab_pin.sym} 157090 -29290 0 0 {name=p156132 lab=_83290_/D }
C {devices/lab_pin.sym} 157270 -29310 0 1 {name=p156133 lab=_83290_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -29300 0 0 {name=X_83290_ }
C {devices/lab_pin.sym} 157120 -29200 0 0 {name=p156134 lab=_58360_/A }
C {devices/lab_pin.sym} 157120 -29160 0 0 {name=p156135 lab=_61598_/X }
C {devices/lab_pin.sym} 157120 -29120 0 0 {name=p156136 lab=_61677_/C }
C {devices/lab_pin.sym} 157120 -29080 0 0 {name=p156137 lab=_72563_/B }
C {devices/lab_pin.sym} 157240 -29140 0 1 {name=p156138 lab=_61669_/A }
C {sky130_stdcells/nand4_4.sym} 157180 -29140 0 0 {name=X_61668_ }
C {devices/lab_pin.sym} 157140 -28990 0 0 {name=p156139 lab=_51149_/A }
C {devices/lab_pin.sym} 157220 -28990 0 1 {name=p156140 lab=_51421_/X }
C {sky130_stdcells/buf_2.sym} 157180 -28990 0 0 {name=X_51421_ }
C {devices/lab_pin.sym} 157120 -28890 0 0 {name=p156141 lab=_63456_/A }
C {devices/lab_pin.sym} 157120 -28850 0 0 {name=p156142 lab=_63456_/B }
C {devices/lab_pin.sym} 157120 -28810 0 0 {name=p156143 lab=_80588_/B }
C {devices/lab_pin.sym} 157240 -28850 0 1 {name=p156144 lab=_63407_/Y }
C {sky130_stdcells/nor3_4.sym} 157180 -28850 0 0 {name=X_63407_ }
C {devices/lab_pin.sym} 157090 -28710 0 0 {name=p156145 lab=_82531_/CLK }
C {devices/lab_pin.sym} 157090 -28690 0 0 {name=p156146 lab=_82273_/Q }
C {devices/lab_pin.sym} 157270 -28710 0 1 {name=p156147 lab=_82241_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -28700 0 0 {name=X_82241_ }
C {devices/lab_pin.sym} 157140 -28570 0 0 {name=p156148 lab=_60619_/A }
C {devices/lab_pin.sym} 157220 -28570 0 1 {name=p156149 lab=_60622_/C }
C {sky130_stdcells/inv_2.sym} 157180 -28570 0 0 {name=X_60619_ }
C {devices/lab_pin.sym} 157120 -28460 0 0 {name=p156150 lab=_67172_/X }
C {devices/lab_pin.sym} 157120 -28420 0 0 {name=p156151 lab=_67174_/X }
C {devices/lab_pin.sym} 157240 -28440 0 1 {name=p156152 lab=_67175_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -28440 0 0 {name=X_67175_ }
C {devices/lab_pin.sym} 157100 -28330 0 0 {name=p156153 lab=_64375_/Y }
C {devices/lab_pin.sym} 157100 -28290 0 0 {name=p156154 lab=_64385_/X }
C {devices/lab_pin.sym} 157100 -28250 0 0 {name=p156155 lab=_64386_/X }
C {devices/lab_pin.sym} 157260 -28290 0 1 {name=p156156 lab=_64387_/X }
C {sky130_stdcells/o21a_4.sym} 157180 -28290 0 0 {name=X_64387_ }
C {devices/lab_pin.sym} 157140 -28150 0 0 {name=p156157 lab=_61317_/A }
C {devices/lab_pin.sym} 157220 -28150 0 1 {name=p156158 lab=_61677_/C }
C {sky130_stdcells/buf_2.sym} 157180 -28150 0 0 {name=X_61599_ }
C {devices/lab_pin.sym} 157140 -28030 0 0 {name=p156159 lab=_54249_/A }
C {devices/lab_pin.sym} 157220 -28030 0 1 {name=p156160 lab=_54140_/X }
C {sky130_stdcells/buf_2.sym} 157180 -28030 0 0 {name=X_54140_ }
C {devices/lab_pin.sym} 157140 -27910 0 0 {name=p156161 lab=_65486_/A }
C {devices/lab_pin.sym} 157220 -27910 0 1 {name=p156162 lab=_66181_/A }
C {sky130_stdcells/buf_2.sym} 157180 -27910 0 0 {name=X_66126_ }
C {devices/lab_pin.sym} 157120 -27810 0 0 {name=p156163 lab=_52533_/A }
C {devices/lab_pin.sym} 157120 -27770 0 0 {name=p156164 lab=_51352_/B }
C {devices/lab_pin.sym} 157120 -27730 0 0 {name=p156165 lab=_51352_/C }
C {devices/lab_pin.sym} 157240 -27770 0 1 {name=p156166 lab=_51352_/X }
C {sky130_stdcells/and3_4.sym} 157180 -27770 0 0 {name=X_51352_ }
C {devices/lab_pin.sym} 157140 -27630 0 0 {name=p156167 lab=_79169_/B }
C {devices/lab_pin.sym} 157220 -27630 0 1 {name=p156168 lab=_63338_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -27630 0 0 {name=X_63338_ }
C {devices/lab_pin.sym} 157090 -27510 0 0 {name=p156169 lab=_81216_/CLK }
C {devices/lab_pin.sym} 157090 -27490 0 0 {name=p156170 lab=_84164_/Q }
C {devices/lab_pin.sym} 157270 -27510 0 1 {name=p156171 lab=_82172_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -27500 0 0 {name=X_82172_ }
C {devices/lab_pin.sym} 157140 -27370 0 0 {name=p156172 lab=clkbuf_9_97_0_CLK/X }
C {devices/lab_pin.sym} 157220 -27370 0 1 {name=p156173 lab=_84276_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 157180 -27370 0 0 {name=Xclkbuf_10_195_0_CLK }
C {devices/lab_pin.sym} 157100 -27270 0 0 {name=p156174 lab=_86227_/Q }
C {devices/lab_pin.sym} 157100 -27230 0 0 {name=p156175 lab=_50282_/X }
C {devices/lab_pin.sym} 157100 -27190 0 0 {name=p156176 lab=_50302_/Y }
C {devices/lab_pin.sym} 157260 -27230 0 1 {name=p156177 lab=_50303_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -27230 0 0 {name=X_50303_ }
C {devices/lab_pin.sym} 157090 -27090 0 0 {name=p156178 lab=_81179_/CLK }
C {devices/lab_pin.sym} 157090 -27070 0 0 {name=p156179 lab=_81123_/D }
C {devices/lab_pin.sym} 157270 -27090 0 1 {name=p156180 lab=_40751_/A }
C {sky130_stdcells/dfxtp_4.sym} 157180 -27080 0 0 {name=X_81123_ }
C {devices/lab_pin.sym} 157120 -26960 0 0 {name=p156181 lab=_54031_/A }
C {devices/lab_pin.sym} 157120 -26920 0 0 {name=p156182 lab=_54071_/B }
C {devices/lab_pin.sym} 157240 -26940 0 1 {name=p156183 lab=_54071_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -26940 0 0 {name=X_54071_ }
C {devices/lab_pin.sym} 157140 -26810 0 0 {name=p156184 lab=_65880_/A }
C {devices/lab_pin.sym} 157220 -26810 0 1 {name=p156185 lab=_66057_/X }
C {sky130_stdcells/buf_2.sym} 157180 -26810 0 0 {name=X_66057_ }
C {devices/lab_pin.sym} 157120 -26700 0 0 {name=p156186 lab=_51298_/A }
C {devices/lab_pin.sym} 157120 -26660 0 0 {name=p156187 lab=_46361_/A }
C {devices/lab_pin.sym} 157240 -26680 0 1 {name=p156188 lab=_51283_/X }
C {sky130_stdcells/and2_4.sym} 157180 -26680 0 0 {name=X_51283_ }
C {devices/lab_pin.sym} 157100 -26570 0 0 {name=p156189 lab=_84339_/Q }
C {devices/lab_pin.sym} 157100 -26530 0 0 {name=p156190 lab=_63258_/X }
C {devices/lab_pin.sym} 157100 -26490 0 0 {name=p156191 lab=_63268_/Y }
C {devices/lab_pin.sym} 157260 -26530 0 1 {name=p156192 lab=_84339_/D }
C {sky130_stdcells/a21o_4.sym} 157180 -26530 0 0 {name=X_63269_ }
C {devices/lab_pin.sym} 157090 -26390 0 0 {name=p156193 lab=_88345_/CLK }
C {devices/lab_pin.sym} 157090 -26370 0 0 {name=p156194 lab=_86980_/D }
C {devices/lab_pin.sym} 157270 -26390 0 1 {name=p156195 lab=_44738_/A }
C {sky130_stdcells/dfxtp_4.sym} 157180 -26380 0 0 {name=X_86980_ }
C {devices/lab_pin.sym} 157100 -26270 0 0 {name=p156196 lab=_85711_/Q }
C {devices/lab_pin.sym} 157100 -26230 0 0 {name=p156197 lab=_53010_/X }
C {devices/lab_pin.sym} 157100 -26190 0 0 {name=p156198 lab=_53021_/Y }
C {devices/lab_pin.sym} 157260 -26230 0 1 {name=p156199 lab=_53022_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -26230 0 0 {name=X_53022_ }
C {devices/lab_pin.sym} 157120 -26110 0 0 {name=p156200 lab=_65004_/X }
C {devices/lab_pin.sym} 157120 -26070 0 0 {name=p156201 lab=_65056_/B }
C {devices/lab_pin.sym} 157120 -26030 0 0 {name=p156202 lab=_65007_/X }
C {devices/lab_pin.sym} 157240 -26070 0 1 {name=p156203 lab=_65019_/A }
C {sky130_stdcells/nand3_4.sym} 157180 -26070 0 0 {name=X_65008_ }
C {devices/lab_pin.sym} 157120 -25940 0 0 {name=p156204 lab=_50230_/A }
C {devices/lab_pin.sym} 157120 -25900 0 0 {name=p156205 lab=_50234_/B }
C {devices/lab_pin.sym} 157240 -25920 0 1 {name=p156206 lab=_50234_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -25920 0 0 {name=X_50234_ }
C {devices/lab_pin.sym} 157090 -25790 0 0 {name=p156207 lab=_86091_/CLK }
C {devices/lab_pin.sym} 157090 -25770 0 0 {name=p156208 lab=_51871_/Y }
C {devices/lab_pin.sym} 157270 -25790 0 1 {name=p156209 lab=_85931_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -25780 0 0 {name=X_85931_ }
C {devices/lab_pin.sym} 157090 -25650 0 0 {name=p156210 lab=_84276_/CLK }
C {devices/lab_pin.sym} 157090 -25630 0 0 {name=p156211 lab=_75513_/X }
C {devices/lab_pin.sym} 157270 -25650 0 1 {name=p156212 lab=_81054_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -25640 0 0 {name=X_81054_ }
C {devices/lab_pin.sym} 157140 -25510 0 0 {name=p156213 lab=clkbuf_7_61_0_CLK/X }
C {devices/lab_pin.sym} 157220 -25510 0 1 {name=p156214 lab=clkbuf_9_247_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 157180 -25510 0 0 {name=Xclkbuf_8_123_0_CLK }
C {devices/lab_pin.sym} 157120 -25400 0 0 {name=p156215 lab=_84930_/Q }
C {devices/lab_pin.sym} 157120 -25360 0 0 {name=p156216 lab=_84178_/Q }
C {devices/lab_pin.sym} 157240 -25380 0 1 {name=p156217 lab=_80005_/X }
C {sky130_stdcells/xor2_4.sym} 157180 -25380 0 0 {name=X_80005_ }
C {devices/lab_pin.sym} 157100 -25270 0 0 {name=p156218 lab=_57826_/Y }
C {devices/lab_pin.sym} 157100 -25230 0 0 {name=p156219 lab=_57828_/Y }
C {devices/lab_pin.sym} 157100 -25190 0 0 {name=p156220 lab=_57829_/X }
C {devices/lab_pin.sym} 157260 -25230 0 1 {name=p156221 lab=_57830_/X }
C {sky130_stdcells/a21o_4.sym} 157180 -25230 0 0 {name=X_57830_ }
C {devices/lab_pin.sym} 157140 -25090 0 0 {name=p156222 lab=_70001_/A }
C {devices/lab_pin.sym} 157220 -25090 0 1 {name=p156223 lab=_69816_/X }
C {sky130_stdcells/buf_2.sym} 157180 -25090 0 0 {name=X_69816_ }
C {devices/lab_pin.sym} 157100 -24990 0 0 {name=p156224 lab=_86251_/Q }
C {devices/lab_pin.sym} 157100 -24950 0 0 {name=p156225 lab=_50162_/X }
C {devices/lab_pin.sym} 157100 -24910 0 0 {name=p156226 lab=_50164_/Y }
C {devices/lab_pin.sym} 157260 -24950 0 1 {name=p156227 lab=_50165_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -24950 0 0 {name=X_50165_ }
C {devices/lab_pin.sym} 157090 -24810 0 0 {name=p156228 lab=_86499_/CLK }
C {devices/lab_pin.sym} 157090 -24790 0 0 {name=p156229 lab=_85862_/D }
C {devices/lab_pin.sym} 157270 -24810 0 1 {name=p156230 lab=_85862_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -24800 0 0 {name=X_85862_ }
C {devices/lab_pin.sym} 157090 -24670 0 0 {name=p156231 lab=_88111_/CLK }
C {devices/lab_pin.sym} 157090 -24650 0 0 {name=p156232 lab=_43029_/Y }
C {devices/lab_pin.sym} 157270 -24670 0 1 {name=p156233 lab=_73599_/A }
C {sky130_stdcells/dfxtp_4.sym} 157180 -24660 0 0 {name=X_87601_ }
C {devices/lab_pin.sym} 157090 -24530 0 0 {name=p156234 lab=_82394_/CLK }
C {devices/lab_pin.sym} 157090 -24510 0 0 {name=p156235 lab=_84813_/D }
C {devices/lab_pin.sym} 157270 -24530 0 1 {name=p156236 lab=_84813_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -24520 0 0 {name=X_84813_ }
C {devices/lab_pin.sym} 157140 -24390 0 0 {name=p156237 lab=_45926_/X }
C {devices/lab_pin.sym} 157220 -24390 0 1 {name=p156238 lab=_57761_/X }
C {sky130_stdcells/buf_2.sym} 157180 -24390 0 0 {name=X_57761_ }
C {devices/lab_pin.sym} 157140 -24270 0 0 {name=p156239 lab=_69747_/A }
C {devices/lab_pin.sym} 157220 -24270 0 1 {name=p156240 lab=_69747_/X }
C {sky130_stdcells/buf_2.sym} 157180 -24270 0 0 {name=X_69747_ }
C {devices/lab_pin.sym} 157100 -24170 0 0 {name=p156241 lab=_86265_/Q }
C {devices/lab_pin.sym} 157100 -24130 0 0 {name=p156242 lab=_50088_/X }
C {devices/lab_pin.sym} 157100 -24090 0 0 {name=p156243 lab=_50095_/Y }
C {devices/lab_pin.sym} 157260 -24130 0 1 {name=p156244 lab=_50096_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -24130 0 0 {name=X_50096_ }
C {devices/lab_pin.sym} 157140 -23990 0 0 {name=p156245 lab=_54973_/A }
C {devices/lab_pin.sym} 157220 -23990 0 1 {name=p156246 lab=_54974_/C }
C {sky130_stdcells/buf_2.sym} 157180 -23990 0 0 {name=X_54973_ }
C {devices/lab_pin.sym} 157120 -23880 0 0 {name=p156247 lab=_66912_/A }
C {devices/lab_pin.sym} 157120 -23840 0 0 {name=p156248 lab=_66959_/B }
C {devices/lab_pin.sym} 157240 -23860 0 1 {name=p156249 lab=_66959_/X }
C {sky130_stdcells/and2_4.sym} 157180 -23860 0 0 {name=X_66959_ }
C {devices/lab_pin.sym} 157090 -23730 0 0 {name=p156250 lab=_83685_/CLK }
C {devices/lab_pin.sym} 157090 -23710 0 0 {name=p156251 lab=_52581_/Y }
C {devices/lab_pin.sym} 157270 -23730 0 1 {name=p156252 lab=_85793_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -23720 0 0 {name=X_85793_ }
C {devices/lab_pin.sym} 157140 -23590 0 0 {name=p156253 lab=_59500_/A }
C {devices/lab_pin.sym} 157220 -23590 0 1 {name=p156254 lab=_59500_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -23590 0 0 {name=X_59500_ }
C {devices/lab_pin.sym} 157140 -23470 0 0 {name=p156255 lab=_56775_/A }
C {devices/lab_pin.sym} 157220 -23470 0 1 {name=p156256 lab=_56713_/A }
C {sky130_stdcells/buf_2.sym} 157180 -23470 0 0 {name=X_56712_ }
C {devices/lab_pin.sym} 157090 -23350 0 0 {name=p156257 lab=_87544_/CLK }
C {devices/lab_pin.sym} 157090 -23330 0 0 {name=p156258 lab=_43221_/Y }
C {devices/lab_pin.sym} 157270 -23350 0 1 {name=p156259 lab=_87532_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -23340 0 0 {name=X_87532_ }
C {devices/lab_pin.sym} 157100 -23230 0 0 {name=p156260 lab=_85541_/Q }
C {devices/lab_pin.sym} 157100 -23190 0 0 {name=p156261 lab=_53921_/X }
C {devices/lab_pin.sym} 157100 -23150 0 0 {name=p156262 lab=_53923_/Y }
C {devices/lab_pin.sym} 157260 -23190 0 1 {name=p156263 lab=_53924_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -23190 0 0 {name=X_53924_ }
C {devices/lab_pin.sym} 157140 -23050 0 0 {name=p156264 lab=clkbuf_7_69_0_CLK/X }
C {devices/lab_pin.sym} 157220 -23050 0 1 {name=p156265 lab=clkbuf_9_277_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 157180 -23050 0 0 {name=Xclkbuf_8_138_0_CLK }
C {devices/lab_pin.sym} 157090 -22930 0 0 {name=p156266 lab=_83438_/CLK }
C {devices/lab_pin.sym} 157090 -22910 0 0 {name=p156267 lab=_84744_/D }
C {devices/lab_pin.sym} 157270 -22930 0 1 {name=p156268 lab=_84744_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -22920 0 0 {name=X_84744_ }
C {devices/lab_pin.sym} 157120 -22800 0 0 {name=p156269 lab=_44151_/X }
C {devices/lab_pin.sym} 157120 -22760 0 0 {name=p156270 lab=_57692_/B }
C {devices/lab_pin.sym} 157240 -22780 0 1 {name=p156271 lab=_57692_/Y }
C {sky130_stdcells/nor2_4.sym} 157180 -22780 0 0 {name=X_57692_ }
C {devices/lab_pin.sym} 157140 -22650 0 0 {name=p156272 lab=clkbuf_9_66_0_CLK/X }
C {devices/lab_pin.sym} 157220 -22650 0 1 {name=p156273 lab=_83842_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 157180 -22650 0 0 {name=Xclkbuf_10_133_0_CLK }
C {devices/lab_pin.sym} 157090 -22530 0 0 {name=p156274 lab=_82339_/CLK }
C {devices/lab_pin.sym} 157090 -22510 0 0 {name=p156275 lab=_81956_/D }
C {devices/lab_pin.sym} 157270 -22530 0 1 {name=p156276 lab=_77890_/B }
C {sky130_stdcells/dfxtp_4.sym} 157180 -22520 0 0 {name=X_81956_ }
C {devices/lab_pin.sym} 157140 -22390 0 0 {name=p156277 lab=_69678_/A }
C {devices/lab_pin.sym} 157220 -22390 0 1 {name=p156278 lab=_69678_/X }
C {sky130_stdcells/buf_2.sym} 157180 -22390 0 0 {name=X_69678_ }
C {devices/lab_pin.sym} 157120 -22280 0 0 {name=p156279 lab=_59430_/Y }
C {devices/lab_pin.sym} 157120 -22240 0 0 {name=p156280 lab=_59424_/B }
C {devices/lab_pin.sym} 157240 -22260 0 1 {name=p156281 lab=_59431_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -22260 0 0 {name=X_59431_ }
C {devices/lab_pin.sym} 157140 -22130 0 0 {name=p156282 lab=clkbuf_9_381_0_CLK/X }
C {devices/lab_pin.sym} 157220 -22130 0 1 {name=p156283 lab=_87525_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 157180 -22130 0 0 {name=Xclkbuf_10_763_0_CLK }
C {devices/lab_pin.sym} 157140 -22010 0 0 {name=p156284 lab=_56642_/Y }
C {devices/lab_pin.sym} 157220 -22010 0 1 {name=p156285 lab=_56643_/X }
C {sky130_stdcells/buf_2.sym} 157180 -22010 0 0 {name=X_56643_ }
C {devices/lab_pin.sym} 157090 -21890 0 0 {name=p156286 lab=_83918_/CLK }
C {devices/lab_pin.sym} 157090 -21870 0 0 {name=p156287 lab=_80907_/D }
C {devices/lab_pin.sym} 157270 -21890 0 1 {name=p156288 lab=_75649_/A }
C {sky130_stdcells/dfxtp_4.sym} 157180 -21880 0 0 {name=X_80907_ }
C {devices/lab_pin.sym} 157100 -21770 0 0 {name=p156289 lab=_68625_/X }
C {devices/lab_pin.sym} 157100 -21730 0 0 {name=p156290 lab=_68628_/X }
C {devices/lab_pin.sym} 157100 -21690 0 0 {name=p156291 lab=_68558_/X }
C {devices/lab_pin.sym} 157260 -21730 0 1 {name=p156292 lab=_68629_/X }
C {sky130_stdcells/a21o_4.sym} 157180 -21730 0 0 {name=X_68629_ }
C {devices/lab_pin.sym} 157090 -21590 0 0 {name=p156293 lab=_87149_/CLK }
C {devices/lab_pin.sym} 157090 -21570 0 0 {name=p156294 lab=_87463_/D }
C {devices/lab_pin.sym} 157270 -21590 0 1 {name=p156295 lab=_87463_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -21580 0 0 {name=X_87463_ }
C {devices/lab_pin.sym} 157100 -21470 0 0 {name=p156296 lab=_53853_/Y }
C {devices/lab_pin.sym} 157100 -21430 0 0 {name=p156297 lab=_53838_/X }
C {devices/lab_pin.sym} 157100 -21390 0 0 {name=p156298 lab=_53854_/Y }
C {devices/lab_pin.sym} 157260 -21430 0 1 {name=p156299 lab=_53855_/Y }
C {sky130_stdcells/a21boi_4.sym} 157180 -21430 0 0 {name=X_53855_ }
C {devices/lab_pin.sym} 157090 -21290 0 0 {name=p156300 lab=_84671_/CLK }
C {devices/lab_pin.sym} 157090 -21270 0 0 {name=p156301 lab=_84675_/D }
C {devices/lab_pin.sym} 157270 -21290 0 1 {name=p156302 lab=_80186_/A }
C {sky130_stdcells/dfxtp_4.sym} 157180 -21280 0 0 {name=X_84675_ }
C {devices/lab_pin.sym} 157090 -21150 0 0 {name=p156303 lab=_81857_/CLK }
C {devices/lab_pin.sym} 157090 -21130 0 0 {name=p156304 lab=_78078_/X }
C {devices/lab_pin.sym} 157270 -21150 0 1 {name=p156305 lab=_81887_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -21140 0 0 {name=X_81887_ }
C {devices/lab_pin.sym} 157090 -21010 0 0 {name=p156306 lab=_86414_/CLK }
C {devices/lab_pin.sym} 157090 -20990 0 0 {name=p156307 lab=_49305_/Y }
C {devices/lab_pin.sym} 157270 -21010 0 1 {name=p156308 lab=_65109_/B }
C {sky130_stdcells/dfxtp_4.sym} 157180 -21000 0 0 {name=X_86414_ }
C {devices/lab_pin.sym} 157140 -20870 0 0 {name=p156309 lab=_40820_/A }
C {devices/lab_pin.sym} 157220 -20870 0 1 {name=p156310 lab=_40820_/X }
C {sky130_stdcells/buf_2.sym} 157180 -20870 0 0 {name=X_40820_ }
C {devices/lab_pin.sym} 157100 -20770 0 0 {name=p156311 lab=_52804_/Y }
C {devices/lab_pin.sym} 157100 -20730 0 0 {name=p156312 lab=_52783_/X }
C {devices/lab_pin.sym} 157100 -20690 0 0 {name=p156313 lab=_52805_/X }
C {devices/lab_pin.sym} 157260 -20730 0 1 {name=p156314 lab=_52806_/Y }
C {sky130_stdcells/a21oi_4.sym} 157180 -20730 0 0 {name=X_52806_ }
C {devices/lab_pin.sym} 157100 -20630 0 0 {name=p156315 lab=_59237_/X }
C {devices/lab_pin.sym} 157100 -20590 0 0 {name=p156316 lab=_59360_/Y }
C {devices/lab_pin.sym} 157100 -20550 0 0 {name=p156317 lab=_59361_/Y }
C {devices/lab_pin.sym} 157100 -20510 0 0 {name=p156318 lab=_59301_/X }
C {devices/lab_pin.sym} 157100 -20470 0 0 {name=p156319 lab=_59241_/X }
C {devices/lab_pin.sym} 157260 -20550 0 1 {name=p156320 lab=_59362_/X }
C {sky130_stdcells/o32a_4.sym} 157180 -20550 0 0 {name=X_59362_ }
C {devices/lab_pin.sym} 157100 -20410 0 0 {name=p156321 lab=_59493_/Y }
C {devices/lab_pin.sym} 157100 -20370 0 0 {name=p156322 lab=_71628_/X }
C {devices/lab_pin.sym} 157100 -20330 0 0 {name=p156323 lab=_71639_/Y }
C {devices/lab_pin.sym} 157260 -20370 0 1 {name=p156324 lab=_71640_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -20370 0 0 {name=X_71640_ }
C {devices/lab_pin.sym} 157090 -20230 0 0 {name=p156325 lab=_83627_/CLK }
C {devices/lab_pin.sym} 157090 -20210 0 0 {name=p156326 lab=_71044_/Y }
C {devices/lab_pin.sym} 157270 -20230 0 1 {name=p156327 lab=_47668_/A }
C {sky130_stdcells/dfxtp_4.sym} 157180 -20220 0 0 {name=X_83626_ }
C {devices/lab_pin.sym} 157140 -20090 0 0 {name=p156328 lab=clkbuf_9_255_0_CLK/A }
C {devices/lab_pin.sym} 157220 -20090 0 1 {name=p156329 lab=clkbuf_9_254_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 157180 -20090 0 0 {name=Xclkbuf_9_254_0_CLK }
C {devices/lab_pin.sym} 157120 -19980 0 0 {name=p156330 lab=_56564_/B }
C {devices/lab_pin.sym} 157120 -19940 0 0 {name=p156331 lab=_56564_/A }
C {devices/lab_pin.sym} 157240 -19960 0 1 {name=p156332 lab=_56574_/Y }
C {sky130_stdcells/xnor2_4.sym} 157180 -19960 0 0 {name=X_56574_ }
C {devices/lab_pin.sym} 157090 -19830 0 0 {name=p156333 lab=_80746_/CLK }
C {devices/lab_pin.sym} 157090 -19810 0 0 {name=p156334 lab=_80870_/Q }
C {devices/lab_pin.sym} 157270 -19830 0 1 {name=p156335 lab=_74869_/B }
C {sky130_stdcells/dfxtp_4.sym} 157180 -19820 0 0 {name=X_80838_ }
C {devices/lab_pin.sym} 157090 -19690 0 0 {name=p156336 lab=_87394_/CLK }
C {devices/lab_pin.sym} 157090 -19670 0 0 {name=p156337 lab=_43492_/X }
C {devices/lab_pin.sym} 157270 -19690 0 1 {name=p156338 lab=_87394_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -19680 0 0 {name=X_87394_ }
C {devices/lab_pin.sym} 157120 -19560 0 0 {name=p156339 lab=_53786_/A }
C {devices/lab_pin.sym} 157120 -19520 0 0 {name=p156340 lab=_48887_/Y }
C {devices/lab_pin.sym} 157240 -19540 0 1 {name=p156341 lab=_53786_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -19540 0 0 {name=X_53786_ }
C {devices/lab_pin.sym} 157120 -19420 0 0 {name=p156342 lab=_51003_/A }
C {devices/lab_pin.sym} 157120 -19380 0 0 {name=p156343 lab=_50998_/B }
C {devices/lab_pin.sym} 157240 -19400 0 1 {name=p156344 lab=_50998_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -19400 0 0 {name=X_50998_ }
C {devices/lab_pin.sym} 157140 -19270 0 0 {name=p156345 lab=_58408_/A }
C {devices/lab_pin.sym} 157220 -19270 0 1 {name=p156346 lab=_58326_/B }
C {sky130_stdcells/buf_2.sym} 157180 -19270 0 0 {name=X_58313_ }
C {devices/lab_pin.sym} 157100 -19180 0 0 {name=p156347 lab=_45553_/A }
C {devices/lab_pin.sym} 157100 -19140 0 0 {name=p156348 lab=_55522_/X }
C {devices/lab_pin.sym} 157100 -19100 0 0 {name=p156349 lab=_55523_/X }
C {devices/lab_pin.sym} 157100 -19060 0 0 {name=p156350 lab=_55524_/Y }
C {devices/lab_pin.sym} 157260 -19120 0 1 {name=p156351 lab=_55525_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -19120 0 0 {name=X_55525_ }
C {devices/lab_pin.sym} 157090 -18970 0 0 {name=p156352 lab=_82381_/CLK }
C {devices/lab_pin.sym} 157090 -18950 0 0 {name=p156353 lab=_86345_/D }
C {devices/lab_pin.sym} 157270 -18970 0 1 {name=p156354 lab=_86345_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -18960 0 0 {name=X_86345_ }
C {devices/lab_pin.sym} 157140 -18830 0 0 {name=p156355 lab=clkbuf_9_74_0_CLK/X }
C {devices/lab_pin.sym} 157220 -18830 0 1 {name=p156356 lab=_81695_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 157180 -18830 0 0 {name=Xclkbuf_10_148_0_CLK }
C {devices/lab_pin.sym} 157120 -18720 0 0 {name=p156357 lab=_40751_/A }
C {devices/lab_pin.sym} 157120 -18680 0 0 {name=p156358 lab=_40765_/B }
C {devices/lab_pin.sym} 157240 -18700 0 1 {name=p156359 lab=_40751_/X }
C {sky130_stdcells/or2_4.sym} 157180 -18700 0 0 {name=X_40751_ }
C {devices/lab_pin.sym} 157140 -18570 0 0 {name=p156360 lab=_52684_/A }
C {devices/lab_pin.sym} 157220 -18570 0 1 {name=p156361 lab=_52737_/X }
C {sky130_stdcells/buf_2.sym} 157180 -18570 0 0 {name=X_52737_ }
C {devices/lab_pin.sym} 157100 -18470 0 0 {name=p156362 lab=_59292_/X }
C {devices/lab_pin.sym} 157100 -18430 0 0 {name=p156363 lab=_85641_/Q }
C {devices/lab_pin.sym} 157100 -18390 0 0 {name=p156364 lab=_59205_/X }
C {devices/lab_pin.sym} 157260 -18430 0 1 {name=p156365 lab=_59293_/X }
C {sky130_stdcells/o21a_4.sym} 157180 -18430 0 0 {name=X_59293_ }
C {devices/lab_pin.sym} 157090 -18290 0 0 {name=p156366 lab=_86237_/CLK }
C {devices/lab_pin.sym} 157090 -18270 0 0 {name=p156367 lab=_71253_/Y }
C {devices/lab_pin.sym} 157270 -18290 0 1 {name=p156368 lab=_47880_/A }
C {sky130_stdcells/dfxtp_4.sym} 157180 -18280 0 0 {name=X_83557_ }
C {devices/lab_pin.sym} 157140 -18150 0 0 {name=p156369 lab=_71164_/B }
C {devices/lab_pin.sym} 157220 -18150 0 1 {name=p156370 lab=_71574_/C }
C {sky130_stdcells/buf_2.sym} 157180 -18150 0 0 {name=X_71571_ }
C {devices/lab_pin.sym} 157090 -18030 0 0 {name=p156371 lab=_83944_/CLK }
C {devices/lab_pin.sym} 157090 -18010 0 0 {name=p156372 lab=_80769_/D }
C {devices/lab_pin.sym} 157270 -18030 0 1 {name=p156373 lab=_75008_/A }
C {sky130_stdcells/dfxtp_4.sym} 157180 -18020 0 0 {name=X_80769_ }
C {devices/lab_pin.sym} 157140 -17890 0 0 {name=p156374 lab=clkbuf_9_389_0_CLK/X }
C {devices/lab_pin.sym} 157220 -17890 0 1 {name=p156375 lab=_82047_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 157180 -17890 0 0 {name=Xclkbuf_10_778_0_CLK }
C {devices/lab_pin.sym} 157120 -17780 0 0 {name=p156376 lab=_73407_/A }
C {devices/lab_pin.sym} 157120 -17740 0 0 {name=p156377 lab=_73310_/B }
C {devices/lab_pin.sym} 157240 -17760 0 1 {name=p156378 lab=_73310_/X }
C {sky130_stdcells/and2_4.sym} 157180 -17760 0 0 {name=X_73310_ }
C {sky130_stdcells/decap_3.sym} 157180 -17600 0 0 {name=XPHY_700 }
C {devices/lab_pin.sym} 157120 -17470 0 0 {name=p156379 lab=_70526_/A }
C {devices/lab_pin.sym} 157120 -17430 0 0 {name=p156380 lab=_74529_/A }
C {devices/lab_pin.sym} 157120 -17390 0 0 {name=p156381 lab=_70962_/C }
C {devices/lab_pin.sym} 157240 -17430 0 1 {name=p156382 lab=_70522_/Y }
C {sky130_stdcells/nand3_4.sym} 157180 -17430 0 0 {name=X_70522_ }
C {devices/lab_pin.sym} 157120 -17300 0 0 {name=p156383 lab=_58241_/X }
C {devices/lab_pin.sym} 157120 -17260 0 0 {name=p156384 lab=_58248_/B }
C {devices/lab_pin.sym} 157240 -17280 0 1 {name=p156385 lab=_58244_/Y }
C {sky130_stdcells/nor2_4.sym} 157180 -17280 0 0 {name=X_58244_ }
C {devices/lab_pin.sym} 157090 -17150 0 0 {name=p156386 lab=_82702_/CLK }
C {devices/lab_pin.sym} 157090 -17130 0 0 {name=p156387 lab=_82508_/D }
C {devices/lab_pin.sym} 157270 -17150 0 1 {name=p156388 lab=_82508_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -17140 0 0 {name=X_82508_ }
C {devices/lab_pin.sym} 157140 -17010 0 0 {name=p156389 lab=_43470_/A }
C {devices/lab_pin.sym} 157220 -17010 0 1 {name=p156390 lab=_43470_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -17010 0 0 {name=X_43470_ }
C {devices/lab_pin.sym} 157100 -16920 0 0 {name=p156391 lab=_45597_/A }
C {devices/lab_pin.sym} 157100 -16880 0 0 {name=p156392 lab=_55453_/X }
C {devices/lab_pin.sym} 157100 -16840 0 0 {name=p156393 lab=_44047_/X }
C {devices/lab_pin.sym} 157100 -16800 0 0 {name=p156394 lab=_55455_/Y }
C {devices/lab_pin.sym} 157260 -16860 0 1 {name=p156395 lab=_55456_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -16860 0 0 {name=X_55456_ }
C {devices/lab_pin.sym} 157140 -16710 0 0 {name=p156396 lab=_72688_/A }
C {devices/lab_pin.sym} 157220 -16710 0 1 {name=p156397 lab=_74297_/B }
C {sky130_stdcells/buf_2.sym} 157180 -16710 0 0 {name=X_74290_ }
C {sky130_stdcells/decap_3.sym} 157180 -16560 0 0 {name=XPHY_711 }
C {devices/lab_pin.sym} 157090 -16410 0 0 {name=p156398 lab=_85955_/CLK }
C {devices/lab_pin.sym} 157090 -16390 0 0 {name=p156399 lab=_86276_/D }
C {devices/lab_pin.sym} 157270 -16410 0 1 {name=p156400 lab=_72461_/B }
C {sky130_stdcells/dfxtp_4.sym} 157180 -16400 0 0 {name=X_86276_ }
C {devices/lab_pin.sym} 157140 -16270 0 0 {name=p156401 lab=_40682_/A }
C {devices/lab_pin.sym} 157220 -16270 0 1 {name=p156402 lab=_40682_/X }
C {sky130_stdcells/buf_2.sym} 157180 -16270 0 0 {name=X_40682_ }
C {devices/lab_pin.sym} 157100 -16170 0 0 {name=p156403 lab=_85776_/Q }
C {devices/lab_pin.sym} 157100 -16130 0 0 {name=p156404 lab=_52656_/X }
C {devices/lab_pin.sym} 157100 -16090 0 0 {name=p156405 lab=_52667_/Y }
C {devices/lab_pin.sym} 157260 -16130 0 1 {name=p156406 lab=_52668_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -16130 0 0 {name=X_52668_ }
C {devices/lab_pin.sym} 157090 -15990 0 0 {name=p156407 lab=_83372_/CLK }
C {devices/lab_pin.sym} 157090 -15970 0 0 {name=p156408 lab=_83488_/D }
C {devices/lab_pin.sym} 157270 -15990 0 1 {name=p156409 lab=_83488_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -15980 0 0 {name=X_83488_ }
C {devices/lab_pin.sym} 157140 -15850 0 0 {name=p156410 lab=_42421_/A }
C {devices/lab_pin.sym} 157220 -15850 0 1 {name=p156411 lab=_42421_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -15850 0 0 {name=X_42421_ }
C {devices/lab_pin.sym} 157090 -15730 0 0 {name=p156412 lab=_87260_/CLK }
C {devices/lab_pin.sym} 157090 -15710 0 0 {name=p156413 lab=_88015_/D }
C {devices/lab_pin.sym} 157270 -15730 0 1 {name=p156414 lab=_88015_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -15720 0 0 {name=X_88015_ }
C {devices/lab_pin.sym} 157100 -15610 0 0 {name=p156415 lab=_85448_/Q }
C {devices/lab_pin.sym} 157100 -15570 0 0 {name=p156416 lab=_54404_/X }
C {devices/lab_pin.sym} 157100 -15530 0 0 {name=p156417 lab=_54406_/Y }
C {devices/lab_pin.sym} 157260 -15570 0 1 {name=p156418 lab=_54407_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -15570 0 0 {name=X_54407_ }
C {devices/lab_pin.sym} 157120 -15440 0 0 {name=p156419 lab=_73237_/X }
C {devices/lab_pin.sym} 157120 -15400 0 0 {name=p156420 lab=_73240_/X }
C {devices/lab_pin.sym} 157240 -15420 0 1 {name=p156421 lab=_73241_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -15420 0 0 {name=X_73241_ }
C {devices/lab_pin.sym} 157140 -15290 0 0 {name=p156422 lab=clkbuf_9_269_0_CLK/A }
C {devices/lab_pin.sym} 157220 -15290 0 1 {name=p156423 lab=clkbuf_9_269_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 157180 -15290 0 0 {name=Xclkbuf_9_269_0_CLK }
C {devices/lab_pin.sym} 157090 -15170 0 0 {name=p156424 lab=_85192_/CLK }
C {devices/lab_pin.sym} 157090 -15150 0 0 {name=p156425 lab=_85227_/D }
C {devices/lab_pin.sym} 157270 -15170 0 1 {name=p156426 lab=_55783_/B }
C {sky130_stdcells/dfxtp_4.sym} 157180 -15160 0 0 {name=X_85227_ }
C {devices/lab_pin.sym} 157120 -15060 0 0 {name=p156427 lab=_51619_/A }
C {devices/lab_pin.sym} 157120 -15020 0 0 {name=p156428 lab=_51619_/B }
C {devices/lab_pin.sym} 157120 -14980 0 0 {name=p156429 lab=_51608_/X }
C {devices/lab_pin.sym} 157120 -14940 0 0 {name=p156430 lab=_53144_/D }
C {devices/lab_pin.sym} 157240 -15000 0 1 {name=p156431 lab=_51619_/X }
C {sky130_stdcells/and4_4.sym} 157180 -15000 0 0 {name=X_51619_ }
C {devices/lab_pin.sym} 157140 -14850 0 0 {name=p156432 lab=_70907_/B }
C {devices/lab_pin.sym} 157220 -14850 0 1 {name=p156433 lab=_70827_/B }
C {sky130_stdcells/buf_2.sym} 157180 -14850 0 0 {name=X_70453_ }
C {devices/lab_pin.sym} 157120 -14740 0 0 {name=p156434 lab=_64282_/A }
C {devices/lab_pin.sym} 157120 -14700 0 0 {name=p156435 lab=_58217_/B }
C {devices/lab_pin.sym} 157240 -14720 0 1 {name=p156436 lab=_58175_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -14720 0 0 {name=X_58175_ }
C {devices/lab_pin.sym} 157090 -14590 0 0 {name=p156437 lab=_82820_/CLK }
C {devices/lab_pin.sym} 157090 -14570 0 0 {name=p156438 lab=_79131_/X }
C {devices/lab_pin.sym} 157270 -14590 0 1 {name=p156439 lab=_82439_/Q }
C {sky130_stdcells/dfxtp_4.sym} 157180 -14580 0 0 {name=X_82439_ }
C {devices/lab_pin.sym} 157140 -14450 0 0 {name=p156440 lab=_55387_/A }
C {devices/lab_pin.sym} 157220 -14450 0 1 {name=p156441 lab=_55387_/X }
C {sky130_stdcells/buf_2.sym} 157180 -14450 0 0 {name=X_55387_ }
C {devices/lab_pin.sym} 157120 -14360 0 0 {name=p156442 lab=_52614_/A }
C {devices/lab_pin.sym} 157120 -14320 0 0 {name=p156443 lab=_52594_/B }
C {devices/lab_pin.sym} 157120 -14280 0 0 {name=p156444 lab=_52622_/C }
C {devices/lab_pin.sym} 157120 -14240 0 0 {name=p156445 lab=_51772_/D }
C {devices/lab_pin.sym} 157240 -14300 0 1 {name=p156446 lab=_52599_/X }
C {sky130_stdcells/and4_4.sym} 157180 -14300 0 0 {name=X_52599_ }
C {devices/lab_pin.sym} 157140 -14150 0 0 {name=p156447 lab=_83026_/Q }
C {devices/lab_pin.sym} 157220 -14150 0 1 {name=p156448 lab=_45141_/A }
C {sky130_stdcells/inv_2.sym} 157180 -14150 0 0 {name=X_45140_ }
C {devices/lab_pin.sym} 157140 -14030 0 0 {name=p156449 lab=_57126_/A }
C {devices/lab_pin.sym} 157220 -14030 0 1 {name=p156450 lab=_57158_/C }
C {sky130_stdcells/buf_2.sym} 157180 -14030 0 0 {name=X_57126_ }
C {devices/lab_pin.sym} 157140 -13910 0 0 {name=p156451 lab=_42352_/A }
C {devices/lab_pin.sym} 157220 -13910 0 1 {name=p156452 lab=_87908_/D }
C {sky130_stdcells/inv_2.sym} 157180 -13910 0 0 {name=X_42352_ }
C {devices/lab_pin.sym} 157140 -13790 0 0 {name=p156453 lab=_54366_/A }
C {devices/lab_pin.sym} 157220 -13790 0 1 {name=p156454 lab=_54338_/X }
C {sky130_stdcells/buf_2.sym} 157180 -13790 0 0 {name=X_54338_ }
C {devices/lab_pin.sym} 157140 -13670 0 0 {name=p156455 lab=clkbuf_9_350_0_CLK/X }
C {devices/lab_pin.sym} 157220 -13670 0 1 {name=p156456 lab=_87888_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 157180 -13670 0 0 {name=Xclkbuf_10_701_0_CLK }
C {devices/lab_pin.sym} 157100 -13570 0 0 {name=p156457 lab=_83162_/Q }
C {devices/lab_pin.sym} 157100 -13530 0 0 {name=p156458 lab=_73079_/X }
C {devices/lab_pin.sym} 157100 -13490 0 0 {name=p156459 lab=_73171_/Y }
C {devices/lab_pin.sym} 157260 -13530 0 1 {name=p156460 lab=_83162_/D }
C {sky130_stdcells/a21o_4.sym} 157180 -13530 0 0 {name=X_73172_ }
C {devices/lab_pin.sym} 157090 -13390 0 0 {name=p156461 lab=_83013_/CLK }
C {devices/lab_pin.sym} 157090 -13370 0 0 {name=p156462 lab=_85158_/D }
C {devices/lab_pin.sym} 157270 -13390 0 1 {name=p156463 lab=_56536_/C }
C {sky130_stdcells/dfxtp_4.sym} 157180 -13380 0 0 {name=X_85158_ }
C {devices/lab_pin.sym} 157120 -13270 0 0 {name=p156464 lab=_70366_/X }
C {devices/lab_pin.sym} 157120 -13230 0 0 {name=p156465 lab=_70383_/X }
C {devices/lab_pin.sym} 157120 -13190 0 0 {name=p156466 lab=_70375_/C }
C {devices/lab_pin.sym} 157240 -13230 0 1 {name=p156467 lab=_70384_/Y }
C {sky130_stdcells/nand3_4.sym} 157180 -13230 0 0 {name=X_70384_ }
C {devices/lab_pin.sym} 157100 -13120 0 0 {name=p156468 lab=_41302_/X }
C {devices/lab_pin.sym} 157100 -13080 0 0 {name=p156469 lab=_41283_/X }
C {devices/lab_pin.sym} 157100 -13040 0 0 {name=p156470 lab=_67411_/B }
C {devices/lab_pin.sym} 157100 -13000 0 0 {name=p156471 lab=_41284_/X }
C {devices/lab_pin.sym} 157260 -13060 0 1 {name=p156472 lab=_88240_/D }
C {sky130_stdcells/a2bb2o_4.sym} 157180 -13060 0 0 {name=X_41303_ }
C {devices/lab_pin.sym} 157140 -12910 0 0 {name=p156473 lab=_72123_/A }
C {devices/lab_pin.sym} 157220 -12910 0 1 {name=p156474 lab=_72123_/X }
C {sky130_stdcells/buf_2.sym} 157180 -12910 0 0 {name=X_72123_ }
C {devices/lab_pin.sym} 157090 -12790 0 0 {name=p156475 lab=_84111_/CLK }
C {devices/lab_pin.sym} 157090 -12770 0 0 {name=p156476 lab=_84109_/D }
C {devices/lab_pin.sym} 157270 -12790 0 1 {name=p156477 lab=_66509_/C }
C {sky130_stdcells/dfxtp_4.sym} 157180 -12780 0 0 {name=X_84109_ }
C {devices/lab_pin.sym} 157100 -12670 0 0 {name=p156478 lab=_45052_/X }
C {devices/lab_pin.sym} 157100 -12630 0 0 {name=p156479 lab=_61447_/B }
C {devices/lab_pin.sym} 157100 -12590 0 0 {name=p156480 lab=_45070_/X }
C {devices/lab_pin.sym} 157260 -12630 0 1 {name=p156481 lab=_45071_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -12630 0 0 {name=X_45071_ }
C {devices/lab_pin.sym} 157100 -12520 0 0 {name=p156482 lab=_57056_/Y }
C {devices/lab_pin.sym} 157100 -12480 0 0 {name=p156483 lab=_56857_/X }
C {devices/lab_pin.sym} 157100 -12440 0 0 {name=p156484 lab=_56995_/X }
C {devices/lab_pin.sym} 157100 -12400 0 0 {name=p156485 lab=_57046_/Y }
C {devices/lab_pin.sym} 157260 -12460 0 1 {name=p156486 lab=_57057_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -12460 0 0 {name=X_57057_ }
C {devices/lab_pin.sym} 157100 -12340 0 0 {name=p156487 lab=_41529_/X }
C {devices/lab_pin.sym} 157100 -12300 0 0 {name=p156488 lab=_42271_/X }
C {devices/lab_pin.sym} 157100 -12260 0 0 {name=p156489 lab=_87941_/Q }
C {devices/lab_pin.sym} 157100 -12220 0 0 {name=p156490 lab=_42272_/X }
C {devices/lab_pin.sym} 157260 -12280 0 1 {name=p156491 lab=_87941_/D }
C {sky130_stdcells/a2bb2o_4.sym} 157180 -12280 0 0 {name=X_42283_ }
C {devices/lab_pin.sym} 157100 -12150 0 0 {name=p156492 lab=_85473_/Q }
C {devices/lab_pin.sym} 157100 -12110 0 0 {name=p156493 lab=_54266_/X }
C {devices/lab_pin.sym} 157100 -12070 0 0 {name=p156494 lab=_54268_/Y }
C {devices/lab_pin.sym} 157260 -12110 0 1 {name=p156495 lab=_54269_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -12110 0 0 {name=X_54269_ }
C {devices/lab_pin.sym} 157120 -11990 0 0 {name=p156496 lab=_77980_/A }
C {devices/lab_pin.sym} 157120 -11950 0 0 {name=p156497 lab=_77972_/Y }
C {devices/lab_pin.sym} 157120 -11910 0 0 {name=p156498 lab=_77980_/C }
C {devices/lab_pin.sym} 157240 -11950 0 1 {name=p156499 lab=_77983_/C }
C {sky130_stdcells/nand3_4.sym} 157180 -11950 0 0 {name=X_77980_ }
C {devices/lab_pin.sym} 157090 -11810 0 0 {name=p156500 lab=_85089_/CLK }
C {devices/lab_pin.sym} 157090 -11790 0 0 {name=p156501 lab=_85089_/D }
C {devices/lab_pin.sym} 157270 -11810 0 1 {name=p156502 lab=_45386_/A }
C {sky130_stdcells/dfxtp_4.sym} 157180 -11800 0 0 {name=X_85089_ }
C {devices/lab_pin.sym} 157140 -11670 0 0 {name=p156503 lab=_64803_/A }
C {devices/lab_pin.sym} 157220 -11670 0 1 {name=p156504 lab=_44022_/X }
C {sky130_stdcells/buf_2.sym} 157180 -11670 0 0 {name=X_44022_ }
C {devices/lab_pin.sym} 157100 -11570 0 0 {name=p156505 lab=_55688_/X }
C {devices/lab_pin.sym} 157100 -11530 0 0 {name=p156506 lab=_56005_/X }
C {devices/lab_pin.sym} 157100 -11490 0 0 {name=p156507 lab=_56007_/Y }
C {devices/lab_pin.sym} 157260 -11530 0 1 {name=p156508 lab=_56008_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -11530 0 0 {name=X_56008_ }
C {devices/lab_pin.sym} 157140 -11390 0 0 {name=p156509 lab=_41233_/X }
C {devices/lab_pin.sym} 157220 -11390 0 1 {name=p156510 lab=_41234_/X }
C {sky130_stdcells/buf_2.sym} 157180 -11390 0 0 {name=X_41234_ }
C {devices/lab_pin.sym} 157100 -11290 0 0 {name=p156511 lab=_83294_/Q }
C {devices/lab_pin.sym} 157100 -11250 0 0 {name=p156512 lab=_72051_/X }
C {devices/lab_pin.sym} 157100 -11210 0 0 {name=p156513 lab=_72053_/Y }
C {devices/lab_pin.sym} 157260 -11250 0 1 {name=p156514 lab=_72054_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -11250 0 0 {name=X_72054_ }
C {devices/lab_pin.sym} 157120 -11120 0 0 {name=p156515 lab=_76931_/A }
C {devices/lab_pin.sym} 157120 -11080 0 0 {name=p156516 lab=_76931_/B }
C {devices/lab_pin.sym} 157240 -11100 0 1 {name=p156517 lab=_76932_/A }
C {sky130_stdcells/and2_4.sym} 157180 -11100 0 0 {name=X_76931_ }
C {devices/lab_pin.sym} 157140 -10970 0 0 {name=p156518 lab=_71005_/A }
C {devices/lab_pin.sym} 157220 -10970 0 1 {name=p156519 lab=_71064_/B }
C {sky130_stdcells/buf_2.sym} 157180 -10970 0 0 {name=X_71005_ }
C {devices/lab_pin.sym} 157140 -10850 0 0 {name=p156520 lab=clkbuf_9_358_0_CLK/X }
C {devices/lab_pin.sym} 157220 -10850 0 1 {name=p156521 lab=_87083_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 157180 -10850 0 0 {name=Xclkbuf_10_716_0_CLK }
C {devices/lab_pin.sym} 157100 -10750 0 0 {name=p156522 lab=_48826_/Y }
C {devices/lab_pin.sym} 157100 -10710 0 0 {name=p156523 lab=_48813_/X }
C {devices/lab_pin.sym} 157100 -10670 0 0 {name=p156524 lab=_48829_/X }
C {devices/lab_pin.sym} 157260 -10710 0 1 {name=p156525 lab=_86475_/D }
C {sky130_stdcells/a21oi_4.sym} 157180 -10710 0 0 {name=X_48830_ }
C {devices/lab_pin.sym} 157120 -10580 0 0 {name=p156526 lab=_79648_/X }
C {devices/lab_pin.sym} 157120 -10540 0 0 {name=p156527 lab=_79650_/B }
C {devices/lab_pin.sym} 157240 -10560 0 1 {name=p156528 lab=_79664_/A }
C {sky130_stdcells/xnor2_4.sym} 157180 -10560 0 0 {name=X_79650_ }
C {devices/lab_pin.sym} 157140 -10430 0 0 {name=p156529 lab=_41165_/A }
C {devices/lab_pin.sym} 157220 -10430 0 1 {name=p156530 lab=_41165_/X }
C {sky130_stdcells/buf_2.sym} 157180 -10430 0 0 {name=X_41165_ }
C {devices/lab_pin.sym} 157120 -10320 0 0 {name=p156531 lab=_76862_/A }
C {devices/lab_pin.sym} 157120 -10280 0 0 {name=p156532 lab=_76862_/B }
C {devices/lab_pin.sym} 157240 -10300 0 1 {name=p156533 lab=_81465_/D }
C {sky130_stdcells/xnor2_4.sym} 157180 -10300 0 0 {name=X_76862_ }
C {devices/lab_pin.sym} 157140 -10170 0 0 {name=p156534 lab=_78601_/A }
C {devices/lab_pin.sym} 157220 -10170 0 1 {name=p156535 lab=_78601_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -10170 0 0 {name=X_78601_ }
C {devices/lab_pin.sym} 157120 -10060 0 0 {name=p156536 lab=_81020_/Q }
C {devices/lab_pin.sym} 157120 -10020 0 0 {name=p156537 lab=_80892_/D }
C {devices/lab_pin.sym} 157240 -10040 0 1 {name=p156538 lab=_80988_/D }
C {sky130_stdcells/xor2_4.sym} 157180 -10040 0 0 {name=X_75813_ }
C {devices/lab_pin.sym} 157140 -9910 0 0 {name=p156539 lab=clkbuf_9_206_0_CLK/A }
C {devices/lab_pin.sym} 157220 -9910 0 1 {name=p156540 lab=clkbuf_9_207_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 157180 -9910 0 0 {name=Xclkbuf_9_207_0_CLK }
C {devices/lab_pin.sym} 157120 -9810 0 0 {name=p156541 lab=_50443_/A }
C {devices/lab_pin.sym} 157120 -9770 0 0 {name=p156542 lab=_48766_/B }
C {devices/lab_pin.sym} 157120 -9730 0 0 {name=p156543 lab=_48761_/C }
C {devices/lab_pin.sym} 157240 -9770 0 1 {name=p156544 lab=_48761_/X }
C {sky130_stdcells/and3_4.sym} 157180 -9770 0 0 {name=X_48761_ }
C {devices/lab_pin.sym} 157120 -9640 0 0 {name=p156545 lab=_79581_/A }
C {devices/lab_pin.sym} 157120 -9600 0 0 {name=p156546 lab=_79581_/B }
C {devices/lab_pin.sym} 157240 -9620 0 1 {name=p156547 lab=_79588_/A }
C {sky130_stdcells/xor2_4.sym} 157180 -9620 0 0 {name=X_79581_ }
C {devices/lab_pin.sym} 157140 -9490 0 0 {name=p156548 lab=_58676_/A }
C {devices/lab_pin.sym} 157220 -9490 0 1 {name=p156549 lab=_58039_/B }
C {sky130_stdcells/buf_2.sym} 157180 -9490 0 0 {name=X_57959_ }
C {devices/lab_pin.sym} 157100 -9400 0 0 {name=p156550 lab=_40399_/Y }
C {devices/lab_pin.sym} 157100 -9360 0 0 {name=p156551 lab=_45963_/X }
C {devices/lab_pin.sym} 157100 -9320 0 0 {name=p156552 lab=_86832_/Q }
C {devices/lab_pin.sym} 157100 -9280 0 0 {name=p156553 lab=_45964_/X }
C {devices/lab_pin.sym} 157260 -9340 0 1 {name=p156554 lab=_86832_/D }
C {sky130_stdcells/a2bb2o_4.sym} 157180 -9340 0 0 {name=X_45973_ }
C {devices/lab_pin.sym} 157120 -9200 0 0 {name=p156555 lab=_41159_/A }
C {devices/lab_pin.sym} 157120 -9160 0 0 {name=p156556 lab=_41096_/B }
C {devices/lab_pin.sym} 157240 -9180 0 1 {name=p156557 lab=_41096_/X }
C {sky130_stdcells/or2_4.sym} 157180 -9180 0 0 {name=X_41096_ }
C {devices/lab_pin.sym} 157120 -9060 0 0 {name=p156558 lab=_76806_/A }
C {devices/lab_pin.sym} 157120 -9020 0 0 {name=p156559 lab=_76792_/Y }
C {devices/lab_pin.sym} 157240 -9040 0 1 {name=p156560 lab=_76801_/A }
C {sky130_stdcells/xor2_4.sym} 157180 -9040 0 0 {name=X_76793_ }
C {devices/lab_pin.sym} 157100 -8930 0 0 {name=p156561 lab=_47707_/Y }
C {devices/lab_pin.sym} 157100 -8890 0 0 {name=p156562 lab=_47698_/X }
C {devices/lab_pin.sym} 157100 -8850 0 0 {name=p156563 lab=_47711_/X }
C {devices/lab_pin.sym} 157260 -8890 0 1 {name=p156564 lab=_86606_/D }
C {sky130_stdcells/a21oi_4.sym} 157180 -8890 0 0 {name=X_47712_ }
C {devices/lab_pin.sym} 157120 -8760 0 0 {name=p156565 lab=_82513_/Q }
C {devices/lab_pin.sym} 157120 -8720 0 0 {name=p156566 lab=_82769_/D }
C {devices/lab_pin.sym} 157240 -8740 0 1 {name=p156567 lab=_82481_/D }
C {sky130_stdcells/xor2_4.sym} 157180 -8740 0 0 {name=X_78532_ }
C {devices/lab_pin.sym} 157100 -8630 0 0 {name=p156568 lab=_44916_/X }
C {devices/lab_pin.sym} 157100 -8590 0 0 {name=p156569 lab=_44921_/X }
C {devices/lab_pin.sym} 157100 -8550 0 0 {name=p156570 lab=_44923_/Y }
C {devices/lab_pin.sym} 157260 -8590 0 1 {name=p156571 lab=_44924_/Y }
C {sky130_stdcells/a21oi_4.sym} 157180 -8590 0 0 {name=X_44924_ }
C {devices/lab_pin.sym} 157120 -8460 0 0 {name=p156572 lab=_75742_/Y }
C {devices/lab_pin.sym} 157120 -8420 0 0 {name=p156573 lab=_75743_/Y }
C {devices/lab_pin.sym} 157240 -8440 0 1 {name=p156574 lab=_75747_/A }
C {sky130_stdcells/xor2_4.sym} 157180 -8440 0 0 {name=X_75744_ }
C {devices/lab_pin.sym} 157100 -8330 0 0 {name=p156575 lab=_48685_/Y }
C {devices/lab_pin.sym} 157100 -8290 0 0 {name=p156576 lab=_48651_/X }
C {devices/lab_pin.sym} 157100 -8250 0 0 {name=p156577 lab=_48691_/X }
C {devices/lab_pin.sym} 157260 -8290 0 1 {name=p156578 lab=_48692_/Y }
C {sky130_stdcells/a21oi_4.sym} 157180 -8290 0 0 {name=X_48692_ }
C {devices/lab_pin.sym} 157120 -8170 0 0 {name=p156579 lab=_60969_/X }
C {devices/lab_pin.sym} 157120 -8130 0 0 {name=p156580 lab=_60835_/X }
C {devices/lab_pin.sym} 157120 -8090 0 0 {name=p156581 lab=_60970_/C }
C {devices/lab_pin.sym} 157240 -8130 0 1 {name=p156582 lab=_60970_/X }
C {sky130_stdcells/or3_4.sym} 157180 -8130 0 0 {name=X_60970_ }
C {devices/lab_pin.sym} 157140 -7990 0 0 {name=p156583 lab=_73352_/A }
C {devices/lab_pin.sym} 157220 -7990 0 1 {name=p156584 lab=_73132_/A }
C {sky130_stdcells/buf_2.sym} 157180 -7990 0 0 {name=X_72956_ }
C {devices/lab_pin.sym} 157140 -7870 0 0 {name=p156585 lab=_81237_/Q }
C {devices/lab_pin.sym} 157220 -7870 0 1 {name=p156586 lab=_55026_/D }
C {sky130_stdcells/inv_2.sym} 157180 -7870 0 0 {name=X_47643_ }
C {devices/lab_pin.sym} 157140 -7750 0 0 {name=p156587 lab=_71894_/Y }
C {devices/lab_pin.sym} 157220 -7750 0 1 {name=p156588 lab=_71928_/D }
C {sky130_stdcells/buf_2.sym} 157180 -7750 0 0 {name=X_71907_ }
C {devices/lab_pin.sym} 157140 -7630 0 0 {name=p156589 lab=_59629_/A }
C {devices/lab_pin.sym} 157220 -7630 0 1 {name=p156590 lab=_59961_/A }
C {sky130_stdcells/buf_2.sym} 157180 -7630 0 0 {name=X_59629_ }
C {devices/lab_pin.sym} 157120 -7520 0 0 {name=p156591 lab=_78463_/A }
C {devices/lab_pin.sym} 157120 -7480 0 0 {name=p156592 lab=_78463_/B }
C {devices/lab_pin.sym} 157240 -7500 0 1 {name=p156593 lab=_78464_/A }
C {sky130_stdcells/and2_4.sym} 157180 -7500 0 0 {name=X_78463_ }
C {devices/lab_pin.sym} 157140 -7370 0 0 {name=p156594 lab=_44855_/A }
C {devices/lab_pin.sym} 157220 -7370 0 1 {name=p156595 lab=_86918_/D }
C {sky130_stdcells/inv_2.sym} 157180 -7370 0 0 {name=X_44855_ }
C {devices/lab_pin.sym} 157120 -7260 0 0 {name=p156596 lab=_81005_/Q }
C {devices/lab_pin.sym} 157120 -7220 0 0 {name=p156597 lab=_75675_/B }
C {devices/lab_pin.sym} 157240 -7240 0 1 {name=p156598 lab=_75675_/X }
C {sky130_stdcells/xor2_4.sym} 157180 -7240 0 0 {name=X_75675_ }
C {devices/lab_pin.sym} 157100 -7130 0 0 {name=p156599 lab=_83173_/Q }
C {devices/lab_pin.sym} 157100 -7090 0 0 {name=p156600 lab=_72794_/X }
C {devices/lab_pin.sym} 157100 -7050 0 0 {name=p156601 lab=_72886_/Y }
C {devices/lab_pin.sym} 157260 -7090 0 1 {name=p156602 lab=_83173_/D }
C {sky130_stdcells/a21o_4.sym} 157180 -7090 0 0 {name=X_72887_ }
C {devices/lab_pin.sym} 157120 -6960 0 0 {name=p156603 lab=_77412_/X }
C {devices/lab_pin.sym} 157120 -6920 0 0 {name=p156604 lab=_77413_/Y }
C {devices/lab_pin.sym} 157240 -6940 0 1 {name=p156605 lab=_77415_/A }
C {sky130_stdcells/and2_4.sym} 157180 -6940 0 0 {name=X_77414_ }
C {devices/lab_pin.sym} 157140 -6810 0 0 {name=p156606 lab=_43806_/A }
C {devices/lab_pin.sym} 157220 -6810 0 1 {name=p156607 lab=_43806_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -6810 0 0 {name=X_43806_ }
C {devices/lab_pin.sym} 157120 -6710 0 0 {name=p156608 lab=_62910_/A }
C {devices/lab_pin.sym} 157120 -6670 0 0 {name=p156609 lab=_60360_/X }
C {devices/lab_pin.sym} 157120 -6630 0 0 {name=p156610 lab=_62640_/C }
C {devices/lab_pin.sym} 157240 -6670 0 1 {name=p156611 lab=_62886_/A }
C {sky130_stdcells/nand3_4.sym} 157180 -6670 0 0 {name=X_62640_ }
C {devices/lab_pin.sym} 157100 -6550 0 0 {name=p156612 lab=_45381_/A }
C {devices/lab_pin.sym} 157100 -6510 0 0 {name=p156613 lab=_74625_/A }
C {devices/lab_pin.sym} 157100 -6470 0 0 {name=p156614 lab=_74625_/Y }
C {devices/lab_pin.sym} 157260 -6510 0 1 {name=p156615 lab=_74626_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -6510 0 0 {name=X_74626_ }
C {devices/lab_pin.sym} 157120 -6380 0 0 {name=p156616 lab=_47574_/A }
C {devices/lab_pin.sym} 157120 -6340 0 0 {name=p156617 lab=_53127_/B }
C {devices/lab_pin.sym} 157240 -6360 0 1 {name=p156618 lab=_47574_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -6360 0 0 {name=X_47574_ }
C {devices/lab_pin.sym} 157100 -6250 0 0 {name=p156619 lab=_71825_/X }
C {devices/lab_pin.sym} 157100 -6210 0 0 {name=p156620 lab=_83357_/Q }
C {devices/lab_pin.sym} 157100 -6170 0 0 {name=p156621 lab=_71837_/X }
C {devices/lab_pin.sym} 157260 -6210 0 1 {name=p156622 lab=_83357_/D }
C {sky130_stdcells/a21o_4.sym} 157180 -6210 0 0 {name=X_71838_ }
C {devices/lab_pin.sym} 157120 -6090 0 0 {name=p156623 lab=_78394_/A }
C {devices/lab_pin.sym} 157120 -6050 0 0 {name=p156624 lab=_78394_/B }
C {devices/lab_pin.sym} 157120 -6010 0 0 {name=p156625 lab=_78394_/C }
C {devices/lab_pin.sym} 157240 -6050 0 1 {name=p156626 lab=_78426_/B }
C {sky130_stdcells/nand3_4.sym} 157180 -6050 0 0 {name=X_78394_ }
C {devices/lab_pin.sym} 157100 -5940 0 0 {name=p156627 lab=_41392_/Y }
C {devices/lab_pin.sym} 157100 -5900 0 0 {name=p156628 lab=_44774_/X }
C {devices/lab_pin.sym} 157100 -5860 0 0 {name=p156629 lab=_86955_/Q }
C {devices/lab_pin.sym} 157100 -5820 0 0 {name=p156630 lab=_44775_/X }
C {devices/lab_pin.sym} 157260 -5880 0 1 {name=p156631 lab=_86955_/D }
C {sky130_stdcells/a2bb2o_4.sym} 157180 -5880 0 0 {name=X_44786_ }
C {devices/lab_pin.sym} 157140 -5730 0 0 {name=p156632 lab=_41998_/A }
C {devices/lab_pin.sym} 157220 -5730 0 1 {name=p156633 lab=_41998_/X }
C {sky130_stdcells/buf_2.sym} 157180 -5730 0 0 {name=X_41998_ }
C {devices/lab_pin.sym} 157100 -5630 0 0 {name=p156634 lab=_49311_/Y }
C {devices/lab_pin.sym} 157100 -5590 0 0 {name=p156635 lab=_49281_/X }
C {devices/lab_pin.sym} 157100 -5550 0 0 {name=p156636 lab=_49312_/X }
C {devices/lab_pin.sym} 157260 -5590 0 1 {name=p156637 lab=_49313_/Y }
C {sky130_stdcells/a21oi_4.sym} 157180 -5590 0 0 {name=X_49313_ }
C {devices/lab_pin.sym} 157140 -5450 0 0 {name=p156638 lab=_47904_/A }
C {devices/lab_pin.sym} 157220 -5450 0 1 {name=p156639 lab=_46525_/X }
C {sky130_stdcells/buf_2.sym} 157180 -5450 0 0 {name=X_46525_ }
C {devices/lab_pin.sym} 157120 -5340 0 0 {name=p156640 lab=_77345_/A }
C {devices/lab_pin.sym} 157120 -5300 0 0 {name=p156641 lab=_77345_/B }
C {devices/lab_pin.sym} 157240 -5320 0 1 {name=p156642 lab=_77371_/C }
C {sky130_stdcells/nand2_4.sym} 157180 -5320 0 0 {name=X_77345_ }
C {devices/lab_pin.sym} 157140 -5190 0 0 {name=p156643 lab=_43673_/A }
C {devices/lab_pin.sym} 157220 -5190 0 1 {name=p156644 lab=_43737_/X }
C {sky130_stdcells/buf_2.sym} 157180 -5190 0 0 {name=X_43737_ }
C {devices/lab_pin.sym} 157100 -5110 0 0 {name=p156645 lab=_61627_/B }
C {devices/lab_pin.sym} 157100 -5070 0 0 {name=p156646 lab=_62548_/C }
C {devices/lab_pin.sym} 157100 -5030 0 0 {name=p156647 lab=_62507_/X }
C {devices/lab_pin.sym} 157100 -4990 0 0 {name=p156648 lab=_62478_/X }
C {devices/lab_pin.sym} 157100 -4960 0 0 {name=p156649 lab=_62570_/X }
C {devices/lab_pin.sym} 157260 -5030 0 1 {name=p156650 lab=_62571_/X }
C {sky130_stdcells/a41o_4.sym} 157180 -5030 0 0 {name=X_62571_ }
C {devices/lab_pin.sym} 157100 -4900 0 0 {name=p156651 lab=_46155_/X }
C {devices/lab_pin.sym} 157100 -4860 0 0 {name=p156652 lab=_74553_/X }
C {devices/lab_pin.sym} 157100 -4820 0 0 {name=p156653 lab=_56030_/X }
C {devices/lab_pin.sym} 157100 -4780 0 0 {name=p156654 lab=_74554_/X }
C {devices/lab_pin.sym} 157260 -4840 0 1 {name=p156655 lab=_74557_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -4840 0 0 {name=X_74557_ }
C {devices/lab_pin.sym} 157100 -4710 0 0 {name=p156656 lab=_40512_/X }
C {devices/lab_pin.sym} 157100 -4670 0 0 {name=p156657 lab=_81727_/Q }
C {devices/lab_pin.sym} 157100 -4630 0 0 {name=p156658 lab=_40948_/X }
C {devices/lab_pin.sym} 157260 -4670 0 1 {name=p156659 lab=_40950_/A }
C {sky130_stdcells/o21a_4.sym} 157180 -4670 0 0 {name=X_40949_ }
C {devices/lab_pin.sym} 157100 -4550 0 0 {name=p156660 lab=_71762_/X }
C {devices/lab_pin.sym} 157100 -4510 0 0 {name=p156661 lab=_83383_/Q }
C {devices/lab_pin.sym} 157100 -4470 0 0 {name=p156662 lab=_71768_/X }
C {devices/lab_pin.sym} 157260 -4510 0 1 {name=p156663 lab=_83383_/D }
C {sky130_stdcells/a21o_4.sym} 157180 -4510 0 0 {name=X_71769_ }
C {devices/lab_pin.sym} 157140 -4370 0 0 {name=p156664 lab=clkbuf_4_7_0_CLK/A }
C {devices/lab_pin.sym} 157220 -4370 0 1 {name=p156665 lab=clkbuf_4_7_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 157180 -4370 0 0 {name=Xclkbuf_4_7_0_CLK }
C {devices/lab_pin.sym} 157100 -4270 0 0 {name=p156666 lab=_58314_/A }
C {devices/lab_pin.sym} 157100 -4230 0 0 {name=p156667 lab=_64308_/X }
C {devices/lab_pin.sym} 157100 -4190 0 0 {name=p156668 lab=_64309_/Y }
C {devices/lab_pin.sym} 157260 -4230 0 1 {name=p156669 lab=_64310_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -4230 0 0 {name=X_64310_ }
C {devices/lab_pin.sym} 157100 -4110 0 0 {name=p156670 lab=_49242_/Y }
C {devices/lab_pin.sym} 157100 -4070 0 0 {name=p156671 lab=_49214_/X }
C {devices/lab_pin.sym} 157100 -4030 0 0 {name=p156672 lab=_49243_/Y }
C {devices/lab_pin.sym} 157260 -4070 0 1 {name=p156673 lab=_49244_/Y }
C {sky130_stdcells/a21boi_4.sym} 157180 -4070 0 0 {name=X_49244_ }
C {devices/lab_pin.sym} 157140 -3930 0 0 {name=p156674 lab=_84865_/Q }
C {devices/lab_pin.sym} 157220 -3930 0 1 {name=p156675 lab=_61522_/X }
C {sky130_stdcells/buf_2.sym} 157180 -3930 0 0 {name=X_61522_ }
C {devices/lab_pin.sym} 157100 -3840 0 0 {name=p156676 lab=_42061_/Y }
C {devices/lab_pin.sym} 157100 -3800 0 0 {name=p156677 lab=_72974_/X }
C {devices/lab_pin.sym} 157100 -3760 0 0 {name=p156678 lab=_73393_/X }
C {devices/lab_pin.sym} 157100 -3720 0 0 {name=p156679 lab=_73507_/Y }
C {devices/lab_pin.sym} 157260 -3780 0 1 {name=p156680 lab=_73508_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -3780 0 0 {name=X_73508_ }
C {devices/lab_pin.sym} 157140 -3630 0 0 {name=p156681 lab=_46455_/Y }
C {devices/lab_pin.sym} 157220 -3630 0 1 {name=p156682 lab=_51324_/B }
C {sky130_stdcells/buf_2.sym} 157180 -3630 0 0 {name=X_46456_ }
C {devices/lab_pin.sym} 157100 -3540 0 0 {name=p156683 lab=_65178_/X }
C {devices/lab_pin.sym} 157100 -3500 0 0 {name=p156684 lab=_83287_/Q }
C {devices/lab_pin.sym} 157100 -3460 0 0 {name=p156685 lab=_65239_/X }
C {devices/lab_pin.sym} 157100 -3420 0 0 {name=p156686 lab=_65289_/X }
C {devices/lab_pin.sym} 157260 -3480 0 1 {name=p156687 lab=_65290_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -3480 0 0 {name=X_65290_ }
C {devices/lab_pin.sym} 157140 -3330 0 0 {name=p156688 lab=_77277_/B }
C {devices/lab_pin.sym} 157220 -3330 0 1 {name=p156689 lab=_77276_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -3330 0 0 {name=X_77276_ }
C {devices/lab_pin.sym} 157100 -3240 0 0 {name=p156690 lab=_40742_/X }
C {devices/lab_pin.sym} 157100 -3200 0 0 {name=p156691 lab=_43659_/X }
C {devices/lab_pin.sym} 157100 -3160 0 0 {name=p156692 lab=_69055_/B }
C {devices/lab_pin.sym} 157100 -3120 0 0 {name=p156693 lab=_43661_/X }
C {devices/lab_pin.sym} 157260 -3180 0 1 {name=p156694 lab=_43668_/X }
C {sky130_stdcells/a2bb2o_4.sym} 157180 -3180 0 0 {name=X_43668_ }
C {devices/lab_pin.sym} 157120 -3050 0 0 {name=p156695 lab=_48644_/A }
C {devices/lab_pin.sym} 157120 -3010 0 0 {name=p156696 lab=_74501_/B }
C {devices/lab_pin.sym} 157120 -2970 0 0 {name=p156697 lab=_74501_/C }
C {devices/lab_pin.sym} 157240 -3010 0 1 {name=p156698 lab=_74488_/X }
C {sky130_stdcells/and3_4.sym} 157180 -3010 0 0 {name=X_74488_ }
C {devices/lab_pin.sym} 157140 -2870 0 0 {name=p156699 lab=_79003_/Y }
C {devices/lab_pin.sym} 157220 -2870 0 1 {name=p156700 lab=_82520_/D }
C {sky130_stdcells/inv_2.sym} 157180 -2870 0 0 {name=X_79015_ }
C {devices/lab_pin.sym} 157100 -2770 0 0 {name=p156701 lab=_45400_/X }
C {devices/lab_pin.sym} 157100 -2730 0 0 {name=p156702 lab=_45404_/X }
C {devices/lab_pin.sym} 157100 -2690 0 0 {name=p156703 lab=_45406_/Y }
C {devices/lab_pin.sym} 157260 -2730 0 1 {name=p156704 lab=_45407_/Y }
C {sky130_stdcells/a21oi_4.sym} 157180 -2730 0 0 {name=X_45407_ }
C {devices/lab_pin.sym} 157100 -2610 0 0 {name=p156705 lab=_79863_/B }
C {devices/lab_pin.sym} 157100 -2570 0 0 {name=p156706 lab=_63258_/X }
C {devices/lab_pin.sym} 157100 -2530 0 0 {name=p156707 lab=_64240_/X }
C {devices/lab_pin.sym} 157260 -2570 0 1 {name=p156708 lab=_84263_/D }
C {sky130_stdcells/a21o_4.sym} 157180 -2570 0 0 {name=X_64241_ }
C {devices/lab_pin.sym} 157120 -2440 0 0 {name=p156709 lab=_81256_/Q }
C {devices/lab_pin.sym} 157120 -2400 0 0 {name=p156710 lab=_81512_/D }
C {devices/lab_pin.sym} 157240 -2420 0 1 {name=p156711 lab=_76232_/A }
C {sky130_stdcells/nor2_4.sym} 157180 -2420 0 0 {name=X_76227_ }
C {devices/lab_pin.sym} 157140 -2290 0 0 {name=p156712 lab=_42619_/A }
C {devices/lab_pin.sym} 157220 -2290 0 1 {name=p156713 lab=_42619_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -2290 0 0 {name=X_42619_ }
C {devices/lab_pin.sym} 157140 -2170 0 0 {name=p156714 lab=_61453_/A }
C {devices/lab_pin.sym} 157220 -2170 0 1 {name=p156715 lab=_61453_/Y }
C {sky130_stdcells/inv_2.sym} 157180 -2170 0 0 {name=X_61453_ }
C {devices/lab_pin.sym} 157140 -2050 0 0 {name=p156716 lab=_49175_/A }
C {devices/lab_pin.sym} 157220 -2050 0 1 {name=p156717 lab=_49176_/A }
C {sky130_stdcells/inv_2.sym} 157180 -2050 0 0 {name=X_49175_ }
C {devices/lab_pin.sym} 157100 -1960 0 0 {name=p156718 lab=_69918_/B }
C {devices/lab_pin.sym} 157100 -1920 0 0 {name=p156719 lab=_73319_/X }
C {devices/lab_pin.sym} 157100 -1880 0 0 {name=p156720 lab=_72890_/X }
C {devices/lab_pin.sym} 157100 -1840 0 0 {name=p156721 lab=_73438_/Y }
C {devices/lab_pin.sym} 157260 -1900 0 1 {name=p156722 lab=_73439_/X }
C {sky130_stdcells/a211o_4.sym} 157180 -1900 0 0 {name=X_73439_ }
C {devices/lab_pin.sym} 157120 -1760 0 0 {name=p156723 lab=_46387_/A }
C {devices/lab_pin.sym} 157120 -1720 0 0 {name=p156724 lab=_49265_/B }
C {devices/lab_pin.sym} 157240 -1740 0 1 {name=p156725 lab=_46387_/Y }
C {sky130_stdcells/nand2_4.sym} 157180 -1740 0 0 {name=X_46387_ }
C {devices/lab_pin.sym} 157140 -1610 0 0 {name=p156726 lab=_87345_/Q }
C {devices/lab_pin.sym} 157220 -1610 0 1 {name=p156727 lab=_68418_/B }
C {sky130_stdcells/inv_2.sym} 157180 -1610 0 0 {name=X_43599_ }
C {devices/lab_pin.sym} 157120 -1500 0 0 {name=p156728 lab=_82341_/Q }
C {devices/lab_pin.sym} 157120 -1460 0 0 {name=p156729 lab=_48086_/B }
C {devices/lab_pin.sym} 157240 -1480 0 1 {name=p156730 lab=_48126_/X }
C {sky130_stdcells/or2_4.sym} 157180 -1480 0 0 {name=X_48126_ }
C {devices/lab_pin.sym} 157120 -1380 0 0 {name=p156731 lab=_60387_/A }
C {devices/lab_pin.sym} 157120 -1340 0 0 {name=p156732 lab=_60404_/B }
C {devices/lab_pin.sym} 157120 -1300 0 0 {name=p156733 lab=_60404_/C }
C {devices/lab_pin.sym} 157120 -1260 0 0 {name=p156734 lab=_60387_/C }
C {devices/lab_pin.sym} 157240 -1320 0 1 {name=p156735 lab=_60404_/Y }
C {sky130_stdcells/nand4_4.sym} 157180 -1320 0 0 {name=X_60404_ }
C {devices/lab_pin.sym} 157100 -1190 0 0 {name=p156736 lab=_56267_/C }
C {devices/lab_pin.sym} 157100 -1150 0 0 {name=p156737 lab=_45297_/X }
C {devices/lab_pin.sym} 157100 -1110 0 0 {name=p156738 lab=_45337_/X }
C {devices/lab_pin.sym} 157260 -1150 0 1 {name=p156739 lab=_45338_/Y }
C {sky130_stdcells/o21ai_4.sym} 157180 -1150 0 0 {name=X_45338_ }
C {devices/lab_pin.sym} 157120 -1040 0 0 {name=p156740 lab=_61675_/B }
C {devices/lab_pin.sym} 157120 -1000 0 0 {name=p156741 lab=_64172_/B }
C {devices/lab_pin.sym} 157120 -960 0 0 {name=p156742 lab=_64172_/C }
C {devices/lab_pin.sym} 157120 -920 0 0 {name=p156743 lab=_64172_/D }
C {devices/lab_pin.sym} 157240 -980 0 1 {name=p156744 lab=_64172_/Y }
C {sky130_stdcells/nand4_4.sym} 157180 -980 0 0 {name=X_64172_ }
C {devices/lab_pin.sym} 157120 -840 0 0 {name=p156745 lab=_76159_/A }
C {devices/lab_pin.sym} 157120 -800 0 0 {name=p156746 lab=_76158_/B }
C {devices/lab_pin.sym} 157240 -820 0 1 {name=p156747 lab=_76158_/X }
C {sky130_stdcells/or2_4.sym} 157180 -820 0 0 {name=X_76158_ }
C {devices/lab_pin.sym} 157120 -710 0 0 {name=p156748 lab=_61384_/A }
C {devices/lab_pin.sym} 157120 -670 0 0 {name=p156749 lab=_61384_/B }
C {devices/lab_pin.sym} 157120 -630 0 0 {name=p156750 lab=_79153_/B }
C {devices/lab_pin.sym} 157240 -670 0 1 {name=p156751 lab=_61384_/Y }
C {sky130_stdcells/nor3_4.sym} 157180 -670 0 0 {name=X_61384_ }
C {devices/lab_pin.sym} 158060 -42150 0 0 {name=p156752 lab=_60484_/A }
C {devices/lab_pin.sym} 158140 -42150 0 1 {name=p156753 lab=_63124_/D }
C {sky130_stdcells/buf_2.sym} 158100 -42150 0 0 {name=X_63123_ }
C {devices/lab_pin.sym} 158040 -42040 0 0 {name=p156754 lab=_75109_/A }
C {devices/lab_pin.sym} 158040 -42000 0 0 {name=p156755 lab=_75109_/B }
C {devices/lab_pin.sym} 158160 -42020 0 1 {name=p156756 lab=_75110_/A }
C {sky130_stdcells/nor2_4.sym} 158100 -42020 0 0 {name=X_75109_ }
C {devices/lab_pin.sym} 158020 -41910 0 0 {name=p156757 lab=_47971_/X }
C {devices/lab_pin.sym} 158020 -41870 0 0 {name=p156758 lab=_82924_/Q }
C {devices/lab_pin.sym} 158020 -41830 0 0 {name=p156759 lab=_48056_/X }
C {devices/lab_pin.sym} 158180 -41870 0 1 {name=p156760 lab=_48058_/B }
C {sky130_stdcells/o21ai_4.sym} 158100 -41870 0 0 {name=X_48057_ }
C {devices/lab_pin.sym} 158040 -41750 0 0 {name=p156761 lab=_62644_/A }
C {devices/lab_pin.sym} 158040 -41710 0 0 {name=p156762 lab=_60239_/B }
C {devices/lab_pin.sym} 158040 -41670 0 0 {name=p156763 lab=_60189_/A }
C {devices/lab_pin.sym} 158160 -41710 0 1 {name=p156764 lab=_60335_/Y }
C {sky130_stdcells/nand3_4.sym} 158100 -41710 0 0 {name=X_60335_ }
C {devices/lab_pin.sym} 158060 -41570 0 0 {name=p156765 lab=_45709_/A }
C {devices/lab_pin.sym} 158140 -41570 0 1 {name=p156766 lab=_45269_/X }
C {sky130_stdcells/buf_2.sym} 158100 -41570 0 0 {name=X_45269_ }
C {devices/lab_pin.sym} 158040 -41460 0 0 {name=p156767 lab=_68770_/X }
C {devices/lab_pin.sym} 158040 -41420 0 0 {name=p156768 lab=_68980_/B }
C {devices/lab_pin.sym} 158160 -41440 0 1 {name=p156769 lab=_68980_/X }
C {sky130_stdcells/and2_4.sym} 158100 -41440 0 0 {name=X_68980_ }
C {devices/lab_pin.sym} 158040 -41320 0 0 {name=p156770 lab=_76086_/Y }
C {devices/lab_pin.sym} 158040 -41280 0 0 {name=p156771 lab=_76089_/B }
C {devices/lab_pin.sym} 158160 -41300 0 1 {name=p156772 lab=_76090_/B }
C {sky130_stdcells/xor2_4.sym} 158100 -41300 0 0 {name=X_76089_ }
C {devices/lab_pin.sym} 158040 -41180 0 0 {name=p156773 lab=_47008_/A }
C {devices/lab_pin.sym} 158040 -41140 0 0 {name=p156774 lab=_52799_/B }
C {devices/lab_pin.sym} 158160 -41160 0 1 {name=p156775 lab=_47008_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -41160 0 0 {name=X_47008_ }
C {devices/lab_pin.sym} 158020 -41050 0 0 {name=p156776 lab=_67928_/X }
C {devices/lab_pin.sym} 158020 -41010 0 0 {name=p156777 lab=_67930_/X }
C {devices/lab_pin.sym} 158020 -40970 0 0 {name=p156778 lab=_67858_/X }
C {devices/lab_pin.sym} 158180 -41010 0 1 {name=p156779 lab=_67934_/A }
C {sky130_stdcells/a21o_4.sym} 158100 -41010 0 0 {name=X_67931_ }
C {devices/lab_pin.sym} 158020 -40890 0 0 {name=p156780 lab=_79914_/B }
C {devices/lab_pin.sym} 158020 -40850 0 0 {name=p156781 lab=_79903_/Y }
C {devices/lab_pin.sym} 158020 -40810 0 0 {name=p156782 lab=_79911_/Y }
C {devices/lab_pin.sym} 158180 -40850 0 1 {name=p156783 lab=_79928_/A }
C {sky130_stdcells/a21oi_4.sym} 158100 -40850 0 0 {name=X_79917_ }
C {devices/lab_pin.sym} 158040 -40740 0 0 {name=p156784 lab=_63054_/A }
C {devices/lab_pin.sym} 158040 -40700 0 0 {name=p156785 lab=_63081_/B }
C {devices/lab_pin.sym} 158040 -40660 0 0 {name=p156786 lab=_63081_/C }
C {devices/lab_pin.sym} 158040 -40620 0 0 {name=p156787 lab=_63033_/D }
C {devices/lab_pin.sym} 158160 -40680 0 1 {name=p156788 lab=_63054_/X }
C {sky130_stdcells/or4_4.sym} 158100 -40680 0 0 {name=X_63054_ }
C {devices/lab_pin.sym} 158020 -40570 0 0 {name=p156789 lab=_59875_/X }
C {devices/lab_pin.sym} 158020 -40530 0 0 {name=p156790 lab=_60233_/Y }
C {devices/lab_pin.sym} 158020 -40490 0 0 {name=p156791 lab=_60263_/Y }
C {devices/lab_pin.sym} 158020 -40450 0 0 {name=p156792 lab=_60264_/Y }
C {devices/lab_pin.sym} 158020 -40410 0 0 {name=p156793 lab=_60265_/X }
C {devices/lab_pin.sym} 158180 -40490 0 1 {name=p156794 lab=_84644_/D }
C {sky130_stdcells/o41a_4.sym} 158100 -40490 0 0 {name=X_60266_ }
C {devices/lab_pin.sym} 158060 -40330 0 0 {name=p156795 lab=_62005_/A }
C {devices/lab_pin.sym} 158140 -40330 0 1 {name=p156796 lab=_63586_/A }
C {sky130_stdcells/inv_2.sym} 158100 -40330 0 0 {name=X_62005_ }
C {devices/lab_pin.sym} 158040 -40220 0 0 {name=p156797 lab=_67859_/X }
C {devices/lab_pin.sym} 158040 -40180 0 0 {name=p156798 lab=_67861_/X }
C {devices/lab_pin.sym} 158160 -40200 0 1 {name=p156799 lab=_67862_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -40200 0 0 {name=X_67862_ }
C {devices/lab_pin.sym} 158040 -40080 0 0 {name=p156800 lab=_79844_/X }
C {devices/lab_pin.sym} 158040 -40040 0 0 {name=p156801 lab=_79866_/B }
C {devices/lab_pin.sym} 158160 -40060 0 1 {name=p156802 lab=_79875_/A }
C {sky130_stdcells/xor2_4.sym} 158100 -40060 0 0 {name=X_79848_ }
C {devices/lab_pin.sym} 158040 -39960 0 0 {name=p156803 lab=_60170_/A }
C {devices/lab_pin.sym} 158040 -39920 0 0 {name=p156804 lab=_60253_/A }
C {devices/lab_pin.sym} 158040 -39880 0 0 {name=p156805 lab=_60197_/C }
C {devices/lab_pin.sym} 158040 -39840 0 0 {name=p156806 lab=_60189_/Y }
C {devices/lab_pin.sym} 158160 -39900 0 1 {name=p156807 lab=_60198_/A }
C {sky130_stdcells/and4_4.sym} 158100 -39900 0 0 {name=X_60197_ }
C {devices/lab_pin.sym} 158020 -39780 0 0 {name=p156808 lab=_69579_/X }
C {devices/lab_pin.sym} 158020 -39740 0 0 {name=p156809 lab=_69599_/Y }
C {devices/lab_pin.sym} 158020 -39700 0 0 {name=p156810 lab=_69516_/X }
C {devices/lab_pin.sym} 158020 -39660 0 0 {name=p156811 lab=_69600_/Y }
C {devices/lab_pin.sym} 158180 -39720 0 1 {name=p156812 lab=_69601_/X }
C {sky130_stdcells/a211o_4.sym} 158100 -39720 0 0 {name=X_69601_ }
C {devices/lab_pin.sym} 158040 -39580 0 0 {name=p156813 lab=_66769_/A }
C {devices/lab_pin.sym} 158040 -39540 0 0 {name=p156814 lab=_88137_/Q }
C {devices/lab_pin.sym} 158160 -39560 0 1 {name=p156815 lab=_66813_/X }
C {sky130_stdcells/and2_4.sym} 158100 -39560 0 0 {name=X_66813_ }
C {devices/lab_pin.sym} 158060 -39430 0 0 {name=p156816 lab=clkbuf_9_510_0_CLK/X }
C {devices/lab_pin.sym} 158140 -39430 0 1 {name=p156817 lab=_83311_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 158100 -39430 0 0 {name=Xclkbuf_10_1020_0_CLK }
C {devices/lab_pin.sym} 158040 -39320 0 0 {name=p156818 lab=_48959_/A }
C {devices/lab_pin.sym} 158040 -39280 0 0 {name=p156819 lab=_48959_/B }
C {devices/lab_pin.sym} 158160 -39300 0 1 {name=p156820 lab=_50599_/B }
C {sky130_stdcells/nor2_4.sym} 158100 -39300 0 0 {name=X_48959_ }
C {devices/lab_pin.sym} 158020 -39190 0 0 {name=p156821 lab=_79770_/Y }
C {devices/lab_pin.sym} 158020 -39150 0 0 {name=p156822 lab=_79766_/X }
C {devices/lab_pin.sym} 158020 -39110 0 0 {name=p156823 lab=_79778_/X }
C {devices/lab_pin.sym} 158180 -39150 0 1 {name=p156824 lab=_79780_/B }
C {sky130_stdcells/a21boi_4.sym} 158100 -39150 0 0 {name=X_79779_ }
C {devices/lab_pin.sym} 158040 -39020 0 0 {name=p156825 lab=_67793_/A }
C {devices/lab_pin.sym} 158040 -38980 0 0 {name=p156826 lab=_67793_/B }
C {devices/lab_pin.sym} 158160 -39000 0 1 {name=p156827 lab=_67793_/X }
C {sky130_stdcells/and2_4.sym} 158100 -39000 0 0 {name=X_67793_ }
C {devices/lab_pin.sym} 158010 -38870 0 0 {name=p156828 lab=_81631_/CLK }
C {devices/lab_pin.sym} 158010 -38850 0 0 {name=p156829 lab=_81618_/Q }
C {devices/lab_pin.sym} 158190 -38870 0 1 {name=p156830 lab=_81810_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -38860 0 0 {name=X_81810_ }
C {devices/lab_pin.sym} 158020 -38760 0 0 {name=p156831 lab=_88022_/Q }
C {devices/lab_pin.sym} 158020 -38720 0 0 {name=p156832 lab=_69424_/X }
C {devices/lab_pin.sym} 158020 -38680 0 0 {name=p156833 lab=_69465_/X }
C {devices/lab_pin.sym} 158020 -38640 0 0 {name=p156834 lab=_69531_/X }
C {devices/lab_pin.sym} 158180 -38700 0 1 {name=p156835 lab=_69532_/X }
C {sky130_stdcells/a211o_4.sym} 158100 -38700 0 0 {name=X_69532_ }
C {devices/lab_pin.sym} 158060 -38550 0 0 {name=p156836 lab=_66625_/A }
C {devices/lab_pin.sym} 158140 -38550 0 1 {name=p156837 lab=_66795_/A }
C {sky130_stdcells/buf_2.sym} 158100 -38550 0 0 {name=X_66744_ }
C {devices/lab_pin.sym} 158040 -38440 0 0 {name=p156838 lab=_51947_/A }
C {devices/lab_pin.sym} 158040 -38400 0 0 {name=p156839 lab=_50268_/B }
C {devices/lab_pin.sym} 158160 -38420 0 1 {name=p156840 lab=_51970_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -38420 0 0 {name=X_51970_ }
C {devices/lab_pin.sym} 158040 -38320 0 0 {name=p156841 lab=_61939_/X }
C {devices/lab_pin.sym} 158040 -38280 0 0 {name=p156842 lab=_63955_/X }
C {devices/lab_pin.sym} 158040 -38240 0 0 {name=p156843 lab=_63905_/C }
C {devices/lab_pin.sym} 158040 -38200 0 0 {name=p156844 lab=_63892_/D }
C {devices/lab_pin.sym} 158160 -38260 0 1 {name=p156845 lab=_63956_/Y }
C {sky130_stdcells/nand4_4.sym} 158100 -38260 0 0 {name=X_63956_ }
C {devices/lab_pin.sym} 158010 -38110 0 0 {name=p156846 lab=_82665_/CLK }
C {devices/lab_pin.sym} 158010 -38090 0 0 {name=p156847 lab=_82822_/Q }
C {devices/lab_pin.sym} 158190 -38110 0 1 {name=p156848 lab=_78360_/B }
C {sky130_stdcells/dfxtp_4.sym} 158100 -38100 0 0 {name=X_82790_ }
C {devices/lab_pin.sym} 158040 -37980 0 0 {name=p156849 lab=_50932_/A }
C {devices/lab_pin.sym} 158040 -37940 0 0 {name=p156850 lab=_46685_/X }
C {devices/lab_pin.sym} 158160 -37960 0 1 {name=p156851 lab=_50921_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -37960 0 0 {name=X_50921_ }
C {devices/lab_pin.sym} 158040 -37850 0 0 {name=p156852 lab=_62965_/A }
C {devices/lab_pin.sym} 158040 -37810 0 0 {name=p156853 lab=_62935_/B }
C {devices/lab_pin.sym} 158040 -37770 0 0 {name=p156854 lab=_63629_/B }
C {devices/lab_pin.sym} 158160 -37810 0 1 {name=p156855 lab=_62907_/Y }
C {sky130_stdcells/nand3_4.sym} 158100 -37810 0 0 {name=X_62907_ }
C {devices/lab_pin.sym} 158010 -37670 0 0 {name=p156856 lab=_82642_/CLK }
C {devices/lab_pin.sym} 158010 -37650 0 0 {name=p156857 lab=_81741_/D }
C {devices/lab_pin.sym} 158190 -37670 0 1 {name=p156858 lab=_81741_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -37660 0 0 {name=X_81741_ }
C {devices/lab_pin.sym} 158020 -37560 0 0 {name=p156859 lab=_69423_/X }
C {devices/lab_pin.sym} 158020 -37520 0 0 {name=p156860 lab=_69461_/Y }
C {devices/lab_pin.sym} 158020 -37480 0 0 {name=p156861 lab=_69405_/X }
C {devices/lab_pin.sym} 158020 -37440 0 0 {name=p156862 lab=_69462_/Y }
C {devices/lab_pin.sym} 158180 -37500 0 1 {name=p156863 lab=_69463_/X }
C {sky130_stdcells/a211o_4.sym} 158100 -37500 0 0 {name=X_69463_ }
C {devices/lab_pin.sym} 158060 -37350 0 0 {name=p156864 lab=_66794_/A }
C {devices/lab_pin.sym} 158140 -37350 0 1 {name=p156865 lab=_66675_/X }
C {sky130_stdcells/buf_2.sym} 158100 -37350 0 0 {name=X_66675_ }
C {devices/lab_pin.sym} 158060 -37230 0 0 {name=p156866 lab=_60906_/X }
C {devices/lab_pin.sym} 158140 -37230 0 1 {name=p156867 lab=_63902_/C }
C {sky130_stdcells/buf_2.sym} 158100 -37230 0 0 {name=X_63887_ }
C {devices/lab_pin.sym} 158060 -37110 0 0 {name=p156868 lab=_68377_/A }
C {devices/lab_pin.sym} 158140 -37110 0 1 {name=p156869 lab=_68414_/X }
C {sky130_stdcells/buf_2.sym} 158100 -37110 0 0 {name=X_68414_ }
C {devices/lab_pin.sym} 158060 -36990 0 0 {name=p156870 lab=_53793_/A }
C {devices/lab_pin.sym} 158140 -36990 0 1 {name=p156871 lab=_53778_/A }
C {sky130_stdcells/buf_2.sym} 158100 -36990 0 0 {name=X_53640_ }
C {devices/lab_pin.sym} 158040 -36880 0 0 {name=p156872 lab=_65779_/A }
C {devices/lab_pin.sym} 158040 -36840 0 0 {name=p156873 lab=_86484_/Q }
C {devices/lab_pin.sym} 158160 -36860 0 1 {name=p156874 lab=_65626_/X }
C {sky130_stdcells/and2_4.sym} 158100 -36860 0 0 {name=X_65626_ }
C {devices/lab_pin.sym} 158010 -36730 0 0 {name=p156875 lab=_82436_/CLK }
C {devices/lab_pin.sym} 158010 -36710 0 0 {name=p156876 lab=_84460_/D }
C {devices/lab_pin.sym} 158190 -36730 0 1 {name=p156877 lab=_79128_/B }
C {sky130_stdcells/dfxtp_4.sym} 158100 -36720 0 0 {name=X_84460_ }
C {devices/lab_pin.sym} 158040 -36600 0 0 {name=p156878 lab=_50806_/A }
C {devices/lab_pin.sym} 158040 -36560 0 0 {name=p156879 lab=_50852_/B }
C {devices/lab_pin.sym} 158160 -36580 0 1 {name=p156880 lab=_50852_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -36580 0 0 {name=X_50852_ }
C {devices/lab_pin.sym} 158060 -36450 0 0 {name=p156881 lab=_62893_/A }
C {devices/lab_pin.sym} 158140 -36450 0 1 {name=p156882 lab=_62838_/X }
C {sky130_stdcells/buf_2.sym} 158100 -36450 0 0 {name=X_62838_ }
C {devices/lab_pin.sym} 158010 -36330 0 0 {name=p156883 lab=_81282_/CLK }
C {devices/lab_pin.sym} 158010 -36310 0 0 {name=p156884 lab=_79993_/X }
C {devices/lab_pin.sym} 158190 -36330 0 1 {name=p156885 lab=_76847_/A }
C {sky130_stdcells/dfxtp_4.sym} 158100 -36320 0 0 {name=X_81672_ }
C {devices/lab_pin.sym} 158040 -36200 0 0 {name=p156886 lab=_69286_/A }
C {devices/lab_pin.sym} 158040 -36160 0 0 {name=p156887 lab=_87776_/Q }
C {devices/lab_pin.sym} 158160 -36180 0 1 {name=p156888 lab=_69394_/X }
C {sky130_stdcells/and2_4.sym} 158100 -36180 0 0 {name=X_69394_ }
C {devices/lab_pin.sym} 158010 -36050 0 0 {name=p156889 lab=_83414_/CLK }
C {devices/lab_pin.sym} 158010 -36030 0 0 {name=p156890 lab=_83411_/D }
C {devices/lab_pin.sym} 158190 -36050 0 1 {name=p156891 lab=_83411_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -36040 0 0 {name=X_83411_ }
C {devices/lab_pin.sym} 158040 -35920 0 0 {name=p156892 lab=_80623_/A }
C {devices/lab_pin.sym} 158040 -35880 0 0 {name=p156893 lab=_80615_/Y }
C {devices/lab_pin.sym} 158160 -35900 0 1 {name=p156894 lab=_80623_/X }
C {sky130_stdcells/or2_4.sym} 158100 -35900 0 0 {name=X_80623_ }
C {devices/lab_pin.sym} 158060 -35770 0 0 {name=p156895 lab=_66560_/X }
C {devices/lab_pin.sym} 158140 -35770 0 1 {name=p156896 lab=_69645_/A }
C {sky130_stdcells/buf_2.sym} 158100 -35770 0 0 {name=X_68345_ }
C {devices/lab_pin.sym} 158020 -35670 0 0 {name=p156897 lab=_53568_/Y }
C {devices/lab_pin.sym} 158020 -35630 0 0 {name=p156898 lab=_53537_/X }
C {devices/lab_pin.sym} 158020 -35590 0 0 {name=p156899 lab=_53570_/X }
C {devices/lab_pin.sym} 158180 -35630 0 1 {name=p156900 lab=_85611_/D }
C {sky130_stdcells/a21oi_4.sym} 158100 -35630 0 0 {name=X_53571_ }
C {devices/lab_pin.sym} 158040 -35500 0 0 {name=p156901 lab=_65557_/A }
C {devices/lab_pin.sym} 158040 -35460 0 0 {name=p156902 lab=_65556_/Y }
C {devices/lab_pin.sym} 158160 -35480 0 1 {name=p156903 lab=_65557_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -35480 0 0 {name=X_65557_ }
C {devices/lab_pin.sym} 158010 -35350 0 0 {name=p156904 lab=_84392_/CLK }
C {devices/lab_pin.sym} 158010 -35330 0 0 {name=p156905 lab=_62688_/Y }
C {devices/lab_pin.sym} 158190 -35350 0 1 {name=p156906 lab=_84391_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -35340 0 0 {name=X_84391_ }
C {devices/lab_pin.sym} 158040 -35220 0 0 {name=p156907 lab=_50764_/A }
C {devices/lab_pin.sym} 158040 -35180 0 0 {name=p156908 lab=_52478_/B }
C {devices/lab_pin.sym} 158160 -35200 0 1 {name=p156909 lab=_50783_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -35200 0 0 {name=X_50783_ }
C {devices/lab_pin.sym} 158060 -35070 0 0 {name=p156910 lab=_62979_/A }
C {devices/lab_pin.sym} 158140 -35070 0 1 {name=p156911 lab=_62819_/A }
C {sky130_stdcells/buf_2.sym} 158100 -35070 0 0 {name=X_62769_ }
C {devices/lab_pin.sym} 158020 -34970 0 0 {name=p156912 lab=_55304_/X }
C {devices/lab_pin.sym} 158020 -34930 0 0 {name=p156913 lab=_55308_/X }
C {devices/lab_pin.sym} 158020 -34890 0 0 {name=p156914 lab=_55309_/X }
C {devices/lab_pin.sym} 158180 -34930 0 1 {name=p156915 lab=_55310_/X }
C {sky130_stdcells/a21o_4.sym} 158100 -34930 0 0 {name=X_55310_ }
C {devices/lab_pin.sym} 158010 -34790 0 0 {name=p156916 lab=_86139_/CLK }
C {devices/lab_pin.sym} 158010 -34770 0 0 {name=p156917 lab=_50803_/Y }
C {devices/lab_pin.sym} 158190 -34790 0 1 {name=p156918 lab=_86130_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -34780 0 0 {name=X_86130_ }
C {devices/lab_pin.sym} 158040 -34660 0 0 {name=p156919 lab=_52518_/A }
C {devices/lab_pin.sym} 158040 -34620 0 0 {name=p156920 lab=_52522_/B }
C {devices/lab_pin.sym} 158160 -34640 0 1 {name=p156921 lab=_52522_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -34640 0 0 {name=X_52522_ }
C {devices/lab_pin.sym} 158060 -34510 0 0 {name=p156922 lab=_64508_/A }
C {devices/lab_pin.sym} 158140 -34510 0 1 {name=p156923 lab=_64741_/B }
C {sky130_stdcells/buf_2.sym} 158100 -34510 0 0 {name=X_64508_ }
C {devices/lab_pin.sym} 158010 -34390 0 0 {name=p156924 lab=_83491_/CLK }
C {devices/lab_pin.sym} 158010 -34370 0 0 {name=p156925 lab=_71882_/X }
C {devices/lab_pin.sym} 158190 -34390 0 1 {name=p156926 lab=_83342_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -34380 0 0 {name=X_83342_ }
C {devices/lab_pin.sym} 158060 -34250 0 0 {name=p156927 lab=_56360_/A }
C {devices/lab_pin.sym} 158140 -34250 0 1 {name=p156928 lab=_56290_/X }
C {sky130_stdcells/buf_2.sym} 158100 -34250 0 0 {name=X_56290_ }
C {devices/lab_pin.sym} 158020 -34150 0 0 {name=p156929 lab=_80551_/Y }
C {devices/lab_pin.sym} 158020 -34110 0 0 {name=p156930 lab=_80534_/Y }
C {devices/lab_pin.sym} 158020 -34070 0 0 {name=p156931 lab=_80553_/X }
C {devices/lab_pin.sym} 158180 -34110 0 1 {name=p156932 lab=_80554_/Y }
C {sky130_stdcells/o21ai_4.sym} 158100 -34110 0 0 {name=X_80554_ }
C {devices/lab_pin.sym} 158020 -33990 0 0 {name=p156933 lab=_67705_/X }
C {devices/lab_pin.sym} 158020 -33950 0 0 {name=p156934 lab=_67708_/X }
C {devices/lab_pin.sym} 158020 -33910 0 0 {name=p156935 lab=_68239_/X }
C {devices/lab_pin.sym} 158180 -33950 0 1 {name=p156936 lab=_68276_/Y }
C {sky130_stdcells/a21oi_4.sym} 158100 -33950 0 0 {name=X_68276_ }
C {devices/lab_pin.sym} 158020 -33840 0 0 {name=p156937 lab=_65484_/X }
C {devices/lab_pin.sym} 158020 -33800 0 0 {name=p156938 lab=_86205_/Q }
C {devices/lab_pin.sym} 158020 -33760 0 0 {name=p156939 lab=_65400_/X }
C {devices/lab_pin.sym} 158020 -33720 0 0 {name=p156940 lab=_65487_/X }
C {devices/lab_pin.sym} 158180 -33780 0 1 {name=p156941 lab=_65488_/X }
C {sky130_stdcells/a211o_4.sym} 158100 -33780 0 0 {name=X_65488_ }
C {devices/lab_pin.sym} 158040 -33640 0 0 {name=p156942 lab=_55228_/Y }
C {devices/lab_pin.sym} 158040 -33600 0 0 {name=p156943 lab=_55241_/B }
C {devices/lab_pin.sym} 158160 -33620 0 1 {name=p156944 lab=_55243_/A }
C {sky130_stdcells/nand2_4.sym} 158100 -33620 0 0 {name=X_55241_ }
C {devices/lab_pin.sym} 158040 -33500 0 0 {name=p156945 lab=_67250_/A }
C {devices/lab_pin.sym} 158040 -33460 0 0 {name=p156946 lab=_67227_/B }
C {devices/lab_pin.sym} 158160 -33480 0 1 {name=p156947 lab=_67227_/X }
C {sky130_stdcells/and2_4.sym} 158100 -33480 0 0 {name=X_67227_ }
C {devices/lab_pin.sym} 158010 -33350 0 0 {name=p156948 lab=_85741_/CLK }
C {devices/lab_pin.sym} 158010 -33330 0 0 {name=p156949 lab=_51172_/Y }
C {devices/lab_pin.sym} 158190 -33350 0 1 {name=p156950 lab=_86061_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -33340 0 0 {name=X_86061_ }
C {devices/lab_pin.sym} 158020 -33230 0 0 {name=p156951 lab=_85819_/Q }
C {devices/lab_pin.sym} 158020 -33190 0 0 {name=p156952 lab=_52438_/X }
C {devices/lab_pin.sym} 158020 -33150 0 0 {name=p156953 lab=_52452_/Y }
C {devices/lab_pin.sym} 158180 -33190 0 1 {name=p156954 lab=_52453_/Y }
C {sky130_stdcells/o21ai_4.sym} 158100 -33190 0 0 {name=X_52453_ }
C {devices/lab_pin.sym} 158010 -33050 0 0 {name=p156955 lab=_85335_/CLK }
C {devices/lab_pin.sym} 158010 -33030 0 0 {name=p156956 lab=_83273_/D }
C {devices/lab_pin.sym} 158190 -33050 0 1 {name=p156957 lab=_72214_/A }
C {sky130_stdcells/dfxtp_4.sym} 158100 -33040 0 0 {name=X_83273_ }
C {devices/lab_pin.sym} 158020 -32930 0 0 {name=p156958 lab=_58261_/Y }
C {devices/lab_pin.sym} 158020 -32890 0 0 {name=p156959 lab=_64423_/X }
C {devices/lab_pin.sym} 158020 -32850 0 0 {name=p156960 lab=_64438_/Y }
C {devices/lab_pin.sym} 158180 -32890 0 1 {name=p156961 lab=_64439_/Y }
C {sky130_stdcells/o21ai_4.sym} 158100 -32890 0 0 {name=X_64439_ }
C {devices/lab_pin.sym} 158040 -32760 0 0 {name=p156962 lab=_80494_/A }
C {devices/lab_pin.sym} 158040 -32720 0 0 {name=p156963 lab=_80494_/B }
C {devices/lab_pin.sym} 158160 -32740 0 1 {name=p156964 lab=_80485_/Y }
C {sky130_stdcells/xnor2_4.sym} 158100 -32740 0 0 {name=X_80485_ }
C {devices/lab_pin.sym} 158010 -32610 0 0 {name=p156965 lab=_85075_/CLK }
C {devices/lab_pin.sym} 158010 -32590 0 0 {name=p156966 lab=_85012_/D }
C {devices/lab_pin.sym} 158190 -32610 0 1 {name=p156967 lab=_45599_/A }
C {sky130_stdcells/dfxtp_4.sym} 158100 -32600 0 0 {name=X_85012_ }
C {devices/lab_pin.sym} 158040 -32480 0 0 {name=p156968 lab=_51403_/X }
C {devices/lab_pin.sym} 158040 -32440 0 0 {name=p156969 lab=_52931_/B }
C {devices/lab_pin.sym} 158160 -32460 0 1 {name=p156970 lab=_51404_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -32460 0 0 {name=X_51404_ }
C {devices/lab_pin.sym} 158010 -32330 0 0 {name=p156971 lab=_81857_/CLK }
C {devices/lab_pin.sym} 158010 -32310 0 0 {name=p156972 lab=_82256_/Q }
C {devices/lab_pin.sym} 158190 -32330 0 1 {name=p156973 lab=_77422_/A }
C {sky130_stdcells/dfxtp_4.sym} 158100 -32320 0 0 {name=X_82224_ }
C {devices/lab_pin.sym} 158060 -32190 0 0 {name=p156974 lab=_55172_/A }
C {devices/lab_pin.sym} 158140 -32190 0 1 {name=p156975 lab=_55172_/X }
C {sky130_stdcells/buf_2.sym} 158100 -32190 0 0 {name=X_55172_ }
C {devices/lab_pin.sym} 158020 -32100 0 0 {name=p156976 lab=_87419_/Q }
C {devices/lab_pin.sym} 158020 -32060 0 0 {name=p156977 lab=_67156_/X }
C {devices/lab_pin.sym} 158020 -32020 0 0 {name=p156978 lab=_67106_/X }
C {devices/lab_pin.sym} 158020 -31980 0 0 {name=p156979 lab=_67157_/X }
C {devices/lab_pin.sym} 158180 -32040 0 1 {name=p156980 lab=_67158_/X }
C {sky130_stdcells/a211o_4.sym} 158100 -32040 0 0 {name=X_67158_ }
C {devices/lab_pin.sym} 158020 -31910 0 0 {name=p156981 lab=_65225_/B }
C {devices/lab_pin.sym} 158020 -31870 0 0 {name=p156982 lab=_52372_/X }
C {devices/lab_pin.sym} 158020 -31830 0 0 {name=p156983 lab=_52383_/Y }
C {devices/lab_pin.sym} 158180 -31870 0 1 {name=p156984 lab=_52384_/Y }
C {sky130_stdcells/o21ai_4.sym} 158100 -31870 0 0 {name=X_52384_ }
C {devices/lab_pin.sym} 158040 -31760 0 0 {name=p156985 lab=_54123_/A }
C {devices/lab_pin.sym} 158040 -31720 0 0 {name=p156986 lab=_54123_/B }
C {devices/lab_pin.sym} 158040 -31680 0 0 {name=p156987 lab=_54118_/X }
C {devices/lab_pin.sym} 158040 -31640 0 0 {name=p156988 lab=_52954_/D }
C {devices/lab_pin.sym} 158160 -31700 0 1 {name=p156989 lab=_54123_/X }
C {sky130_stdcells/and4_4.sym} 158100 -31700 0 0 {name=X_54123_ }
C {devices/lab_pin.sym} 158040 -31570 0 0 {name=p156990 lab=_66164_/A }
C {devices/lab_pin.sym} 158040 -31530 0 0 {name=p156991 lab=_66164_/B }
C {devices/lab_pin.sym} 158040 -31490 0 0 {name=p156992 lab=_66109_/C }
C {devices/lab_pin.sym} 158160 -31530 0 1 {name=p156993 lab=_66109_/Y }
C {sky130_stdcells/nor3_4.sym} 158100 -31530 0 0 {name=X_66109_ }
C {devices/lab_pin.sym} 158040 -31400 0 0 {name=p156994 lab=_51350_/A }
C {devices/lab_pin.sym} 158040 -31360 0 0 {name=p156995 lab=_50827_/B }
C {devices/lab_pin.sym} 158160 -31380 0 1 {name=p156996 lab=_51335_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -31380 0 0 {name=X_51335_ }
C {devices/lab_pin.sym} 158010 -31250 0 0 {name=p156997 lab=_84220_/CLK }
C {devices/lab_pin.sym} 158010 -31230 0 0 {name=p156998 lab=_80397_/B }
C {devices/lab_pin.sym} 158190 -31250 0 1 {name=p156999 lab=_82155_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -31240 0 0 {name=X_82155_ }
C {devices/lab_pin.sym} 158020 -31130 0 0 {name=p157000 lab=_67086_/X }
C {devices/lab_pin.sym} 158020 -31090 0 0 {name=p157001 lab=_67088_/X }
C {devices/lab_pin.sym} 158020 -31050 0 0 {name=p157002 lab=_67015_/X }
C {devices/lab_pin.sym} 158180 -31090 0 1 {name=p157003 lab=_67089_/Y }
C {sky130_stdcells/a21oi_4.sym} 158100 -31090 0 0 {name=X_67089_ }
C {devices/lab_pin.sym} 158060 -30950 0 0 {name=p157004 lab=_60781_/A }
C {devices/lab_pin.sym} 158140 -30950 0 1 {name=p157005 lab=_59980_/X }
C {sky130_stdcells/buf_2.sym} 158100 -30950 0 0 {name=X_59980_ }
C {devices/lab_pin.sym} 158010 -30830 0 0 {name=p157006 lab=_81070_/CLK }
C {devices/lab_pin.sym} 158010 -30810 0 0 {name=p157007 lab=_79729_/X }
C {devices/lab_pin.sym} 158190 -30830 0 1 {name=p157008 lab=_75574_/A }
C {sky130_stdcells/dfxtp_4.sym} 158100 -30820 0 0 {name=X_81106_ }
C {devices/lab_pin.sym} 158020 -30710 0 0 {name=p157009 lab=_58927_/Y }
C {devices/lab_pin.sym} 158020 -30670 0 0 {name=p157010 lab=_58930_/Y }
C {devices/lab_pin.sym} 158020 -30630 0 0 {name=p157011 lab=_58883_/X }
C {devices/lab_pin.sym} 158180 -30670 0 1 {name=p157012 lab=_58931_/X }
C {sky130_stdcells/a21o_4.sym} 158100 -30670 0 0 {name=X_58931_ }
C {devices/lab_pin.sym} 158040 -30540 0 0 {name=p157013 lab=_54020_/A }
C {devices/lab_pin.sym} 158040 -30500 0 0 {name=p157014 lab=_54054_/B }
C {devices/lab_pin.sym} 158160 -30520 0 1 {name=p157015 lab=_54054_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -30520 0 0 {name=X_54054_ }
C {devices/lab_pin.sym} 158040 -30410 0 0 {name=p157016 lab=_50755_/A }
C {devices/lab_pin.sym} 158040 -30370 0 0 {name=p157017 lab=_51266_/B }
C {devices/lab_pin.sym} 158040 -30330 0 0 {name=p157018 lab=_51330_/C }
C {devices/lab_pin.sym} 158160 -30370 0 1 {name=p157019 lab=_51266_/X }
C {sky130_stdcells/and3_4.sym} 158100 -30370 0 0 {name=X_51266_ }
C {devices/lab_pin.sym} 158010 -30230 0 0 {name=p157020 lab=_86934_/CLK }
C {devices/lab_pin.sym} 158010 -30210 0 0 {name=p157021 lab=_86963_/D }
C {devices/lab_pin.sym} 158190 -30230 0 1 {name=p157022 lab=_86963_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -30220 0 0 {name=X_86963_ }
C {devices/lab_pin.sym} 158010 -30090 0 0 {name=p157023 lab=_81970_/CLK }
C {devices/lab_pin.sym} 158010 -30070 0 0 {name=p157024 lab=_82086_/D }
C {devices/lab_pin.sym} 158190 -30090 0 1 {name=p157025 lab=_82086_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -30080 0 0 {name=X_82086_ }
C {devices/lab_pin.sym} 158040 -29960 0 0 {name=p157026 lab=_52999_/A }
C {devices/lab_pin.sym} 158040 -29920 0 0 {name=p157027 lab=_53005_/B }
C {devices/lab_pin.sym} 158160 -29940 0 1 {name=p157028 lab=_53005_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -29940 0 0 {name=X_53005_ }
C {devices/lab_pin.sym} 158060 -29810 0 0 {name=p157029 lab=_50217_/A }
C {devices/lab_pin.sym} 158140 -29810 0 1 {name=p157030 lab=_50217_/Y }
C {sky130_stdcells/inv_2.sym} 158100 -29810 0 0 {name=X_50217_ }
C {devices/lab_pin.sym} 158010 -29690 0 0 {name=p157031 lab=_86238_/CLK }
C {devices/lab_pin.sym} 158010 -29670 0 0 {name=p157032 lab=_85914_/D }
C {devices/lab_pin.sym} 158190 -29690 0 1 {name=p157033 lab=_66006_/B }
C {sky130_stdcells/dfxtp_4.sym} 158100 -29680 0 0 {name=X_85914_ }
C {devices/lab_pin.sym} 158010 -29550 0 0 {name=p157034 lab=_81061_/CLK }
C {devices/lab_pin.sym} 158010 -29530 0 0 {name=p157035 lab=_81037_/D }
C {devices/lab_pin.sym} 158190 -29550 0 1 {name=p157036 lab=_81229_/D }
C {sky130_stdcells/dfxtp_4.sym} 158100 -29540 0 0 {name=X_81037_ }
C {devices/lab_pin.sym} 158020 -29430 0 0 {name=p157037 lab=_58796_/X }
C {devices/lab_pin.sym} 158020 -29390 0 0 {name=p157038 lab=_86090_/Q }
C {devices/lab_pin.sym} 158020 -29350 0 0 {name=p157039 lab=_58861_/X }
C {devices/lab_pin.sym} 158180 -29390 0 1 {name=p157040 lab=_58862_/Y }
C {sky130_stdcells/o21ai_4.sym} 158100 -29390 0 0 {name=X_58862_ }
C {devices/lab_pin.sym} 158040 -29280 0 0 {name=p157041 lab=_51191_/X }
C {devices/lab_pin.sym} 158040 -29240 0 0 {name=p157042 lab=_51192_/B }
C {devices/lab_pin.sym} 158040 -29200 0 0 {name=p157043 lab=_51197_/C }
C {devices/lab_pin.sym} 158040 -29160 0 0 {name=p157044 lab=_52887_/D }
C {devices/lab_pin.sym} 158160 -29220 0 1 {name=p157045 lab=_51197_/X }
C {sky130_stdcells/and4_4.sym} 158100 -29220 0 0 {name=X_51197_ }
C {devices/lab_pin.sym} 158010 -29070 0 0 {name=p157046 lab=_86896_/CLK }
C {devices/lab_pin.sym} 158010 -29050 0 0 {name=p157047 lab=_45173_/Y }
C {devices/lab_pin.sym} 158190 -29070 0 1 {name=p157048 lab=_64411_/B }
C {sky130_stdcells/dfxtp_4.sym} 158100 -29060 0 0 {name=X_86894_ }
C {devices/lab_pin.sym} 158020 -28950 0 0 {name=p157049 lab=_57811_/X }
C {devices/lab_pin.sym} 158020 -28910 0 0 {name=p157050 lab=_85404_/Q }
C {devices/lab_pin.sym} 158020 -28870 0 0 {name=p157051 lab=_57812_/X }
C {devices/lab_pin.sym} 158180 -28910 0 1 {name=p157052 lab=_57813_/Y }
C {sky130_stdcells/o21ai_4.sym} 158100 -28910 0 0 {name=X_57813_ }
C {devices/lab_pin.sym} 158020 -28790 0 0 {name=p157053 lab=_50145_/Y }
C {devices/lab_pin.sym} 158020 -28750 0 0 {name=p157054 lab=_50141_/X }
C {devices/lab_pin.sym} 158020 -28710 0 0 {name=p157055 lab=_50147_/X }
C {devices/lab_pin.sym} 158180 -28750 0 1 {name=p157056 lab=_86255_/D }
C {sky130_stdcells/a21oi_4.sym} 158100 -28750 0 0 {name=X_50148_ }
C {devices/lab_pin.sym} 158010 -28610 0 0 {name=p157057 lab=_85555_/CLK }
C {devices/lab_pin.sym} 158010 -28590 0 0 {name=p157058 lab=_52329_/Y }
C {devices/lab_pin.sym} 158190 -28610 0 1 {name=p157059 lab=_85845_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -28600 0 0 {name=X_85845_ }
C {devices/lab_pin.sym} 158060 -28470 0 0 {name=p157060 lab=_58793_/A }
C {devices/lab_pin.sym} 158140 -28470 0 1 {name=p157061 lab=_58793_/X }
C {sky130_stdcells/buf_2.sym} 158100 -28470 0 0 {name=X_58793_ }
C {devices/lab_pin.sym} 158020 -28380 0 0 {name=p157062 lab=_72750_/X }
C {devices/lab_pin.sym} 158020 -28340 0 0 {name=p157063 lab=_85599_/Q }
C {devices/lab_pin.sym} 158020 -28300 0 0 {name=p157064 lab=_44130_/X }
C {devices/lab_pin.sym} 158020 -28260 0 0 {name=p157065 lab=_72809_/X }
C {devices/lab_pin.sym} 158180 -28320 0 1 {name=p157066 lab=_72810_/X }
C {sky130_stdcells/a211o_4.sym} 158100 -28320 0 0 {name=X_72810_ }
C {devices/lab_pin.sym} 158040 -28180 0 0 {name=p157067 lab=_44151_/X }
C {devices/lab_pin.sym} 158040 -28140 0 0 {name=p157068 lab=_86334_/Q }
C {devices/lab_pin.sym} 158160 -28160 0 1 {name=p157069 lab=_57744_/Y }
C {sky130_stdcells/nor2_4.sym} 158100 -28160 0 0 {name=X_57744_ }
C {devices/lab_pin.sym} 158060 -28030 0 0 {name=p157070 lab=_43774_/A }
C {devices/lab_pin.sym} 158140 -28030 0 1 {name=p157071 lab=_42970_/X }
C {sky130_stdcells/buf_2.sym} 158100 -28030 0 0 {name=X_42970_ }
C {devices/lab_pin.sym} 158020 -27930 0 0 {name=p157072 lab=_50076_/Y }
C {devices/lab_pin.sym} 158020 -27890 0 0 {name=p157073 lab=_50068_/X }
C {devices/lab_pin.sym} 158020 -27850 0 0 {name=p157074 lab=_50078_/X }
C {devices/lab_pin.sym} 158180 -27890 0 1 {name=p157075 lab=_86269_/D }
C {sky130_stdcells/a21oi_4.sym} 158100 -27890 0 0 {name=X_50079_ }
C {devices/lab_pin.sym} 158020 -27770 0 0 {name=p157076 lab=_54954_/Y }
C {devices/lab_pin.sym} 158020 -27730 0 0 {name=p157077 lab=_54936_/X }
C {devices/lab_pin.sym} 158020 -27690 0 0 {name=p157078 lab=_54955_/X }
C {devices/lab_pin.sym} 158180 -27730 0 1 {name=p157079 lab=_85346_/D }
C {sky130_stdcells/a21oi_4.sym} 158100 -27730 0 0 {name=X_54956_ }
C {devices/lab_pin.sym} 158040 -27600 0 0 {name=p157080 lab=_53501_/B }
C {devices/lab_pin.sym} 158040 -27560 0 0 {name=p157081 lab=_73789_/Y }
C {devices/lab_pin.sym} 158160 -27580 0 1 {name=p157082 lab=_73790_/X }
C {sky130_stdcells/xor2_4.sym} 158100 -27580 0 0 {name=X_73790_ }
C {devices/lab_pin.sym} 158010 -27450 0 0 {name=p157083 lab=_85778_/CLK }
C {devices/lab_pin.sym} 158010 -27430 0 0 {name=p157084 lab=_85776_/D }
C {devices/lab_pin.sym} 158190 -27450 0 1 {name=p157085 lab=_85776_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -27440 0 0 {name=X_85776_ }
C {devices/lab_pin.sym} 158010 -27310 0 0 {name=p157086 lab=_82987_/CLK }
C {devices/lab_pin.sym} 158010 -27290 0 0 {name=p157087 lab=_74678_/Y }
C {devices/lab_pin.sym} 158190 -27310 0 1 {name=p157088 lab=_45727_/A }
C {sky130_stdcells/dfxtp_4.sym} 158100 -27300 0 0 {name=X_82988_ }
C {devices/lab_pin.sym} 158010 -27170 0 0 {name=p157089 lab=_87273_/CLK }
C {devices/lab_pin.sym} 158010 -27150 0 0 {name=p157090 lab=_87515_/D }
C {devices/lab_pin.sym} 158190 -27170 0 1 {name=p157091 lab=_87515_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -27160 0 0 {name=X_87515_ }
C {devices/lab_pin.sym} 158020 -27070 0 0 {name=p157092 lab=_41887_/X }
C {devices/lab_pin.sym} 158020 -27030 0 0 {name=p157093 lab=_41919_/X }
C {devices/lab_pin.sym} 158020 -26990 0 0 {name=p157094 lab=_40646_/X }
C {devices/lab_pin.sym} 158020 -26950 0 0 {name=p157095 lab=_41920_/Y }
C {devices/lab_pin.sym} 158020 -26910 0 0 {name=p157096 lab=_41891_/X }
C {devices/lab_pin.sym} 158180 -26990 0 1 {name=p157097 lab=_88105_/D }
C {sky130_stdcells/o32ai_4.sym} 158100 -26990 0 0 {name=X_41921_ }
C {devices/lab_pin.sym} 158020 -26850 0 0 {name=p157098 lab=_53905_/Y }
C {devices/lab_pin.sym} 158020 -26810 0 0 {name=p157099 lab=_53862_/X }
C {devices/lab_pin.sym} 158020 -26770 0 0 {name=p157100 lab=_53906_/Y }
C {devices/lab_pin.sym} 158180 -26810 0 1 {name=p157101 lab=_85545_/D }
C {sky130_stdcells/a21boi_4.sym} 158100 -26810 0 0 {name=X_53907_ }
C {devices/lab_pin.sym} 158060 -26670 0 0 {name=p157102 lab=_73007_/A }
C {devices/lab_pin.sym} 158140 -26670 0 1 {name=p157103 lab=_72741_/X }
C {sky130_stdcells/buf_2.sym} 158100 -26670 0 0 {name=X_72741_ }
C {devices/lab_pin.sym} 158010 -26550 0 0 {name=p157104 lab=_84727_/CLK }
C {devices/lab_pin.sym} 158010 -26530 0 0 {name=p157105 lab=_84727_/D }
C {devices/lab_pin.sym} 158190 -26550 0 1 {name=p157106 lab=_59456_/A }
C {sky130_stdcells/dfxtp_4.sym} 158100 -26540 0 0 {name=X_84727_ }
C {devices/lab_pin.sym} 158040 -26420 0 0 {name=p157107 lab=_58230_/A }
C {devices/lab_pin.sym} 158040 -26380 0 0 {name=p157108 lab=_57674_/Y }
C {devices/lab_pin.sym} 158160 -26400 0 1 {name=p157109 lab=_57675_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -26400 0 0 {name=X_57675_ }
C {devices/lab_pin.sym} 158010 -26270 0 0 {name=p157110 lab=_81954_/CLK }
C {devices/lab_pin.sym} 158010 -26250 0 0 {name=p157111 lab=_81939_/D }
C {devices/lab_pin.sym} 158190 -26270 0 1 {name=p157112 lab=_77485_/A }
C {sky130_stdcells/dfxtp_4.sym} 158100 -26260 0 0 {name=X_81939_ }
C {devices/lab_pin.sym} 158060 -26130 0 0 {name=p157113 lab=clkbuf_8_96_0_CLK/X }
C {devices/lab_pin.sym} 158140 -26130 0 1 {name=p157114 lab=clkbuf_9_193_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 158100 -26130 0 0 {name=Xclkbuf_9_193_0_CLK }
C {devices/lab_pin.sym} 158060 -26010 0 0 {name=p157115 lab=_54344_/A }
C {devices/lab_pin.sym} 158140 -26010 0 1 {name=p157116 lab=_54888_/A }
C {sky130_stdcells/buf_2.sym} 158100 -26010 0 0 {name=X_54887_ }
C {devices/lab_pin.sym} 158060 -25890 0 0 {name=p157117 lab=_59413_/Y }
C {devices/lab_pin.sym} 158140 -25890 0 1 {name=p157118 lab=_59415_/A }
C {sky130_stdcells/buf_2.sym} 158100 -25890 0 0 {name=X_59414_ }
C {devices/lab_pin.sym} 158060 -25770 0 0 {name=p157119 lab=_44714_/A }
C {devices/lab_pin.sym} 158140 -25770 0 1 {name=p157120 lab=_44640_/X }
C {sky130_stdcells/buf_2.sym} 158100 -25770 0 0 {name=X_44640_ }
C {devices/lab_pin.sym} 158060 -25650 0 0 {name=p157121 lab=_56626_/A }
C {devices/lab_pin.sym} 158140 -25650 0 1 {name=p157122 lab=_56626_/X }
C {sky130_stdcells/buf_2.sym} 158100 -25650 0 0 {name=X_56626_ }
C {devices/lab_pin.sym} 158010 -25530 0 0 {name=p157123 lab=_87446_/CLK }
C {devices/lab_pin.sym} 158010 -25510 0 0 {name=p157124 lab=_87446_/D }
C {devices/lab_pin.sym} 158190 -25530 0 1 {name=p157125 lab=_87446_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -25520 0 0 {name=X_87446_ }
C {devices/lab_pin.sym} 158020 -25410 0 0 {name=p157126 lab=_75442_/Y }
C {devices/lab_pin.sym} 158020 -25370 0 0 {name=p157127 lab=_75443_/Y }
C {devices/lab_pin.sym} 158020 -25330 0 0 {name=p157128 lab=_75445_/A }
C {devices/lab_pin.sym} 158180 -25370 0 1 {name=p157129 lab=_75461_/A }
C {sky130_stdcells/o21a_4.sym} 158100 -25370 0 0 {name=X_75460_ }
C {devices/lab_pin.sym} 158020 -25260 0 0 {name=p157130 lab=_40520_/X }
C {devices/lab_pin.sym} 158020 -25220 0 0 {name=p157131 lab=_41847_/X }
C {devices/lab_pin.sym} 158020 -25180 0 0 {name=p157132 lab=_67183_/B }
C {devices/lab_pin.sym} 158020 -25140 0 0 {name=p157133 lab=_41848_/X }
C {devices/lab_pin.sym} 158180 -25200 0 1 {name=p157134 lab=_88122_/D }
C {sky130_stdcells/a2bb2o_4.sym} 158100 -25200 0 0 {name=X_41852_ }
C {devices/lab_pin.sym} 158060 -25050 0 0 {name=p157135 lab=_53838_/A }
C {devices/lab_pin.sym} 158140 -25050 0 1 {name=p157136 lab=_53838_/X }
C {sky130_stdcells/buf_2.sym} 158100 -25050 0 0 {name=X_53838_ }
C {devices/lab_pin.sym} 158060 -24930 0 0 {name=p157137 lab=_72630_/X }
C {devices/lab_pin.sym} 158140 -24930 0 1 {name=p157138 lab=_72672_/X }
C {sky130_stdcells/buf_2.sym} 158100 -24930 0 0 {name=X_72672_ }
C {devices/lab_pin.sym} 158010 -24810 0 0 {name=p157139 lab=_84503_/CLK }
C {devices/lab_pin.sym} 158010 -24790 0 0 {name=p157140 lab=_60126_/Y }
C {devices/lab_pin.sym} 158190 -24810 0 1 {name=p157141 lab=_84658_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -24800 0 0 {name=X_84658_ }
C {devices/lab_pin.sym} 158020 -24690 0 0 {name=p157142 lab=_74409_/Y }
C {devices/lab_pin.sym} 158020 -24650 0 0 {name=p157143 lab=_74405_/X }
C {devices/lab_pin.sym} 158020 -24610 0 0 {name=p157144 lab=_74410_/X }
C {devices/lab_pin.sym} 158180 -24650 0 1 {name=p157145 lab=_74411_/Y }
C {sky130_stdcells/a21oi_4.sym} 158100 -24650 0 0 {name=X_74411_ }
C {devices/lab_pin.sym} 158020 -24540 0 0 {name=p157146 lab=_40802_/X }
C {devices/lab_pin.sym} 158020 -24500 0 0 {name=p157147 lab=_40793_/X }
C {devices/lab_pin.sym} 158020 -24460 0 0 {name=p157148 lab=_88332_/Q }
C {devices/lab_pin.sym} 158020 -24420 0 0 {name=p157149 lab=_40794_/X }
C {devices/lab_pin.sym} 158180 -24480 0 1 {name=p157150 lab=_88332_/D }
C {sky130_stdcells/a2bb2o_4.sym} 158100 -24480 0 0 {name=X_40803_ }
C {devices/lab_pin.sym} 158060 -24330 0 0 {name=p157151 lab=_64678_/A }
C {devices/lab_pin.sym} 158140 -24330 0 1 {name=p157152 lab=_59345_/X }
C {sky130_stdcells/buf_2.sym} 158100 -24330 0 0 {name=X_59345_ }
C {devices/lab_pin.sym} 158020 -24230 0 0 {name=p157153 lab=_71603_/Y }
C {devices/lab_pin.sym} 158020 -24190 0 0 {name=p157154 lab=_83434_/Q }
C {devices/lab_pin.sym} 158020 -24150 0 0 {name=p157155 lab=_71622_/Y }
C {devices/lab_pin.sym} 158180 -24190 0 1 {name=p157156 lab=_71623_/X }
C {sky130_stdcells/a21o_4.sym} 158100 -24190 0 0 {name=X_71623_ }
C {devices/lab_pin.sym} 158010 -24050 0 0 {name=p157157 lab=_85554_/CLK }
C {devices/lab_pin.sym} 158010 -24030 0 0 {name=p157158 lab=_83609_/D }
C {devices/lab_pin.sym} 158190 -24050 0 1 {name=p157159 lab=_49044_/A }
C {sky130_stdcells/dfxtp_4.sym} 158100 -24040 0 0 {name=X_83609_ }
C {devices/lab_pin.sym} 158020 -23950 0 0 {name=p157160 lab=_44565_/X }
C {devices/lab_pin.sym} 158020 -23910 0 0 {name=p157161 lab=_44567_/X }
C {devices/lab_pin.sym} 158020 -23870 0 0 {name=p157162 lab=_40874_/X }
C {devices/lab_pin.sym} 158020 -23830 0 0 {name=p157163 lab=_87051_/Q }
C {devices/lab_pin.sym} 158020 -23790 0 0 {name=p157164 lab=_44568_/X }
C {devices/lab_pin.sym} 158180 -23870 0 1 {name=p157165 lab=_44571_/Y }
C {sky130_stdcells/o32ai_4.sym} 158100 -23870 0 0 {name=X_44571_ }
C {devices/lab_pin.sym} 158040 -23740 0 0 {name=p157166 lab=_56556_/Y }
C {devices/lab_pin.sym} 158040 -23700 0 0 {name=p157167 lab=_55570_/D }
C {devices/lab_pin.sym} 158040 -23660 0 0 {name=p157168 lab=_72648_/C }
C {devices/lab_pin.sym} 158040 -23620 0 0 {name=p157169 lab=_72643_/C }
C {devices/lab_pin.sym} 158160 -23680 0 1 {name=p157170 lab=_56557_/X }
C {sky130_stdcells/and4_4.sym} 158100 -23680 0 0 {name=X_56557_ }
C {devices/lab_pin.sym} 158040 -23540 0 0 {name=p157171 lab=_80791_/Q }
C {devices/lab_pin.sym} 158040 -23500 0 0 {name=p157172 lab=_75390_/X }
C {devices/lab_pin.sym} 158160 -23520 0 1 {name=p157173 lab=_80759_/D }
C {sky130_stdcells/xor2_4.sym} 158100 -23520 0 0 {name=X_75391_ }
C {devices/lab_pin.sym} 158020 -23420 0 0 {name=p157174 lab=_41782_/X }
C {devices/lab_pin.sym} 158020 -23380 0 0 {name=p157175 lab=_41750_/X }
C {devices/lab_pin.sym} 158020 -23340 0 0 {name=p157176 lab=_88150_/Q }
C {devices/lab_pin.sym} 158020 -23300 0 0 {name=p157177 lab=_41751_/X }
C {devices/lab_pin.sym} 158180 -23360 0 1 {name=p157178 lab=_88150_/D }
C {sky130_stdcells/a2bb2o_4.sym} 158100 -23360 0 0 {name=X_41783_ }
C {devices/lab_pin.sym} 158010 -23210 0 0 {name=p157179 lab=_88144_/CLK }
C {devices/lab_pin.sym} 158010 -23190 0 0 {name=p157180 lab=_87377_/D }
C {devices/lab_pin.sym} 158190 -23210 0 1 {name=p157181 lab=_87377_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -23200 0 0 {name=X_87377_ }
C {devices/lab_pin.sym} 158020 -23090 0 0 {name=p157182 lab=_53767_/Y }
C {devices/lab_pin.sym} 158020 -23050 0 0 {name=p157183 lab=_53747_/X }
C {devices/lab_pin.sym} 158020 -23010 0 0 {name=p157184 lab=_53768_/X }
C {devices/lab_pin.sym} 158180 -23050 0 1 {name=p157185 lab=_85572_/D }
C {sky130_stdcells/a21oi_4.sym} 158100 -23050 0 0 {name=X_53769_ }
C {devices/lab_pin.sym} 158010 -22910 0 0 {name=p157186 lab=_84469_/CLK }
C {devices/lab_pin.sym} 158010 -22890 0 0 {name=p157187 lab=_60604_/Y }
C {devices/lab_pin.sym} 158190 -22910 0 1 {name=p157188 lab=_79129_/A }
C {sky130_stdcells/dfxtp_4.sym} 158100 -22900 0 0 {name=X_84589_ }
C {devices/lab_pin.sym} 158060 -22770 0 0 {name=p157189 lab=_53511_/A }
C {devices/lab_pin.sym} 158140 -22770 0 1 {name=p157190 lab=_46428_/C }
C {sky130_stdcells/buf_2.sym} 158100 -22770 0 0 {name=X_46310_ }
C {devices/lab_pin.sym} 158040 -22660 0 0 {name=p157191 lab=_77130_/A }
C {devices/lab_pin.sym} 158040 -22620 0 0 {name=p157192 lab=_77129_/X }
C {devices/lab_pin.sym} 158160 -22640 0 1 {name=p157193 lab=_77142_/A }
C {sky130_stdcells/nand2_4.sym} 158100 -22640 0 0 {name=X_77130_ }
C {devices/lab_pin.sym} 158020 -22540 0 0 {name=p157194 lab=_40331_/X }
C {devices/lab_pin.sym} 158020 -22500 0 0 {name=p157195 lab=_43513_/X }
C {devices/lab_pin.sym} 158020 -22460 0 0 {name=p157196 lab=_87378_/Q }
C {devices/lab_pin.sym} 158020 -22420 0 0 {name=p157197 lab=_43514_/X }
C {devices/lab_pin.sym} 158180 -22480 0 1 {name=p157198 lab=_87378_/D }
C {sky130_stdcells/a2bb2o_4.sym} 158100 -22480 0 0 {name=X_43522_ }
C {devices/lab_pin.sym} 158040 -22340 0 0 {name=p157199 lab=_55507_/X }
C {devices/lab_pin.sym} 158040 -22300 0 0 {name=p157200 lab=_55508_/B }
C {devices/lab_pin.sym} 158160 -22320 0 1 {name=p157201 lab=_55508_/Y }
C {sky130_stdcells/nor2_4.sym} 158100 -22320 0 0 {name=X_55508_ }
C {devices/lab_pin.sym} 158060 -22190 0 0 {name=p157202 lab=_74342_/A }
C {devices/lab_pin.sym} 158140 -22190 0 1 {name=p157203 lab=_74342_/X }
C {sky130_stdcells/buf_2.sym} 158100 -22190 0 0 {name=X_74342_ }
C {devices/lab_pin.sym} 158010 -22070 0 0 {name=p157204 lab=_86647_/CLK }
C {devices/lab_pin.sym} 158010 -22050 0 0 {name=p157205 lab=_49762_/Y }
C {devices/lab_pin.sym} 158190 -22070 0 1 {name=p157206 lab=_57857_/B }
C {sky130_stdcells/dfxtp_4.sym} 158100 -22060 0 0 {name=X_86328_ }
C {devices/lab_pin.sym} 158060 -21930 0 0 {name=p157207 lab=_40733_/Y }
C {devices/lab_pin.sym} 158140 -21930 0 1 {name=p157208 lab=_40734_/X }
C {sky130_stdcells/buf_2.sym} 158100 -21930 0 0 {name=X_40734_ }
C {devices/lab_pin.sym} 158040 -21820 0 0 {name=p157209 lab=_47287_/X }
C {devices/lab_pin.sym} 158040 -21780 0 0 {name=p157210 lab=_52965_/B }
C {devices/lab_pin.sym} 158160 -21800 0 1 {name=p157211 lab=_47290_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -21800 0 0 {name=X_47290_ }
C {devices/lab_pin.sym} 158020 -21690 0 0 {name=p157212 lab=_71530_/Y }
C {devices/lab_pin.sym} 158020 -21650 0 0 {name=p157213 lab=_83458_/Q }
C {devices/lab_pin.sym} 158020 -21610 0 0 {name=p157214 lab=_71553_/Y }
C {devices/lab_pin.sym} 158180 -21650 0 1 {name=p157215 lab=_83458_/D }
C {sky130_stdcells/a21o_4.sym} 158100 -21650 0 0 {name=X_71554_ }
C {devices/lab_pin.sym} 158020 -21530 0 0 {name=p157216 lab=_59199_/X }
C {devices/lab_pin.sym} 158020 -21490 0 0 {name=p157217 lab=_85739_/Q }
C {devices/lab_pin.sym} 158020 -21450 0 0 {name=p157218 lab=_59263_/X }
C {devices/lab_pin.sym} 158180 -21490 0 1 {name=p157219 lab=_59276_/X }
C {sky130_stdcells/o21a_4.sym} 158100 -21490 0 0 {name=X_59276_ }
C {devices/lab_pin.sym} 158040 -21370 0 0 {name=p157220 lab=_56487_/X }
C {devices/lab_pin.sym} 158040 -21330 0 0 {name=p157221 lab=_56484_/X }
C {devices/lab_pin.sym} 158040 -21290 0 0 {name=p157222 lab=_56488_/C }
C {devices/lab_pin.sym} 158160 -21330 0 1 {name=p157223 lab=_56488_/Y }
C {sky130_stdcells/nand3_4.sym} 158100 -21330 0 0 {name=X_56488_ }
C {devices/lab_pin.sym} 158040 -21210 0 0 {name=p157224 lab=_70696_/B }
C {devices/lab_pin.sym} 158040 -21170 0 0 {name=p157225 lab=_70758_/B }
C {devices/lab_pin.sym} 158040 -21130 0 0 {name=p157226 lab=_71136_/A }
C {devices/lab_pin.sym} 158160 -21170 0 1 {name=p157227 lab=_70506_/A }
C {sky130_stdcells/nor3_4.sym} 158100 -21170 0 0 {name=X_70505_ }
C {devices/lab_pin.sym} 158020 -21050 0 0 {name=p157228 lab=_40877_/X }
C {devices/lab_pin.sym} 158020 -21010 0 0 {name=p157229 lab=_82945_/Q }
C {devices/lab_pin.sym} 158020 -20970 0 0 {name=p157230 lab=_46240_/Y }
C {devices/lab_pin.sym} 158180 -21010 0 1 {name=p157231 lab=_46241_/X }
C {sky130_stdcells/o21a_4.sym} 158100 -21010 0 0 {name=X_46241_ }
C {sky130_stdcells/decap_3.sym} 158100 -20840 0 0 {name=XPHY_530 }
C {devices/lab_pin.sym} 158020 -20710 0 0 {name=p157232 lab=_58219_/X }
C {devices/lab_pin.sym} 158020 -20670 0 0 {name=p157233 lab=_58224_/Y }
C {devices/lab_pin.sym} 158020 -20630 0 0 {name=p157234 lab=_58226_/Y }
C {devices/lab_pin.sym} 158180 -20670 0 1 {name=p157235 lab=_58227_/Y }
C {sky130_stdcells/a21oi_4.sym} 158100 -20670 0 0 {name=X_58227_ }
C {devices/lab_pin.sym} 158040 -20540 0 0 {name=p157236 lab=_77069_/A }
C {devices/lab_pin.sym} 158040 -20500 0 0 {name=p157237 lab=_82283_/D }
C {devices/lab_pin.sym} 158160 -20520 0 1 {name=p157238 lab=_77067_/B }
C {sky130_stdcells/xor2_4.sym} 158100 -20520 0 0 {name=X_77061_ }
C {devices/lab_pin.sym} 158020 -20430 0 0 {name=p157239 lab=_43449_/X }
C {devices/lab_pin.sym} 158020 -20390 0 0 {name=p157240 lab=_43452_/X }
C {devices/lab_pin.sym} 158020 -20350 0 0 {name=p157241 lab=_41616_/X }
C {devices/lab_pin.sym} 158020 -20310 0 0 {name=p157242 lab=_87414_/Q }
C {devices/lab_pin.sym} 158020 -20270 0 0 {name=p157243 lab=_43434_/X }
C {devices/lab_pin.sym} 158180 -20350 0 1 {name=p157244 lab=_43454_/A }
C {sky130_stdcells/o32ai_4.sym} 158100 -20350 0 0 {name=X_43453_ }
C {devices/lab_pin.sym} 158040 -20200 0 0 {name=p157245 lab=_56719_/A }
C {devices/lab_pin.sym} 158040 -20160 0 0 {name=p157246 lab=_56719_/B }
C {devices/lab_pin.sym} 158160 -20180 0 1 {name=p157247 lab=_55439_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -20180 0 0 {name=X_55439_ }
C {devices/lab_pin.sym} 158040 -20060 0 0 {name=p157248 lab=_73040_/A }
C {devices/lab_pin.sym} 158040 -20020 0 0 {name=p157249 lab=_86562_/Q }
C {devices/lab_pin.sym} 158160 -20040 0 1 {name=p157250 lab=_74273_/X }
C {sky130_stdcells/and2_4.sym} 158100 -20040 0 0 {name=X_74273_ }
C {devices/lab_pin.sym} 158010 -19910 0 0 {name=p157251 lab=_85557_/CLK }
C {devices/lab_pin.sym} 158010 -19890 0 0 {name=p157252 lab=_50127_/Y }
C {devices/lab_pin.sym} 158190 -19910 0 1 {name=p157253 lab=_86259_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -19900 0 0 {name=X_86259_ }
C {sky130_stdcells/decap_3.sym} 158100 -19740 0 0 {name=XPHY_541 }
C {devices/lab_pin.sym} 158040 -19600 0 0 {name=p157254 lab=_40829_/A }
C {devices/lab_pin.sym} 158040 -19560 0 0 {name=p157255 lab=_82867_/Q }
C {devices/lab_pin.sym} 158160 -19580 0 1 {name=p157256 lab=_40665_/X }
C {sky130_stdcells/or2_4.sym} 158100 -19580 0 0 {name=X_40665_ }
C {devices/lab_pin.sym} 158060 -19450 0 0 {name=p157257 lab=clkbuf_9_320_0_CLK/X }
C {devices/lab_pin.sym} 158140 -19450 0 1 {name=p157258 lab=_87471_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 158100 -19450 0 0 {name=Xclkbuf_10_640_0_CLK }
C {devices/lab_pin.sym} 158040 -19340 0 0 {name=p157259 lab=_71289_/B }
C {devices/lab_pin.sym} 158040 -19300 0 0 {name=p157260 lab=_71485_/B }
C {devices/lab_pin.sym} 158160 -19320 0 1 {name=p157261 lab=_71486_/A }
C {sky130_stdcells/nor2_4.sym} 158100 -19320 0 0 {name=X_71485_ }
C {sky130_stdcells/decap_3.sym} 158100 -19160 0 0 {name=XPHY_552 }
C {sky130_stdcells/decap_3.sym} 158100 -18980 0 0 {name=XPHY_563 }
C {devices/lab_pin.sym} 158040 -18840 0 0 {name=p157262 lab=_81711_/D }
C {devices/lab_pin.sym} 158040 -18800 0 0 {name=p157263 lab=_76021_/B }
C {devices/lab_pin.sym} 158160 -18820 0 1 {name=p157264 lab=_76015_/A }
C {sky130_stdcells/xor2_4.sym} 158100 -18820 0 0 {name=X_76012_ }
C {devices/lab_pin.sym} 158020 -18730 0 0 {name=p157265 lab=_42401_/X }
C {devices/lab_pin.sym} 158020 -18690 0 0 {name=p157266 lab=_42397_/X }
C {devices/lab_pin.sym} 158020 -18650 0 0 {name=p157267 lab=_40440_/X }
C {devices/lab_pin.sym} 158020 -18610 0 0 {name=p157268 lab=_87879_/Q }
C {devices/lab_pin.sym} 158020 -18570 0 0 {name=p157269 lab=_42398_/X }
C {devices/lab_pin.sym} 158180 -18650 0 1 {name=p157270 lab=_42405_/A }
C {sky130_stdcells/o32ai_4.sym} 158100 -18650 0 0 {name=X_42404_ }
C {sky130_stdcells/decap_3.sym} 158100 -18460 0 0 {name=XPHY_574 }
C {devices/lab_pin.sym} 158060 -18310 0 0 {name=p157271 lab=_57376_/X }
C {devices/lab_pin.sym} 158140 -18310 0 1 {name=p157272 lab=_73224_/X }
C {sky130_stdcells/buf_2.sym} 158100 -18310 0 0 {name=X_73224_ }
C {devices/lab_pin.sym} 158020 -18210 0 0 {name=p157273 lab=_46168_/Y }
C {devices/lab_pin.sym} 158020 -18170 0 0 {name=p157274 lab=_46169_/Y }
C {devices/lab_pin.sym} 158020 -18130 0 0 {name=p157275 lab=_46171_/Y }
C {devices/lab_pin.sym} 158180 -18170 0 1 {name=p157276 lab=_46172_/Y }
C {sky130_stdcells/a21oi_4.sym} 158100 -18170 0 0 {name=X_46172_ }
C {devices/lab_pin.sym} 158020 -18050 0 0 {name=p157277 lab=_48231_/B }
C {devices/lab_pin.sym} 158020 -18010 0 0 {name=p157278 lab=_70422_/X }
C {devices/lab_pin.sym} 158020 -17970 0 0 {name=p157279 lab=_70435_/Y }
C {devices/lab_pin.sym} 158180 -18010 0 1 {name=p157280 lab=_83775_/D }
C {sky130_stdcells/o21ai_4.sym} 158100 -18010 0 0 {name=X_70436_ }
C {devices/lab_pin.sym} 158060 -17870 0 0 {name=p157281 lab=_84918_/Q }
C {devices/lab_pin.sym} 158140 -17870 0 1 {name=p157282 lab=_63044_/A }
C {sky130_stdcells/inv_2.sym} 158100 -17870 0 0 {name=X_58158_ }
C {sky130_stdcells/decap_3.sym} 158100 -17720 0 0 {name=XPHY_585 }
C {devices/lab_pin.sym} 158020 -17600 0 0 {name=p157283 lab=_41429_/X }
C {devices/lab_pin.sym} 158020 -17560 0 0 {name=p157284 lab=_43371_/X }
C {devices/lab_pin.sym} 158020 -17520 0 0 {name=p157285 lab=_87449_/Q }
C {devices/lab_pin.sym} 158020 -17480 0 0 {name=p157286 lab=_43372_/X }
C {devices/lab_pin.sym} 158180 -17540 0 1 {name=p157287 lab=_87449_/D }
C {sky130_stdcells/a2bb2o_4.sym} 158100 -17540 0 0 {name=X_43384_ }
C {sky130_stdcells/decap_3.sym} 158100 -17360 0 0 {name=XPHY_596 }
C {devices/lab_pin.sym} 158060 -17210 0 0 {name=p157288 lab=clkbuf_8_65_0_CLK/X }
C {devices/lab_pin.sym} 158140 -17210 0 1 {name=p157289 lab=clkbuf_9_131_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 158100 -17210 0 0 {name=Xclkbuf_9_131_0_CLK }
C {devices/lab_pin.sym} 158060 -17090 0 0 {name=p157290 lab=_40595_/X }
C {devices/lab_pin.sym} 158140 -17090 0 1 {name=p157291 lab=_40596_/X }
C {sky130_stdcells/buf_2.sym} 158100 -17090 0 0 {name=X_40596_ }
C {devices/lab_pin.sym} 158060 -16970 0 0 {name=p157292 lab=_44968_/X }
C {devices/lab_pin.sym} 158140 -16970 0 1 {name=p157293 lab=_45182_/B }
C {sky130_stdcells/buf_2.sym} 158100 -16970 0 0 {name=X_45123_ }
C {devices/lab_pin.sym} 158060 -16850 0 0 {name=p157294 lab=_57096_/Y }
C {devices/lab_pin.sym} 158140 -16850 0 1 {name=p157295 lab=_57109_/X }
C {sky130_stdcells/buf_2.sym} 158100 -16850 0 0 {name=X_57109_ }
C {devices/lab_pin.sym} 158060 -16730 0 0 {name=p157296 lab=_42335_/A }
C {devices/lab_pin.sym} 158140 -16730 0 1 {name=p157297 lab=_42335_/Y }
C {sky130_stdcells/inv_2.sym} 158100 -16730 0 0 {name=X_42335_ }
C {devices/lab_pin.sym} 158020 -16630 0 0 {name=p157298 lab=_44556_/Y }
C {devices/lab_pin.sym} 158020 -16590 0 0 {name=p157299 lab=_72899_/X }
C {devices/lab_pin.sym} 158020 -16550 0 0 {name=p157300 lab=_73154_/Y }
C {devices/lab_pin.sym} 158180 -16590 0 1 {name=p157301 lab=_73155_/X }
C {sky130_stdcells/a21o_4.sym} 158100 -16590 0 0 {name=X_73155_ }
C {devices/lab_pin.sym} 158060 -16450 0 0 {name=p157302 lab=DATA_TO_HASH[7] }
C {devices/lab_pin.sym} 158140 -16450 0 1 {name=p157303 lab=_70984_/A }
C {sky130_stdcells/buf_2.sym} 158100 -16450 0 0 {name=X_70367_ }
C {devices/lab_pin.sym} 158060 -16330 0 0 {name=p157304 lab=_58928_/A }
C {devices/lab_pin.sym} 158140 -16330 0 1 {name=p157305 lab=_58089_/X }
C {sky130_stdcells/buf_2.sym} 158100 -16330 0 0 {name=X_58089_ }
C {devices/lab_pin.sym} 158040 -16230 0 0 {name=p157306 lab=_59579_/A }
C {devices/lab_pin.sym} 158040 -16190 0 0 {name=p157307 lab=_61183_/A }
C {devices/lab_pin.sym} 158040 -16150 0 0 {name=p157308 lab=_60593_/B }
C {devices/lab_pin.sym} 158160 -16190 0 1 {name=p157309 lab=_60155_/D }
C {sky130_stdcells/nor3_4.sym} 158100 -16190 0 0 {name=X_60120_ }
C {devices/lab_pin.sym} 158020 -16070 0 0 {name=p157310 lab=_83283_/Q }
C {devices/lab_pin.sym} 158020 -16030 0 0 {name=p157311 lab=_72090_/X }
C {devices/lab_pin.sym} 158020 -15990 0 0 {name=p157312 lab=_72105_/Y }
C {devices/lab_pin.sym} 158180 -16030 0 1 {name=p157313 lab=_72106_/Y }
C {sky130_stdcells/o21ai_4.sym} 158100 -16030 0 0 {name=X_72106_ }
C {devices/lab_pin.sym} 158060 -15890 0 0 {name=p157314 lab=_49930_/X }
C {devices/lab_pin.sym} 158140 -15890 0 1 {name=p157315 lab=_49953_/C }
C {sky130_stdcells/buf_2.sym} 158100 -15890 0 0 {name=X_49931_ }
C {devices/lab_pin.sym} 158020 -15790 0 0 {name=p157316 lab=_45052_/X }
C {devices/lab_pin.sym} 158020 -15750 0 0 {name=p157317 lab=_61437_/B }
C {devices/lab_pin.sym} 158020 -15710 0 0 {name=p157318 lab=_44995_/X }
C {devices/lab_pin.sym} 158180 -15750 0 1 {name=p157319 lab=_45054_/Y }
C {sky130_stdcells/o21ai_4.sym} 158100 -15750 0 0 {name=X_45054_ }
C {devices/lab_pin.sym} 158060 -15610 0 0 {name=p157320 lab=clkbuf_9_327_0_CLK/X }
C {devices/lab_pin.sym} 158140 -15610 0 1 {name=p157321 lab=_88220_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 158100 -15610 0 0 {name=Xclkbuf_10_655_0_CLK }
C {devices/lab_pin.sym} 158020 -15530 0 0 {name=p157322 lab=_42252_/X }
C {devices/lab_pin.sym} 158020 -15490 0 0 {name=p157323 lab=_42243_/X }
C {devices/lab_pin.sym} 158020 -15450 0 0 {name=p157324 lab=_41493_/X }
C {devices/lab_pin.sym} 158020 -15410 0 0 {name=p157325 lab=_87949_/Q }
C {devices/lab_pin.sym} 158020 -15370 0 0 {name=p157326 lab=_42244_/X }
C {devices/lab_pin.sym} 158180 -15450 0 1 {name=p157327 lab=_42266_/Y }
C {sky130_stdcells/o32ai_4.sym} 158100 -15450 0 0 {name=X_42266_ }
C {devices/lab_pin.sym} 158040 -15300 0 0 {name=p157328 lab=_82252_/Q }
C {devices/lab_pin.sym} 158040 -15260 0 0 {name=p157329 lab=_81964_/Q }
C {devices/lab_pin.sym} 158160 -15280 0 1 {name=p157330 lab=_81948_/D }
C {sky130_stdcells/xor2_4.sym} 158100 -15280 0 0 {name=X_77963_ }
C {devices/lab_pin.sym} 158060 -15150 0 0 {name=p157331 lab=_73530_/B }
C {devices/lab_pin.sym} 158140 -15150 0 1 {name=p157332 lab=_73086_/X }
C {sky130_stdcells/buf_2.sym} 158100 -15150 0 0 {name=X_73086_ }
C {devices/lab_pin.sym} 158060 -15030 0 0 {name=p157333 lab=_70249_/X }
C {devices/lab_pin.sym} 158140 -15030 0 1 {name=p157334 lab=_70301_/D }
C {sky130_stdcells/buf_2.sym} 158100 -15030 0 0 {name=X_70298_ }
C {devices/lab_pin.sym} 158020 -14940 0 0 {name=p157335 lab=_59901_/C }
C {devices/lab_pin.sym} 158020 -14900 0 0 {name=p157336 lab=_59584_/C }
C {devices/lab_pin.sym} 158020 -14860 0 0 {name=p157337 lab=_59598_/A }
C {devices/lab_pin.sym} 158020 -14820 0 0 {name=p157338 lab=_44004_/Y }
C {devices/lab_pin.sym} 158180 -14880 0 1 {name=p157339 lab=_44005_/X }
C {sky130_stdcells/a2bb2o_4.sym} 158100 -14880 0 0 {name=X_44005_ }
C {devices/lab_pin.sym} 158040 -14740 0 0 {name=p157340 lab=_79702_/A }
C {devices/lab_pin.sym} 158040 -14700 0 0 {name=p157341 lab=_79701_/Y }
C {devices/lab_pin.sym} 158160 -14720 0 1 {name=p157342 lab=_79702_/X }
C {sky130_stdcells/xor2_4.sym} 158100 -14720 0 0 {name=X_79702_ }
C {devices/lab_pin.sym} 158060 -14590 0 0 {name=p157343 lab=_40413_/X }
C {devices/lab_pin.sym} 158140 -14590 0 1 {name=p157344 lab=_41513_/A }
C {sky130_stdcells/buf_2.sym} 158100 -14590 0 0 {name=X_41217_ }
C {devices/lab_pin.sym} 158040 -14490 0 0 {name=p157345 lab=_60064_/A }
C {devices/lab_pin.sym} 158040 -14450 0 0 {name=p157346 lab=_60081_/B }
C {devices/lab_pin.sym} 158040 -14410 0 0 {name=p157347 lab=_60051_/C }
C {devices/lab_pin.sym} 158160 -14450 0 1 {name=p157348 lab=_60051_/Y }
C {sky130_stdcells/nor3_4.sym} 158100 -14450 0 0 {name=X_60051_ }
C {devices/lab_pin.sym} 158020 -14330 0 0 {name=p157349 lab=_83297_/Q }
C {devices/lab_pin.sym} 158020 -14290 0 0 {name=p157350 lab=_72016_/X }
C {devices/lab_pin.sym} 158020 -14250 0 0 {name=p157351 lab=_72036_/Y }
C {devices/lab_pin.sym} 158180 -14290 0 1 {name=p157352 lab=_72037_/Y }
C {sky130_stdcells/o21ai_4.sym} 158100 -14290 0 0 {name=X_72037_ }
C {devices/lab_pin.sym} 158040 -14160 0 0 {name=p157353 lab=_76914_/A }
C {devices/lab_pin.sym} 158040 -14120 0 0 {name=p157354 lab=_76914_/B }
C {devices/lab_pin.sym} 158160 -14140 0 1 {name=p157355 lab=_81470_/D }
C {sky130_stdcells/xor2_4.sym} 158100 -14140 0 0 {name=X_76914_ }
C {devices/lab_pin.sym} 158040 -14040 0 0 {name=p157356 lab=_49851_/A }
C {devices/lab_pin.sym} 158040 -14000 0 0 {name=p157357 lab=_49884_/B }
C {devices/lab_pin.sym} 158040 -13960 0 0 {name=p157358 lab=_49862_/C }
C {devices/lab_pin.sym} 158040 -13920 0 0 {name=p157359 lab=_53074_/D }
C {devices/lab_pin.sym} 158160 -13980 0 1 {name=p157360 lab=_49862_/X }
C {sky130_stdcells/and4_4.sym} 158100 -13980 0 0 {name=X_49862_ }
C {devices/lab_pin.sym} 158060 -13830 0 0 {name=p157361 lab=clkbuf_8_73_0_CLK/X }
C {devices/lab_pin.sym} 158140 -13830 0 1 {name=p157362 lab=clkbuf_9_146_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 158100 -13830 0 0 {name=Xclkbuf_9_146_0_CLK }
C {devices/lab_pin.sym} 158020 -13740 0 0 {name=p157363 lab=_41306_/X }
C {devices/lab_pin.sym} 158020 -13700 0 0 {name=p157364 lab=_42192_/X }
C {devices/lab_pin.sym} 158020 -13660 0 0 {name=p157365 lab=_87983_/Q }
C {devices/lab_pin.sym} 158020 -13620 0 0 {name=p157366 lab=_42193_/X }
C {devices/lab_pin.sym} 158180 -13680 0 1 {name=p157367 lab=_87983_/D }
C {sky130_stdcells/a2bb2o_4.sym} 158100 -13680 0 0 {name=X_42197_ }
C {devices/lab_pin.sym} 158020 -13560 0 0 {name=p157368 lab=_77885_/A }
C {devices/lab_pin.sym} 158020 -13520 0 0 {name=p157369 lab=_77872_/Y }
C {devices/lab_pin.sym} 158020 -13480 0 0 {name=p157370 lab=_77884_/A }
C {devices/lab_pin.sym} 158020 -13440 0 0 {name=p157371 lab=_77883_/Y }
C {devices/lab_pin.sym} 158180 -13500 0 1 {name=p157372 lab=_77894_/X }
C {sky130_stdcells/o22a_4.sym} 158100 -13500 0 0 {name=X_77894_ }
C {devices/lab_pin.sym} 158060 -13350 0 0 {name=p157373 lab=clkbuf_9_72_0_CLK/A }
C {devices/lab_pin.sym} 158140 -13350 0 1 {name=p157374 lab=clkbuf_9_73_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 158100 -13350 0 0 {name=Xclkbuf_9_73_0_CLK }
C {devices/lab_pin.sym} 158060 -13230 0 0 {name=p157375 lab=_48840_/A }
C {devices/lab_pin.sym} 158140 -13230 0 1 {name=p157376 lab=_48813_/X }
C {sky130_stdcells/buf_2.sym} 158100 -13230 0 0 {name=X_48813_ }
C {devices/lab_pin.sym} 158040 -13120 0 0 {name=p157377 lab=_79633_/A }
C {devices/lab_pin.sym} 158040 -13080 0 0 {name=p157378 lab=_79632_/Y }
C {devices/lab_pin.sym} 158160 -13100 0 1 {name=p157379 lab=_79633_/X }
C {sky130_stdcells/xor2_4.sym} 158100 -13100 0 0 {name=X_79633_ }
C {devices/lab_pin.sym} 158020 -13000 0 0 {name=p157380 lab=_41147_/X }
C {devices/lab_pin.sym} 158020 -12960 0 0 {name=p157381 lab=_41109_/X }
C {devices/lab_pin.sym} 158020 -12920 0 0 {name=p157382 lab=_88269_/Q }
C {devices/lab_pin.sym} 158020 -12880 0 0 {name=p157383 lab=_41110_/X }
C {devices/lab_pin.sym} 158180 -12940 0 1 {name=p157384 lab=_88269_/D }
C {sky130_stdcells/a2bb2o_4.sym} 158100 -12940 0 0 {name=X_41148_ }
C {devices/lab_pin.sym} 158040 -12800 0 0 {name=p157385 lab=_76845_/A }
C {devices/lab_pin.sym} 158040 -12760 0 0 {name=p157386 lab=_76845_/B }
C {devices/lab_pin.sym} 158160 -12780 0 1 {name=p157387 lab=_76845_/X }
C {sky130_stdcells/xor2_4.sym} 158100 -12780 0 0 {name=X_76845_ }
C {devices/lab_pin.sym} 158060 -12650 0 0 {name=p157388 lab=_49793_/A }
C {devices/lab_pin.sym} 158140 -12650 0 1 {name=p157389 lab=_52679_/A }
C {sky130_stdcells/buf_2.sym} 158100 -12650 0 0 {name=X_49793_ }
C {devices/lab_pin.sym} 158060 -12530 0 0 {name=p157390 lab=_63741_/A }
C {devices/lab_pin.sym} 158140 -12530 0 1 {name=p157391 lab=_63810_/X }
C {sky130_stdcells/buf_2.sym} 158100 -12530 0 0 {name=X_63810_ }
C {devices/lab_pin.sym} 158040 -12430 0 0 {name=p157392 lab=_48744_/A }
C {devices/lab_pin.sym} 158040 -12390 0 0 {name=p157393 lab=_48766_/B }
C {devices/lab_pin.sym} 158040 -12350 0 0 {name=p157394 lab=_48761_/C }
C {devices/lab_pin.sym} 158160 -12390 0 1 {name=p157395 lab=_48744_/X }
C {sky130_stdcells/and3_4.sym} 158100 -12390 0 0 {name=X_48744_ }
C {devices/lab_pin.sym} 158020 -12270 0 0 {name=p157396 lab=_79557_/A }
C {devices/lab_pin.sym} 158020 -12230 0 0 {name=p157397 lab=_79549_/Y }
C {devices/lab_pin.sym} 158020 -12190 0 0 {name=p157398 lab=_79550_/Y }
C {devices/lab_pin.sym} 158180 -12230 0 1 {name=p157399 lab=_79564_/Y }
C {sky130_stdcells/a21boi_4.sym} 158100 -12230 0 0 {name=X_79564_ }
C {devices/lab_pin.sym} 158060 -12090 0 0 {name=p157400 lab=_45955_/X }
C {devices/lab_pin.sym} 158140 -12090 0 1 {name=p157401 lab=_45957_/A }
C {sky130_stdcells/buf_2.sym} 158100 -12090 0 0 {name=X_45956_ }
C {devices/lab_pin.sym} 158060 -11970 0 0 {name=p157402 lab=_41013_/A }
C {devices/lab_pin.sym} 158140 -11970 0 1 {name=p157403 lab=_41079_/X }
C {sky130_stdcells/buf_2.sym} 158100 -11970 0 0 {name=X_41079_ }
C {devices/lab_pin.sym} 158040 -11870 0 0 {name=p157404 lab=_64637_/X }
C {devices/lab_pin.sym} 158040 -11830 0 0 {name=p157405 lab=_64913_/B }
C {devices/lab_pin.sym} 158040 -11790 0 0 {name=p157406 lab=_84227_/Q }
C {devices/lab_pin.sym} 158160 -11830 0 1 {name=p157407 lab=_64790_/X }
C {sky130_stdcells/and3_4.sym} 158100 -11830 0 0 {name=X_64790_ }
C {devices/lab_pin.sym} 158040 -11700 0 0 {name=p157408 lab=_76762_/Y }
C {devices/lab_pin.sym} 158040 -11660 0 0 {name=p157409 lab=_76776_/B }
C {devices/lab_pin.sym} 158160 -11680 0 1 {name=p157410 lab=_76776_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -11680 0 0 {name=X_76776_ }
C {devices/lab_pin.sym} 158020 -11580 0 0 {name=p157411 lab=_68826_/B }
C {devices/lab_pin.sym} 158020 -11540 0 0 {name=p157412 lab=_72853_/X }
C {devices/lab_pin.sym} 158020 -11500 0 0 {name=p157413 lab=_45897_/X }
C {devices/lab_pin.sym} 158020 -11460 0 0 {name=p157414 lab=_73987_/Y }
C {devices/lab_pin.sym} 158180 -11520 0 1 {name=p157415 lab=_73988_/X }
C {sky130_stdcells/a211o_4.sym} 158100 -11520 0 0 {name=X_73988_ }
C {devices/lab_pin.sym} 158040 -11380 0 0 {name=p157416 lab=_78515_/A }
C {devices/lab_pin.sym} 158040 -11340 0 0 {name=p157417 lab=_78514_/Y }
C {devices/lab_pin.sym} 158160 -11360 0 1 {name=p157418 lab=_78515_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -11360 0 0 {name=X_78515_ }
C {devices/lab_pin.sym} 158060 -11230 0 0 {name=p157419 lab=_44907_/A }
C {devices/lab_pin.sym} 158140 -11230 0 1 {name=p157420 lab=_44907_/X }
C {sky130_stdcells/buf_2.sym} 158100 -11230 0 0 {name=X_44907_ }
C {devices/lab_pin.sym} 158060 -11110 0 0 {name=p157421 lab=_63741_/A }
C {devices/lab_pin.sym} 158140 -11110 0 1 {name=p157422 lab=_63741_/X }
C {sky130_stdcells/buf_2.sym} 158100 -11110 0 0 {name=X_63741_ }
C {devices/lab_pin.sym} 158040 -11000 0 0 {name=p157423 lab=_75727_/A }
C {devices/lab_pin.sym} 158040 -10960 0 0 {name=p157424 lab=_75726_/Y }
C {devices/lab_pin.sym} 158160 -10980 0 1 {name=p157425 lab=_75736_/B }
C {sky130_stdcells/xor2_4.sym} 158100 -10980 0 0 {name=X_75727_ }
C {devices/lab_pin.sym} 158040 -10870 0 0 {name=p157426 lab=_60901_/B }
C {devices/lab_pin.sym} 158040 -10830 0 0 {name=p157427 lab=_60882_/X }
C {devices/lab_pin.sym} 158040 -10790 0 0 {name=p157428 lab=_60910_/B }
C {devices/lab_pin.sym} 158160 -10830 0 1 {name=p157429 lab=_60953_/X }
C {sky130_stdcells/and3_4.sym} 158100 -10830 0 0 {name=X_60953_ }
C {devices/lab_pin.sym} 158020 -10710 0 0 {name=p157430 lab=_72926_/X }
C {devices/lab_pin.sym} 158020 -10670 0 0 {name=p157431 lab=_72928_/X }
C {devices/lab_pin.sym} 158020 -10630 0 0 {name=p157432 lab=_72938_/X }
C {devices/lab_pin.sym} 158180 -10670 0 1 {name=p157433 lab=_72939_/X }
C {sky130_stdcells/a21o_4.sym} 158100 -10670 0 0 {name=X_72939_ }
C {devices/lab_pin.sym} 158060 -10530 0 0 {name=p157434 lab=_48675_/A }
C {devices/lab_pin.sym} 158140 -10530 0 1 {name=p157435 lab=_48676_/A }
C {sky130_stdcells/inv_2.sym} 158100 -10530 0 0 {name=X_48675_ }
C {devices/lab_pin.sym} 158040 -10420 0 0 {name=p157436 lab=_79491_/Y }
C {devices/lab_pin.sym} 158040 -10380 0 0 {name=p157437 lab=_79494_/Y }
C {devices/lab_pin.sym} 158160 -10400 0 1 {name=p157438 lab=_79505_/B }
C {sky130_stdcells/xor2_4.sym} 158100 -10400 0 0 {name=X_79495_ }
C {devices/lab_pin.sym} 158060 -10270 0 0 {name=p157439 lab=clkbuf_9_88_0_CLK/A }
C {devices/lab_pin.sym} 158140 -10270 0 1 {name=p157440 lab=clkbuf_9_88_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 158100 -10270 0 0 {name=Xclkbuf_9_88_0_CLK }
C {devices/lab_pin.sym} 158060 -10150 0 0 {name=p157441 lab=_44038_/X }
C {devices/lab_pin.sym} 158140 -10150 0 1 {name=p157442 lab=_45888_/A }
C {sky130_stdcells/buf_2.sym} 158100 -10150 0 0 {name=X_45887_ }
C {devices/lab_pin.sym} 158060 -10030 0 0 {name=p157443 lab=_47530_/A }
C {devices/lab_pin.sym} 158140 -10030 0 1 {name=p157444 lab=_47655_/A }
C {sky130_stdcells/buf_2.sym} 158100 -10030 0 0 {name=X_47626_ }
C {devices/lab_pin.sym} 158020 -9930 0 0 {name=p157445 lab=_66458_/Y }
C {devices/lab_pin.sym} 158020 -9890 0 0 {name=p157446 lab=_66459_/Y }
C {devices/lab_pin.sym} 158020 -9850 0 0 {name=p157447 lab=_60529_/A }
C {devices/lab_pin.sym} 158180 -9890 0 1 {name=p157448 lab=_66460_/X }
C {sky130_stdcells/a21o_4.sym} 158100 -9890 0 0 {name=X_66460_ }
C {devices/lab_pin.sym} 158040 -9760 0 0 {name=p157449 lab=_78455_/A }
C {devices/lab_pin.sym} 158040 -9720 0 0 {name=p157450 lab=_82668_/D }
C {devices/lab_pin.sym} 158160 -9740 0 1 {name=p157451 lab=_78447_/B }
C {sky130_stdcells/xor2_4.sym} 158100 -9740 0 0 {name=X_78446_ }
C {devices/lab_pin.sym} 158060 -9610 0 0 {name=p157452 lab=_43927_/X }
C {devices/lab_pin.sym} 158140 -9610 0 1 {name=p157453 lab=_44838_/X }
C {sky130_stdcells/buf_2.sym} 158100 -9610 0 0 {name=X_44838_ }
C {devices/lab_pin.sym} 158040 -9520 0 0 {name=p157454 lab=_63655_/A }
C {devices/lab_pin.sym} 158040 -9480 0 0 {name=p157455 lab=_63672_/B }
C {devices/lab_pin.sym} 158040 -9440 0 0 {name=p157456 lab=_63672_/C }
C {devices/lab_pin.sym} 158040 -9400 0 0 {name=p157457 lab=_63595_/D }
C {devices/lab_pin.sym} 158160 -9460 0 1 {name=p157458 lab=_63672_/X }
C {sky130_stdcells/and4_4.sym} 158100 -9460 0 0 {name=X_63672_ }
C {devices/lab_pin.sym} 158040 -9320 0 0 {name=p157459 lab=_75658_/A }
C {devices/lab_pin.sym} 158040 -9280 0 0 {name=p157460 lab=_75657_/Y }
C {devices/lab_pin.sym} 158160 -9300 0 1 {name=p157461 lab=_75666_/A }
C {sky130_stdcells/xor2_4.sym} 158100 -9300 0 0 {name=X_75658_ }
C {devices/lab_pin.sym} 158060 -9170 0 0 {name=p157462 lab=_60865_/C }
C {devices/lab_pin.sym} 158140 -9170 0 1 {name=p157463 lab=_60901_/A }
C {sky130_stdcells/buf_2.sym} 158100 -9170 0 0 {name=X_60884_ }
C {devices/lab_pin.sym} 158040 -9060 0 0 {name=p157464 lab=_65258_/A }
C {devices/lab_pin.sym} 158040 -9020 0 0 {name=p157465 lab=_65411_/B }
C {devices/lab_pin.sym} 158160 -9040 0 1 {name=p157466 lab=_65411_/X }
C {sky130_stdcells/and2_4.sym} 158100 -9040 0 0 {name=X_65411_ }
C {devices/lab_pin.sym} 158040 -8940 0 0 {name=p157467 lab=_62623_/A }
C {devices/lab_pin.sym} 158040 -8900 0 0 {name=p157468 lab=_62174_/X }
C {devices/lab_pin.sym} 158040 -8860 0 0 {name=p157469 lab=_62623_/C }
C {devices/lab_pin.sym} 158040 -8820 0 0 {name=p157470 lab=_62623_/D }
C {devices/lab_pin.sym} 158160 -8880 0 1 {name=p157471 lab=_62623_/X }
C {sky130_stdcells/and4_4.sym} 158100 -8880 0 0 {name=X_62623_ }
C {devices/lab_pin.sym} 158020 -8750 0 0 {name=p157472 lab=_45273_/A }
C {devices/lab_pin.sym} 158020 -8710 0 0 {name=p157473 lab=_74598_/X }
C {devices/lab_pin.sym} 158020 -8670 0 0 {name=p157474 lab=_74608_/X }
C {devices/lab_pin.sym} 158180 -8710 0 1 {name=p157475 lab=_74609_/Y }
C {sky130_stdcells/o21ai_4.sym} 158100 -8710 0 0 {name=X_74609_ }
C {devices/lab_pin.sym} 158060 -8570 0 0 {name=p157476 lab=_81246_/Q }
C {devices/lab_pin.sym} 158140 -8570 0 1 {name=p157477 lab=_47558_/A }
C {sky130_stdcells/inv_2.sym} 158100 -8570 0 0 {name=X_47557_ }
C {devices/lab_pin.sym} 158060 -8450 0 0 {name=p157478 lab=_66391_/A }
C {devices/lab_pin.sym} 158140 -8450 0 1 {name=p157479 lab=_66417_/B }
C {sky130_stdcells/buf_2.sym} 158100 -8450 0 0 {name=X_66391_ }
C {devices/lab_pin.sym} 158020 -8350 0 0 {name=p157480 lab=_78374_/X }
C {devices/lab_pin.sym} 158020 -8310 0 0 {name=p157481 lab=_78375_/Y }
C {devices/lab_pin.sym} 158020 -8270 0 0 {name=p157482 lab=_78378_/A }
C {devices/lab_pin.sym} 158180 -8310 0 1 {name=p157483 lab=_78380_/A }
C {sky130_stdcells/a21oi_4.sym} 158100 -8310 0 0 {name=X_78377_ }
C {devices/lab_pin.sym} 158020 -8210 0 0 {name=p157484 lab=_44766_/X }
C {devices/lab_pin.sym} 158020 -8170 0 0 {name=p157485 lab=_44767_/X }
C {devices/lab_pin.sym} 158020 -8130 0 0 {name=p157486 lab=_41340_/X }
C {devices/lab_pin.sym} 158020 -8090 0 0 {name=p157487 lab=_86965_/Q }
C {devices/lab_pin.sym} 158020 -8050 0 0 {name=p157488 lab=_44768_/X }
C {devices/lab_pin.sym} 158180 -8130 0 1 {name=p157489 lab=_44770_/A }
C {sky130_stdcells/o32ai_4.sym} 158100 -8130 0 0 {name=X_44769_ }
C {devices/lab_pin.sym} 158060 -7970 0 0 {name=p157490 lab=_80820_/Q }
C {devices/lab_pin.sym} 158140 -7970 0 1 {name=p157491 lab=_75589_/Y }
C {sky130_stdcells/inv_2.sym} 158100 -7970 0 0 {name=X_75589_ }
C {devices/lab_pin.sym} 158060 -7850 0 0 {name=p157492 lab=clkbuf_opt_9_CLK/A }
C {devices/lab_pin.sym} 158140 -7850 0 1 {name=p157493 lab=_84886_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 158100 -7850 0 0 {name=Xclkbuf_opt_9_CLK }
C {devices/lab_pin.sym} 158060 -7730 0 0 {name=p157494 lab=clkbuf_8_5_0_CLK/X }
C {devices/lab_pin.sym} 158140 -7730 0 1 {name=p157495 lab=clkbuf_9_11_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 158100 -7730 0 0 {name=Xclkbuf_9_11_0_CLK }
C {devices/lab_pin.sym} 158020 -7630 0 0 {name=p157496 lab=_66821_/X }
C {devices/lab_pin.sym} 158020 -7590 0 0 {name=p157497 lab=_66824_/X }
C {devices/lab_pin.sym} 158020 -7550 0 0 {name=p157498 lab=_68129_/X }
C {devices/lab_pin.sym} 158180 -7590 0 1 {name=p157499 lab=_68130_/Y }
C {sky130_stdcells/a21oi_4.sym} 158100 -7590 0 0 {name=X_68130_ }
C {devices/lab_pin.sym} 158040 -7470 0 0 {name=p157500 lab=_52533_/A }
C {devices/lab_pin.sym} 158040 -7430 0 0 {name=p157501 lab=_46487_/B }
C {devices/lab_pin.sym} 158040 -7390 0 0 {name=p157502 lab=_46472_/C }
C {devices/lab_pin.sym} 158160 -7430 0 1 {name=p157503 lab=_46508_/X }
C {sky130_stdcells/and3_4.sym} 158100 -7430 0 0 {name=X_46508_ }
C {devices/lab_pin.sym} 158060 -7290 0 0 {name=p157504 lab=_65660_/A }
C {devices/lab_pin.sym} 158140 -7290 0 1 {name=p157505 lab=_65342_/X }
C {sky130_stdcells/buf_2.sym} 158100 -7290 0 0 {name=X_65342_ }
C {devices/lab_pin.sym} 158060 -7170 0 0 {name=p157506 lab=_77323_/Y }
C {devices/lab_pin.sym} 158140 -7170 0 1 {name=p157507 lab=_77328_/Y }
C {sky130_stdcells/inv_2.sym} 158100 -7170 0 0 {name=X_77328_ }
C {devices/lab_pin.sym} 158040 -7070 0 0 {name=p157508 lab=_62551_/X }
C {devices/lab_pin.sym} 158040 -7030 0 0 {name=p157509 lab=_62553_/X }
C {devices/lab_pin.sym} 158040 -6990 0 0 {name=p157510 lab=_84402_/Q }
C {devices/lab_pin.sym} 158160 -7030 0 1 {name=p157511 lab=_62554_/Y }
C {sky130_stdcells/nor3_4.sym} 158100 -7030 0 0 {name=X_62554_ }
C {devices/lab_pin.sym} 158020 -6910 0 0 {name=p157512 lab=_47483_/Y }
C {devices/lab_pin.sym} 158020 -6870 0 0 {name=p157513 lab=_47462_/X }
C {devices/lab_pin.sym} 158020 -6830 0 0 {name=p157514 lab=_47487_/X }
C {devices/lab_pin.sym} 158180 -6870 0 1 {name=p157515 lab=_86630_/D }
C {sky130_stdcells/a21oi_4.sym} 158100 -6870 0 0 {name=X_47488_ }
C {devices/lab_pin.sym} 158020 -6750 0 0 {name=p157516 lab=_49225_/Y }
C {devices/lab_pin.sym} 158020 -6710 0 0 {name=p157517 lab=_49214_/X }
C {devices/lab_pin.sym} 158020 -6670 0 0 {name=p157518 lab=_49226_/Y }
C {devices/lab_pin.sym} 158180 -6710 0 1 {name=p157519 lab=_86430_/D }
C {sky130_stdcells/a21boi_4.sym} 158100 -6710 0 0 {name=X_49227_ }
C {devices/lab_pin.sym} 158060 -6570 0 0 {name=p157520 lab=clkbuf_9_304_0_CLK/X }
C {devices/lab_pin.sym} 158140 -6570 0 1 {name=p157521 lab=_81169_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 158100 -6570 0 0 {name=Xclkbuf_10_608_0_CLK }
C {devices/lab_pin.sym} 158060 -6450 0 0 {name=p157522 lab=_61504_/Y }
C {devices/lab_pin.sym} 158140 -6450 0 1 {name=p157523 lab=_61505_/Y }
C {sky130_stdcells/inv_2.sym} 158100 -6450 0 0 {name=X_61505_ }
C {devices/lab_pin.sym} 158020 -6360 0 0 {name=p157524 lab=_87137_/Q }
C {devices/lab_pin.sym} 158020 -6320 0 0 {name=p157525 lab=_68059_/X }
C {devices/lab_pin.sym} 158020 -6280 0 0 {name=p157526 lab=_67991_/X }
C {devices/lab_pin.sym} 158020 -6240 0 0 {name=p157527 lab=_68060_/X }
C {devices/lab_pin.sym} 158180 -6300 0 1 {name=p157528 lab=_68061_/X }
C {sky130_stdcells/a211o_4.sym} 158100 -6300 0 0 {name=X_68061_ }
C {devices/lab_pin.sym} 158040 -6160 0 0 {name=p157529 lab=_46408_/A }
C {devices/lab_pin.sym} 158040 -6120 0 0 {name=p157530 lab=_50808_/B }
C {devices/lab_pin.sym} 158160 -6140 0 1 {name=p157531 lab=_46439_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -6140 0 0 {name=X_46439_ }
C {devices/lab_pin.sym} 158060 -6010 0 0 {name=p157532 lab=_64567_/A }
C {devices/lab_pin.sym} 158140 -6010 0 1 {name=p157533 lab=_65877_/A }
C {sky130_stdcells/buf_2.sym} 158100 -6010 0 0 {name=X_65273_ }
C {devices/lab_pin.sym} 158060 -5890 0 0 {name=p157534 lab=_77258_/Y }
C {devices/lab_pin.sym} 158140 -5890 0 1 {name=p157535 lab=_77259_/Y }
C {sky130_stdcells/inv_2.sym} 158100 -5890 0 0 {name=X_77259_ }
C {devices/lab_pin.sym} 158040 -5790 0 0 {name=p157536 lab=_62483_/X }
C {devices/lab_pin.sym} 158040 -5750 0 0 {name=p157537 lab=_62541_/B }
C {devices/lab_pin.sym} 158040 -5710 0 0 {name=p157538 lab=_62485_/C }
C {devices/lab_pin.sym} 158160 -5750 0 1 {name=p157539 lab=_62485_/Y }
C {sky130_stdcells/nor3_4.sym} 158100 -5750 0 0 {name=X_62485_ }
C {devices/lab_pin.sym} 158020 -5640 0 0 {name=p157540 lab=_87117_/Q }
C {devices/lab_pin.sym} 158020 -5600 0 0 {name=p157541 lab=_66988_/X }
C {devices/lab_pin.sym} 158020 -5560 0 0 {name=p157542 lab=_66919_/X }
C {devices/lab_pin.sym} 158020 -5520 0 0 {name=p157543 lab=_67011_/X }
C {devices/lab_pin.sym} 158180 -5580 0 1 {name=p157544 lab=_67012_/X }
C {sky130_stdcells/a211o_4.sym} 158100 -5580 0 0 {name=X_67012_ }
C {devices/lab_pin.sym} 158060 -5430 0 0 {name=p157545 lab=_64285_/A }
C {devices/lab_pin.sym} 158140 -5430 0 1 {name=p157546 lab=_64248_/A }
C {sky130_stdcells/buf_2.sym} 158100 -5430 0 0 {name=X_64224_ }
C {devices/lab_pin.sym} 158060 -5310 0 0 {name=p157547 lab=_53917_/B }
C {devices/lab_pin.sym} 158140 -5310 0 1 {name=p157548 lab=_50188_/B }
C {sky130_stdcells/buf_2.sym} 158100 -5310 0 0 {name=X_49158_ }
C {devices/lab_pin.sym} 158060 -5190 0 0 {name=p157549 lab=_61374_/A }
C {devices/lab_pin.sym} 158140 -5190 0 1 {name=p157550 lab=_61437_/A }
C {sky130_stdcells/buf_2.sym} 158100 -5190 0 0 {name=X_61436_ }
C {devices/lab_pin.sym} 158040 -5080 0 0 {name=p157551 lab=_84746_/Q }
C {devices/lab_pin.sym} 158040 -5040 0 0 {name=p157552 lab=_84138_/Q }
C {devices/lab_pin.sym} 158160 -5060 0 1 {name=p157553 lab=_80270_/X }
C {sky130_stdcells/or2_4.sym} 158100 -5060 0 0 {name=X_80270_ }
C {devices/lab_pin.sym} 158060 -4930 0 0 {name=p157554 lab=clkbuf_9_27_0_CLK/A }
C {devices/lab_pin.sym} 158140 -4930 0 1 {name=p157555 lab=clkbuf_9_26_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 158100 -4930 0 0 {name=Xclkbuf_9_26_0_CLK }
C {devices/lab_pin.sym} 158060 -4810 0 0 {name=p157556 lab=_48734_/A }
C {devices/lab_pin.sym} 158140 -4810 0 1 {name=p157557 lab=_48109_/X }
C {sky130_stdcells/buf_2.sym} 158100 -4810 0 0 {name=X_48109_ }
C {devices/lab_pin.sym} 158040 -4720 0 0 {name=p157558 lab=_61666_/A }
C {devices/lab_pin.sym} 158040 -4680 0 0 {name=p157559 lab=_64177_/B }
C {devices/lab_pin.sym} 158040 -4640 0 0 {name=p157560 lab=_64155_/C }
C {devices/lab_pin.sym} 158040 -4600 0 0 {name=p157561 lab=_64177_/D }
C {devices/lab_pin.sym} 158160 -4660 0 1 {name=p157562 lab=_64155_/Y }
C {sky130_stdcells/nand4_4.sym} 158100 -4660 0 0 {name=X_64155_ }
C {devices/lab_pin.sym} 158060 -4510 0 0 {name=p157563 lab=_49089_/A }
C {devices/lab_pin.sym} 158140 -4510 0 1 {name=p157564 lab=_52365_/A }
C {sky130_stdcells/buf_2.sym} 158100 -4510 0 0 {name=X_49089_ }
C {devices/lab_pin.sym} 158040 -4420 0 0 {name=p157565 lab=_61367_/A }
C {devices/lab_pin.sym} 158040 -4380 0 0 {name=p157566 lab=_61367_/B }
C {devices/lab_pin.sym} 158040 -4340 0 0 {name=p157567 lab=_61367_/C }
C {devices/lab_pin.sym} 158040 -4300 0 0 {name=p157568 lab=_61367_/D }
C {devices/lab_pin.sym} 158160 -4360 0 1 {name=p157569 lab=_61367_/Y }
C {sky130_stdcells/nand4_4.sym} 158100 -4360 0 0 {name=X_61367_ }
C {devices/lab_pin.sym} 158060 -4210 0 0 {name=p157570 lab=_51013_/A }
C {devices/lab_pin.sym} 158140 -4210 0 1 {name=p157571 lab=_51121_/B }
C {sky130_stdcells/buf_2.sym} 158100 -4210 0 0 {name=X_51120_ }
C {devices/lab_pin.sym} 158020 -4130 0 0 {name=p157572 lab=_58541_/A }
C {devices/lab_pin.sym} 158020 -4090 0 0 {name=p157573 lab=_63073_/X }
C {devices/lab_pin.sym} 158020 -4050 0 0 {name=p157574 lab=_63059_/X }
C {devices/lab_pin.sym} 158020 -4010 0 0 {name=p157575 lab=_58317_/A }
C {devices/lab_pin.sym} 158020 -3970 0 0 {name=p157576 lab=_63060_/X }
C {devices/lab_pin.sym} 158180 -4050 0 1 {name=p157577 lab=_63106_/Y }
C {sky130_stdcells/o32ai_4.sym} 158100 -4050 0 0 {name=X_63106_ }
C {devices/lab_pin.sym} 158020 -3930 0 0 {name=p157578 lab=_60192_/Y }
C {devices/lab_pin.sym} 158020 -3890 0 0 {name=p157579 lab=_60284_/A }
C {devices/lab_pin.sym} 158020 -3850 0 0 {name=p157580 lab=_60259_/Y }
C {devices/lab_pin.sym} 158020 -3810 0 0 {name=p157581 lab=_60367_/B }
C {devices/lab_pin.sym} 158020 -3780 0 0 {name=p157582 lab=_60317_/Y }
C {devices/lab_pin.sym} 158180 -3850 0 1 {name=p157583 lab=_60318_/Y }
C {sky130_stdcells/a41oi_4.sym} 158100 -3850 0 0 {name=X_60318_ }
C {devices/lab_pin.sym} 158060 -3690 0 0 {name=p157584 lab=_65044_/A }
C {devices/lab_pin.sym} 158140 -3690 0 1 {name=p157585 lab=_64508_/A }
C {sky130_stdcells/buf_2.sym} 158100 -3690 0 0 {name=X_64086_ }
C {devices/lab_pin.sym} 158020 -3600 0 0 {name=p157586 lab=_74119_/A }
C {devices/lab_pin.sym} 158020 -3560 0 0 {name=p157587 lab=_68864_/X }
C {devices/lab_pin.sym} 158020 -3520 0 0 {name=p157588 lab=_68891_/X }
C {devices/lab_pin.sym} 158020 -3480 0 0 {name=p157589 lab=_68962_/X }
C {devices/lab_pin.sym} 158180 -3540 0 1 {name=p157590 lab=_68963_/X }
C {sky130_stdcells/a211o_4.sym} 158100 -3540 0 0 {name=X_68963_ }
C {devices/lab_pin.sym} 158040 -3410 0 0 {name=p157591 lab=_61329_/A }
C {devices/lab_pin.sym} 158040 -3370 0 0 {name=p157592 lab=_61298_/B }
C {devices/lab_pin.sym} 158040 -3330 0 0 {name=p157593 lab=_72549_/B }
C {devices/lab_pin.sym} 158160 -3370 0 1 {name=p157594 lab=_61298_/Y }
C {sky130_stdcells/nand3_4.sym} 158100 -3370 0 0 {name=X_61298_ }
C {devices/lab_pin.sym} 158040 -3260 0 0 {name=p157595 lab=_51029_/A }
C {devices/lab_pin.sym} 158040 -3220 0 0 {name=p157596 lab=_51045_/B }
C {devices/lab_pin.sym} 158040 -3180 0 0 {name=p157597 lab=_51045_/C }
C {devices/lab_pin.sym} 158040 -3140 0 0 {name=p157598 lab=_52742_/D }
C {devices/lab_pin.sym} 158160 -3200 0 1 {name=p157599 lab=_51051_/X }
C {sky130_stdcells/and4_4.sym} 158100 -3200 0 0 {name=X_51051_ }
C {devices/lab_pin.sym} 158060 -3050 0 0 {name=p157600 lab=_68451_/A }
C {devices/lab_pin.sym} 158140 -3050 0 1 {name=p157601 lab=_67914_/X }
C {sky130_stdcells/buf_2.sym} 158100 -3050 0 0 {name=X_67914_ }
C {devices/lab_pin.sym} 158060 -2930 0 0 {name=p157602 lab=_60452_/X }
C {devices/lab_pin.sym} 158140 -2930 0 1 {name=p157603 lab=_63038_/A }
C {sky130_stdcells/buf_2.sym} 158100 -2930 0 0 {name=X_63037_ }
C {devices/lab_pin.sym} 158060 -2810 0 0 {name=p157604 lab=_60359_/A }
C {devices/lab_pin.sym} 158140 -2810 0 1 {name=p157605 lab=_60249_/X }
C {sky130_stdcells/buf_2.sym} 158100 -2810 0 0 {name=X_60249_ }
C {devices/lab_pin.sym} 158010 -2690 0 0 {name=p157606 lab=_83967_/CLK }
C {devices/lab_pin.sym} 158010 -2670 0 0 {name=p157607 lab=_68812_/X }
C {devices/lab_pin.sym} 158190 -2690 0 1 {name=p157608 lab=_80816_/D }
C {sky130_stdcells/dfxtp_4.sym} 158100 -2680 0 0 {name=X_83960_ }
C {devices/lab_pin.sym} 158020 -2570 0 0 {name=p157609 lab=_68890_/X }
C {devices/lab_pin.sym} 158020 -2530 0 0 {name=p157610 lab=_68893_/X }
C {devices/lab_pin.sym} 158020 -2490 0 0 {name=p157611 lab=_68846_/X }
C {devices/lab_pin.sym} 158180 -2530 0 1 {name=p157612 lab=_68894_/Y }
C {sky130_stdcells/a21oi_4.sym} 158100 -2530 0 0 {name=X_68894_ }
C {devices/lab_pin.sym} 158020 -2410 0 0 {name=p157613 lab=_86283_/Q }
C {devices/lab_pin.sym} 158020 -2370 0 0 {name=p157614 lab=_49986_/X }
C {devices/lab_pin.sym} 158020 -2330 0 0 {name=p157615 lab=_50001_/Y }
C {devices/lab_pin.sym} 158180 -2370 0 1 {name=p157616 lab=_50002_/Y }
C {sky130_stdcells/o21ai_4.sym} 158100 -2370 0 0 {name=X_50002_ }
C {devices/lab_pin.sym} 158010 -2230 0 0 {name=p157617 lab=_87416_/CLK }
C {devices/lab_pin.sym} 158010 -2210 0 0 {name=p157618 lab=_78293_/B }
C {devices/lab_pin.sym} 158190 -2230 0 1 {name=p157619 lab=_82911_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -2220 0 0 {name=X_82911_ }
C {devices/lab_pin.sym} 158040 -2100 0 0 {name=p157620 lab=_67891_/A }
C {devices/lab_pin.sym} 158040 -2060 0 0 {name=p157621 lab=_67845_/B }
C {devices/lab_pin.sym} 158160 -2080 0 1 {name=p157622 lab=_67845_/X }
C {sky130_stdcells/and2_4.sym} 158100 -2080 0 0 {name=X_67845_ }
C {devices/lab_pin.sym} 158010 -1950 0 0 {name=p157623 lab=_82299_/CLK }
C {devices/lab_pin.sym} 158010 -1930 0 0 {name=p157624 lab=_69869_/X }
C {devices/lab_pin.sym} 158190 -1950 0 1 {name=p157625 lab=_81963_/D }
C {sky130_stdcells/dfxtp_4.sym} 158100 -1940 0 0 {name=X_83891_ }
C {devices/lab_pin.sym} 158040 -1840 0 0 {name=p157626 lab=_54825_/A }
C {devices/lab_pin.sym} 158040 -1800 0 0 {name=p157627 lab=_54816_/B }
C {devices/lab_pin.sym} 158040 -1760 0 0 {name=p157628 lab=_54831_/C }
C {devices/lab_pin.sym} 158040 -1720 0 0 {name=p157629 lab=_53118_/D }
C {devices/lab_pin.sym} 158160 -1780 0 1 {name=p157630 lab=_54810_/X }
C {sky130_stdcells/and4_4.sym} 158100 -1780 0 0 {name=X_54810_ }
C {devices/lab_pin.sym} 158010 -1630 0 0 {name=p157631 lab=_85630_/CLK }
C {devices/lab_pin.sym} 158010 -1610 0 0 {name=p157632 lab=_85630_/D }
C {devices/lab_pin.sym} 158190 -1630 0 1 {name=p157633 lab=_85630_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -1620 0 0 {name=X_85630_ }
C {devices/lab_pin.sym} 158010 -1490 0 0 {name=p157634 lab=_82748_/CLK }
C {devices/lab_pin.sym} 158010 -1470 0 0 {name=p157635 lab=_79443_/X }
C {devices/lab_pin.sym} 158190 -1490 0 1 {name=p157636 lab=_82842_/Q }
C {sky130_stdcells/dfxtp_4.sym} 158100 -1480 0 0 {name=X_82842_ }
C {devices/lab_pin.sym} 158040 -1360 0 0 {name=p157637 lab=_55787_/X }
C {devices/lab_pin.sym} 158040 -1320 0 0 {name=p157638 lab=_55790_/B }
C {devices/lab_pin.sym} 158160 -1340 0 1 {name=p157639 lab=_55790_/X }
C {sky130_stdcells/and2_4.sym} 158100 -1340 0 0 {name=X_55790_ }
C {devices/lab_pin.sym} 158060 -1210 0 0 {name=p157640 lab=_67657_/X }
C {devices/lab_pin.sym} 158140 -1210 0 1 {name=p157641 lab=_67873_/A }
C {sky130_stdcells/buf_2.sym} 158100 -1210 0 0 {name=X_67776_ }
C {devices/lab_pin.sym} 158020 -1120 0 0 {name=p157642 lab=_64828_/X }
C {devices/lab_pin.sym} 158020 -1080 0 0 {name=p157643 lab=_85555_/Q }
C {devices/lab_pin.sym} 158020 -1040 0 0 {name=p157644 lab=_64829_/X }
C {devices/lab_pin.sym} 158020 -1000 0 0 {name=p157645 lab=_64987_/X }
C {devices/lab_pin.sym} 158180 -1060 0 1 {name=p157646 lab=_64988_/X }
C {sky130_stdcells/a211o_4.sym} 158100 -1060 0 0 {name=X_64988_ }
C {devices/lab_pin.sym} 158040 -920 0 0 {name=p157647 lab=_69511_/X }
C {devices/lab_pin.sym} 158040 -880 0 0 {name=p157648 lab=_69515_/B }
C {devices/lab_pin.sym} 158160 -900 0 1 {name=p157649 lab=_69515_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -900 0 0 {name=X_69515_ }
C {devices/lab_pin.sym} 158040 -780 0 0 {name=p157650 lab=_54731_/X }
C {devices/lab_pin.sym} 158040 -740 0 0 {name=p157651 lab=_47442_/Y }
C {devices/lab_pin.sym} 158160 -760 0 1 {name=p157652 lab=_54741_/Y }
C {sky130_stdcells/nand2_4.sym} 158100 -760 0 0 {name=X_54741_ }
C {devices/lab_pin.sym} 158940 -42170 0 0 {name=p157653 lab=_66722_/X }
C {devices/lab_pin.sym} 158940 -42130 0 0 {name=p157654 lab=_66725_/X }
C {devices/lab_pin.sym} 158940 -42090 0 0 {name=p157655 lab=_66726_/X }
C {devices/lab_pin.sym} 159100 -42130 0 1 {name=p157656 lab=_66727_/X }
C {sky130_stdcells/a21o_4.sym} 159020 -42130 0 0 {name=X_66727_ }
C {devices/lab_pin.sym} 158930 -41990 0 0 {name=p157657 lab=_85561_/CLK }
C {devices/lab_pin.sym} 158930 -41970 0 0 {name=p157658 lab=_85561_/D }
C {devices/lab_pin.sym} 159110 -41990 0 1 {name=p157659 lab=_85561_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -41980 0 0 {name=X_85561_ }
C {devices/lab_pin.sym} 158940 -41870 0 0 {name=p157660 lab=_51948_/Y }
C {devices/lab_pin.sym} 158940 -41830 0 0 {name=p157661 lab=_51951_/X }
C {devices/lab_pin.sym} 158940 -41790 0 0 {name=p157662 lab=_51952_/X }
C {devices/lab_pin.sym} 159100 -41830 0 1 {name=p157663 lab=_85918_/D }
C {sky130_stdcells/a21oi_4.sym} 159020 -41830 0 0 {name=X_51953_ }
C {devices/lab_pin.sym} 158930 -41690 0 0 {name=p157664 lab=_82774_/CLK }
C {devices/lab_pin.sym} 158930 -41670 0 0 {name=p157665 lab=_82773_/D }
C {devices/lab_pin.sym} 159110 -41690 0 1 {name=p157666 lab=_82773_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -41680 0 0 {name=X_82773_ }
C {devices/lab_pin.sym} 158960 -41580 0 0 {name=p157667 lab=_63933_/Y }
C {devices/lab_pin.sym} 158960 -41540 0 0 {name=p157668 lab=_63935_/Y }
C {devices/lab_pin.sym} 158960 -41500 0 0 {name=p157669 lab=_63937_/Y }
C {devices/lab_pin.sym} 158960 -41460 0 0 {name=p157670 lab=_63939_/D }
C {devices/lab_pin.sym} 159080 -41520 0 1 {name=p157671 lab=_63939_/X }
C {sky130_stdcells/and4_4.sym} 159020 -41520 0 0 {name=X_63939_ }
C {devices/lab_pin.sym} 158930 -41370 0 0 {name=p157672 lab=_87820_/CLK }
C {devices/lab_pin.sym} 158930 -41350 0 0 {name=p157673 lab=_43709_/X }
C {devices/lab_pin.sym} 159110 -41370 0 1 {name=p157674 lab=_73149_/A }
C {sky130_stdcells/dfxtp_4.sym} 159020 -41360 0 0 {name=X_87300_ }
C {devices/lab_pin.sym} 158930 -41230 0 0 {name=p157675 lab=_84518_/CLK }
C {devices/lab_pin.sym} 158930 -41210 0 0 {name=p157676 lab=_84512_/D }
C {devices/lab_pin.sym} 159110 -41230 0 1 {name=p157677 lab=_61185_/C }
C {sky130_stdcells/dfxtp_4.sym} 159020 -41220 0 0 {name=X_84512_ }
C {devices/lab_pin.sym} 158960 -41120 0 0 {name=p157678 lab=_50908_/A }
C {devices/lab_pin.sym} 158960 -41080 0 0 {name=p157679 lab=_50919_/B }
C {devices/lab_pin.sym} 158960 -41040 0 0 {name=p157680 lab=_50897_/X }
C {devices/lab_pin.sym} 158960 -41000 0 0 {name=p157681 lab=_51768_/D }
C {devices/lab_pin.sym} 159080 -41060 0 1 {name=p157682 lab=_50904_/X }
C {sky130_stdcells/and4_4.sym} 159020 -41060 0 0 {name=X_50904_ }
C {devices/lab_pin.sym} 158960 -40920 0 0 {name=p157683 lab=_57050_/A }
C {devices/lab_pin.sym} 158960 -40880 0 0 {name=p157684 lab=_57400_/X }
C {devices/lab_pin.sym} 159080 -40900 0 1 {name=p157685 lab=_57460_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -40900 0 0 {name=X_57460_ }
C {devices/lab_pin.sym} 158930 -40770 0 0 {name=p157686 lab=_80928_/CLK }
C {devices/lab_pin.sym} 158930 -40750 0 0 {name=p157687 lab=_81724_/D }
C {devices/lab_pin.sym} 159110 -40770 0 1 {name=p157688 lab=_81724_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -40760 0 0 {name=X_81724_ }
C {devices/lab_pin.sym} 158960 -40640 0 0 {name=p157689 lab=_69322_/A }
C {devices/lab_pin.sym} 158960 -40600 0 0 {name=p157690 lab=_88285_/Q }
C {devices/lab_pin.sym} 159080 -40620 0 1 {name=p157691 lab=_69446_/X }
C {sky130_stdcells/and2_4.sym} 159020 -40620 0 0 {name=X_69446_ }
C {devices/lab_pin.sym} 158930 -40490 0 0 {name=p157692 lab=_88288_/CLK }
C {devices/lab_pin.sym} 158930 -40470 0 0 {name=p157693 lab=_41090_/Y }
C {devices/lab_pin.sym} 159110 -40490 0 1 {name=p157694 lab=_69513_/B }
C {sky130_stdcells/dfxtp_4.sym} 159020 -40480 0 0 {name=X_88280_ }
C {devices/lab_pin.sym} 158980 -40350 0 0 {name=p157695 lab=_54400_/A }
C {devices/lab_pin.sym} 159060 -40350 0 1 {name=p157696 lab=_54672_/X }
C {sky130_stdcells/buf_2.sym} 159020 -40350 0 0 {name=X_54672_ }
C {devices/lab_pin.sym} 158980 -40230 0 0 {name=p157697 lab=_60150_/A }
C {devices/lab_pin.sym} 159060 -40230 0 1 {name=p157698 lab=_66658_/X }
C {sky130_stdcells/buf_2.sym} 159020 -40230 0 0 {name=X_66658_ }
C {devices/lab_pin.sym} 158930 -40110 0 0 {name=p157699 lab=_85492_/CLK }
C {devices/lab_pin.sym} 158930 -40090 0 0 {name=p157700 lab=_85492_/D }
C {devices/lab_pin.sym} 159110 -40110 0 1 {name=p157701 lab=_85492_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -40100 0 0 {name=X_85492_ }
C {devices/lab_pin.sym} 158960 -39980 0 0 {name=p157702 lab=_51875_/A }
C {devices/lab_pin.sym} 158960 -39940 0 0 {name=p157703 lab=_51022_/B }
C {devices/lab_pin.sym} 159080 -39960 0 1 {name=p157704 lab=_51884_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -39960 0 0 {name=X_51884_ }
C {devices/lab_pin.sym} 158980 -39830 0 0 {name=p157705 lab=_56436_/A }
C {devices/lab_pin.sym} 159060 -39830 0 1 {name=p157706 lab=_56418_/B }
C {sky130_stdcells/buf_2.sym} 159020 -39830 0 0 {name=X_56411_ }
C {devices/lab_pin.sym} 158930 -39710 0 0 {name=p157707 lab=_87748_/CLK }
C {devices/lab_pin.sym} 158930 -39690 0 0 {name=p157708 lab=_43858_/Y }
C {devices/lab_pin.sym} 159110 -39710 0 1 {name=p157709 lab=_87231_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -39700 0 0 {name=X_87231_ }
C {devices/lab_pin.sym} 158940 -39590 0 0 {name=p157710 lab=_85600_/Q }
C {devices/lab_pin.sym} 158940 -39550 0 0 {name=p157711 lab=_53556_/X }
C {devices/lab_pin.sym} 158940 -39510 0 0 {name=p157712 lab=_53622_/Y }
C {devices/lab_pin.sym} 159100 -39550 0 1 {name=p157713 lab=_53623_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -39550 0 0 {name=X_53623_ }
C {devices/lab_pin.sym} 158960 -39420 0 0 {name=p157714 lab=_65731_/A }
C {devices/lab_pin.sym} 158960 -39380 0 0 {name=p157715 lab=_85877_/Q }
C {devices/lab_pin.sym} 159080 -39400 0 1 {name=p157716 lab=_65609_/X }
C {sky130_stdcells/and2_4.sym} 159020 -39400 0 0 {name=X_65609_ }
C {devices/lab_pin.sym} 158930 -39270 0 0 {name=p157717 lab=_84452_/CLK }
C {devices/lab_pin.sym} 158930 -39250 0 0 {name=p157718 lab=_84443_/D }
C {devices/lab_pin.sym} 159110 -39270 0 1 {name=p157719 lab=_78066_/B }
C {sky130_stdcells/dfxtp_4.sym} 159020 -39260 0 0 {name=X_84443_ }
C {devices/lab_pin.sym} 158940 -39150 0 0 {name=p157720 lab=_50833_/Y }
C {devices/lab_pin.sym} 158940 -39110 0 0 {name=p157721 lab=_50801_/X }
C {devices/lab_pin.sym} 158940 -39070 0 0 {name=p157722 lab=_50834_/X }
C {devices/lab_pin.sym} 159100 -39110 0 1 {name=p157723 lab=_86124_/D }
C {sky130_stdcells/a21oi_4.sym} 159020 -39110 0 0 {name=X_50835_ }
C {devices/lab_pin.sym} 158980 -38970 0 0 {name=p157724 lab=_57379_/Y }
C {devices/lab_pin.sym} 159060 -38970 0 1 {name=p157725 lab=_57391_/Y }
C {sky130_stdcells/inv_2.sym} 159020 -38970 0 0 {name=X_57391_ }
C {devices/lab_pin.sym} 158930 -38850 0 0 {name=p157726 lab=_81697_/CLK }
C {devices/lab_pin.sym} 158930 -38830 0 0 {name=p157727 lab=_81687_/Q }
C {devices/lab_pin.sym} 159110 -38850 0 1 {name=p157728 lab=_76453_/A }
C {sky130_stdcells/dfxtp_4.sym} 159020 -38840 0 0 {name=X_81655_ }
C {devices/lab_pin.sym} 158940 -38740 0 0 {name=p157729 lab=_87022_/Q }
C {devices/lab_pin.sym} 158940 -38700 0 0 {name=p157730 lab=_69239_/X }
C {devices/lab_pin.sym} 158940 -38660 0 0 {name=p157731 lab=_69361_/X }
C {devices/lab_pin.sym} 158940 -38620 0 0 {name=p157732 lab=_69376_/X }
C {devices/lab_pin.sym} 159100 -38680 0 1 {name=p157733 lab=_69377_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -38680 0 0 {name=X_69377_ }
C {devices/lab_pin.sym} 158940 -38560 0 0 {name=p157734 lab=_87954_/Q }
C {devices/lab_pin.sym} 158940 -38520 0 0 {name=p157735 lab=_66529_/X }
C {devices/lab_pin.sym} 158940 -38480 0 0 {name=p157736 lab=_66531_/X }
C {devices/lab_pin.sym} 158940 -38440 0 0 {name=p157737 lab=_66588_/X }
C {devices/lab_pin.sym} 159100 -38500 0 1 {name=p157738 lab=_66589_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -38500 0 0 {name=X_66589_ }
C {devices/lab_pin.sym} 158960 -38360 0 0 {name=p157739 lab=_59117_/A }
C {devices/lab_pin.sym} 158960 -38320 0 0 {name=p157740 lab=_86358_/Q }
C {devices/lab_pin.sym} 159080 -38340 0 1 {name=p157741 lab=_59130_/Y }
C {sky130_stdcells/nor2_4.sym} 159020 -38340 0 0 {name=X_59130_ }
C {devices/lab_pin.sym} 158960 -38220 0 0 {name=p157742 lab=_80606_/A }
C {devices/lab_pin.sym} 158960 -38180 0 0 {name=p157743 lab=_80606_/B }
C {devices/lab_pin.sym} 159080 -38200 0 1 {name=p157744 lab=_80607_/B }
C {sky130_stdcells/xnor2_4.sym} 159020 -38200 0 0 {name=X_80606_ }
C {devices/lab_pin.sym} 158940 -38090 0 0 {name=p157745 lab=_56114_/X }
C {devices/lab_pin.sym} 158940 -38050 0 0 {name=p157746 lab=_56337_/X }
C {devices/lab_pin.sym} 158940 -38010 0 0 {name=p157747 lab=_56341_/Y }
C {devices/lab_pin.sym} 159100 -38050 0 1 {name=p157748 lab=_85229_/D }
C {sky130_stdcells/o21ai_4.sym} 159020 -38050 0 0 {name=X_56342_ }
C {devices/lab_pin.sym} 158940 -37930 0 0 {name=p157749 lab=_68011_/X }
C {devices/lab_pin.sym} 158940 -37890 0 0 {name=p157750 lab=_68014_/X }
C {devices/lab_pin.sym} 158940 -37850 0 0 {name=p157751 lab=_68327_/X }
C {devices/lab_pin.sym} 159100 -37890 0 1 {name=p157752 lab=_68328_/Y }
C {sky130_stdcells/a21oi_4.sym} 159020 -37890 0 0 {name=X_68328_ }
C {devices/lab_pin.sym} 158930 -37750 0 0 {name=p157753 lab=_86935_/CLK }
C {devices/lab_pin.sym} 158930 -37730 0 0 {name=p157754 lab=_87162_/D }
C {devices/lab_pin.sym} 159110 -37750 0 1 {name=p157755 lab=_87162_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -37740 0 0 {name=X_87162_ }
C {devices/lab_pin.sym} 158960 -37630 0 0 {name=p157756 lab=_48287_/A }
C {devices/lab_pin.sym} 158960 -37590 0 0 {name=p157757 lab=_53474_/B }
C {devices/lab_pin.sym} 158960 -37550 0 0 {name=p157758 lab=_53492_/X }
C {devices/lab_pin.sym} 159080 -37590 0 1 {name=p157759 lab=_53554_/X }
C {sky130_stdcells/and3_4.sym} 159020 -37590 0 0 {name=X_53554_ }
C {devices/lab_pin.sym} 158930 -37450 0 0 {name=p157760 lab=_84438_/CLK }
C {devices/lab_pin.sym} 158930 -37430 0 0 {name=p157761 lab=_84374_/D }
C {devices/lab_pin.sym} 159110 -37450 0 1 {name=p157762 lab=_84374_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -37440 0 0 {name=X_84374_ }
C {devices/lab_pin.sym} 158960 -37320 0 0 {name=p157763 lab=_50771_/A }
C {devices/lab_pin.sym} 158960 -37280 0 0 {name=p157764 lab=_49245_/B }
C {devices/lab_pin.sym} 159080 -37300 0 1 {name=p157765 lab=_50766_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -37300 0 0 {name=X_50766_ }
C {devices/lab_pin.sym} 158930 -37170 0 0 {name=p157766 lab=_80912_/CLK }
C {devices/lab_pin.sym} 158930 -37150 0 0 {name=p157767 lab=_84186_/Q }
C {devices/lab_pin.sym} 159110 -37170 0 1 {name=p157768 lab=_76802_/A }
C {sky130_stdcells/dfxtp_4.sym} 159020 -37160 0 0 {name=X_81586_ }
C {devices/lab_pin.sym} 158930 -37030 0 0 {name=p157769 lab=_83685_/CLK }
C {devices/lab_pin.sym} 158930 -37010 0 0 {name=p157770 lab=_86113_/D }
C {devices/lab_pin.sym} 159110 -37030 0 1 {name=p157771 lab=_86113_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -37020 0 0 {name=X_86113_ }
C {devices/lab_pin.sym} 158940 -36910 0 0 {name=p157772 lab=_52503_/Y }
C {devices/lab_pin.sym} 158940 -36870 0 0 {name=p157773 lab=_52486_/X }
C {devices/lab_pin.sym} 158940 -36830 0 0 {name=p157774 lab=_52504_/Y }
C {devices/lab_pin.sym} 159100 -36870 0 1 {name=p157775 lab=_85809_/D }
C {sky130_stdcells/a21boi_4.sym} 159020 -36870 0 0 {name=X_52505_ }
C {devices/lab_pin.sym} 158980 -36730 0 0 {name=p157776 lab=_59061_/A }
C {devices/lab_pin.sym} 159060 -36730 0 1 {name=p157777 lab=_59061_/X }
C {sky130_stdcells/buf_2.sym} 159020 -36730 0 0 {name=X_59061_ }
C {devices/lab_pin.sym} 158930 -36610 0 0 {name=p157778 lab=_83325_/CLK }
C {devices/lab_pin.sym} 158930 -36590 0 0 {name=p157779 lab=_83325_/D }
C {devices/lab_pin.sym} 159110 -36610 0 1 {name=p157780 lab=_83325_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -36600 0 0 {name=X_83325_ }
C {devices/lab_pin.sym} 158980 -36470 0 0 {name=p157781 lab=_73359_/A }
C {devices/lab_pin.sym} 159060 -36470 0 1 {name=p157782 lab=_56273_/X }
C {sky130_stdcells/buf_2.sym} 159020 -36470 0 0 {name=X_56273_ }
C {devices/lab_pin.sym} 158940 -36370 0 0 {name=p157783 lab=_59102_/Y }
C {devices/lab_pin.sym} 158940 -36330 0 0 {name=p157784 lab=_66048_/C }
C {devices/lab_pin.sym} 158940 -36290 0 0 {name=p157785 lab=_80536_/Y }
C {devices/lab_pin.sym} 159100 -36330 0 1 {name=p157786 lab=_80537_/X }
C {sky130_stdcells/o21a_4.sym} 159020 -36330 0 0 {name=X_80537_ }
C {devices/lab_pin.sym} 158980 -36190 0 0 {name=p157787 lab=_68338_/A }
C {devices/lab_pin.sym} 159060 -36190 0 1 {name=p157788 lab=_68259_/X }
C {sky130_stdcells/buf_2.sym} 159020 -36190 0 0 {name=X_68259_ }
C {devices/lab_pin.sym} 158930 -36070 0 0 {name=p157789 lab=_88268_/CLK }
C {devices/lab_pin.sym} 158930 -36050 0 0 {name=p157790 lab=_87093_/D }
C {devices/lab_pin.sym} 159110 -36070 0 1 {name=p157791 lab=_87093_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -36060 0 0 {name=X_87093_ }
C {devices/lab_pin.sym} 158940 -35950 0 0 {name=p157792 lab=_53483_/Y }
C {devices/lab_pin.sym} 158940 -35910 0 0 {name=p157793 lab=_53455_/X }
C {devices/lab_pin.sym} 158940 -35870 0 0 {name=p157794 lab=_53484_/Y }
C {devices/lab_pin.sym} 159100 -35910 0 1 {name=p157795 lab=_53485_/Y }
C {sky130_stdcells/a21boi_4.sym} 159020 -35910 0 0 {name=X_53485_ }
C {devices/lab_pin.sym} 158960 -35780 0 0 {name=p157796 lab=_50682_/A }
C {devices/lab_pin.sym} 158960 -35740 0 0 {name=p157797 lab=_49144_/X }
C {devices/lab_pin.sym} 159080 -35760 0 1 {name=p157798 lab=_50697_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -35760 0 0 {name=X_50697_ }
C {devices/lab_pin.sym} 158960 -35640 0 0 {name=p157799 lab=_58070_/A }
C {devices/lab_pin.sym} 158960 -35600 0 0 {name=p157800 lab=_58012_/B }
C {devices/lab_pin.sym} 159080 -35620 0 1 {name=p157801 lab=_58012_/Y }
C {sky130_stdcells/nor2_4.sym} 159020 -35620 0 0 {name=X_58012_ }
C {devices/lab_pin.sym} 158960 -35500 0 0 {name=p157802 lab=_55224_/A }
C {devices/lab_pin.sym} 158960 -35460 0 0 {name=p157803 lab=_56920_/B }
C {devices/lab_pin.sym} 159080 -35480 0 1 {name=p157804 lab=_55224_/X }
C {sky130_stdcells/and2_4.sym} 159020 -35480 0 0 {name=X_55224_ }
C {devices/lab_pin.sym} 158930 -35350 0 0 {name=p157805 lab=_86139_/CLK }
C {devices/lab_pin.sym} 158930 -35330 0 0 {name=p157806 lab=_51267_/Y }
C {devices/lab_pin.sym} 159110 -35350 0 1 {name=p157807 lab=_64745_/B }
C {sky130_stdcells/dfxtp_4.sym} 159020 -35340 0 0 {name=X_86044_ }
C {devices/lab_pin.sym} 158960 -35220 0 0 {name=p157808 lab=_52436_/A }
C {devices/lab_pin.sym} 158960 -35180 0 0 {name=p157809 lab=_53953_/B }
C {devices/lab_pin.sym} 159080 -35200 0 1 {name=p157810 lab=_52436_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -35200 0 0 {name=X_52436_ }
C {devices/lab_pin.sym} 158960 -35080 0 0 {name=p157811 lab=_82323_/Q }
C {devices/lab_pin.sym} 158960 -35040 0 0 {name=p157812 lab=_40907_/B }
C {devices/lab_pin.sym} 159080 -35060 0 1 {name=p157813 lab=_40450_/X }
C {sky130_stdcells/or2_4.sym} 159020 -35060 0 0 {name=X_40450_ }
C {devices/lab_pin.sym} 158940 -34950 0 0 {name=p157814 lab=_53183_/B }
C {devices/lab_pin.sym} 158940 -34910 0 0 {name=p157815 lab=_71265_/X }
C {devices/lab_pin.sym} 158940 -34870 0 0 {name=p157816 lab=_71269_/Y }
C {devices/lab_pin.sym} 159100 -34910 0 1 {name=p157817 lab=_71270_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -34910 0 0 {name=X_71270_ }
C {devices/lab_pin.sym} 158930 -34770 0 0 {name=p157818 lab=_86600_/CLK }
C {devices/lab_pin.sym} 158930 -34750 0 0 {name=p157819 lab=_72426_/Y }
C {devices/lab_pin.sym} 159110 -34770 0 1 {name=p157820 lab=_83256_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -34760 0 0 {name=X_83256_ }
C {devices/lab_pin.sym} 158940 -34660 0 0 {name=p157821 lab=_80458_/A }
C {devices/lab_pin.sym} 158940 -34620 0 0 {name=p157822 lab=_80458_/B }
C {devices/lab_pin.sym} 158940 -34580 0 0 {name=p157823 lab=_80457_/A }
C {devices/lab_pin.sym} 158940 -34540 0 0 {name=p157824 lab=_80456_/Y }
C {devices/lab_pin.sym} 159100 -34600 0 1 {name=p157825 lab=_80468_/X }
C {sky130_stdcells/o22a_4.sym} 159020 -34600 0 0 {name=X_80468_ }
C {devices/lab_pin.sym} 158930 -34450 0 0 {name=p157826 lab=_82965_/CLK }
C {devices/lab_pin.sym} 158930 -34430 0 0 {name=p157827 lab=_77685_/X }
C {devices/lab_pin.sym} 159110 -34450 0 1 {name=p157828 lab=_82207_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -34440 0 0 {name=X_82207_ }
C {devices/lab_pin.sym} 158960 -34340 0 0 {name=p157829 lab=_70229_/A }
C {devices/lab_pin.sym} 158960 -34300 0 0 {name=p157830 lab=_70229_/B }
C {devices/lab_pin.sym} 158960 -34260 0 0 {name=p157831 lab=_70221_/C }
C {devices/lab_pin.sym} 158960 -34220 0 0 {name=p157832 lab=_70229_/D }
C {devices/lab_pin.sym} 159080 -34280 0 1 {name=p157833 lab=_70221_/X }
C {sky130_stdcells/and4_4.sym} 159020 -34280 0 0 {name=X_70221_ }
C {devices/lab_pin.sym} 158940 -34160 0 0 {name=p157834 lab=_57326_/B }
C {devices/lab_pin.sym} 158940 -34120 0 0 {name=p157835 lab=_55152_/X }
C {devices/lab_pin.sym} 158940 -34080 0 0 {name=p157836 lab=_55168_/A }
C {devices/lab_pin.sym} 158940 -34040 0 0 {name=p157837 lab=_55154_/X }
C {devices/lab_pin.sym} 159100 -34100 0 1 {name=p157838 lab=_55155_/X }
C {sky130_stdcells/a211o_4.sym} 159020 -34100 0 0 {name=X_55155_ }
C {devices/lab_pin.sym} 158980 -33950 0 0 {name=p157839 lab=_40380_/X }
C {devices/lab_pin.sym} 159060 -33950 0 1 {name=p157840 lab=_40381_/X }
C {sky130_stdcells/buf_2.sym} 159020 -33950 0 0 {name=X_40381_ }
C {devices/lab_pin.sym} 158960 -33840 0 0 {name=p157841 lab=_52349_/A }
C {devices/lab_pin.sym} 158960 -33800 0 0 {name=p157842 lab=_52367_/B }
C {devices/lab_pin.sym} 159080 -33820 0 1 {name=p157843 lab=_52367_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -33820 0 0 {name=X_52367_ }
C {devices/lab_pin.sym} 158930 -33690 0 0 {name=p157844 lab=_83187_/CLK }
C {devices/lab_pin.sym} 158930 -33670 0 0 {name=p157845 lab=_83187_/D }
C {devices/lab_pin.sym} 159110 -33690 0 1 {name=p157846 lab=_70236_/C }
C {sky130_stdcells/dfxtp_4.sym} 159020 -33680 0 0 {name=X_83187_ }
C {devices/lab_pin.sym} 158960 -33560 0 0 {name=p157847 lab=_84756_/Q }
C {devices/lab_pin.sym} 158960 -33520 0 0 {name=p157848 lab=_84148_/Q }
C {devices/lab_pin.sym} 159080 -33540 0 1 {name=p157849 lab=_80401_/A }
C {sky130_stdcells/xor2_4.sym} 159020 -33540 0 0 {name=X_80399_ }
C {devices/lab_pin.sym} 158980 -33410 0 0 {name=p157850 lab=_42083_/A }
C {devices/lab_pin.sym} 159060 -33410 0 1 {name=p157851 lab=_42120_/X }
C {sky130_stdcells/buf_2.sym} 159020 -33410 0 0 {name=X_42120_ }
C {devices/lab_pin.sym} 158960 -33300 0 0 {name=p157852 lab=_53434_/A }
C {devices/lab_pin.sym} 158960 -33260 0 0 {name=p157853 lab=_54106_/B }
C {devices/lab_pin.sym} 159080 -33280 0 1 {name=p157854 lab=_54106_/Y }
C {sky130_stdcells/nand2_4.sym} 159020 -33280 0 0 {name=X_54106_ }
C {devices/lab_pin.sym} 158960 -33160 0 0 {name=p157855 lab=_51306_/X }
C {devices/lab_pin.sym} 158960 -33120 0 0 {name=p157856 lab=_46438_/A }
C {devices/lab_pin.sym} 159080 -33140 0 1 {name=p157857 lab=_51318_/X }
C {sky130_stdcells/and2_4.sym} 159020 -33140 0 0 {name=X_51318_ }
C {devices/lab_pin.sym} 158960 -33020 0 0 {name=p157858 lab=_70150_/Y }
C {devices/lab_pin.sym} 158960 -32980 0 0 {name=p157859 lab=_70151_/Y }
C {devices/lab_pin.sym} 159080 -33000 0 1 {name=p157860 lab=_70153_/A }
C {sky130_stdcells/nand2_4.sym} 159020 -33000 0 0 {name=X_70152_ }
C {devices/lab_pin.sym} 158930 -32870 0 0 {name=p157861 lab=_82047_/CLK }
C {devices/lab_pin.sym} 158930 -32850 0 0 {name=p157862 lab=_82138_/D }
C {devices/lab_pin.sym} 159110 -32870 0 1 {name=p157863 lab=_82094_/D }
C {sky130_stdcells/dfxtp_4.sym} 159020 -32860 0 0 {name=X_82138_ }
C {devices/lab_pin.sym} 158940 -32750 0 0 {name=p157864 lab=_85321_/Q }
C {devices/lab_pin.sym} 158940 -32710 0 0 {name=p157865 lab=_55072_/X }
C {devices/lab_pin.sym} 158940 -32670 0 0 {name=p157866 lab=_55085_/Y }
C {devices/lab_pin.sym} 159100 -32710 0 1 {name=p157867 lab=_55086_/Y }
C {sky130_stdcells/o21ai_4.sym} 159020 -32710 0 0 {name=X_55086_ }
C {devices/lab_pin.sym} 158940 -32600 0 0 {name=p157868 lab=_80241_/A }
C {devices/lab_pin.sym} 158940 -32560 0 0 {name=p157869 lab=_59787_/X }
C {devices/lab_pin.sym} 158940 -32520 0 0 {name=p157870 lab=_61205_/B }
C {devices/lab_pin.sym} 158940 -32480 0 0 {name=p157871 lab=_59962_/X }
C {devices/lab_pin.sym} 159100 -32540 0 1 {name=p157872 lab=_59964_/A }
C {sky130_stdcells/a2bb2o_4.sym} 159020 -32540 0 0 {name=X_59963_ }
C {devices/lab_pin.sym} 158980 -32390 0 0 {name=p157873 lab=_52271_/A }
C {devices/lab_pin.sym} 159060 -32390 0 1 {name=p157874 lab=_52299_/A }
C {sky130_stdcells/buf_2.sym} 159020 -32390 0 0 {name=X_52298_ }
C {devices/lab_pin.sym} 158930 -32270 0 0 {name=p157875 lab=_87995_/CLK }
C {devices/lab_pin.sym} 158930 -32250 0 0 {name=p157876 lab=_87995_/D }
C {devices/lab_pin.sym} 159110 -32270 0 1 {name=p157877 lab=_87995_/Q }
C {sky130_stdcells/dfxtp_4.sym} 159020 -32260 0 0 {name=X_87995_ }
C {devices/lab_pin.sym} 158940 -32150 0 0 {name=p157878 lab=_58904_/X }
C {devices/lab_pin.sym} 158940 -32110 0 0 {name=p157879 lab=_85766_/Q }
C {devices/lab_pin.sym} 158940 -32070 0 0 {name=p157880 lab=_58838_/X }
C {devices/lab_pin.sym} 159100 -32110 0 1 {name=p157881 lab=_58914_/X }
