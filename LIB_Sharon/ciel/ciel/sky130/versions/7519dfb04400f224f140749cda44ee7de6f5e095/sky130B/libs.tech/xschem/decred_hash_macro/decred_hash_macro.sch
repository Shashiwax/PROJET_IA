C {devices/lab_pin.sym} 128580 -23370 0 0 {name=p127707 lab=_59733_/Y }
C {devices/lab_pin.sym} 128580 -23340 0 0 {name=p127708 lab=_59737_/Y }
C {devices/lab_pin.sym} 128740 -23410 0 1 {name=p127709 lab=_59738_/Y }
C {sky130_stdcells/a41oi_4.sym} 128660 -23410 0 0 {name=X_59738_ }
C {devices/lab_pin.sym} 128620 -23250 0 0 {name=p127710 lab=_78572_/A }
C {devices/lab_pin.sym} 128700 -23250 0 1 {name=p127711 lab=_78572_/Y }
C {sky130_stdcells/inv_2.sym} 128660 -23250 0 0 {name=X_78572_ }
C {devices/lab_pin.sym} 128620 -23130 0 0 {name=p127712 lab=_44887_/X }
C {devices/lab_pin.sym} 128700 -23130 0 1 {name=p127713 lab=_44964_/X }
C {sky130_stdcells/buf_2.sym} 128660 -23130 0 0 {name=X_44964_ }
C {devices/lab_pin.sym} 128600 -23020 0 0 {name=p127714 lab=_75784_/A }
C {devices/lab_pin.sym} 128600 -22980 0 0 {name=p127715 lab=_75783_/Y }
C {devices/lab_pin.sym} 128720 -23000 0 1 {name=p127716 lab=_80889_/D }
C {sky130_stdcells/xnor2_4.sym} 128660 -23000 0 0 {name=X_75784_ }
C {devices/lab_pin.sym} 128600 -22880 0 0 {name=p127717 lab=_74403_/B }
C {devices/lab_pin.sym} 128600 -22840 0 0 {name=p127718 lab=_72996_/B }
C {devices/lab_pin.sym} 128720 -22860 0 1 {name=p127719 lab=_72996_/X }
C {sky130_stdcells/xor2_4.sym} 128660 -22860 0 0 {name=X_72996_ }
C {devices/lab_pin.sym} 128580 -22750 0 0 {name=p127720 lab=_58677_/A }
C {devices/lab_pin.sym} 128580 -22710 0 0 {name=p127721 lab=_46672_/X }
C {devices/lab_pin.sym} 128580 -22670 0 0 {name=p127722 lab=_46702_/Y }
C {devices/lab_pin.sym} 128740 -22710 0 1 {name=p127723 lab=_46703_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -22710 0 0 {name=X_46703_ }
C {devices/lab_pin.sym} 128620 -22570 0 0 {name=p127724 lab=_77512_/B }
C {devices/lab_pin.sym} 128700 -22570 0 1 {name=p127725 lab=_77523_/Y }
C {sky130_stdcells/inv_2.sym} 128660 -22570 0 0 {name=X_77523_ }
C {devices/lab_pin.sym} 128620 -22450 0 0 {name=p127726 lab=_43914_/Y }
C {devices/lab_pin.sym} 128700 -22450 0 1 {name=p127727 lab=_43915_/Y }
C {sky130_stdcells/inv_2.sym} 128660 -22450 0 0 {name=X_43915_ }
C {devices/lab_pin.sym} 128620 -22330 0 0 {name=p127728 lab=_74734_/Y }
C {devices/lab_pin.sym} 128700 -22330 0 1 {name=p127729 lab=_74735_/X }
C {sky130_stdcells/buf_2.sym} 128660 -22330 0 0 {name=X_74735_ }
C {devices/lab_pin.sym} 128620 -22210 0 0 {name=p127730 lab=_47682_/Y }
C {devices/lab_pin.sym} 128700 -22210 0 1 {name=p127731 lab=_53185_/D }
C {sky130_stdcells/buf_2.sym} 128660 -22210 0 0 {name=X_47683_ }
C {devices/lab_pin.sym} 128600 -22120 0 0 {name=p127732 lab=_70383_/X }
C {devices/lab_pin.sym} 128600 -22080 0 0 {name=p127733 lab=_70766_/C }
C {devices/lab_pin.sym} 128600 -22040 0 0 {name=p127734 lab=_71349_/D }
C {devices/lab_pin.sym} 128600 -22000 0 0 {name=p127735 lab=_71945_/D }
C {devices/lab_pin.sym} 128720 -22060 0 1 {name=p127736 lab=_71947_/Y }
C {sky130_stdcells/nand4_4.sym} 128660 -22060 0 0 {name=X_71947_ }
C {devices/lab_pin.sym} 128620 -21910 0 0 {name=p127737 lab=_45923_/X }
C {devices/lab_pin.sym} 128700 -21910 0 1 {name=p127738 lab=_64738_/A }
C {sky130_stdcells/buf_2.sym} 128660 -21910 0 0 {name=X_59669_ }
C {devices/lab_pin.sym} 128620 -21790 0 0 {name=p127739 lab=_45193_/A }
C {devices/lab_pin.sym} 128700 -21790 0 1 {name=p127740 lab=_44895_/X }
C {sky130_stdcells/buf_2.sym} 128660 -21790 0 0 {name=X_44895_ }
C {devices/lab_pin.sym} 128600 -21680 0 0 {name=p127741 lab=_49418_/A }
C {devices/lab_pin.sym} 128600 -21640 0 0 {name=p127742 lab=_51807_/B }
C {devices/lab_pin.sym} 128720 -21660 0 1 {name=p127743 lab=_49422_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -21660 0 0 {name=X_49422_ }
C {devices/lab_pin.sym} 128600 -21550 0 0 {name=p127744 lab=_61690_/A }
C {devices/lab_pin.sym} 128600 -21510 0 0 {name=p127745 lab=_61690_/B }
C {devices/lab_pin.sym} 128600 -21470 0 0 {name=p127746 lab=_84458_/Q }
C {devices/lab_pin.sym} 128720 -21510 0 1 {name=p127747 lab=_61700_/Y }
C {sky130_stdcells/nor3_4.sym} 128660 -21510 0 0 {name=X_61700_ }
C {devices/lab_pin.sym} 128620 -21370 0 0 {name=p127748 lab=_54277_/B }
C {devices/lab_pin.sym} 128700 -21370 0 1 {name=p127749 lab=_50893_/B }
C {sky130_stdcells/buf_2.sym} 128660 -21370 0 0 {name=X_46634_ }
C {devices/lab_pin.sym} 128580 -21270 0 0 {name=p127750 lab=_77447_/A }
C {devices/lab_pin.sym} 128580 -21230 0 0 {name=p127751 lab=_77444_/Y }
C {devices/lab_pin.sym} 128580 -21190 0 0 {name=p127752 lab=_77446_/A }
C {devices/lab_pin.sym} 128740 -21230 0 1 {name=p127753 lab=_77454_/X }
C {sky130_stdcells/o21a_4.sym} 128660 -21230 0 0 {name=X_77454_ }
C {devices/lab_pin.sym} 128620 -21090 0 0 {name=p127754 lab=_43810_/A }
C {devices/lab_pin.sym} 128700 -21090 0 1 {name=p127755 lab=_43846_/X }
C {sky130_stdcells/buf_2.sym} 128660 -21090 0 0 {name=X_43846_ }
C {devices/lab_pin.sym} 128620 -20970 0 0 {name=p127756 lab=_62679_/X }
C {devices/lab_pin.sym} 128700 -20970 0 1 {name=p127757 lab=_62694_/B }
C {sky130_stdcells/buf_2.sym} 128660 -20970 0 0 {name=X_62680_ }
C {devices/lab_pin.sym} 128620 -20850 0 0 {name=p127758 lab=_74675_/A }
C {devices/lab_pin.sym} 128700 -20850 0 1 {name=p127759 lab=_74679_/A }
C {sky130_stdcells/buf_2.sym} 128660 -20850 0 0 {name=X_74666_ }
C {devices/lab_pin.sym} 128620 -20730 0 0 {name=p127760 lab=_71319_/B }
C {devices/lab_pin.sym} 128700 -20730 0 1 {name=p127761 lab=_71883_/D }
C {sky130_stdcells/buf_2.sym} 128660 -20730 0 0 {name=X_71878_ }
C {devices/lab_pin.sym} 128580 -20630 0 0 {name=p127762 lab=_76387_/B }
C {devices/lab_pin.sym} 128580 -20590 0 0 {name=p127763 lab=_76387_/A }
C {devices/lab_pin.sym} 128580 -20550 0 0 {name=p127764 lab=_76404_/X }
C {devices/lab_pin.sym} 128740 -20590 0 1 {name=p127765 lab=_76405_/Y }
C {sky130_stdcells/a21boi_4.sym} 128660 -20590 0 0 {name=X_76405_ }
C {devices/lab_pin.sym} 128600 -20480 0 0 {name=p127766 lab=_58348_/A }
C {devices/lab_pin.sym} 128600 -20440 0 0 {name=p127767 lab=_61598_/X }
C {devices/lab_pin.sym} 128600 -20400 0 0 {name=p127768 lab=_61677_/C }
C {devices/lab_pin.sym} 128600 -20360 0 0 {name=p127769 lab=_61563_/D }
C {devices/lab_pin.sym} 128720 -20420 0 1 {name=p127770 lab=_61632_/A }
C {sky130_stdcells/nand4_4.sym} 128660 -20420 0 0 {name=X_61631_ }
C {devices/lab_pin.sym} 128580 -20290 0 0 {name=p127771 lab=_65381_/B }
C {devices/lab_pin.sym} 128580 -20250 0 0 {name=p127772 lab=_49334_/X }
C {devices/lab_pin.sym} 128580 -20210 0 0 {name=p127773 lab=_49352_/Y }
C {devices/lab_pin.sym} 128740 -20250 0 1 {name=p127774 lab=_49353_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -20250 0 0 {name=X_49353_ }
C {devices/lab_pin.sym} 128580 -20140 0 0 {name=p127775 lab=_72829_/X }
C {devices/lab_pin.sym} 128580 -20100 0 0 {name=p127776 lab=_84991_/Q }
C {devices/lab_pin.sym} 128580 -20060 0 0 {name=p127777 lab=_73614_/X }
C {devices/lab_pin.sym} 128580 -20020 0 0 {name=p127778 lab=_73616_/X }
C {devices/lab_pin.sym} 128740 -20080 0 1 {name=p127779 lab=_73617_/X }
C {sky130_stdcells/a211o_4.sym} 128660 -20080 0 0 {name=X_73617_ }
C {devices/lab_pin.sym} 128600 -19940 0 0 {name=p127780 lab=_46547_/A }
C {devices/lab_pin.sym} 128600 -19900 0 0 {name=p127781 lab=_51378_/B }
C {devices/lab_pin.sym} 128720 -19920 0 1 {name=p127782 lab=_46565_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -19920 0 0 {name=X_46565_ }
C {devices/lab_pin.sym} 128620 -19790 0 0 {name=p127783 lab=_70832_/A }
C {devices/lab_pin.sym} 128700 -19790 0 1 {name=p127784 lab=_70830_/B }
C {sky130_stdcells/inv_2.sym} 128660 -19790 0 0 {name=X_70829_ }
C {devices/lab_pin.sym} 128620 -19670 0 0 {name=p127785 lab=_77385_/A }
C {devices/lab_pin.sym} 128700 -19670 0 1 {name=p127786 lab=_77386_/B }
C {sky130_stdcells/buf_2.sym} 128660 -19670 0 0 {name=X_77385_ }
C {devices/lab_pin.sym} 128580 -19590 0 0 {name=p127787 lab=_43774_/X }
C {devices/lab_pin.sym} 128580 -19550 0 0 {name=p127788 lab=_43760_/X }
C {devices/lab_pin.sym} 128580 -19510 0 0 {name=p127789 lab=_40994_/X }
C {devices/lab_pin.sym} 128580 -19470 0 0 {name=p127790 lab=_69288_/B }
C {devices/lab_pin.sym} 128580 -19430 0 0 {name=p127791 lab=_43776_/X }
C {devices/lab_pin.sym} 128740 -19510 0 1 {name=p127792 lab=_43777_/Y }
C {sky130_stdcells/o32ai_4.sym} 128660 -19510 0 0 {name=X_43777_ }
C {devices/lab_pin.sym} 128580 -19370 0 0 {name=p127793 lab=_45216_/A }
C {devices/lab_pin.sym} 128580 -19330 0 0 {name=p127794 lab=_74582_/X }
C {devices/lab_pin.sym} 128580 -19290 0 0 {name=p127795 lab=_74596_/X }
C {devices/lab_pin.sym} 128740 -19330 0 1 {name=p127796 lab=_83021_/D }
C {sky130_stdcells/o21ai_4.sym} 128660 -19330 0 0 {name=X_74597_ }
C {devices/lab_pin.sym} 128620 -19190 0 0 {name=p127797 lab=_40989_/A }
C {devices/lab_pin.sym} 128700 -19190 0 1 {name=p127798 lab=_40989_/X }
C {sky130_stdcells/buf_2.sym} 128660 -19190 0 0 {name=X_40989_ }
C {devices/lab_pin.sym} 128580 -19090 0 0 {name=p127799 lab=_48301_/Y }
C {devices/lab_pin.sym} 128580 -19050 0 0 {name=p127800 lab=_48302_/X }
C {devices/lab_pin.sym} 128580 -19010 0 0 {name=p127801 lab=_48303_/X }
C {devices/lab_pin.sym} 128740 -19050 0 1 {name=p127802 lab=_86539_/D }
C {sky130_stdcells/a21oi_4.sym} 128660 -19050 0 0 {name=X_48304_ }
C {devices/lab_pin.sym} 128620 -18910 0 0 {name=p127803 lab=_79123_/Y }
C {devices/lab_pin.sym} 128700 -18910 0 1 {name=p127804 lab=_79124_/Y }
C {sky130_stdcells/inv_2.sym} 128660 -18910 0 0 {name=X_79124_ }
C {devices/lab_pin.sym} 128620 -18790 0 0 {name=p127805 lab=_45596_/A }
C {devices/lab_pin.sym} 128700 -18790 0 1 {name=p127806 lab=_45516_/X }
C {sky130_stdcells/buf_2.sym} 128660 -18790 0 0 {name=X_45516_ }
C {devices/lab_pin.sym} 128580 -18690 0 0 {name=p127807 lab=_79764_/B }
C {devices/lab_pin.sym} 128580 -18650 0 0 {name=p127808 lab=_64314_/X }
C {devices/lab_pin.sym} 128580 -18610 0 0 {name=p127809 lab=_64349_/X }
C {devices/lab_pin.sym} 128740 -18650 0 1 {name=p127810 lab=_64350_/X }
C {sky130_stdcells/a21o_4.sym} 128660 -18650 0 0 {name=X_64350_ }
C {devices/lab_pin.sym} 128600 -18520 0 0 {name=p127811 lab=_76336_/A }
C {devices/lab_pin.sym} 128600 -18480 0 0 {name=p127812 lab=_76336_/B }
C {devices/lab_pin.sym} 128720 -18500 0 1 {name=p127813 lab=_76337_/A }
C {sky130_stdcells/and2_4.sym} 128660 -18500 0 0 {name=X_76336_ }
C {devices/lab_pin.sym} 128580 -18410 0 0 {name=p127814 lab=_42721_/X }
C {devices/lab_pin.sym} 128580 -18370 0 0 {name=p127815 lab=_42723_/X }
C {devices/lab_pin.sym} 128580 -18330 0 0 {name=p127816 lab=_41193_/X }
C {devices/lab_pin.sym} 128580 -18290 0 0 {name=p127817 lab=_68755_/B }
C {devices/lab_pin.sym} 128580 -18250 0 0 {name=p127818 lab=_42700_/X }
C {devices/lab_pin.sym} 128740 -18330 0 1 {name=p127819 lab=_42728_/Y }
C {sky130_stdcells/o32ai_4.sym} 128660 -18330 0 0 {name=X_42728_ }
C {devices/lab_pin.sym} 128580 -18190 0 0 {name=p127820 lab=_49280_/Y }
C {devices/lab_pin.sym} 128580 -18150 0 0 {name=p127821 lab=_49281_/X }
C {devices/lab_pin.sym} 128580 -18110 0 0 {name=p127822 lab=_49283_/X }
C {devices/lab_pin.sym} 128740 -18150 0 1 {name=p127823 lab=_49284_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -18150 0 0 {name=X_49284_ }
C {devices/lab_pin.sym} 128620 -18010 0 0 {name=p127824 lab=_61380_/A }
C {devices/lab_pin.sym} 128700 -18010 0 1 {name=p127825 lab=_61563_/D }
C {sky130_stdcells/buf_2.sym} 128660 -18010 0 0 {name=X_61562_ }
C {devices/lab_pin.sym} 128580 -17910 0 0 {name=p127826 lab=_83146_/Q }
C {devices/lab_pin.sym} 128580 -17870 0 0 {name=p127827 lab=_73437_/X }
C {devices/lab_pin.sym} 128580 -17830 0 0 {name=p127828 lab=_73547_/Y }
C {devices/lab_pin.sym} 128740 -17870 0 1 {name=p127829 lab=_73548_/X }
C {sky130_stdcells/a21o_4.sym} 128660 -17870 0 0 {name=X_73548_ }
C {devices/lab_pin.sym} 128580 -17750 0 0 {name=p127830 lab=_46493_/X }
C {devices/lab_pin.sym} 128580 -17710 0 0 {name=p127831 lab=_82924_/Q }
C {devices/lab_pin.sym} 128580 -17670 0 0 {name=p127832 lab=_46495_/Y }
C {devices/lab_pin.sym} 128740 -17710 0 1 {name=p127833 lab=_54047_/A }
C {sky130_stdcells/o21ai_4.sym} 128660 -17710 0 0 {name=X_46496_ }
C {devices/lab_pin.sym} 128600 -17600 0 0 {name=p127834 lab=_84871_/Q }
C {devices/lab_pin.sym} 128600 -17560 0 0 {name=p127835 lab=_63281_/B }
C {devices/lab_pin.sym} 128600 -17520 0 0 {name=p127836 lab=_63301_/C }
C {devices/lab_pin.sym} 128600 -17480 0 0 {name=p127837 lab=_63281_/D }
C {devices/lab_pin.sym} 128720 -17540 0 1 {name=p127838 lab=_63301_/X }
C {sky130_stdcells/or4_4.sym} 128660 -17540 0 0 {name=X_63301_ }
C {devices/lab_pin.sym} 128580 -17410 0 0 {name=p127839 lab=_48232_/Y }
C {devices/lab_pin.sym} 128580 -17370 0 0 {name=p127840 lab=_48233_/X }
C {devices/lab_pin.sym} 128580 -17330 0 0 {name=p127841 lab=_48234_/X }
C {devices/lab_pin.sym} 128740 -17370 0 1 {name=p127842 lab=_48235_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -17370 0 0 {name=X_48235_ }
C {devices/lab_pin.sym} 128600 -17250 0 0 {name=p127843 lab=_60513_/A }
C {devices/lab_pin.sym} 128600 -17210 0 0 {name=p127844 lab=_60513_/B }
C {devices/lab_pin.sym} 128600 -17170 0 0 {name=p127845 lab=_79148_/A }
C {devices/lab_pin.sym} 128720 -17210 0 1 {name=p127846 lab=_60513_/X }
C {sky130_stdcells/or3_4.sym} 128660 -17210 0 0 {name=X_60513_ }
C {devices/lab_pin.sym} 128600 -17080 0 0 {name=p127847 lab=_79055_/A }
C {devices/lab_pin.sym} 128600 -17040 0 0 {name=p127848 lab=_79055_/B }
C {devices/lab_pin.sym} 128720 -17060 0 1 {name=p127849 lab=_79057_/C }
C {sky130_stdcells/nor2_4.sym} 128660 -17060 0 0 {name=X_79055_ }
C {devices/lab_pin.sym} 128580 -16950 0 0 {name=p127850 lab=_45441_/X }
C {devices/lab_pin.sym} 128580 -16910 0 0 {name=p127851 lab=_45445_/X }
C {devices/lab_pin.sym} 128580 -16870 0 0 {name=p127852 lab=_45446_/X }
C {devices/lab_pin.sym} 128740 -16910 0 1 {name=p127853 lab=_45447_/X }
C {sky130_stdcells/a21o_4.sym} 128660 -16910 0 0 {name=X_45447_ }
C {devices/lab_pin.sym} 128580 -16790 0 0 {name=p127854 lab=_84260_/Q }
C {devices/lab_pin.sym} 128580 -16750 0 0 {name=p127855 lab=_64255_/X }
C {devices/lab_pin.sym} 128580 -16710 0 0 {name=p127856 lab=_64280_/X }
C {devices/lab_pin.sym} 128740 -16750 0 1 {name=p127857 lab=_84260_/D }
C {sky130_stdcells/a21o_4.sym} 128660 -16750 0 0 {name=X_64281_ }
C {devices/lab_pin.sym} 128600 -16620 0 0 {name=p127858 lab=_76267_/A }
C {devices/lab_pin.sym} 128600 -16580 0 0 {name=p127859 lab=_76267_/B }
C {devices/lab_pin.sym} 128720 -16600 0 1 {name=p127860 lab=_76273_/A }
C {sky130_stdcells/nand2_4.sym} 128660 -16600 0 0 {name=X_76267_ }
C {devices/lab_pin.sym} 128580 -16510 0 0 {name=p127861 lab=_42647_/X }
C {devices/lab_pin.sym} 128580 -16470 0 0 {name=p127862 lab=_42648_/X }
C {devices/lab_pin.sym} 128580 -16430 0 0 {name=p127863 lab=_41004_/X }
C {devices/lab_pin.sym} 128580 -16390 0 0 {name=p127864 lab=_87783_/Q }
C {devices/lab_pin.sym} 128580 -16350 0 0 {name=p127865 lab=_42658_/X }
C {devices/lab_pin.sym} 128740 -16430 0 1 {name=p127866 lab=_42659_/Y }
C {sky130_stdcells/o32ai_4.sym} 128660 -16430 0 0 {name=X_42659_ }
C {devices/lab_pin.sym} 128600 -16300 0 0 {name=p127867 lab=_59411_/A }
C {devices/lab_pin.sym} 128600 -16260 0 0 {name=p127868 lab=_61484_/B }
C {devices/lab_pin.sym} 128600 -16220 0 0 {name=p127869 lab=_61484_/C }
C {devices/lab_pin.sym} 128600 -16180 0 0 {name=p127870 lab=_61452_/D }
C {devices/lab_pin.sym} 128720 -16240 0 1 {name=p127871 lab=_61494_/A }
C {sky130_stdcells/nand4_4.sym} 128660 -16240 0 0 {name=X_61493_ }
C {devices/lab_pin.sym} 128600 -16100 0 0 {name=p127872 lab=_48672_/A }
C {devices/lab_pin.sym} 128600 -16060 0 0 {name=p127873 lab=_73478_/Y }
C {devices/lab_pin.sym} 128720 -16080 0 1 {name=p127874 lab=_73479_/X }
C {sky130_stdcells/xor2_4.sym} 128660 -16080 0 0 {name=X_73479_ }
C {devices/lab_pin.sym} 128620 -15950 0 0 {name=p127875 lab=_66366_/A }
C {devices/lab_pin.sym} 128700 -15950 0 1 {name=p127876 lab=_66020_/X }
C {sky130_stdcells/buf_2.sym} 128660 -15950 0 0 {name=X_66020_ }
C {devices/lab_pin.sym} 128600 -15840 0 0 {name=p127877 lab=_78003_/A }
C {devices/lab_pin.sym} 128600 -15800 0 0 {name=p127878 lab=_78006_/B }
C {devices/lab_pin.sym} 128720 -15820 0 1 {name=p127879 lab=_78006_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -15820 0 0 {name=X_78006_ }
C {devices/lab_pin.sym} 128580 -15710 0 0 {name=p127880 lab=_63228_/Y }
C {devices/lab_pin.sym} 128580 -15670 0 0 {name=p127881 lab=_63230_/X }
C {devices/lab_pin.sym} 128580 -15630 0 0 {name=p127882 lab=_63231_/X }
C {devices/lab_pin.sym} 128740 -15670 0 1 {name=p127883 lab=_63232_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -15670 0 0 {name=X_63232_ }
C {devices/lab_pin.sym} 128580 -15550 0 0 {name=p127884 lab=_75207_/Y }
C {devices/lab_pin.sym} 128580 -15510 0 0 {name=p127885 lab=_75190_/Y }
C {devices/lab_pin.sym} 128580 -15470 0 0 {name=p127886 lab=_75205_/A }
C {devices/lab_pin.sym} 128740 -15510 0 1 {name=p127887 lab=_75218_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -15510 0 0 {name=X_75218_ }
C {devices/lab_pin.sym} 128580 -15390 0 0 {name=p127888 lab=_73568_/B }
C {devices/lab_pin.sym} 128580 -15350 0 0 {name=p127889 lab=_40568_/X }
C {devices/lab_pin.sym} 128580 -15310 0 0 {name=p127890 lab=_48165_/X }
C {devices/lab_pin.sym} 128740 -15350 0 1 {name=p127891 lab=_48166_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -15350 0 0 {name=X_48166_ }
C {devices/lab_pin.sym} 128580 -15250 0 0 {name=p127892 lab=_60515_/C }
C {devices/lab_pin.sym} 128580 -15210 0 0 {name=p127893 lab=_60476_/D }
C {devices/lab_pin.sym} 128580 -15170 0 0 {name=p127894 lab=_60399_/B }
C {devices/lab_pin.sym} 128580 -15130 0 0 {name=p127895 lab=_72296_/A }
C {devices/lab_pin.sym} 128580 -15090 0 0 {name=p127896 lab=_72176_/A }
C {devices/lab_pin.sym} 128740 -15170 0 1 {name=p127897 lab=_60444_/Y }
C {sky130_stdcells/o32ai_4.sym} 128660 -15170 0 0 {name=X_60444_ }
C {devices/lab_pin.sym} 128620 -15010 0 0 {name=p127898 lab=_45651_/A }
C {devices/lab_pin.sym} 128700 -15010 0 1 {name=p127899 lab=_45378_/X }
C {sky130_stdcells/buf_2.sym} 128660 -15010 0 0 {name=X_45378_ }
C {devices/lab_pin.sym} 128620 -14890 0 0 {name=p127900 lab=_76199_/B }
C {devices/lab_pin.sym} 128700 -14890 0 1 {name=p127901 lab=_76198_/Y }
C {sky130_stdcells/inv_2.sym} 128660 -14890 0 0 {name=X_76198_ }
C {devices/lab_pin.sym} 128600 -14780 0 0 {name=p127902 lab=_47109_/A }
C {devices/lab_pin.sym} 128600 -14740 0 0 {name=p127903 lab=_52863_/B }
C {devices/lab_pin.sym} 128720 -14760 0 1 {name=p127904 lab=_47117_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -14760 0 0 {name=X_47117_ }
C {devices/lab_pin.sym} 128620 -14630 0 0 {name=p127905 lab=_44587_/A }
C {devices/lab_pin.sym} 128700 -14630 0 1 {name=p127906 lab=_44381_/A }
C {sky130_stdcells/buf_2.sym} 128660 -14630 0 0 {name=X_44329_ }
C {devices/lab_pin.sym} 128580 -14530 0 0 {name=p127907 lab=_79372_/A }
C {devices/lab_pin.sym} 128580 -14490 0 0 {name=p127908 lab=_63130_/X }
C {devices/lab_pin.sym} 128580 -14450 0 0 {name=p127909 lab=_63162_/Y }
C {devices/lab_pin.sym} 128740 -14490 0 1 {name=p127910 lab=_63163_/X }
C {sky130_stdcells/a21o_4.sym} 128660 -14490 0 0 {name=X_63163_ }
C {devices/lab_pin.sym} 128600 -14360 0 0 {name=p127911 lab=_75147_/Y }
C {devices/lab_pin.sym} 128600 -14320 0 0 {name=p127912 lab=_75148_/Y }
C {devices/lab_pin.sym} 128720 -14340 0 1 {name=p127913 lab=_81031_/D }
C {sky130_stdcells/xor2_4.sym} 128660 -14340 0 0 {name=X_75149_ }
C {devices/lab_pin.sym} 128580 -14230 0 0 {name=p127914 lab=_47867_/X }
C {devices/lab_pin.sym} 128580 -14190 0 0 {name=p127915 lab=_82920_/Q }
C {devices/lab_pin.sym} 128580 -14150 0 0 {name=p127916 lab=_48096_/Y }
C {devices/lab_pin.sym} 128740 -14190 0 1 {name=p127917 lab=_57619_/A }
C {sky130_stdcells/o21ai_4.sym} 128660 -14190 0 0 {name=X_48097_ }
C {devices/lab_pin.sym} 128580 -14090 0 0 {name=p127918 lab=_60359_/X }
C {devices/lab_pin.sym} 128580 -14050 0 0 {name=p127919 lab=_60252_/X }
C {devices/lab_pin.sym} 128580 -14010 0 0 {name=p127920 lab=_60229_/Y }
C {devices/lab_pin.sym} 128580 -13970 0 0 {name=p127921 lab=_60363_/Y }
C {devices/lab_pin.sym} 128580 -13940 0 0 {name=p127922 lab=_60374_/Y }
C {devices/lab_pin.sym} 128740 -14010 0 1 {name=p127923 lab=_84618_/D }
C {sky130_stdcells/a41oi_4.sym} 128660 -14010 0 0 {name=X_60375_ }
C {devices/lab_pin.sym} 128620 -13850 0 0 {name=p127924 lab=_61712_/X }
C {devices/lab_pin.sym} 128700 -13850 0 1 {name=p127925 lab=_62175_/B }
C {sky130_stdcells/buf_2.sym} 128660 -13850 0 0 {name=X_62114_ }
C {devices/lab_pin.sym} 128600 -13760 0 0 {name=p127926 lab=_47029_/A }
C {devices/lab_pin.sym} 128600 -13720 0 0 {name=p127927 lab=_47039_/B }
C {devices/lab_pin.sym} 128600 -13680 0 0 {name=p127928 lab=_47048_/C }
C {devices/lab_pin.sym} 128600 -13640 0 0 {name=p127929 lab=_52827_/D }
C {devices/lab_pin.sym} 128720 -13700 0 1 {name=p127930 lab=_47048_/X }
C {sky130_stdcells/and4_4.sym} 128660 -13700 0 0 {name=X_47048_ }
C {devices/lab_pin.sym} 128580 -13570 0 0 {name=p127931 lab=_81479_/D }
C {devices/lab_pin.sym} 128580 -13530 0 0 {name=p127932 lab=_67925_/X }
C {devices/lab_pin.sym} 128580 -13490 0 0 {name=p127933 lab=_67970_/X }
C {devices/lab_pin.sym} 128740 -13530 0 1 {name=p127934 lab=_84047_/D }
C {sky130_stdcells/a21bo_4.sym} 128660 -13530 0 0 {name=X_67971_ }
C {devices/lab_pin.sym} 128580 -13410 0 0 {name=p127935 lab=_79436_/A }
C {devices/lab_pin.sym} 128580 -13370 0 0 {name=p127936 lab=_63072_/X }
C {devices/lab_pin.sym} 128580 -13330 0 0 {name=p127937 lab=_63093_/Y }
C {devices/lab_pin.sym} 128740 -13370 0 1 {name=p127938 lab=_84354_/D }
C {sky130_stdcells/a21o_4.sym} 128660 -13370 0 0 {name=X_63094_ }
C {devices/lab_pin.sym} 128600 -13250 0 0 {name=p127939 lab=_79957_/A }
C {devices/lab_pin.sym} 128600 -13210 0 0 {name=p127940 lab=_79957_/B }
C {devices/lab_pin.sym} 128600 -13170 0 0 {name=p127941 lab=_79957_/C }
C {devices/lab_pin.sym} 128720 -13210 0 1 {name=p127942 lab=_79957_/Y }
C {sky130_stdcells/nand3_4.sym} 128660 -13210 0 0 {name=X_79957_ }
C {devices/lab_pin.sym} 128600 -13080 0 0 {name=p127943 lab=_69687_/A }
C {devices/lab_pin.sym} 128600 -13040 0 0 {name=p127944 lab=_69710_/B }
C {devices/lab_pin.sym} 128720 -13060 0 1 {name=p127945 lab=_69710_/Y }
C {sky130_stdcells/nor2_4.sym} 128660 -13060 0 0 {name=X_69710_ }
C {devices/lab_pin.sym} 128580 -12950 0 0 {name=p127946 lab=_66918_/X }
C {devices/lab_pin.sym} 128580 -12910 0 0 {name=p127947 lab=_66921_/X }
C {devices/lab_pin.sym} 128580 -12870 0 0 {name=p127948 lab=_66871_/X }
C {devices/lab_pin.sym} 128740 -12910 0 1 {name=p127949 lab=_66922_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -12910 0 0 {name=X_66922_ }
C {devices/lab_pin.sym} 128620 -12770 0 0 {name=p127950 lab=_59699_/A }
C {devices/lab_pin.sym} 128700 -12770 0 1 {name=p127951 lab=_62046_/D }
C {sky130_stdcells/buf_2.sym} 128660 -12770 0 0 {name=X_62045_ }
C {devices/lab_pin.sym} 128600 -12660 0 0 {name=p127952 lab=_78908_/A }
C {devices/lab_pin.sym} 128600 -12620 0 0 {name=p127953 lab=_78907_/Y }
C {devices/lab_pin.sym} 128720 -12640 0 1 {name=p127954 lab=_78909_/B }
C {sky130_stdcells/xnor2_4.sym} 128660 -12640 0 0 {name=X_78908_ }
C {devices/lab_pin.sym} 128600 -12520 0 0 {name=p127955 lab=_79883_/X }
C {devices/lab_pin.sym} 128600 -12480 0 0 {name=p127956 lab=_79888_/B }
C {devices/lab_pin.sym} 128720 -12500 0 1 {name=p127957 lab=_79889_/A }
C {sky130_stdcells/xnor2_4.sym} 128660 -12500 0 0 {name=X_79888_ }
C {devices/lab_pin.sym} 128580 -12390 0 0 {name=p127958 lab=_69208_/X }
C {devices/lab_pin.sym} 128580 -12350 0 0 {name=p127959 lab=_69210_/X }
C {devices/lab_pin.sym} 128580 -12310 0 0 {name=p127960 lab=_69575_/X }
C {devices/lab_pin.sym} 128740 -12350 0 1 {name=p127961 lab=_69641_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -12350 0 0 {name=X_69641_ }
C {devices/lab_pin.sym} 128580 -12240 0 0 {name=p127962 lab=_87943_/Q }
C {devices/lab_pin.sym} 128580 -12200 0 0 {name=p127963 lab=_66759_/X }
C {devices/lab_pin.sym} 128580 -12160 0 0 {name=p127964 lab=_66807_/X }
C {devices/lab_pin.sym} 128580 -12120 0 0 {name=p127965 lab=_66852_/X }
C {devices/lab_pin.sym} 128740 -12180 0 1 {name=p127966 lab=_66853_/X }
C {sky130_stdcells/a211o_4.sym} 128660 -12180 0 0 {name=X_66853_ }
C {devices/lab_pin.sym} 128600 -12040 0 0 {name=p127967 lab=_82838_/Q }
C {devices/lab_pin.sym} 128600 -12000 0 0 {name=p127968 lab=_78839_/B }
C {devices/lab_pin.sym} 128720 -12020 0 1 {name=p127969 lab=_78839_/X }
C {sky130_stdcells/xor2_4.sym} 128660 -12020 0 0 {name=X_78839_ }
C {devices/lab_pin.sym} 128600 -11900 0 0 {name=p127970 lab=_49022_/A }
C {devices/lab_pin.sym} 128600 -11860 0 0 {name=p127971 lab=_72014_/B }
C {devices/lab_pin.sym} 128720 -11880 0 1 {name=p127972 lab=_48999_/X }
C {sky130_stdcells/and2_4.sym} 128660 -11880 0 0 {name=X_48999_ }
C {devices/lab_pin.sym} 128600 -11760 0 0 {name=p127973 lab=_65804_/A }
C {devices/lab_pin.sym} 128600 -11720 0 0 {name=p127974 lab=_85864_/Q }
C {devices/lab_pin.sym} 128720 -11740 0 1 {name=p127975 lab=_65804_/X }
C {sky130_stdcells/and2_4.sym} 128660 -11740 0 0 {name=X_65804_ }
C {devices/lab_pin.sym} 128570 -11610 0 0 {name=p127976 lab=_82221_/CLK }
C {devices/lab_pin.sym} 128570 -11590 0 0 {name=p127977 lab=_81882_/Q }
C {devices/lab_pin.sym} 128750 -11610 0 1 {name=p127978 lab=_77582_/A }
C {sky130_stdcells/dfxtp_4.sym} 128660 -11600 0 0 {name=X_81850_ }
C {devices/lab_pin.sym} 128600 -11480 0 0 {name=p127979 lab=_69586_/A }
C {devices/lab_pin.sym} 128600 -11440 0 0 {name=p127980 lab=_88339_/Q }
C {devices/lab_pin.sym} 128720 -11460 0 1 {name=p127981 lab=_69572_/X }
C {sky130_stdcells/and2_4.sym} 128660 -11460 0 0 {name=X_69572_ }
C {devices/lab_pin.sym} 128620 -11330 0 0 {name=p127982 lab=_68614_/A }
C {devices/lab_pin.sym} 128700 -11330 0 1 {name=p127983 lab=_66785_/A }
C {sky130_stdcells/buf_2.sym} 128660 -11330 0 0 {name=X_66784_ }
C {devices/lab_pin.sym} 128580 -11230 0 0 {name=p127984 lab=_63993_/X }
C {devices/lab_pin.sym} 128580 -11190 0 0 {name=p127985 lab=_63994_/X }
C {devices/lab_pin.sym} 128580 -11150 0 0 {name=p127986 lab=_63995_/Y }
C {devices/lab_pin.sym} 128740 -11190 0 1 {name=p127987 lab=_84282_/D }
C {sky130_stdcells/a21oi_4.sym} 128660 -11190 0 0 {name=X_63996_ }
C {devices/lab_pin.sym} 128570 -11050 0 0 {name=p127988 lab=_81065_/CLK }
C {devices/lab_pin.sym} 128570 -11030 0 0 {name=p127989 lab=_75872_/B }
C {devices/lab_pin.sym} 128750 -11050 0 1 {name=p127990 lab=_80801_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -11040 0 0 {name=X_80801_ }
C {devices/lab_pin.sym} 128600 -10920 0 0 {name=p127991 lab=_68444_/A }
C {devices/lab_pin.sym} 128600 -10880 0 0 {name=p127992 lab=_88365_/Q }
C {devices/lab_pin.sym} 128720 -10900 0 1 {name=p127993 lab=_68523_/X }
C {sky130_stdcells/and2_4.sym} 128660 -10900 0 0 {name=X_68523_ }
C {devices/lab_pin.sym} 128620 -10770 0 0 {name=p127994 lab=clkbuf_9_346_0_CLK/X }
C {devices/lab_pin.sym} 128700 -10770 0 1 {name=p127995 lab=_88398_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 128660 -10770 0 0 {name=Xclkbuf_10_692_0_CLK }
C {devices/lab_pin.sym} 128600 -10660 0 0 {name=p127996 lab=_65735_/A }
C {devices/lab_pin.sym} 128600 -10620 0 0 {name=p127997 lab=_86477_/Q }
C {devices/lab_pin.sym} 128720 -10640 0 1 {name=p127998 lab=_65735_/X }
C {sky130_stdcells/and2_4.sym} 128660 -10640 0 0 {name=X_65735_ }
C {devices/lab_pin.sym} 128600 -10520 0 0 {name=p127999 lab=_50938_/X }
C {devices/lab_pin.sym} 128600 -10480 0 0 {name=p128000 lab=_50961_/B }
C {devices/lab_pin.sym} 128720 -10500 0 1 {name=p128001 lab=_50961_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -10500 0 0 {name=X_50961_ }
C {devices/lab_pin.sym} 128600 -10400 0 0 {name=p128002 lab=_61637_/X }
C {devices/lab_pin.sym} 128600 -10360 0 0 {name=p128003 lab=_62926_/B }
C {devices/lab_pin.sym} 128600 -10320 0 0 {name=p128004 lab=_62681_/X }
C {devices/lab_pin.sym} 128600 -10280 0 0 {name=p128005 lab=_60228_/A }
C {devices/lab_pin.sym} 128720 -10340 0 1 {name=p128006 lab=_62947_/Y }
C {sky130_stdcells/nand4_4.sym} 128660 -10340 0 0 {name=X_62947_ }
C {devices/lab_pin.sym} 128570 -10190 0 0 {name=p128007 lab=_81703_/CLK }
C {devices/lab_pin.sym} 128570 -10170 0 0 {name=p128008 lab=_76113_/X }
C {devices/lab_pin.sym} 128750 -10190 0 1 {name=p128009 lab=_81781_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -10180 0 0 {name=X_81781_ }
C {devices/lab_pin.sym} 128600 -10060 0 0 {name=p128010 lab=_52706_/A }
C {devices/lab_pin.sym} 128600 -10020 0 0 {name=p128011 lab=_52700_/B }
C {devices/lab_pin.sym} 128720 -10040 0 1 {name=p128012 lab=_52700_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -10040 0 0 {name=X_52700_ }
C {devices/lab_pin.sym} 128570 -9910 0 0 {name=p128013 lab=_83520_/CLK }
C {devices/lab_pin.sym} 128570 -9890 0 0 {name=p128014 lab=_83520_/D }
C {devices/lab_pin.sym} 128750 -9910 0 1 {name=p128015 lab=_83520_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -9900 0 0 {name=X_83520_ }
C {devices/lab_pin.sym} 128570 -9770 0 0 {name=p128016 lab=_83749_/CLK }
C {devices/lab_pin.sym} 128570 -9750 0 0 {name=p128017 lab=_75918_/X }
C {devices/lab_pin.sym} 128750 -9770 0 1 {name=p128018 lab=_80732_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -9760 0 0 {name=X_80732_ }
C {devices/lab_pin.sym} 128580 -9650 0 0 {name=p128019 lab=_68449_/X }
C {devices/lab_pin.sym} 128580 -9610 0 0 {name=p128020 lab=_68453_/X }
C {devices/lab_pin.sym} 128580 -9570 0 0 {name=p128021 lab=_68429_/X }
C {devices/lab_pin.sym} 128740 -9610 0 1 {name=p128022 lab=_68454_/X }
C {sky130_stdcells/a21o_4.sym} 128660 -9610 0 0 {name=X_68454_ }
C {devices/lab_pin.sym} 128620 -9470 0 0 {name=p128023 lab=clkbuf_8_91_0_CLK/X }
C {devices/lab_pin.sym} 128700 -9470 0 1 {name=p128024 lab=clkbuf_9_183_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 128660 -9470 0 0 {name=Xclkbuf_9_183_0_CLK }
C {devices/lab_pin.sym} 128620 -9350 0 0 {name=p128025 lab=_53747_/A }
C {devices/lab_pin.sym} 128700 -9350 0 1 {name=p128026 lab=_53680_/X }
C {sky130_stdcells/buf_2.sym} 128660 -9350 0 0 {name=X_53680_ }
C {devices/lab_pin.sym} 128580 -9250 0 0 {name=p128027 lab=_65664_/Y }
C {devices/lab_pin.sym} 128580 -9210 0 0 {name=p128028 lab=_65602_/X }
C {devices/lab_pin.sym} 128580 -9170 0 0 {name=p128029 lab=_65665_/X }
C {devices/lab_pin.sym} 128740 -9210 0 1 {name=p128030 lab=_84186_/D }
C {sky130_stdcells/a21o_4.sym} 128660 -9210 0 0 {name=X_65666_ }
C {devices/lab_pin.sym} 128580 -9090 0 0 {name=p128031 lab=_50889_/Y }
C {devices/lab_pin.sym} 128580 -9050 0 0 {name=p128032 lab=_50839_/X }
C {devices/lab_pin.sym} 128580 -9010 0 0 {name=p128033 lab=_50891_/X }
C {devices/lab_pin.sym} 128740 -9050 0 1 {name=p128034 lab=_50892_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -9050 0 0 {name=X_50892_ }
C {devices/lab_pin.sym} 128600 -8930 0 0 {name=p128035 lab=_62869_/A }
C {devices/lab_pin.sym} 128600 -8890 0 0 {name=p128036 lab=_62935_/B }
C {devices/lab_pin.sym} 128600 -8850 0 0 {name=p128037 lab=_62027_/X }
C {devices/lab_pin.sym} 128720 -8890 0 1 {name=p128038 lab=_62878_/Y }
C {sky130_stdcells/nand3_4.sym} 128660 -8890 0 0 {name=X_62878_ }
C {devices/lab_pin.sym} 128620 -8750 0 0 {name=p128039 lab=_67046_/A }
C {devices/lab_pin.sym} 128700 -8750 0 1 {name=p128040 lab=_67405_/X }
C {sky130_stdcells/buf_2.sym} 128660 -8750 0 0 {name=X_67405_ }
C {devices/lab_pin.sym} 128620 -8630 0 0 {name=p128041 lab=_52657_/A }
C {devices/lab_pin.sym} 128700 -8630 0 1 {name=p128042 lab=_52637_/A }
C {sky130_stdcells/buf_2.sym} 128660 -8630 0 0 {name=X_52631_ }
C {devices/lab_pin.sym} 128600 -8520 0 0 {name=p128043 lab=_64769_/A }
C {devices/lab_pin.sym} 128600 -8480 0 0 {name=p128044 lab=_64617_/B }
C {devices/lab_pin.sym} 128720 -8500 0 1 {name=p128045 lab=_64617_/X }
C {sky130_stdcells/and2_4.sym} 128660 -8500 0 0 {name=X_64617_ }
C {devices/lab_pin.sym} 128570 -8370 0 0 {name=p128046 lab=_83451_/CLK }
C {devices/lab_pin.sym} 128570 -8350 0 0 {name=p128047 lab=_83451_/D }
C {devices/lab_pin.sym} 128750 -8370 0 1 {name=p128048 lab=_58336_/B }
C {sky130_stdcells/dfxtp_4.sym} 128660 -8360 0 0 {name=X_83451_ }
C {devices/lab_pin.sym} 128600 -8260 0 0 {name=p128049 lab=_61399_/X }
C {devices/lab_pin.sym} 128600 -8220 0 0 {name=p128050 lab=_61794_/B }
C {devices/lab_pin.sym} 128600 -8180 0 0 {name=p128051 lab=_61809_/C }
C {devices/lab_pin.sym} 128600 -8140 0 0 {name=p128052 lab=_61776_/D }
C {devices/lab_pin.sym} 128720 -8200 0 1 {name=p128053 lab=_61829_/Y }
C {sky130_stdcells/nand4_4.sym} 128660 -8200 0 0 {name=X_61829_ }
C {devices/lab_pin.sym} 128570 -8050 0 0 {name=p128054 lab=_80657_/CLK }
C {devices/lab_pin.sym} 128570 -8030 0 0 {name=p128055 lab=_74817_/Y }
C {devices/lab_pin.sym} 128750 -8050 0 1 {name=p128056 lab=_46188_/A }
C {sky130_stdcells/dfxtp_4.sym} 128660 -8040 0 0 {name=X_80663_ }
C {devices/lab_pin.sym} 128620 -7910 0 0 {name=p128057 lab=_68385_/A }
C {devices/lab_pin.sym} 128700 -7910 0 1 {name=p128058 lab=_68385_/X }
C {sky130_stdcells/buf_2.sym} 128660 -7910 0 0 {name=X_68385_ }
C {devices/lab_pin.sym} 128600 -7800 0 0 {name=p128059 lab=_65474_/X }
C {devices/lab_pin.sym} 128600 -7760 0 0 {name=p128060 lab=_73070_/B }
C {devices/lab_pin.sym} 128720 -7780 0 1 {name=p128061 lab=_65597_/X }
C {sky130_stdcells/and2_4.sym} 128660 -7780 0 0 {name=X_65597_ }
C {devices/lab_pin.sym} 128570 -7650 0 0 {name=p128062 lab=_82786_/CLK }
C {devices/lab_pin.sym} 128570 -7630 0 0 {name=p128063 lab=_82434_/Q }
C {devices/lab_pin.sym} 128750 -7650 0 1 {name=p128064 lab=_78312_/A }
C {sky130_stdcells/dfxtp_4.sym} 128660 -7640 0 0 {name=X_82402_ }
C {devices/lab_pin.sym} 128580 -7540 0 0 {name=p128065 lab=_82993_/Q }
C {devices/lab_pin.sym} 128580 -7500 0 0 {name=p128066 lab=_44061_/X }
C {devices/lab_pin.sym} 128580 -7460 0 0 {name=p128067 lab=_55312_/X }
C {devices/lab_pin.sym} 128580 -7420 0 0 {name=p128068 lab=_55349_/X }
C {devices/lab_pin.sym} 128740 -7480 0 1 {name=p128069 lab=_55352_/C }
C {sky130_stdcells/a211o_4.sym} 128660 -7480 0 0 {name=X_55350_ }
C {devices/lab_pin.sym} 128580 -7360 0 0 {name=p128070 lab=_87475_/Q }
C {devices/lab_pin.sym} 128580 -7320 0 0 {name=p128071 lab=_67239_/X }
C {devices/lab_pin.sym} 128580 -7280 0 0 {name=p128072 lab=_67240_/X }
C {devices/lab_pin.sym} 128580 -7240 0 0 {name=p128073 lab=_67335_/X }
C {devices/lab_pin.sym} 128740 -7300 0 1 {name=p128074 lab=_67336_/X }
C {sky130_stdcells/a211o_4.sym} 128660 -7300 0 0 {name=X_67336_ }
C {devices/lab_pin.sym} 128570 -7150 0 0 {name=p128075 lab=_83306_/CLK }
C {devices/lab_pin.sym} 128570 -7130 0 0 {name=p128076 lab=_86170_/D }
C {devices/lab_pin.sym} 128750 -7150 0 1 {name=p128077 lab=_86170_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -7140 0 0 {name=X_86170_ }
C {devices/lab_pin.sym} 128580 -7030 0 0 {name=p128078 lab=_52560_/Y }
C {devices/lab_pin.sym} 128580 -6990 0 0 {name=p128079 lab=_52541_/X }
C {devices/lab_pin.sym} 128580 -6950 0 0 {name=p128080 lab=_52561_/Y }
C {devices/lab_pin.sym} 128740 -6990 0 1 {name=p128081 lab=_85797_/D }
C {sky130_stdcells/a21boi_4.sym} 128660 -6990 0 0 {name=X_52562_ }
C {devices/lab_pin.sym} 128580 -6870 0 0 {name=p128082 lab=_58990_/Y }
C {devices/lab_pin.sym} 128580 -6830 0 0 {name=p128083 lab=_64226_/X }
C {devices/lab_pin.sym} 128580 -6790 0 0 {name=p128084 lab=_64547_/Y }
C {devices/lab_pin.sym} 128740 -6830 0 1 {name=p128085 lab=_64548_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -6830 0 0 {name=X_64548_ }
C {devices/lab_pin.sym} 128570 -6690 0 0 {name=p128086 lab=_83415_/CLK }
C {devices/lab_pin.sym} 128570 -6670 0 0 {name=p128087 lab=_71771_/X }
C {devices/lab_pin.sym} 128750 -6690 0 1 {name=p128088 lab=_83382_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -6680 0 0 {name=X_83382_ }
C {devices/lab_pin.sym} 128600 -6560 0 0 {name=p128089 lab=_80593_/Y }
C {devices/lab_pin.sym} 128600 -6520 0 0 {name=p128090 lab=_80571_/X }
C {devices/lab_pin.sym} 128720 -6540 0 1 {name=p128091 lab=_80594_/X }
C {sky130_stdcells/and2_4.sym} 128660 -6540 0 0 {name=X_80594_ }
C {sky130_stdcells/decap_3.sym} 128660 -6380 0 0 {name=XPHY_407 }
C {sky130_stdcells/decap_3.sym} 128660 -6200 0 0 {name=XPHY_418 }
C {devices/lab_pin.sym} 128580 -6070 0 0 {name=p128092 lab=_85467_/Q }
C {devices/lab_pin.sym} 128580 -6030 0 0 {name=p128093 lab=_54294_/X }
C {devices/lab_pin.sym} 128580 -5990 0 0 {name=p128094 lab=_54300_/Y }
C {devices/lab_pin.sym} 128740 -6030 0 1 {name=p128095 lab=_54301_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -6030 0 0 {name=X_54301_ }
C {sky130_stdcells/decap_3.sym} 128660 -5860 0 0 {name=XPHY_429 }
C {devices/lab_pin.sym} 128570 -5710 0 0 {name=p128096 lab=_85074_/CLK }
C {devices/lab_pin.sym} 128570 -5690 0 0 {name=p128097 lab=_56942_/X }
C {devices/lab_pin.sym} 128750 -5710 0 1 {name=p128098 lab=_85121_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -5700 0 0 {name=X_85121_ }
C {devices/lab_pin.sym} 128620 -5570 0 0 {name=p128099 lab=_51622_/A }
C {devices/lab_pin.sym} 128700 -5570 0 1 {name=p128100 lab=_51514_/A }
C {sky130_stdcells/buf_2.sym} 128660 -5570 0 0 {name=X_51513_ }
C {devices/lab_pin.sym} 128620 -5450 0 0 {name=p128101 lab=clkbuf_8_99_0_CLK/X }
C {devices/lab_pin.sym} 128700 -5450 0 1 {name=p128102 lab=clkbuf_9_198_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 128660 -5450 0 0 {name=Xclkbuf_9_198_0_CLK }
C {devices/lab_pin.sym} 128570 -5330 0 0 {name=p128103 lab=_82284_/CLK }
C {devices/lab_pin.sym} 128570 -5310 0 0 {name=p128104 lab=_77199_/B }
C {devices/lab_pin.sym} 128750 -5330 0 1 {name=p128105 lab=_82333_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -5320 0 0 {name=X_82333_ }
C {devices/lab_pin.sym} 128580 -5220 0 0 {name=p128106 lab=_88374_/Q }
C {devices/lab_pin.sym} 128580 -5180 0 0 {name=p128107 lab=_67193_/X }
C {devices/lab_pin.sym} 128580 -5140 0 0 {name=p128108 lab=_67194_/X }
C {devices/lab_pin.sym} 128580 -5100 0 0 {name=p128109 lab=_67266_/X }
C {devices/lab_pin.sym} 128740 -5160 0 1 {name=p128110 lab=_67267_/X }
C {sky130_stdcells/a211o_4.sym} 128660 -5160 0 0 {name=X_67267_ }
C {devices/lab_pin.sym} 128620 -5010 0 0 {name=p128111 lab=_55281_/A }
C {devices/lab_pin.sym} 128700 -5010 0 1 {name=p128112 lab=_55282_/B }
C {sky130_stdcells/inv_2.sym} 128660 -5010 0 0 {name=X_55281_ }
C {devices/lab_pin.sym} 128580 -4910 0 0 {name=p128113 lab=_52491_/Y }
C {devices/lab_pin.sym} 128580 -4870 0 0 {name=p128114 lab=_52486_/X }
C {devices/lab_pin.sym} 128580 -4830 0 0 {name=p128115 lab=_52492_/Y }
C {devices/lab_pin.sym} 128740 -4870 0 1 {name=p128116 lab=_52493_/Y }
C {sky130_stdcells/a21boi_4.sym} 128660 -4870 0 0 {name=X_52493_ }
C {devices/lab_pin.sym} 128580 -4750 0 0 {name=p128117 lab=_58277_/A }
C {devices/lab_pin.sym} 128580 -4710 0 0 {name=p128118 lab=_61085_/X }
C {devices/lab_pin.sym} 128580 -4670 0 0 {name=p128119 lab=_64478_/Y }
C {devices/lab_pin.sym} 128740 -4710 0 1 {name=p128120 lab=_64479_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -4710 0 0 {name=X_64479_ }
C {devices/lab_pin.sym} 128580 -4590 0 0 {name=p128121 lab=_56797_/A }
C {devices/lab_pin.sym} 128580 -4550 0 0 {name=p128122 lab=_56796_/Y }
C {devices/lab_pin.sym} 128580 -4510 0 0 {name=p128123 lab=_44213_/X }
C {devices/lab_pin.sym} 128740 -4550 0 1 {name=p128124 lab=_57020_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -4550 0 0 {name=X_57020_ }
C {devices/lab_pin.sym} 128580 -4430 0 0 {name=p128125 lab=_69003_/X }
C {devices/lab_pin.sym} 128580 -4390 0 0 {name=p128126 lab=_69005_/X }
C {devices/lab_pin.sym} 128580 -4350 0 0 {name=p128127 lab=_60014_/X }
C {devices/lab_pin.sym} 128740 -4390 0 1 {name=p128128 lab=_69006_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -4390 0 0 {name=X_69006_ }
C {devices/lab_pin.sym} 128600 -4280 0 0 {name=p128129 lab=_54208_/X }
C {devices/lab_pin.sym} 128600 -4240 0 0 {name=p128130 lab=_54237_/B }
C {devices/lab_pin.sym} 128600 -4200 0 0 {name=p128131 lab=_54237_/C }
C {devices/lab_pin.sym} 128600 -4160 0 0 {name=p128132 lab=_53063_/D }
C {devices/lab_pin.sym} 128720 -4220 0 1 {name=p128133 lab=_54232_/X }
C {sky130_stdcells/and4_4.sym} 128660 -4220 0 0 {name=X_54232_ }
C {devices/lab_pin.sym} 128600 -4090 0 0 {name=p128134 lab=_66123_/A }
C {devices/lab_pin.sym} 128600 -4050 0 0 {name=p128135 lab=_66151_/B }
C {devices/lab_pin.sym} 128600 -4010 0 0 {name=p128136 lab=_84148_/Q }
C {devices/lab_pin.sym} 128720 -4050 0 1 {name=p128137 lab=_66218_/X }
C {sky130_stdcells/and3_4.sym} 128660 -4050 0 0 {name=X_66218_ }
C {devices/lab_pin.sym} 128570 -3910 0 0 {name=p128138 lab=_85050_/CLK }
C {devices/lab_pin.sym} 128570 -3890 0 0 {name=p128139 lab=_85052_/D }
C {devices/lab_pin.sym} 128750 -3910 0 1 {name=p128140 lab=_85052_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -3900 0 0 {name=X_85052_ }
C {devices/lab_pin.sym} 128580 -3790 0 0 {name=p128141 lab=_51441_/Y }
C {devices/lab_pin.sym} 128580 -3750 0 0 {name=p128142 lab=_51420_/X }
C {devices/lab_pin.sym} 128580 -3710 0 0 {name=p128143 lab=_51443_/X }
C {devices/lab_pin.sym} 128740 -3750 0 1 {name=p128144 lab=_86009_/D }
C {sky130_stdcells/a21oi_4.sym} 128660 -3750 0 0 {name=X_51444_ }
C {devices/lab_pin.sym} 128620 -3610 0 0 {name=p128145 lab=clkbuf_9_315_0_CLK/X }
C {devices/lab_pin.sym} 128700 -3610 0 1 {name=p128146 lab=_82133_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 128660 -3610 0 0 {name=Xclkbuf_10_630_0_CLK }
C {devices/lab_pin.sym} 128570 -3490 0 0 {name=p128147 lab=_83515_/CLK }
C {devices/lab_pin.sym} 128570 -3470 0 0 {name=p128148 lab=_82264_/D }
C {devices/lab_pin.sym} 128750 -3490 0 1 {name=p128149 lab=_82264_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -3480 0 0 {name=X_82264_ }
C {devices/lab_pin.sym} 128600 -3360 0 0 {name=p128150 lab=_67131_/A }
C {devices/lab_pin.sym} 128600 -3320 0 0 {name=p128151 lab=_87609_/Q }
C {devices/lab_pin.sym} 128720 -3340 0 1 {name=p128152 lab=_67198_/X }
C {sky130_stdcells/and2_4.sym} 128660 -3340 0 0 {name=X_67198_ }
C {devices/lab_pin.sym} 128570 -3210 0 0 {name=p128153 lab=_84003_/CLK }
C {devices/lab_pin.sym} 128570 -3190 0 0 {name=p128154 lab=_68242_/X }
C {devices/lab_pin.sym} 128750 -3210 0 1 {name=p128155 lab=_84003_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -3200 0 0 {name=X_84003_ }
C {devices/lab_pin.sym} 128570 -3070 0 0 {name=p128156 lab=_82284_/CLK }
C {devices/lab_pin.sym} 128570 -3050 0 0 {name=p128157 lab=_74874_/X }
C {devices/lab_pin.sym} 128750 -3070 0 1 {name=p128158 lab=_81215_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -3060 0 0 {name=X_81215_ }
C {devices/lab_pin.sym} 128580 -2950 0 0 {name=p128159 lab=_85492_/Q }
C {devices/lab_pin.sym} 128580 -2910 0 0 {name=p128160 lab=_54140_/X }
C {devices/lab_pin.sym} 128580 -2870 0 0 {name=p128161 lab=_54162_/Y }
C {devices/lab_pin.sym} 128740 -2910 0 1 {name=p128162 lab=_54163_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -2910 0 0 {name=X_54163_ }
C {devices/lab_pin.sym} 128580 -2790 0 0 {name=p128163 lab=_66068_/X }
C {devices/lab_pin.sym} 128580 -2750 0 0 {name=p128164 lab=_65676_/Y }
C {devices/lab_pin.sym} 128580 -2710 0 0 {name=p128165 lab=_66148_/Y }
C {devices/lab_pin.sym} 128740 -2750 0 1 {name=p128166 lab=_66149_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -2750 0 0 {name=X_66149_ }
C {devices/lab_pin.sym} 128580 -2630 0 0 {name=p128167 lab=_86022_/Q }
C {devices/lab_pin.sym} 128580 -2590 0 0 {name=p128168 lab=_51362_/X }
C {devices/lab_pin.sym} 128580 -2550 0 0 {name=p128169 lab=_51374_/Y }
C {devices/lab_pin.sym} 128740 -2590 0 1 {name=p128170 lab=_51375_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -2590 0 0 {name=X_51375_ }
C {devices/lab_pin.sym} 128620 -2450 0 0 {name=p128171 lab=clkbuf_8_60_0_CLK/X }
C {devices/lab_pin.sym} 128700 -2450 0 1 {name=p128172 lab=clkbuf_9_121_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 128660 -2450 0 0 {name=Xclkbuf_9_121_0_CLK }
C {devices/lab_pin.sym} 128570 -2330 0 0 {name=p128173 lab=_85491_/CLK }
C {devices/lab_pin.sym} 128570 -2310 0 0 {name=p128174 lab=_82195_/D }
C {devices/lab_pin.sym} 128750 -2330 0 1 {name=p128175 lab=_82387_/D }
C {sky130_stdcells/dfxtp_4.sym} 128660 -2320 0 0 {name=X_82195_ }
C {devices/lab_pin.sym} 128580 -2210 0 0 {name=p128176 lab=_53110_/Y }
C {devices/lab_pin.sym} 128580 -2170 0 0 {name=p128177 lab=_53111_/X }
C {devices/lab_pin.sym} 128580 -2130 0 0 {name=p128178 lab=_53113_/X }
C {devices/lab_pin.sym} 128740 -2170 0 1 {name=p128179 lab=_85695_/D }
C {sky130_stdcells/a21oi_4.sym} 128660 -2170 0 0 {name=X_53114_ }
C {devices/lab_pin.sym} 128600 -2040 0 0 {name=p128180 lab=_50356_/A }
C {devices/lab_pin.sym} 128600 -2000 0 0 {name=p128181 lab=_50326_/B }
C {devices/lab_pin.sym} 128720 -2020 0 1 {name=p128182 lab=_50326_/Y }
C {sky130_stdcells/nand2_4.sym} 128660 -2020 0 0 {name=X_50326_ }
C {devices/lab_pin.sym} 128570 -1890 0 0 {name=p128183 lab=_82327_/CLK }
C {devices/lab_pin.sym} 128570 -1870 0 0 {name=p128184 lab=_81146_/D }
C {devices/lab_pin.sym} 128750 -1890 0 1 {name=p128185 lab=_40624_/A }
C {sky130_stdcells/dfxtp_4.sym} 128660 -1880 0 0 {name=X_81146_ }
C {devices/lab_pin.sym} 128580 -1770 0 0 {name=p128186 lab=_85505_/Q }
C {devices/lab_pin.sym} 128580 -1730 0 0 {name=p128187 lab=_53431_/X }
C {devices/lab_pin.sym} 128580 -1690 0 0 {name=p128188 lab=_54093_/Y }
C {devices/lab_pin.sym} 128740 -1730 0 1 {name=p128189 lab=_54094_/Y }
C {sky130_stdcells/o21ai_4.sym} 128660 -1730 0 0 {name=X_54094_ }
C {devices/lab_pin.sym} 128580 -1610 0 0 {name=p128190 lab=_58559_/X }
C {devices/lab_pin.sym} 128580 -1570 0 0 {name=p128191 lab=_83441_/Q }
C {devices/lab_pin.sym} 128580 -1530 0 0 {name=p128192 lab=_58970_/Y }
C {devices/lab_pin.sym} 128740 -1570 0 1 {name=p128193 lab=_58971_/X }
C {sky130_stdcells/o21a_4.sym} 128660 -1570 0 0 {name=X_58971_ }
C {devices/lab_pin.sym} 128620 -1430 0 0 {name=p128194 lab=clkbuf_9_322_0_CLK/X }
C {devices/lab_pin.sym} 128700 -1430 0 1 {name=p128195 lab=_83987_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 128660 -1430 0 0 {name=Xclkbuf_10_645_0_CLK }
C {devices/lab_pin.sym} 128580 -1330 0 0 {name=p128196 lab=_53042_/Y }
C {devices/lab_pin.sym} 128580 -1290 0 0 {name=p128197 lab=_53028_/X }
C {devices/lab_pin.sym} 128580 -1250 0 0 {name=p128198 lab=_53044_/X }
C {devices/lab_pin.sym} 128740 -1290 0 1 {name=p128199 lab=_53045_/Y }
C {sky130_stdcells/a21oi_4.sym} 128660 -1290 0 0 {name=X_53045_ }
C {devices/lab_pin.sym} 128620 -1150 0 0 {name=p128200 lab=_84939_/Q }
C {devices/lab_pin.sym} 128700 -1150 0 1 {name=p128201 lab=_57922_/Y }
C {sky130_stdcells/inv_2.sym} 128660 -1150 0 0 {name=X_57922_ }
C {devices/lab_pin.sym} 128600 -1040 0 0 {name=p128202 lab=_69908_/A }
C {devices/lab_pin.sym} 128600 -1000 0 0 {name=p128203 lab=_42611_/Y }
C {devices/lab_pin.sym} 128720 -1020 0 1 {name=p128204 lab=_69908_/Y }
C {sky130_stdcells/nor2_4.sym} 128660 -1020 0 0 {name=X_69908_ }
C {devices/lab_pin.sym} 128620 -890 0 0 {name=p128205 lab=_50918_/A }
C {devices/lab_pin.sym} 128700 -890 0 1 {name=p128206 lab=_50257_/X }
C {sky130_stdcells/buf_2.sym} 128660 -890 0 0 {name=X_50257_ }
C {devices/lab_pin.sym} 128570 -770 0 0 {name=p128207 lab=_85471_/CLK }
C {devices/lab_pin.sym} 128570 -750 0 0 {name=p128208 lab=_51743_/Y }
C {devices/lab_pin.sym} 128750 -770 0 1 {name=p128209 lab=_85954_/Q }
C {sky130_stdcells/dfxtp_4.sym} 128660 -760 0 0 {name=X_85954_ }
C {devices/lab_pin.sym} 129490 -42150 0 0 {name=p128210 lab=_81121_/CLK }
C {devices/lab_pin.sym} 129490 -42130 0 0 {name=p128211 lab=_81109_/Q }
C {devices/lab_pin.sym} 129670 -42150 0 1 {name=p128212 lab=_75348_/A }
C {sky130_stdcells/dfxtp_4.sym} 129580 -42140 0 0 {name=X_81077_ }
C {devices/lab_pin.sym} 129520 -42020 0 0 {name=p128213 lab=_80026_/X }
C {devices/lab_pin.sym} 129520 -41980 0 0 {name=p128214 lab=_80027_/X }
C {devices/lab_pin.sym} 129640 -42000 0 1 {name=p128215 lab=_80043_/B }
C {sky130_stdcells/xnor2_4.sym} 129580 -42000 0 0 {name=X_80028_ }
C {devices/lab_pin.sym} 129490 -41870 0 0 {name=p128216 lab=_84905_/CLK }
C {devices/lab_pin.sym} 129490 -41850 0 0 {name=p128217 lab=_84905_/D }
C {devices/lab_pin.sym} 129670 -41870 0 1 {name=p128218 lab=_84905_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -41860 0 0 {name=X_84905_ }
C {devices/lab_pin.sym} 129540 -41730 0 0 {name=p128219 lab=clkbuf_8_68_0_CLK/X }
C {devices/lab_pin.sym} 129620 -41730 0 1 {name=p128220 lab=clkbuf_9_136_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 129580 -41730 0 0 {name=Xclkbuf_9_136_0_CLK }
C {devices/lab_pin.sym} 129500 -41630 0 0 {name=p128221 lab=_57852_/X }
C {devices/lab_pin.sym} 129500 -41590 0 0 {name=p128222 lab=_85721_/Q }
C {devices/lab_pin.sym} 129500 -41550 0 0 {name=p128223 lab=_57814_/X }
C {devices/lab_pin.sym} 129660 -41590 0 1 {name=p128224 lab=_57853_/X }
C {sky130_stdcells/o21a_4.sym} 129580 -41590 0 0 {name=X_57853_ }
C {devices/lab_pin.sym} 129500 -41480 0 0 {name=p128225 lab=_73275_/A }
C {devices/lab_pin.sym} 129500 -41440 0 0 {name=p128226 lab=_69837_/X }
C {devices/lab_pin.sym} 129500 -41400 0 0 {name=p128227 lab=_69779_/X }
C {devices/lab_pin.sym} 129500 -41360 0 0 {name=p128228 lab=_69838_/Y }
C {devices/lab_pin.sym} 129660 -41420 0 1 {name=p128229 lab=_69839_/X }
C {sky130_stdcells/a211o_4.sym} 129580 -41420 0 0 {name=X_69839_ }
C {devices/lab_pin.sym} 129520 -41280 0 0 {name=p128230 lab=_50187_/X }
C {devices/lab_pin.sym} 129520 -41240 0 0 {name=p128231 lab=_50188_/B }
C {devices/lab_pin.sym} 129640 -41260 0 1 {name=p128232 lab=_50188_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -41260 0 0 {name=X_50188_ }
C {devices/lab_pin.sym} 129490 -41130 0 0 {name=p128233 lab=_83572_/CLK }
C {devices/lab_pin.sym} 129490 -41110 0 0 {name=p128234 lab=_52120_/Y }
C {devices/lab_pin.sym} 129670 -41130 0 1 {name=p128235 lab=_85885_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -41120 0 0 {name=X_85885_ }
C {devices/lab_pin.sym} 129540 -40990 0 0 {name=p128236 lab=clkbuf_9_63_0_CLK/A }
C {devices/lab_pin.sym} 129620 -40990 0 1 {name=p128237 lab=clkbuf_9_63_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 129580 -40990 0 0 {name=Xclkbuf_9_63_0_CLK }
C {devices/lab_pin.sym} 129500 -40910 0 0 {name=p128238 lab=_56758_/X }
C {devices/lab_pin.sym} 129500 -40870 0 0 {name=p128239 lab=_56756_/X }
C {devices/lab_pin.sym} 129500 -40830 0 0 {name=p128240 lab=_56788_/X }
C {devices/lab_pin.sym} 129500 -40790 0 0 {name=p128241 lab=_57163_/C }
C {devices/lab_pin.sym} 129500 -40760 0 0 {name=p128242 lab=_45835_/A }
C {devices/lab_pin.sym} 129660 -40830 0 1 {name=p128243 lab=_56804_/Y }
C {sky130_stdcells/a41oi_4.sym} 129580 -40830 0 0 {name=X_56804_ }
C {devices/lab_pin.sym} 129490 -40670 0 0 {name=p128244 lab=_87883_/CLK }
C {devices/lab_pin.sym} 129490 -40650 0 0 {name=p128245 lab=_87624_/D }
C {devices/lab_pin.sym} 129670 -40670 0 1 {name=p128246 lab=_87624_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -40660 0 0 {name=X_87624_ }
C {devices/lab_pin.sym} 129500 -40550 0 0 {name=p128247 lab=_83174_/Q }
C {devices/lab_pin.sym} 129500 -40510 0 0 {name=p128248 lab=_72794_/X }
C {devices/lab_pin.sym} 129500 -40470 0 0 {name=p128249 lab=_72849_/Y }
C {devices/lab_pin.sym} 129660 -40510 0 1 {name=p128250 lab=_83174_/D }
C {sky130_stdcells/a21o_4.sym} 129580 -40510 0 0 {name=X_72850_ }
C {devices/lab_pin.sym} 129490 -40370 0 0 {name=p128251 lab=_84308_/CLK }
C {devices/lab_pin.sym} 129490 -40350 0 0 {name=p128252 lab=_84836_/D }
C {devices/lab_pin.sym} 129670 -40370 0 1 {name=p128253 lab=_84836_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -40360 0 0 {name=X_84836_ }
C {devices/lab_pin.sym} 129540 -40230 0 0 {name=p128254 lab=_69182_/A }
C {devices/lab_pin.sym} 129620 -40230 0 1 {name=p128255 lab=_58749_/A }
C {sky130_stdcells/buf_2.sym} 129580 -40230 0 0 {name=X_57784_ }
C {devices/lab_pin.sym} 129520 -40120 0 0 {name=p128256 lab=_55011_/A }
C {devices/lab_pin.sym} 129520 -40080 0 0 {name=p128257 lab=_47589_/Y }
C {devices/lab_pin.sym} 129640 -40100 0 1 {name=p128258 lab=_54996_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -40100 0 0 {name=X_54996_ }
C {devices/lab_pin.sym} 129520 -40000 0 0 {name=p128259 lab=_70370_/A }
C {devices/lab_pin.sym} 129520 -39960 0 0 {name=p128260 lab=_71716_/B }
C {devices/lab_pin.sym} 129520 -39920 0 0 {name=p128261 lab=_71439_/C }
C {devices/lab_pin.sym} 129520 -39880 0 0 {name=p128262 lab=_71716_/D }
C {devices/lab_pin.sym} 129640 -39940 0 1 {name=p128263 lab=_71801_/X }
C {sky130_stdcells/and4_4.sym} 129580 -39940 0 0 {name=X_71801_ }
C {devices/lab_pin.sym} 129540 -39790 0 0 {name=p128264 lab=_59519_/C }
C {devices/lab_pin.sym} 129620 -39790 0 1 {name=p128265 lab=_59741_/C }
C {sky130_stdcells/buf_2.sym} 129580 -39790 0 0 {name=X_59523_ }
C {devices/lab_pin.sym} 129540 -39670 0 0 {name=p128266 lab=_57149_/D }
C {devices/lab_pin.sym} 129620 -39670 0 1 {name=p128267 lab=_56735_/X }
C {sky130_stdcells/buf_2.sym} 129580 -39670 0 0 {name=X_56735_ }
C {devices/lab_pin.sym} 129500 -39590 0 0 {name=p128268 lab=_41960_/X }
C {devices/lab_pin.sym} 129500 -39550 0 0 {name=p128269 lab=_41951_/X }
C {devices/lab_pin.sym} 129500 -39510 0 0 {name=p128270 lab=_40724_/X }
C {devices/lab_pin.sym} 129500 -39470 0 0 {name=p128271 lab=_74121_/A }
C {devices/lab_pin.sym} 129500 -39430 0 0 {name=p128272 lab=_41953_/X }
C {devices/lab_pin.sym} 129660 -39510 0 1 {name=p128273 lab=_41961_/Y }
C {sky130_stdcells/o32ai_4.sym} 129580 -39510 0 0 {name=X_41961_ }
C {devices/lab_pin.sym} 129490 -39350 0 0 {name=p128274 lab=_88060_/CLK }
C {devices/lab_pin.sym} 129490 -39330 0 0 {name=p128275 lab=_43156_/Y }
C {devices/lab_pin.sym} 129670 -39350 0 1 {name=p128276 lab=_87555_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -39340 0 0 {name=X_87555_ }
C {devices/lab_pin.sym} 129500 -39230 0 0 {name=p128277 lab=_85536_/Q }
C {devices/lab_pin.sym} 129500 -39190 0 0 {name=p128278 lab=_53921_/X }
C {devices/lab_pin.sym} 129500 -39150 0 0 {name=p128279 lab=_53946_/Y }
C {devices/lab_pin.sym} 129660 -39190 0 1 {name=p128280 lab=_53947_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -39190 0 0 {name=X_53947_ }
C {devices/lab_pin.sym} 129520 -39060 0 0 {name=p128281 lab=_73535_/A }
C {devices/lab_pin.sym} 129520 -39020 0 0 {name=p128282 lab=_65441_/B }
C {devices/lab_pin.sym} 129640 -39040 0 1 {name=p128283 lab=_72781_/X }
C {sky130_stdcells/and2_4.sym} 129580 -39040 0 0 {name=X_72781_ }
C {devices/lab_pin.sym} 129490 -38910 0 0 {name=p128284 lab=_86361_/CLK }
C {devices/lab_pin.sym} 129490 -38890 0 0 {name=p128285 lab=_59128_/Y }
C {devices/lab_pin.sym} 129670 -38910 0 1 {name=p128286 lab=_84767_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -38900 0 0 {name=X_84767_ }
C {devices/lab_pin.sym} 129490 -38770 0 0 {name=p128287 lab=_82234_/CLK }
C {devices/lab_pin.sym} 129490 -38750 0 0 {name=p128288 lab=_83907_/Q }
C {devices/lab_pin.sym} 129670 -38770 0 1 {name=p128289 lab=_81979_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -38760 0 0 {name=X_81979_ }
C {devices/lab_pin.sym} 129540 -38630 0 0 {name=p128290 lab=_43606_/A }
C {devices/lab_pin.sym} 129620 -38630 0 1 {name=p128291 lab=_43700_/X }
C {sky130_stdcells/buf_2.sym} 129580 -38630 0 0 {name=X_43700_ }
C {devices/lab_pin.sym} 129520 -38540 0 0 {name=p128292 lab=_70374_/X }
C {devices/lab_pin.sym} 129520 -38500 0 0 {name=p128293 lab=_74518_/B }
C {devices/lab_pin.sym} 129520 -38460 0 0 {name=p128294 lab=_70880_/C }
C {devices/lab_pin.sym} 129520 -38420 0 0 {name=p128295 lab=_74518_/D }
C {devices/lab_pin.sym} 129640 -38480 0 1 {name=p128296 lab=_74520_/Y }
C {sky130_stdcells/nand4_4.sym} 129580 -38480 0 0 {name=X_74520_ }
C {devices/lab_pin.sym} 129490 -38330 0 0 {name=p128297 lab=_86506_/CLK }
C {devices/lab_pin.sym} 129490 -38310 0 0 {name=p128298 lab=_86506_/D }
C {devices/lab_pin.sym} 129670 -38330 0 1 {name=p128299 lab=_86506_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -38320 0 0 {name=X_86506_ }
C {devices/lab_pin.sym} 129520 -38200 0 0 {name=p128300 lab=_40829_/A }
C {devices/lab_pin.sym} 129520 -38160 0 0 {name=p128301 lab=_40912_/B }
C {devices/lab_pin.sym} 129640 -38180 0 1 {name=p128302 lab=_40912_/X }
C {sky130_stdcells/or2_4.sym} 129580 -38180 0 0 {name=X_40912_ }
C {devices/lab_pin.sym} 129500 -38070 0 0 {name=p128303 lab=_58240_/Y }
C {devices/lab_pin.sym} 129500 -38030 0 0 {name=p128304 lab=_71711_/Y }
C {devices/lab_pin.sym} 129500 -37990 0 0 {name=p128305 lab=_71731_/Y }
C {devices/lab_pin.sym} 129660 -38030 0 1 {name=p128306 lab=_71732_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -38030 0 0 {name=X_71732_ }
C {devices/lab_pin.sym} 129520 -37900 0 0 {name=p128307 lab=_59454_/A }
C {devices/lab_pin.sym} 129520 -37860 0 0 {name=p128308 lab=_59444_/X }
C {devices/lab_pin.sym} 129640 -37880 0 1 {name=p128309 lab=_59454_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -37880 0 0 {name=X_59454_ }
C {devices/lab_pin.sym} 129490 -37750 0 0 {name=p128310 lab=_83721_/CLK }
C {devices/lab_pin.sym} 129490 -37730 0 0 {name=p128311 lab=_70718_/Y }
C {devices/lab_pin.sym} 129670 -37750 0 1 {name=p128312 lab=_83718_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -37740 0 0 {name=X_83718_ }
C {devices/lab_pin.sym} 129540 -37610 0 0 {name=p128313 lab=_41936_/A }
C {devices/lab_pin.sym} 129620 -37610 0 1 {name=p128314 lab=_44680_/X }
C {sky130_stdcells/buf_2.sym} 129580 -37610 0 0 {name=X_44680_ }
C {devices/lab_pin.sym} 129540 -37490 0 0 {name=p128315 lab=clkbuf_9_79_0_CLK/A }
C {devices/lab_pin.sym} 129620 -37490 0 1 {name=p128316 lab=clkbuf_9_78_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 129580 -37490 0 0 {name=Xclkbuf_9_78_0_CLK }
C {devices/lab_pin.sym} 129500 -37390 0 0 {name=p128317 lab=_56972_/A }
C {devices/lab_pin.sym} 129500 -37350 0 0 {name=p128318 lab=_56650_/Y }
C {devices/lab_pin.sym} 129500 -37310 0 0 {name=p128319 lab=_56665_/Y }
C {devices/lab_pin.sym} 129660 -37350 0 1 {name=p128320 lab=_56666_/Y }
C {sky130_stdcells/a21oi_4.sym} 129580 -37350 0 0 {name=X_56666_ }
C {devices/lab_pin.sym} 129490 -37210 0 0 {name=p128321 lab=_87487_/CLK }
C {devices/lab_pin.sym} 129490 -37190 0 0 {name=p128322 lab=_87486_/D }
C {devices/lab_pin.sym} 129670 -37210 0 1 {name=p128323 lab=_87486_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -37200 0 0 {name=X_87486_ }
C {devices/lab_pin.sym} 129500 -37110 0 0 {name=p128324 lab=_41887_/X }
C {devices/lab_pin.sym} 129500 -37070 0 0 {name=p128325 lab=_41888_/X }
C {devices/lab_pin.sym} 129500 -37030 0 0 {name=p128326 lab=_40590_/X }
C {devices/lab_pin.sym} 129500 -36990 0 0 {name=p128327 lab=_41889_/Y }
C {devices/lab_pin.sym} 129500 -36950 0 0 {name=p128328 lab=_41891_/X }
C {devices/lab_pin.sym} 129660 -37030 0 1 {name=p128329 lab=_41892_/Y }
C {sky130_stdcells/o32ai_4.sym} 129580 -37030 0 0 {name=X_41892_ }
C {devices/lab_pin.sym} 129500 -36890 0 0 {name=p128330 lab=_85550_/Q }
C {devices/lab_pin.sym} 129500 -36850 0 0 {name=p128331 lab=_53846_/X }
C {devices/lab_pin.sym} 129500 -36810 0 0 {name=p128332 lab=_53877_/Y }
C {devices/lab_pin.sym} 129660 -36850 0 1 {name=p128333 lab=_53878_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -36850 0 0 {name=X_53878_ }
C {devices/lab_pin.sym} 129490 -36710 0 0 {name=p128334 lab=_84713_/CLK }
C {devices/lab_pin.sym} 129490 -36690 0 0 {name=p128335 lab=_59800_/Y }
C {devices/lab_pin.sym} 129670 -36710 0 1 {name=p128336 lab=_80464_/A }
C {sky130_stdcells/dfxtp_4.sym} 129580 -36700 0 0 {name=X_84698_ }
C {devices/lab_pin.sym} 129540 -36570 0 0 {name=p128337 lab=_58981_/A }
C {devices/lab_pin.sym} 129620 -36570 0 1 {name=p128338 lab=_58423_/A }
C {sky130_stdcells/buf_2.sym} 129580 -36570 0 0 {name=X_58405_ }
C {devices/lab_pin.sym} 129500 -36480 0 0 {name=p128339 lab=_40660_/X }
C {devices/lab_pin.sym} 129500 -36440 0 0 {name=p128340 lab=_43609_/X }
C {devices/lab_pin.sym} 129500 -36400 0 0 {name=p128341 lab=_68695_/B }
C {devices/lab_pin.sym} 129500 -36360 0 0 {name=p128342 lab=_43611_/X }
C {devices/lab_pin.sym} 129660 -36420 0 1 {name=p128343 lab=_43632_/A }
C {sky130_stdcells/a2bb2o_4.sym} 129580 -36420 0 0 {name=X_43631_ }
C {devices/lab_pin.sym} 129540 -36270 0 0 {name=p128344 lab=_55617_/A }
C {devices/lab_pin.sym} 129620 -36270 0 1 {name=p128345 lab=_55617_/X }
C {sky130_stdcells/buf_2.sym} 129580 -36270 0 0 {name=X_55617_ }
C {devices/lab_pin.sym} 129520 -36160 0 0 {name=p128346 lab=_74442_/X }
C {devices/lab_pin.sym} 129520 -36120 0 0 {name=p128347 lab=_48559_/Y }
C {devices/lab_pin.sym} 129640 -36140 0 1 {name=p128348 lab=_74451_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -36140 0 0 {name=X_74451_ }
C {devices/lab_pin.sym} 129490 -36010 0 0 {name=p128349 lab=_86436_/CLK }
C {devices/lab_pin.sym} 129490 -35990 0 0 {name=p128350 lab=_86437_/D }
C {devices/lab_pin.sym} 129670 -36010 0 1 {name=p128351 lab=_86437_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -36000 0 0 {name=X_86437_ }
C {devices/lab_pin.sym} 129520 -35880 0 0 {name=p128352 lab=_82866_/Q }
C {devices/lab_pin.sym} 129520 -35840 0 0 {name=p128353 lab=_40842_/X }
C {devices/lab_pin.sym} 129640 -35860 0 1 {name=p128354 lab=_40843_/X }
C {sky130_stdcells/or2_4.sym} 129580 -35860 0 0 {name=X_40843_ }
C {devices/lab_pin.sym} 129520 -35740 0 0 {name=p128355 lab=_52843_/A }
C {devices/lab_pin.sym} 129520 -35700 0 0 {name=p128356 lab=_52829_/B }
C {devices/lab_pin.sym} 129640 -35720 0 1 {name=p128357 lab=_52829_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -35720 0 0 {name=X_52829_ }
C {devices/lab_pin.sym} 129500 -35620 0 0 {name=p128358 lab=_84746_/Q }
C {devices/lab_pin.sym} 129500 -35580 0 0 {name=p128359 lab=_59339_/X }
C {devices/lab_pin.sym} 129500 -35540 0 0 {name=p128360 lab=_59378_/X }
C {devices/lab_pin.sym} 129500 -35500 0 0 {name=p128361 lab=_59384_/X }
C {devices/lab_pin.sym} 129660 -35560 0 1 {name=p128362 lab=_59385_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 129580 -35560 0 0 {name=X_59385_ }
C {devices/lab_pin.sym} 129500 -35430 0 0 {name=p128363 lab=_58522_/Y }
C {devices/lab_pin.sym} 129500 -35390 0 0 {name=p128364 lab=_71649_/A }
C {devices/lab_pin.sym} 129500 -35350 0 0 {name=p128365 lab=_71662_/Y }
C {devices/lab_pin.sym} 129660 -35390 0 1 {name=p128366 lab=_83420_/D }
C {sky130_stdcells/o21ai_4.sym} 129580 -35390 0 0 {name=X_71663_ }
C {devices/lab_pin.sym} 129490 -35250 0 0 {name=p128367 lab=_82774_/CLK }
C {devices/lab_pin.sym} 129490 -35230 0 0 {name=p128368 lab=_70963_/Y }
C {devices/lab_pin.sym} 129670 -35250 0 1 {name=p128369 lab=_83649_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -35240 0 0 {name=X_83649_ }
C {devices/lab_pin.sym} 129520 -35120 0 0 {name=p128370 lab=_55562_/X }
C {devices/lab_pin.sym} 129520 -35080 0 0 {name=p128371 lab=_55568_/X }
C {devices/lab_pin.sym} 129640 -35100 0 1 {name=p128372 lab=_56597_/X }
C {sky130_stdcells/and2_4.sym} 129580 -35100 0 0 {name=X_56597_ }
C {devices/lab_pin.sym} 129500 -35000 0 0 {name=p128373 lab=_73257_/X }
C {devices/lab_pin.sym} 129500 -34960 0 0 {name=p128374 lab=_86184_/Q }
C {devices/lab_pin.sym} 129500 -34920 0 0 {name=p128375 lab=_73351_/X }
C {devices/lab_pin.sym} 129500 -34880 0 0 {name=p128376 lab=_73401_/X }
C {devices/lab_pin.sym} 129660 -34940 0 1 {name=p128377 lab=_73402_/X }
C {sky130_stdcells/a211o_4.sym} 129580 -34940 0 0 {name=X_73402_ }
C {devices/lab_pin.sym} 129520 -34800 0 0 {name=p128378 lab=_46350_/A }
C {devices/lab_pin.sym} 129520 -34760 0 0 {name=p128379 lab=_46380_/B }
C {devices/lab_pin.sym} 129640 -34780 0 1 {name=p128380 lab=_46350_/X }
C {sky130_stdcells/or2_4.sym} 129580 -34780 0 0 {name=X_46350_ }
C {devices/lab_pin.sym} 129500 -34670 0 0 {name=p128381 lab=_52991_/B }
C {devices/lab_pin.sym} 129500 -34630 0 0 {name=p128382 lab=_70584_/X }
C {devices/lab_pin.sym} 129500 -34590 0 0 {name=p128383 lab=_70613_/Y }
C {devices/lab_pin.sym} 129660 -34630 0 1 {name=p128384 lab=_83741_/D }
C {sky130_stdcells/o21ai_4.sym} 129580 -34630 0 0 {name=X_70614_ }
C {devices/lab_pin.sym} 129520 -34500 0 0 {name=p128385 lab=_58151_/A }
C {devices/lab_pin.sym} 129520 -34460 0 0 {name=p128386 lab=_58336_/B }
C {devices/lab_pin.sym} 129640 -34480 0 1 {name=p128387 lab=_58336_/Y }
C {sky130_stdcells/nor2_4.sym} 129580 -34480 0 0 {name=X_58336_ }
C {devices/lab_pin.sym} 129520 -34360 0 0 {name=p128388 lab=_77170_/A }
C {devices/lab_pin.sym} 129520 -34320 0 0 {name=p128389 lab=_77170_/B }
C {devices/lab_pin.sym} 129640 -34340 0 1 {name=p128390 lab=_77171_/A }
C {sky130_stdcells/nand2_4.sym} 129580 -34340 0 0 {name=X_77170_ }
C {devices/lab_pin.sym} 129500 -34240 0 0 {name=p128391 lab=_40485_/X }
C {devices/lab_pin.sym} 129500 -34200 0 0 {name=p128392 lab=_43560_/X }
C {devices/lab_pin.sym} 129500 -34160 0 0 {name=p128393 lab=_87360_/Q }
C {devices/lab_pin.sym} 129500 -34120 0 0 {name=p128394 lab=_43561_/X }
C {devices/lab_pin.sym} 129660 -34180 0 1 {name=p128395 lab=_87360_/D }
C {sky130_stdcells/a2bb2o_4.sym} 129580 -34180 0 0 {name=X_43562_ }
C {devices/lab_pin.sym} 129500 -34060 0 0 {name=p128396 lab=_83000_/Q }
C {devices/lab_pin.sym} 129500 -34020 0 0 {name=p128397 lab=_55511_/X }
C {devices/lab_pin.sym} 129500 -33980 0 0 {name=p128398 lab=_55532_/X }
C {devices/lab_pin.sym} 129500 -33940 0 0 {name=p128399 lab=_55547_/X }
C {devices/lab_pin.sym} 129660 -34000 0 1 {name=p128400 lab=_56616_/B }
C {sky130_stdcells/a211o_4.sym} 129580 -34000 0 0 {name=X_55548_ }
C {devices/lab_pin.sym} 129500 -33870 0 0 {name=p128401 lab=_74380_/Y }
C {devices/lab_pin.sym} 129500 -33830 0 0 {name=p128402 lab=_74370_/X }
C {devices/lab_pin.sym} 129500 -33790 0 0 {name=p128403 lab=_74381_/X }
C {devices/lab_pin.sym} 129660 -33830 0 1 {name=p128404 lab=_74382_/Y }
C {sky130_stdcells/a21oi_4.sym} 129580 -33830 0 0 {name=X_74382_ }
C {devices/lab_pin.sym} 129490 -33690 0 0 {name=p128405 lab=_83721_/CLK }
C {devices/lab_pin.sym} 129490 -33670 0 0 {name=p128406 lab=_49545_/Y }
C {devices/lab_pin.sym} 129670 -33690 0 1 {name=p128407 lab=_86368_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -33680 0 0 {name=X_86368_ }
C {devices/lab_pin.sym} 129520 -33560 0 0 {name=p128408 lab=_82879_/Q }
C {devices/lab_pin.sym} 129520 -33520 0 0 {name=p128409 lab=_40765_/B }
C {devices/lab_pin.sym} 129640 -33540 0 1 {name=p128410 lab=_40774_/X }
C {sky130_stdcells/or2_4.sym} 129580 -33540 0 0 {name=X_40774_ }
C {devices/lab_pin.sym} 129540 -33410 0 0 {name=p128411 lab=_71189_/B }
C {devices/lab_pin.sym} 129620 -33410 0 1 {name=p128412 lab=_71598_/C }
C {sky130_stdcells/buf_2.sym} 129580 -33410 0 0 {name=X_71594_ }
C {devices/lab_pin.sym} 129500 -33310 0 0 {name=p128413 lab=_56444_/C }
C {devices/lab_pin.sym} 129500 -33270 0 0 {name=p128414 lab=_45252_/X }
C {devices/lab_pin.sym} 129500 -33230 0 0 {name=p128415 lab=_45300_/X }
C {devices/lab_pin.sym} 129660 -33270 0 1 {name=p128416 lab=_45301_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -33270 0 0 {name=X_45301_ }
C {devices/lab_pin.sym} 129520 -33140 0 0 {name=p128417 lab=_81533_/Q }
C {devices/lab_pin.sym} 129520 -33100 0 0 {name=p128418 lab=_76121_/B }
C {devices/lab_pin.sym} 129640 -33120 0 1 {name=p128419 lab=_76121_/X }
C {sky130_stdcells/xor2_4.sym} 129580 -33120 0 0 {name=X_76121_ }
C {devices/lab_pin.sym} 129490 -32990 0 0 {name=p128420 lab=_87595_/CLK }
C {devices/lab_pin.sym} 129490 -32970 0 0 {name=p128421 lab=_88107_/D }
C {devices/lab_pin.sym} 129670 -32990 0 1 {name=p128422 lab=_41914_/A }
C {sky130_stdcells/dfxtp_4.sym} 129580 -32980 0 0 {name=X_88107_ }
C {devices/lab_pin.sym} 129500 -32890 0 0 {name=p128423 lab=_42495_/X }
C {devices/lab_pin.sym} 129500 -32850 0 0 {name=p128424 lab=_42496_/X }
C {devices/lab_pin.sym} 129500 -32810 0 0 {name=p128425 lab=_40707_/X }
C {devices/lab_pin.sym} 129500 -32770 0 0 {name=p128426 lab=_87838_/Q }
C {devices/lab_pin.sym} 129500 -32730 0 0 {name=p128427 lab=_42506_/X }
C {devices/lab_pin.sym} 129660 -32810 0 1 {name=p128428 lab=_42514_/A }
C {sky130_stdcells/o32ai_4.sym} 129580 -32810 0 0 {name=X_42513_ }
C {devices/lab_pin.sym} 129500 -32670 0 0 {name=p128429 lab=_73330_/X }
C {devices/lab_pin.sym} 129500 -32630 0 0 {name=p128430 lab=_73332_/X }
C {devices/lab_pin.sym} 129500 -32590 0 0 {name=p128431 lab=_72877_/X }
C {devices/lab_pin.sym} 129660 -32630 0 1 {name=p128432 lab=_73333_/X }
C {sky130_stdcells/a21o_4.sym} 129580 -32630 0 0 {name=X_73333_ }
C {devices/lab_pin.sym} 129490 -32490 0 0 {name=p128433 lab=_85351_/CLK }
C {devices/lab_pin.sym} 129490 -32470 0 0 {name=p128434 lab=_55097_/Y }
C {devices/lab_pin.sym} 129670 -32490 0 1 {name=p128435 lab=_85319_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -32480 0 0 {name=X_85319_ }
C {devices/lab_pin.sym} 129540 -32350 0 0 {name=p128436 lab=_83654_/Q }
C {devices/lab_pin.sym} 129620 -32350 0 1 {name=p128437 lab=_52440_/B }
C {sky130_stdcells/inv_2.sym} 129580 -32350 0 0 {name=X_46281_ }
C {devices/lab_pin.sym} 129520 -32260 0 0 {name=p128438 lab=_71586_/A }
C {devices/lab_pin.sym} 129520 -32220 0 0 {name=p128439 lab=_70692_/B }
C {devices/lab_pin.sym} 129520 -32180 0 0 {name=p128440 lab=_70538_/X }
C {devices/lab_pin.sym} 129520 -32140 0 0 {name=p128441 lab=_70550_/D }
C {devices/lab_pin.sym} 129640 -32200 0 1 {name=p128442 lab=_70545_/Y }
C {sky130_stdcells/nor4_4.sym} 129580 -32200 0 0 {name=X_70545_ }
C {devices/lab_pin.sym} 129540 -32050 0 0 {name=p128443 lab=_84892_/Q }
C {devices/lab_pin.sym} 129620 -32050 0 1 {name=p128444 lab=_58268_/A }
C {sky130_stdcells/inv_2.sym} 129580 -32050 0 0 {name=X_58267_ }
C {devices/lab_pin.sym} 129500 -31960 0 0 {name=p128445 lab=_41727_/X }
C {devices/lab_pin.sym} 129500 -31920 0 0 {name=p128446 lab=_43484_/X }
C {devices/lab_pin.sym} 129500 -31880 0 0 {name=p128447 lab=_87393_/Q }
C {devices/lab_pin.sym} 129500 -31840 0 0 {name=p128448 lab=_43485_/X }
C {devices/lab_pin.sym} 129660 -31900 0 1 {name=p128449 lab=_43493_/X }
C {sky130_stdcells/a2bb2o_4.sym} 129580 -31900 0 0 {name=X_43493_ }
C {devices/lab_pin.sym} 129520 -31760 0 0 {name=p128450 lab=_55474_/X }
C {devices/lab_pin.sym} 129520 -31720 0 0 {name=p128451 lab=_55478_/X }
C {devices/lab_pin.sym} 129640 -31740 0 1 {name=p128452 lab=_55646_/A }
C {sky130_stdcells/and2_4.sym} 129580 -31740 0 0 {name=X_55479_ }
C {devices/lab_pin.sym} 129490 -31610 0 0 {name=p128453 lab=_86301_/CLK }
C {devices/lab_pin.sym} 129490 -31590 0 0 {name=p128454 lab=_49921_/Y }
C {devices/lab_pin.sym} 129670 -31610 0 1 {name=p128455 lab=_72192_/B }
C {sky130_stdcells/dfxtp_4.sym} 129580 -31600 0 0 {name=X_86299_ }
C {devices/lab_pin.sym} 129520 -31480 0 0 {name=p128456 lab=_47981_/X }
C {devices/lab_pin.sym} 129520 -31440 0 0 {name=p128457 lab=_48020_/B }
C {devices/lab_pin.sym} 129640 -31460 0 1 {name=p128458 lab=_48020_/X }
C {sky130_stdcells/and2_4.sym} 129580 -31460 0 0 {name=X_48020_ }
C {devices/lab_pin.sym} 129520 -31340 0 0 {name=p128459 lab=_45232_/A }
C {devices/lab_pin.sym} 129520 -31300 0 0 {name=p128460 lab=_45199_/B }
C {devices/lab_pin.sym} 129640 -31320 0 1 {name=p128461 lab=_45232_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -31320 0 0 {name=X_45232_ }
C {devices/lab_pin.sym} 129500 -31210 0 0 {name=p128462 lab=_57216_/Y }
C {devices/lab_pin.sym} 129500 -31170 0 0 {name=p128463 lab=_57217_/Y }
C {devices/lab_pin.sym} 129500 -31130 0 0 {name=p128464 lab=_57112_/X }
C {devices/lab_pin.sym} 129660 -31170 0 1 {name=p128465 lab=_57218_/Y }
C {sky130_stdcells/a21oi_4.sym} 129580 -31170 0 0 {name=X_57218_ }
C {devices/lab_pin.sym} 129520 -31040 0 0 {name=p128466 lab=_76048_/Y }
C {devices/lab_pin.sym} 129520 -31000 0 0 {name=p128467 lab=_76051_/X }
C {devices/lab_pin.sym} 129640 -31020 0 1 {name=p128468 lab=_76052_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -31020 0 0 {name=X_76052_ }
C {devices/lab_pin.sym} 129500 -30920 0 0 {name=p128469 lab=_40548_/X }
C {devices/lab_pin.sym} 129500 -30880 0 0 {name=p128470 lab=_42434_/X }
C {devices/lab_pin.sym} 129500 -30840 0 0 {name=p128471 lab=_87860_/Q }
C {devices/lab_pin.sym} 129500 -30800 0 0 {name=p128472 lab=_42435_/X }
C {devices/lab_pin.sym} 129660 -30860 0 1 {name=p128473 lab=_42444_/X }
C {sky130_stdcells/a2bb2o_4.sym} 129580 -30860 0 0 {name=X_42444_ }
C {devices/lab_pin.sym} 129490 -30710 0 0 {name=p128474 lab=_88044_/CLK }
C {devices/lab_pin.sym} 129490 -30690 0 0 {name=p128475 lab=_42093_/Y }
C {devices/lab_pin.sym} 129670 -30710 0 1 {name=p128476 lab=_88038_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -30700 0 0 {name=X_88038_ }
C {devices/lab_pin.sym} 129540 -30570 0 0 {name=p128477 lab=_73516_/A }
C {devices/lab_pin.sym} 129620 -30570 0 1 {name=p128478 lab=_73407_/A }
C {sky130_stdcells/buf_2.sym} 129580 -30570 0 0 {name=X_73264_ }
C {devices/lab_pin.sym} 129540 -30450 0 0 {name=p128479 lab=_70382_/A }
C {devices/lab_pin.sym} 129620 -30450 0 1 {name=p128480 lab=_70476_/X }
C {sky130_stdcells/buf_2.sym} 129580 -30450 0 0 {name=X_70476_ }
C {devices/lab_pin.sym} 129520 -30340 0 0 {name=p128481 lab=_58198_/A }
C {devices/lab_pin.sym} 129520 -30300 0 0 {name=p128482 lab=_58184_/B }
C {devices/lab_pin.sym} 129640 -30320 0 1 {name=p128483 lab=_58198_/Y }
C {sky130_stdcells/nor2_4.sym} 129580 -30320 0 0 {name=X_58198_ }
C {devices/lab_pin.sym} 129520 -30200 0 0 {name=p128484 lab=_81143_/D }
C {devices/lab_pin.sym} 129520 -30160 0 0 {name=p128485 lab=_75003_/B }
C {devices/lab_pin.sym} 129640 -30180 0 1 {name=p128486 lab=_75003_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -30180 0 0 {name=X_75003_ }
C {devices/lab_pin.sym} 129500 -30070 0 0 {name=p128487 lab=_72180_/X }
C {devices/lab_pin.sym} 129500 -30030 0 0 {name=p128488 lab=_85337_/Q }
C {devices/lab_pin.sym} 129500 -29990 0 0 {name=p128489 lab=_59365_/X }
C {devices/lab_pin.sym} 129660 -30030 0 1 {name=p128490 lab=_72215_/X }
C {sky130_stdcells/o21a_4.sym} 129580 -30030 0 0 {name=X_72215_ }
C {devices/lab_pin.sym} 129500 -29910 0 0 {name=p128491 lab=_85264_/Q }
C {devices/lab_pin.sym} 129500 -29870 0 0 {name=p128492 lab=_45147_/X }
C {devices/lab_pin.sym} 129500 -29830 0 0 {name=p128493 lab=_45162_/X }
C {devices/lab_pin.sym} 129660 -29870 0 1 {name=p128494 lab=_45163_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -29870 0 0 {name=X_45163_ }
C {devices/lab_pin.sym} 129520 -29760 0 0 {name=p128495 lab=_56700_/Y }
C {devices/lab_pin.sym} 129520 -29720 0 0 {name=p128496 lab=_57149_/B }
C {devices/lab_pin.sym} 129520 -29680 0 0 {name=p128497 lab=_57149_/C }
C {devices/lab_pin.sym} 129520 -29640 0 0 {name=p128498 lab=_57149_/D }
C {devices/lab_pin.sym} 129640 -29700 0 1 {name=p128499 lab=_57149_/X }
C {sky130_stdcells/and4_4.sym} 129580 -29700 0 0 {name=X_57149_ }
C {devices/lab_pin.sym} 129540 -29550 0 0 {name=p128500 lab=_42304_/X }
C {devices/lab_pin.sym} 129620 -29550 0 1 {name=p128501 lab=_42375_/X }
C {sky130_stdcells/buf_2.sym} 129580 -29550 0 0 {name=X_42375_ }
C {devices/lab_pin.sym} 129540 -29430 0 0 {name=p128502 lab=_73195_/A }
C {devices/lab_pin.sym} 129620 -29430 0 1 {name=p128503 lab=_73196_/B }
C {sky130_stdcells/buf_2.sym} 129580 -29430 0 0 {name=X_73195_ }
C {devices/lab_pin.sym} 129540 -29310 0 0 {name=p128504 lab=clkbuf_8_8_0_CLK/X }
C {devices/lab_pin.sym} 129620 -29310 0 1 {name=p128505 lab=clkbuf_9_16_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 129580 -29310 0 0 {name=Xclkbuf_9_16_0_CLK }
C {devices/lab_pin.sym} 129540 -29190 0 0 {name=p128506 lab=_44113_/X }
C {devices/lab_pin.sym} 129620 -29190 0 1 {name=p128507 lab=_44115_/A }
C {sky130_stdcells/buf_2.sym} 129580 -29190 0 0 {name=X_44114_ }
C {devices/lab_pin.sym} 129500 -29090 0 0 {name=p128508 lab=_79795_/X }
C {devices/lab_pin.sym} 129500 -29050 0 0 {name=p128509 lab=_79798_/Y }
C {devices/lab_pin.sym} 129500 -29010 0 0 {name=p128510 lab=_79810_/X }
C {devices/lab_pin.sym} 129660 -29050 0 1 {name=p128511 lab=_79811_/X }
C {sky130_stdcells/a21o_4.sym} 129580 -29050 0 0 {name=X_79811_ }
C {devices/lab_pin.sym} 129520 -28920 0 0 {name=p128512 lab=_41326_/A }
C {devices/lab_pin.sym} 129520 -28880 0 0 {name=p128513 lab=_41325_/X }
C {devices/lab_pin.sym} 129640 -28900 0 1 {name=p128514 lab=_41326_/X }
C {sky130_stdcells/or2_4.sym} 129580 -28900 0 0 {name=X_41326_ }
C {devices/lab_pin.sym} 129540 -28770 0 0 {name=p128515 lab=_59037_/A }
C {devices/lab_pin.sym} 129620 -28770 0 1 {name=p128516 lab=_72146_/X }
C {sky130_stdcells/buf_2.sym} 129580 -28770 0 0 {name=X_72146_ }
C {devices/lab_pin.sym} 129520 -28660 0 0 {name=p128517 lab=_59574_/A }
C {devices/lab_pin.sym} 129520 -28620 0 0 {name=p128518 lab=_60160_/B }
C {devices/lab_pin.sym} 129640 -28640 0 1 {name=p128519 lab=_60222_/C }
C {sky130_stdcells/and2_4.sym} 129580 -28640 0 0 {name=X_60160_ }
C {devices/lab_pin.sym} 129520 -28520 0 0 {name=p128520 lab=_49981_/A }
C {devices/lab_pin.sym} 129520 -28480 0 0 {name=p128521 lab=_53183_/B }
C {devices/lab_pin.sym} 129640 -28500 0 1 {name=p128522 lab=_49971_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -28500 0 0 {name=X_49971_ }
C {devices/lab_pin.sym} 129540 -28370 0 0 {name=p128523 lab=_45094_/A }
C {devices/lab_pin.sym} 129620 -28370 0 1 {name=p128524 lab=_45095_/A }
C {sky130_stdcells/inv_2.sym} 129580 -28370 0 0 {name=X_45094_ }
C {devices/lab_pin.sym} 129520 -28260 0 0 {name=p128525 lab=_48901_/A }
C {devices/lab_pin.sym} 129520 -28220 0 0 {name=p128526 lab=_48922_/B }
C {devices/lab_pin.sym} 129640 -28240 0 1 {name=p128527 lab=_48922_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -28240 0 0 {name=X_48922_ }
C {devices/lab_pin.sym} 129540 -28110 0 0 {name=p128528 lab=_44044_/X }
C {devices/lab_pin.sym} 129620 -28110 0 1 {name=p128529 lab=_44045_/X }
C {sky130_stdcells/buf_2.sym} 129580 -28110 0 0 {name=X_44045_ }
C {devices/lab_pin.sym} 129520 -28000 0 0 {name=p128530 lab=_79742_/A }
C {devices/lab_pin.sym} 129520 -27960 0 0 {name=p128531 lab=_79742_/B }
C {devices/lab_pin.sym} 129640 -27980 0 1 {name=p128532 lab=_79742_/X }
C {sky130_stdcells/xor2_4.sym} 129580 -27980 0 0 {name=X_79742_ }
C {devices/lab_pin.sym} 129520 -27860 0 0 {name=p128533 lab=_81703_/Q }
C {devices/lab_pin.sym} 129520 -27820 0 0 {name=p128534 lab=_41280_/B }
C {devices/lab_pin.sym} 129640 -27840 0 1 {name=p128535 lab=_41257_/X }
C {sky130_stdcells/or2_4.sym} 129580 -27840 0 0 {name=X_41257_ }
C {devices/lab_pin.sym} 129520 -27730 0 0 {name=p128536 lab=_60091_/A }
C {devices/lab_pin.sym} 129520 -27690 0 0 {name=p128537 lab=_60091_/B }
C {devices/lab_pin.sym} 129520 -27650 0 0 {name=p128538 lab=_60091_/C }
C {devices/lab_pin.sym} 129640 -27690 0 1 {name=p128539 lab=_60091_/Y }
C {sky130_stdcells/nand3_4.sym} 129580 -27690 0 0 {name=X_60091_ }
C {devices/lab_pin.sym} 129520 -27560 0 0 {name=p128540 lab=_72053_/A }
C {devices/lab_pin.sym} 129520 -27520 0 0 {name=p128541 lab=_72077_/B }
C {devices/lab_pin.sym} 129640 -27540 0 1 {name=p128542 lab=_72077_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -27540 0 0 {name=X_72077_ }
C {devices/lab_pin.sym} 129520 -27420 0 0 {name=p128543 lab=_76957_/A }
C {devices/lab_pin.sym} 129520 -27380 0 0 {name=p128544 lab=_76957_/C }
C {devices/lab_pin.sym} 129640 -27400 0 1 {name=p128545 lab=_76956_/A }
C {sky130_stdcells/nand2_4.sym} 129580 -27400 0 0 {name=X_76954_ }
C {devices/lab_pin.sym} 129540 -27270 0 0 {name=p128546 lab=clkbuf_9_5_0_CLK/A }
C {devices/lab_pin.sym} 129620 -27270 0 1 {name=p128547 lab=clkbuf_9_4_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 129580 -27270 0 0 {name=Xclkbuf_9_4_0_CLK }
C {devices/lab_pin.sym} 129500 -27170 0 0 {name=p128548 lab=_53153_/B }
C {devices/lab_pin.sym} 129500 -27130 0 0 {name=p128549 lab=_71013_/X }
C {devices/lab_pin.sym} 129500 -27090 0 0 {name=p128550 lab=_71027_/Y }
C {devices/lab_pin.sym} 129660 -27130 0 1 {name=p128551 lab=_83631_/D }
C {sky130_stdcells/o21ai_4.sym} 129580 -27130 0 0 {name=X_71028_ }
C {devices/lab_pin.sym} 129520 -27000 0 0 {name=p128552 lab=_84503_/Q }
C {devices/lab_pin.sym} 129520 -26960 0 0 {name=p128553 lab=_62873_/C }
C {devices/lab_pin.sym} 129640 -26980 0 1 {name=p128554 lab=_75905_/X }
C {sky130_stdcells/xor2_4.sym} 129580 -26980 0 0 {name=X_75905_ }
C {devices/lab_pin.sym} 129540 -26850 0 0 {name=p128555 lab=_48853_/A }
C {devices/lab_pin.sym} 129620 -26850 0 1 {name=p128556 lab=_48854_/C }
C {sky130_stdcells/buf_2.sym} 129580 -26850 0 0 {name=X_48853_ }
C {devices/lab_pin.sym} 129520 -26740 0 0 {name=p128557 lab=_79669_/X }
C {devices/lab_pin.sym} 129520 -26700 0 0 {name=p128558 lab=_79672_/Y }
C {devices/lab_pin.sym} 129640 -26720 0 1 {name=p128559 lab=_79673_/X }
C {sky130_stdcells/xor2_4.sym} 129580 -26720 0 0 {name=X_79673_ }
C {devices/lab_pin.sym} 129500 -26610 0 0 {name=p128560 lab=_41184_/X }
C {devices/lab_pin.sym} 129500 -26570 0 0 {name=p128561 lab=_81139_/Q }
C {devices/lab_pin.sym} 129500 -26530 0 0 {name=p128562 lab=_41187_/X }
C {devices/lab_pin.sym} 129660 -26570 0 1 {name=p128563 lab=_41189_/A }
C {sky130_stdcells/o21ai_4.sym} 129580 -26570 0 0 {name=X_41188_ }
C {devices/lab_pin.sym} 129520 -26440 0 0 {name=p128564 lab=_81500_/Q }
C {devices/lab_pin.sym} 129520 -26400 0 0 {name=p128565 lab=_76884_/X }
C {devices/lab_pin.sym} 129640 -26420 0 1 {name=p128566 lab=_76885_/X }
C {sky130_stdcells/xor2_4.sym} 129580 -26420 0 0 {name=X_76885_ }
C {devices/lab_pin.sym} 129520 -26320 0 0 {name=p128567 lab=_47804_/A }
C {devices/lab_pin.sym} 129520 -26280 0 0 {name=p128568 lab=_49364_/B }
C {devices/lab_pin.sym} 129520 -26240 0 0 {name=p128569 lab=_50886_/C }
C {devices/lab_pin.sym} 129520 -26200 0 0 {name=p128570 lab=_53253_/D }
C {devices/lab_pin.sym} 129640 -26260 0 1 {name=p128571 lab=_47804_/X }
C {sky130_stdcells/and4_4.sym} 129580 -26260 0 0 {name=X_47804_ }
C {devices/lab_pin.sym} 129500 -26130 0 0 {name=p128572 lab=_78586_/Y }
C {devices/lab_pin.sym} 129500 -26090 0 0 {name=p128573 lab=_78588_/X }
C {devices/lab_pin.sym} 129500 -26050 0 0 {name=p128574 lab=_78623_/A }
C {devices/lab_pin.sym} 129660 -26090 0 1 {name=p128575 lab=_78640_/A }
C {sky130_stdcells/a21o_4.sym} 129580 -26090 0 0 {name=X_78624_ }
C {devices/lab_pin.sym} 129520 -25970 0 0 {name=p128576 lab=_63848_/X }
C {devices/lab_pin.sym} 129520 -25930 0 0 {name=p128577 lab=_63849_/X }
C {devices/lab_pin.sym} 129520 -25890 0 0 {name=p128578 lab=_84291_/Q }
C {devices/lab_pin.sym} 129640 -25930 0 1 {name=p128579 lab=_63850_/Y }
C {sky130_stdcells/nor3_4.sym} 129580 -25930 0 0 {name=X_63850_ }
C {devices/lab_pin.sym} 129520 -25800 0 0 {name=p128580 lab=_75836_/A }
C {devices/lab_pin.sym} 129520 -25760 0 0 {name=p128581 lab=_75836_/B }
C {devices/lab_pin.sym} 129640 -25780 0 1 {name=p128582 lab=_80894_/D }
C {sky130_stdcells/xor2_4.sym} 129580 -25780 0 0 {name=X_75836_ }
C {devices/lab_pin.sym} 129500 -25670 0 0 {name=p128583 lab=_86483_/Q }
C {devices/lab_pin.sym} 129500 -25630 0 0 {name=p128584 lab=_48781_/X }
C {devices/lab_pin.sym} 129500 -25590 0 0 {name=p128585 lab=_48783_/Y }
C {devices/lab_pin.sym} 129660 -25630 0 1 {name=p128586 lab=_48784_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -25630 0 0 {name=X_48784_ }
C {devices/lab_pin.sym} 129500 -25530 0 0 {name=p128587 lab=_45994_/X }
C {devices/lab_pin.sym} 129500 -25490 0 0 {name=p128588 lab=_45987_/X }
C {devices/lab_pin.sym} 129500 -25450 0 0 {name=p128589 lab=_40458_/X }
C {devices/lab_pin.sym} 129500 -25410 0 0 {name=p128590 lab=_66938_/B }
C {devices/lab_pin.sym} 129500 -25370 0 0 {name=p128591 lab=_45995_/X }
C {devices/lab_pin.sym} 129660 -25450 0 1 {name=p128592 lab=_45996_/Y }
C {sky130_stdcells/o32ai_4.sym} 129580 -25450 0 0 {name=X_45996_ }
C {devices/lab_pin.sym} 129540 -25290 0 0 {name=p128593 lab=_62681_/X }
C {devices/lab_pin.sym} 129620 -25290 0 1 {name=p128594 lab=_62801_/X }
C {sky130_stdcells/buf_2.sym} 129580 -25290 0 0 {name=X_62801_ }
C {devices/lab_pin.sym} 129520 -25180 0 0 {name=p128595 lab=_47715_/X }
C {devices/lab_pin.sym} 129520 -25140 0 0 {name=p128596 lab=_53213_/B }
C {devices/lab_pin.sym} 129640 -25160 0 1 {name=p128597 lab=_47735_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -25160 0 0 {name=X_47735_ }
C {devices/lab_pin.sym} 129520 -25040 0 0 {name=p128598 lab=_78555_/A }
C {devices/lab_pin.sym} 129520 -25000 0 0 {name=p128599 lab=_78552_/A }
C {devices/lab_pin.sym} 129640 -25020 0 1 {name=p128600 lab=_78555_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -25020 0 0 {name=X_78555_ }
C {devices/lab_pin.sym} 129500 -24910 0 0 {name=p128601 lab=_56386_/C }
C {devices/lab_pin.sym} 129500 -24870 0 0 {name=p128602 lab=_44945_/X }
C {devices/lab_pin.sym} 129500 -24830 0 0 {name=p128603 lab=_44946_/X }
C {devices/lab_pin.sym} 129660 -24870 0 1 {name=p128604 lab=_44947_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -24870 0 0 {name=X_44947_ }
C {devices/lab_pin.sym} 129520 -24760 0 0 {name=p128605 lab=_61356_/X }
C {devices/lab_pin.sym} 129520 -24720 0 0 {name=p128606 lab=_63781_/B }
C {devices/lab_pin.sym} 129520 -24680 0 0 {name=p128607 lab=_63781_/C }
C {devices/lab_pin.sym} 129520 -24640 0 0 {name=p128608 lab=_63761_/X }
C {devices/lab_pin.sym} 129640 -24700 0 1 {name=p128609 lab=_63781_/Y }
C {sky130_stdcells/nand4_4.sym} 129580 -24700 0 0 {name=X_63781_ }
C {devices/lab_pin.sym} 129520 -24560 0 0 {name=p128610 lab=_81015_/Q }
C {devices/lab_pin.sym} 129520 -24520 0 0 {name=p128611 lab=_80887_/D }
C {devices/lab_pin.sym} 129640 -24540 0 1 {name=p128612 lab=_75767_/X }
C {sky130_stdcells/xor2_4.sym} 129580 -24540 0 0 {name=X_75767_ }
C {devices/lab_pin.sym} 129520 -24430 0 0 {name=p128613 lab=_60992_/X }
C {devices/lab_pin.sym} 129520 -24390 0 0 {name=p128614 lab=_60993_/B }
C {devices/lab_pin.sym} 129520 -24350 0 0 {name=p128615 lab=_60934_/X }
C {devices/lab_pin.sym} 129640 -24390 0 1 {name=p128616 lab=_60993_/Y }
C {sky130_stdcells/nor3_4.sym} 129580 -24390 0 0 {name=X_60993_ }
C {devices/lab_pin.sym} 129540 -24250 0 0 {name=p128617 lab=_44272_/X }
C {devices/lab_pin.sym} 129620 -24250 0 1 {name=p128618 lab=_72979_/X }
C {sky130_stdcells/buf_2.sym} 129580 -24250 0 0 {name=X_72979_ }
C {devices/lab_pin.sym} 129500 -24160 0 0 {name=p128619 lab=_65334_/X }
C {devices/lab_pin.sym} 129500 -24120 0 0 {name=p128620 lab=_86203_/Q }
C {devices/lab_pin.sym} 129500 -24080 0 0 {name=p128621 lab=_65517_/X }
C {devices/lab_pin.sym} 129500 -24040 0 0 {name=p128622 lab=_65519_/X }
C {devices/lab_pin.sym} 129660 -24100 0 1 {name=p128623 lab=_65520_/X }
C {sky130_stdcells/a211o_4.sym} 129580 -24100 0 0 {name=X_65520_ }
C {devices/lab_pin.sym} 129520 -23960 0 0 {name=p128624 lab=_77507_/A }
C {devices/lab_pin.sym} 129520 -23920 0 0 {name=p128625 lab=_82101_/D }
C {devices/lab_pin.sym} 129640 -23940 0 1 {name=p128626 lab=_77509_/B }
C {sky130_stdcells/nor2_4.sym} 129580 -23940 0 0 {name=X_77506_ }
C {devices/lab_pin.sym} 129500 -23850 0 0 {name=p128627 lab=_62726_/Y }
C {devices/lab_pin.sym} 129500 -23810 0 0 {name=p128628 lab=_62713_/X }
C {devices/lab_pin.sym} 129500 -23770 0 0 {name=p128629 lab=_62727_/Y }
C {devices/lab_pin.sym} 129500 -23730 0 0 {name=p128630 lab=_62729_/Y }
C {devices/lab_pin.sym} 129500 -23700 0 0 {name=p128631 lab=_62731_/X }
C {devices/lab_pin.sym} 129660 -23770 0 1 {name=p128632 lab=_62732_/X }
C {sky130_stdcells/a41o_4.sym} 129580 -23770 0 0 {name=X_62732_ }
C {devices/lab_pin.sym} 129540 -23610 0 0 {name=p128633 lab=_74739_/B }
C {devices/lab_pin.sym} 129620 -23610 0 1 {name=p128634 lab=_74720_/C }
C {sky130_stdcells/buf_2.sym} 129580 -23610 0 0 {name=X_74718_ }
C {devices/lab_pin.sym} 129540 -23490 0 0 {name=p128635 lab=_47619_/A }
C {devices/lab_pin.sym} 129620 -23490 0 1 {name=p128636 lab=_47666_/X }
C {sky130_stdcells/buf_2.sym} 129580 -23490 0 0 {name=X_47666_ }
C {devices/lab_pin.sym} 129500 -23390 0 0 {name=p128637 lab=_78472_/X }
C {devices/lab_pin.sym} 129500 -23350 0 0 {name=p128638 lab=_82798_/Q }
C {devices/lab_pin.sym} 129500 -23310 0 0 {name=p128639 lab=_78485_/Y }
C {devices/lab_pin.sym} 129660 -23350 0 1 {name=p128640 lab=_78486_/Y }
C {sky130_stdcells/a21oi_4.sym} 129580 -23350 0 0 {name=X_78486_ }
C {devices/lab_pin.sym} 129540 -23210 0 0 {name=p128641 lab=_45387_/A }
C {devices/lab_pin.sym} 129620 -23210 0 1 {name=p128642 lab=_44932_/A }
C {sky130_stdcells/buf_2.sym} 129580 -23210 0 0 {name=X_44878_ }
C {devices/lab_pin.sym} 129520 -23100 0 0 {name=p128643 lab=_75684_/Y }
C {devices/lab_pin.sym} 129520 -23060 0 0 {name=p128644 lab=_75697_/X }
C {devices/lab_pin.sym} 129640 -23080 0 1 {name=p128645 lab=_75703_/A }
C {sky130_stdcells/nand2_4.sym} 129580 -23080 0 0 {name=X_75698_ }
C {devices/lab_pin.sym} 129540 -22950 0 0 {name=p128646 lab=_49405_/A }
C {devices/lab_pin.sym} 129620 -22950 0 1 {name=p128647 lab=_49405_/X }
C {sky130_stdcells/buf_2.sym} 129580 -22950 0 0 {name=X_49405_ }
C {devices/lab_pin.sym} 129540 -22830 0 0 {name=p128648 lab=_46617_/A }
C {devices/lab_pin.sym} 129620 -22830 0 1 {name=p128649 lab=_46659_/C }
C {sky130_stdcells/buf_2.sym} 129580 -22830 0 0 {name=X_46617_ }
C {devices/lab_pin.sym} 129520 -22720 0 0 {name=p128650 lab=_65401_/A }
C {devices/lab_pin.sym} 129520 -22680 0 0 {name=p128651 lab=_65451_/B }
C {devices/lab_pin.sym} 129640 -22700 0 1 {name=p128652 lab=_65451_/X }
C {sky130_stdcells/and2_4.sym} 129580 -22700 0 0 {name=X_65451_ }
C {devices/lab_pin.sym} 129500 -22590 0 0 {name=p128653 lab=_77412_/X }
C {devices/lab_pin.sym} 129500 -22550 0 0 {name=p128654 lab=_77413_/Y }
C {devices/lab_pin.sym} 129500 -22510 0 0 {name=p128655 lab=_77416_/A }
C {devices/lab_pin.sym} 129660 -22550 0 1 {name=p128656 lab=_77437_/Y }
C {sky130_stdcells/a21boi_4.sym} 129580 -22550 0 0 {name=X_77437_ }
C {devices/lab_pin.sym} 129500 -22450 0 0 {name=p128657 lab=_43810_/X }
C {devices/lab_pin.sym} 129500 -22410 0 0 {name=p128658 lab=_43824_/X }
C {devices/lab_pin.sym} 129500 -22370 0 0 {name=p128659 lab=_41139_/X }
C {devices/lab_pin.sym} 129500 -22330 0 0 {name=p128660 lab=_87246_/Q }
C {devices/lab_pin.sym} 129500 -22290 0 0 {name=p128661 lab=_43811_/X }
C {devices/lab_pin.sym} 129660 -22370 0 1 {name=p128662 lab=_43830_/A }
C {sky130_stdcells/o32ai_4.sym} 129580 -22370 0 0 {name=X_43829_ }
C {devices/lab_pin.sym} 129540 -22210 0 0 {name=p128663 lab=_60202_/A }
C {devices/lab_pin.sym} 129620 -22210 0 1 {name=p128664 lab=_62664_/D }
C {sky130_stdcells/buf_2.sym} 129580 -22210 0 0 {name=X_62663_ }
C {devices/lab_pin.sym} 129500 -22120 0 0 {name=p128665 lab=_74638_/X }
C {devices/lab_pin.sym} 129500 -22080 0 0 {name=p128666 lab=_56619_/A }
C {devices/lab_pin.sym} 129500 -22040 0 0 {name=p128667 lab=_83000_/Q }
C {devices/lab_pin.sym} 129500 -22000 0 0 {name=p128668 lab=_74645_/X }
C {devices/lab_pin.sym} 129660 -22060 0 1 {name=p128669 lab=_74649_/X }
C {sky130_stdcells/a2bb2o_4.sym} 129580 -22060 0 0 {name=X_74649_ }
C {devices/lab_pin.sym} 129540 -21910 0 0 {name=p128670 lab=_47597_/A }
C {devices/lab_pin.sym} 129620 -21910 0 1 {name=p128671 lab=_47598_/A }
C {sky130_stdcells/inv_2.sym} 129580 -21910 0 0 {name=X_47597_ }
C {devices/lab_pin.sym} 129540 -21790 0 0 {name=p128672 lab=_64285_/A }
C {devices/lab_pin.sym} 129620 -21790 0 1 {name=p128673 lab=_64402_/X }
C {sky130_stdcells/buf_2.sym} 129580 -21790 0 0 {name=X_64402_ }
C {devices/lab_pin.sym} 129520 -21680 0 0 {name=p128674 lab=_49352_/A }
C {devices/lab_pin.sym} 129520 -21640 0 0 {name=p128675 lab=_50858_/B }
C {devices/lab_pin.sym} 129640 -21660 0 1 {name=p128676 lab=_49336_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -21660 0 0 {name=X_49336_ }
C {devices/lab_pin.sym} 129500 -21570 0 0 {name=p128677 lab=_61607_/Y }
C {devices/lab_pin.sym} 129500 -21530 0 0 {name=p128678 lab=_61610_/Y }
C {devices/lab_pin.sym} 129500 -21490 0 0 {name=p128679 lab=_61583_/Y }
C {devices/lab_pin.sym} 129500 -21450 0 0 {name=p128680 lab=_61611_/Y }
C {devices/lab_pin.sym} 129500 -21420 0 0 {name=p128681 lab=_61613_/Y }
C {devices/lab_pin.sym} 129660 -21490 0 1 {name=p128682 lab=_61614_/X }
C {sky130_stdcells/a41o_4.sym} 129580 -21490 0 0 {name=X_61614_ }
C {devices/lab_pin.sym} 129500 -21350 0 0 {name=p128683 lab=_67061_/X }
C {devices/lab_pin.sym} 129500 -21310 0 0 {name=p128684 lab=_67065_/X }
C {devices/lab_pin.sym} 129500 -21270 0 0 {name=p128685 lab=_68169_/X }
C {devices/lab_pin.sym} 129660 -21310 0 1 {name=p128686 lab=_68170_/Y }
C {sky130_stdcells/a21oi_4.sym} 129580 -21310 0 0 {name=X_68170_ }
C {devices/lab_pin.sym} 129500 -21190 0 0 {name=p128687 lab=_86727_/Q }
C {devices/lab_pin.sym} 129500 -21150 0 0 {name=p128688 lab=_46543_/X }
C {devices/lab_pin.sym} 129500 -21110 0 0 {name=p128689 lab=_46547_/Y }
C {devices/lab_pin.sym} 129660 -21150 0 1 {name=p128690 lab=_46548_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -21150 0 0 {name=X_46548_ }
C {devices/lab_pin.sym} 129500 -21040 0 0 {name=p128691 lab=_44150_/X }
C {devices/lab_pin.sym} 129500 -21000 0 0 {name=p128692 lab=_86723_/Q }
C {devices/lab_pin.sym} 129500 -20960 0 0 {name=p128693 lab=_64980_/X }
C {devices/lab_pin.sym} 129500 -20920 0 0 {name=p128694 lab=_65381_/X }
C {devices/lab_pin.sym} 129660 -20980 0 1 {name=p128695 lab=_65383_/C }
C {sky130_stdcells/a211o_4.sym} 129580 -20980 0 0 {name=X_65382_ }
C {devices/lab_pin.sym} 129520 -20840 0 0 {name=p128696 lab=_82220_/Q }
C {devices/lab_pin.sym} 129520 -20800 0 0 {name=p128697 lab=_77367_/X }
C {devices/lab_pin.sym} 129640 -20820 0 1 {name=p128698 lab=_77387_/B }
C {sky130_stdcells/xnor2_4.sym} 129580 -20820 0 0 {name=X_77368_ }
C {devices/lab_pin.sym} 129520 -20710 0 0 {name=p128699 lab=_62551_/X }
C {devices/lab_pin.sym} 129520 -20670 0 0 {name=p128700 lab=_62553_/X }
C {devices/lab_pin.sym} 129520 -20630 0 0 {name=p128701 lab=_84398_/Q }
C {devices/lab_pin.sym} 129640 -20670 0 1 {name=p128702 lab=_62594_/Y }
C {sky130_stdcells/nor3_4.sym} 129580 -20670 0 0 {name=X_62594_ }
C {devices/lab_pin.sym} 129540 -20530 0 0 {name=p128703 lab=_67120_/X }
C {devices/lab_pin.sym} 129620 -20530 0 1 {name=p128704 lab=_67121_/X }
C {sky130_stdcells/buf_2.sym} 129580 -20530 0 0 {name=X_67121_ }
C {devices/lab_pin.sym} 129540 -20410 0 0 {name=p128705 lab=_79107_/A }
C {devices/lab_pin.sym} 129620 -20410 0 1 {name=p128706 lab=_79108_/B }
C {sky130_stdcells/inv_2.sym} 129580 -20410 0 0 {name=X_79107_ }
C {devices/lab_pin.sym} 129540 -20290 0 0 {name=p128707 lab=_76319_/A }
C {devices/lab_pin.sym} 129620 -20290 0 1 {name=p128708 lab=_76319_/Y }
C {sky130_stdcells/inv_2.sym} 129580 -20290 0 0 {name=X_76319_ }
C {devices/lab_pin.sym} 129540 -20170 0 0 {name=p128709 lab=_64274_/A }
C {devices/lab_pin.sym} 129620 -20170 0 1 {name=p128710 lab=_64333_/X }
C {sky130_stdcells/buf_2.sym} 129580 -20170 0 0 {name=X_64333_ }
C {devices/lab_pin.sym} 129520 -20060 0 0 {name=p128711 lab=_49263_/A }
C {devices/lab_pin.sym} 129520 -20020 0 0 {name=p128712 lab=_52482_/B }
C {devices/lab_pin.sym} 129640 -20040 0 1 {name=p128713 lab=_49267_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -20040 0 0 {name=X_49267_ }
C {devices/lab_pin.sym} 129500 -19950 0 0 {name=p128714 lab=_61538_/Y }
C {devices/lab_pin.sym} 129500 -19910 0 0 {name=p128715 lab=_61541_/Y }
C {devices/lab_pin.sym} 129500 -19870 0 0 {name=p128716 lab=_61525_/X }
C {devices/lab_pin.sym} 129500 -19830 0 0 {name=p128717 lab=_61542_/Y }
C {devices/lab_pin.sym} 129500 -19800 0 0 {name=p128718 lab=_61544_/Y }
C {devices/lab_pin.sym} 129660 -19870 0 1 {name=p128719 lab=_61545_/X }
C {sky130_stdcells/a41o_4.sym} 129580 -19870 0 0 {name=X_61545_ }
C {devices/lab_pin.sym} 129500 -19730 0 0 {name=p128720 lab=_86733_/Q }
C {devices/lab_pin.sym} 129500 -19690 0 0 {name=p128721 lab=_46474_/X }
C {devices/lab_pin.sym} 129500 -19650 0 0 {name=p128722 lab=_46478_/Y }
C {devices/lab_pin.sym} 129660 -19690 0 1 {name=p128723 lab=_46479_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -19690 0 0 {name=X_46479_ }
C {devices/lab_pin.sym} 129520 -19570 0 0 {name=p128724 lab=_77297_/Y }
C {devices/lab_pin.sym} 129520 -19530 0 0 {name=p128725 lab=_77295_/X }
C {devices/lab_pin.sym} 129520 -19490 0 0 {name=p128726 lab=_77296_/Y }
C {devices/lab_pin.sym} 129640 -19530 0 1 {name=p128727 lab=_77300_/A }
C {sky130_stdcells/nand3_4.sym} 129580 -19530 0 0 {name=X_77299_ }
C {devices/lab_pin.sym} 129500 -19410 0 0 {name=p128728 lab=_48216_/Y }
C {devices/lab_pin.sym} 129500 -19370 0 0 {name=p128729 lab=_48194_/X }
C {devices/lab_pin.sym} 129500 -19330 0 0 {name=p128730 lab=_48217_/X }
C {devices/lab_pin.sym} 129660 -19370 0 1 {name=p128731 lab=_48218_/Y }
C {sky130_stdcells/a21oi_4.sym} 129580 -19370 0 0 {name=X_48218_ }
C {devices/lab_pin.sym} 129520 -19240 0 0 {name=p128732 lab=_67028_/A }
C {devices/lab_pin.sym} 129520 -19200 0 0 {name=p128733 lab=_67052_/B }
C {devices/lab_pin.sym} 129640 -19220 0 1 {name=p128734 lab=_67052_/X }
C {sky130_stdcells/and2_4.sym} 129580 -19220 0 0 {name=X_67052_ }
C {devices/lab_pin.sym} 129520 -19110 0 0 {name=p128735 lab=_79037_/C }
C {devices/lab_pin.sym} 129520 -19070 0 0 {name=p128736 lab=_79021_/A }
C {devices/lab_pin.sym} 129520 -19030 0 0 {name=p128737 lab=_79021_/B }
C {devices/lab_pin.sym} 129640 -19070 0 1 {name=p128738 lab=_79038_/Y }
C {sky130_stdcells/nand3_4.sym} 129580 -19070 0 0 {name=X_79038_ }
C {devices/lab_pin.sym} 129540 -18930 0 0 {name=p128739 lab=_64323_/A }
C {devices/lab_pin.sym} 129620 -18930 0 1 {name=p128740 lab=_64287_/C }
C {sky130_stdcells/buf_2.sym} 129580 -18930 0 0 {name=X_64264_ }
C {devices/lab_pin.sym} 129500 -18830 0 0 {name=p128741 lab=_86434_/Q }
C {devices/lab_pin.sym} 129500 -18790 0 0 {name=p128742 lab=_49153_/X }
C {devices/lab_pin.sym} 129500 -18750 0 0 {name=p128743 lab=_49197_/Y }
C {devices/lab_pin.sym} 129660 -18790 0 1 {name=p128744 lab=_49198_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -18790 0 0 {name=X_49198_ }
C {devices/lab_pin.sym} 129540 -18650 0 0 {name=p128745 lab=_61476_/A }
C {devices/lab_pin.sym} 129620 -18650 0 1 {name=p128746 lab=_61518_/B }
C {sky130_stdcells/buf_2.sym} 129580 -18650 0 0 {name=X_61476_ }
C {devices/lab_pin.sym} 129540 -18530 0 0 {name=p128747 lab=_66003_/A }
C {devices/lab_pin.sym} 129620 -18530 0 1 {name=p128748 lab=_66004_/B }
C {sky130_stdcells/buf_2.sym} 129580 -18530 0 0 {name=X_66003_ }
C {devices/lab_pin.sym} 129520 -18440 0 0 {name=p128749 lab=_63203_/X }
C {devices/lab_pin.sym} 129520 -18400 0 0 {name=p128750 lab=_64422_/C }
C {devices/lab_pin.sym} 129520 -18360 0 0 {name=p128751 lab=_63204_/X }
C {devices/lab_pin.sym} 129520 -18320 0 0 {name=p128752 lab=_63239_/D }
C {devices/lab_pin.sym} 129640 -18380 0 1 {name=p128753 lab=_63215_/X }
C {sky130_stdcells/and4_4.sym} 129580 -18380 0 0 {name=X_63215_ }
C {devices/lab_pin.sym} 129540 -18230 0 0 {name=p128754 lab=_60427_/A }
C {devices/lab_pin.sym} 129620 -18230 0 1 {name=p128755 lab=_60435_/A }
C {sky130_stdcells/inv_2.sym} 129580 -18230 0 0 {name=X_60427_ }
C {devices/lab_pin.sym} 129500 -18130 0 0 {name=p128756 lab=_48143_/Y }
C {devices/lab_pin.sym} 129500 -18090 0 0 {name=p128757 lab=_48109_/X }
C {devices/lab_pin.sym} 129500 -18050 0 0 {name=p128758 lab=_48148_/X }
C {devices/lab_pin.sym} 129660 -18090 0 1 {name=p128759 lab=_86563_/D }
C {sky130_stdcells/a21oi_4.sym} 129580 -18090 0 0 {name=X_48149_ }
C {devices/lab_pin.sym} 129500 -17970 0 0 {name=p128760 lab=_84906_/Q }
C {devices/lab_pin.sym} 129500 -17930 0 0 {name=p128761 lab=_63761_/X }
C {devices/lab_pin.sym} 129500 -17890 0 0 {name=p128762 lab=_60895_/X }
C {devices/lab_pin.sym} 129660 -17930 0 1 {name=p128763 lab=_64195_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -17930 0 0 {name=X_64195_ }
C {devices/lab_pin.sym} 129490 -17790 0 0 {name=p128764 lab=_81134_/CLK }
C {devices/lab_pin.sym} 129490 -17770 0 0 {name=p128765 lab=_65268_/C }
C {devices/lab_pin.sym} 129670 -17790 0 1 {name=p128766 lab=_75628_/A }
C {sky130_stdcells/dfxtp_4.sym} 129580 -17780 0 0 {name=X_81000_ }
C {devices/lab_pin.sym} 129520 -17680 0 0 {name=p128767 lab=_51160_/A }
C {devices/lab_pin.sym} 129520 -17640 0 0 {name=p128768 lab=_51160_/B }
C {devices/lab_pin.sym} 129520 -17600 0 0 {name=p128769 lab=_51141_/X }
C {devices/lab_pin.sym} 129520 -17560 0 0 {name=p128770 lab=_52853_/D }
C {devices/lab_pin.sym} 129640 -17620 0 1 {name=p128771 lab=_51160_/X }
C {sky130_stdcells/and4_4.sym} 129580 -17620 0 0 {name=X_51160_ }
C {devices/lab_pin.sym} 129520 -17500 0 0 {name=p128772 lab=_63144_/X }
C {devices/lab_pin.sym} 129520 -17460 0 0 {name=p128773 lab=_84829_/Q }
C {devices/lab_pin.sym} 129520 -17420 0 0 {name=p128774 lab=_63146_/C }
C {devices/lab_pin.sym} 129520 -17380 0 0 {name=p128775 lab=_63135_/D }
C {devices/lab_pin.sym} 129640 -17440 0 1 {name=p128776 lab=_63146_/X }
C {sky130_stdcells/and4_4.sym} 129580 -17440 0 0 {name=X_63146_ }
C {devices/lab_pin.sym} 129500 -17330 0 0 {name=p128777 lab=_60344_/Y }
C {devices/lab_pin.sym} 129500 -17290 0 0 {name=p128778 lab=_60300_/C }
C {devices/lab_pin.sym} 129500 -17250 0 0 {name=p128779 lab=_60284_/B }
C {devices/lab_pin.sym} 129500 -17210 0 0 {name=p128780 lab=_60356_/Y }
C {devices/lab_pin.sym} 129500 -17180 0 0 {name=p128781 lab=_60357_/Y }
C {devices/lab_pin.sym} 129660 -17250 0 1 {name=p128782 lab=_60358_/Y }
C {sky130_stdcells/a41oi_4.sym} 129580 -17250 0 0 {name=X_60358_ }
C {devices/lab_pin.sym} 129500 -17110 0 0 {name=p128783 lab=_50109_/Y }
C {devices/lab_pin.sym} 129500 -17070 0 0 {name=p128784 lab=_50092_/X }
C {devices/lab_pin.sym} 129500 -17030 0 0 {name=p128785 lab=_50110_/X }
C {devices/lab_pin.sym} 129660 -17070 0 1 {name=p128786 lab=_50111_/Y }
C {sky130_stdcells/a21oi_4.sym} 129580 -17070 0 0 {name=X_50111_ }
C {devices/lab_pin.sym} 129520 -16940 0 0 {name=p128787 lab=_51097_/A }
C {devices/lab_pin.sym} 129520 -16900 0 0 {name=p128788 lab=_52781_/B }
C {devices/lab_pin.sym} 129640 -16920 0 1 {name=p128789 lab=_51091_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -16920 0 0 {name=X_51091_ }
C {devices/lab_pin.sym} 129540 -16790 0 0 {name=p128790 lab=_69779_/A }
C {devices/lab_pin.sym} 129620 -16790 0 1 {name=p128791 lab=_67954_/X }
C {sky130_stdcells/buf_2.sym} 129580 -16790 0 0 {name=X_67954_ }
C {devices/lab_pin.sym} 129520 -16700 0 0 {name=p128792 lab=_63039_/A }
C {devices/lab_pin.sym} 129520 -16660 0 0 {name=p128793 lab=_64286_/C }
C {devices/lab_pin.sym} 129520 -16620 0 0 {name=p128794 lab=_63028_/X }
C {devices/lab_pin.sym} 129520 -16580 0 0 {name=p128795 lab=_63077_/D }
C {devices/lab_pin.sym} 129640 -16640 0 1 {name=p128796 lab=_63077_/X }
C {sky130_stdcells/and4_4.sym} 129580 -16640 0 0 {name=X_63077_ }
C {devices/lab_pin.sym} 129540 -16490 0 0 {name=p128797 lab=_60288_/X }
C {devices/lab_pin.sym} 129620 -16490 0 1 {name=p128798 lab=_60325_/B }
C {sky130_stdcells/inv_2.sym} 129580 -16490 0 0 {name=X_60289_ }
C {devices/lab_pin.sym} 129520 -16380 0 0 {name=p128799 lab=_50048_/A }
C {devices/lab_pin.sym} 129520 -16340 0 0 {name=p128800 lab=_53255_/B }
C {devices/lab_pin.sym} 129640 -16360 0 1 {name=p128801 lab=_50042_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -16360 0 0 {name=X_50042_ }
C {devices/lab_pin.sym} 129540 -16230 0 0 {name=p128802 lab=_66547_/A }
C {devices/lab_pin.sym} 129620 -16230 0 1 {name=p128803 lab=_66905_/X }
C {sky130_stdcells/buf_2.sym} 129580 -16230 0 0 {name=X_66905_ }
C {devices/lab_pin.sym} 129540 -16110 0 0 {name=p128804 lab=_61777_/A }
C {devices/lab_pin.sym} 129620 -16110 0 1 {name=p128805 lab=_62046_/C }
C {sky130_stdcells/buf_2.sym} 129580 -16110 0 0 {name=X_62028_ }
C {devices/lab_pin.sym} 129490 -15990 0 0 {name=p128806 lab=_82961_/CLK }
C {devices/lab_pin.sym} 129490 -15970 0 0 {name=p128807 lab=_82759_/Q }
C {devices/lab_pin.sym} 129670 -15990 0 1 {name=p128808 lab=_82951_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -15980 0 0 {name=X_82951_ }
C {devices/lab_pin.sym} 129520 -15860 0 0 {name=p128809 lab=_67909_/A }
C {devices/lab_pin.sym} 129520 -15820 0 0 {name=p128810 lab=_67885_/B }
C {devices/lab_pin.sym} 129640 -15840 0 1 {name=p128811 lab=_67885_/X }
C {sky130_stdcells/and2_4.sym} 129580 -15840 0 0 {name=X_67885_ }
C {devices/lab_pin.sym} 129490 -15710 0 0 {name=p128812 lab=_81985_/CLK }
C {devices/lab_pin.sym} 129490 -15690 0 0 {name=p128813 lab=_81902_/D }
C {devices/lab_pin.sym} 129670 -15710 0 1 {name=p128814 lab=_77023_/B }
C {sky130_stdcells/dfxtp_4.sym} 129580 -15700 0 0 {name=X_81902_ }
C {devices/lab_pin.sym} 129540 -15570 0 0 {name=p128815 lab=_69768_/A }
C {devices/lab_pin.sym} 129620 -15570 0 1 {name=p128816 lab=_69624_/X }
C {sky130_stdcells/buf_2.sym} 129580 -15570 0 0 {name=X_69624_ }
C {devices/lab_pin.sym} 129520 -15460 0 0 {name=p128817 lab=_54850_/A }
C {devices/lab_pin.sym} 129520 -15420 0 0 {name=p128818 lab=_47632_/A }
C {devices/lab_pin.sym} 129640 -15440 0 1 {name=p128819 lab=_54850_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -15440 0 0 {name=X_54850_ }
C {devices/lab_pin.sym} 129500 -15340 0 0 {name=p128820 lab=_87124_/Q }
C {devices/lab_pin.sym} 129500 -15300 0 0 {name=p128821 lab=_66833_/X }
C {devices/lab_pin.sym} 129500 -15260 0 0 {name=p128822 lab=_66834_/X }
C {devices/lab_pin.sym} 129500 -15220 0 0 {name=p128823 lab=_66835_/X }
C {devices/lab_pin.sym} 129660 -15280 0 1 {name=p128824 lab=_66836_/X }
C {sky130_stdcells/a211o_4.sym} 129580 -15280 0 0 {name=X_66836_ }
C {devices/lab_pin.sym} 129490 -15130 0 0 {name=p128825 lab=_84815_/CLK }
C {devices/lab_pin.sym} 129490 -15110 0 0 {name=p128826 lab=_53245_/Y }
C {devices/lab_pin.sym} 129670 -15130 0 1 {name=p128827 lab=_85670_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -15120 0 0 {name=X_85670_ }
C {devices/lab_pin.sym} 129490 -14990 0 0 {name=p128828 lab=_82327_/CLK }
C {devices/lab_pin.sym} 129490 -14970 0 0 {name=p128829 lab=_78082_/B }
C {devices/lab_pin.sym} 129670 -14990 0 1 {name=p128830 lab=_82882_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -14980 0 0 {name=X_82882_ }
C {devices/lab_pin.sym} 129520 -14860 0 0 {name=p128831 lab=_71974_/B }
C {devices/lab_pin.sym} 129520 -14820 0 0 {name=p128832 lab=_53801_/B }
C {devices/lab_pin.sym} 129640 -14840 0 1 {name=p128833 lab=_53801_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -14840 0 0 {name=X_53801_ }
C {devices/lab_pin.sym} 129490 -14710 0 0 {name=p128834 lab=_84620_/CLK }
C {devices/lab_pin.sym} 129490 -14690 0 0 {name=p128835 lab=_60368_/X }
C {devices/lab_pin.sym} 129670 -14710 0 1 {name=p128836 lab=_79566_/B }
C {sky130_stdcells/dfxtp_4.sym} 129580 -14700 0 0 {name=X_84621_ }
C {devices/lab_pin.sym} 129520 -14580 0 0 {name=p128837 lab=_69626_/A }
C {devices/lab_pin.sym} 129520 -14540 0 0 {name=p128838 lab=_69555_/B }
C {devices/lab_pin.sym} 129640 -14560 0 1 {name=p128839 lab=_69555_/X }
C {sky130_stdcells/and2_4.sym} 129580 -14560 0 0 {name=X_69555_ }
C {devices/lab_pin.sym} 129490 -14430 0 0 {name=p128840 lab=_84441_/CLK }
C {devices/lab_pin.sym} 129490 -14410 0 0 {name=p128841 lab=_81865_/Q }
C {devices/lab_pin.sym} 129670 -14430 0 1 {name=p128842 lab=_77324_/A }
C {sky130_stdcells/dfxtp_4.sym} 129580 -14420 0 0 {name=X_81833_ }
C {devices/lab_pin.sym} 129520 -14320 0 0 {name=p128843 lab=_54798_/A }
C {devices/lab_pin.sym} 129520 -14280 0 0 {name=p128844 lab=_54788_/B }
C {devices/lab_pin.sym} 129520 -14240 0 0 {name=p128845 lab=_54798_/C }
C {devices/lab_pin.sym} 129520 -14200 0 0 {name=p128846 lab=_47511_/Y }
C {devices/lab_pin.sym} 129640 -14260 0 1 {name=p128847 lab=_54781_/X }
C {sky130_stdcells/and4_4.sym} 129580 -14260 0 0 {name=X_54781_ }
C {devices/lab_pin.sym} 129500 -14130 0 0 {name=p128848 lab=_66761_/X }
C {devices/lab_pin.sym} 129500 -14090 0 0 {name=p128849 lab=_66766_/X }
C {devices/lab_pin.sym} 129500 -14050 0 0 {name=p128850 lab=_66667_/X }
C {devices/lab_pin.sym} 129660 -14090 0 1 {name=p128851 lab=_66771_/A }
C {sky130_stdcells/a21o_4.sym} 129580 -14090 0 0 {name=X_66767_ }
C {devices/lab_pin.sym} 129500 -13970 0 0 {name=p128852 lab=_51991_/Y }
C {devices/lab_pin.sym} 129500 -13930 0 0 {name=p128853 lab=_51981_/X }
C {devices/lab_pin.sym} 129500 -13890 0 0 {name=p128854 lab=_51992_/Y }
C {devices/lab_pin.sym} 129660 -13930 0 1 {name=p128855 lab=_85910_/D }
C {sky130_stdcells/a21boi_4.sym} 129580 -13930 0 0 {name=X_51993_ }
C {devices/lab_pin.sym} 129520 -13820 0 0 {name=p128856 lab=_61513_/A }
C {devices/lab_pin.sym} 129520 -13780 0 0 {name=p128857 lab=_63947_/B }
C {devices/lab_pin.sym} 129520 -13740 0 0 {name=p128858 lab=_64040_/C }
C {devices/lab_pin.sym} 129520 -13700 0 0 {name=p128859 lab=_64025_/D }
C {devices/lab_pin.sym} 129640 -13760 0 1 {name=p128860 lab=_63979_/Y }
C {sky130_stdcells/nand4_4.sym} 129580 -13760 0 0 {name=X_63979_ }
C {devices/lab_pin.sym} 129520 -13630 0 0 {name=p128861 lab=_56523_/A }
C {devices/lab_pin.sym} 129520 -13590 0 0 {name=p128862 lab=_56520_/B }
C {devices/lab_pin.sym} 129520 -13550 0 0 {name=p128863 lab=_85164_/Q }
C {devices/lab_pin.sym} 129640 -13590 0 1 {name=p128864 lab=_56520_/Y }
C {sky130_stdcells/nand3_4.sym} 129580 -13590 0 0 {name=X_56520_ }
C {devices/lab_pin.sym} 129500 -13480 0 0 {name=p128865 lab=_87502_/Q }
C {devices/lab_pin.sym} 129500 -13440 0 0 {name=p128866 lab=_68504_/X }
C {devices/lab_pin.sym} 129500 -13400 0 0 {name=p128867 lab=_68450_/X }
C {devices/lab_pin.sym} 129500 -13360 0 0 {name=p128868 lab=_68505_/X }
C {devices/lab_pin.sym} 129660 -13420 0 1 {name=p128869 lab=_68506_/X }
C {sky130_stdcells/a211o_4.sym} 129580 -13420 0 0 {name=X_68506_ }
C {devices/lab_pin.sym} 129490 -13270 0 0 {name=p128870 lab=_87045_/CLK }
C {devices/lab_pin.sym} 129490 -13250 0 0 {name=p128871 lab=_87340_/D }
C {devices/lab_pin.sym} 129670 -13270 0 1 {name=p128872 lab=_87340_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -13260 0 0 {name=X_87340_ }
C {devices/lab_pin.sym} 129500 -13150 0 0 {name=p128873 lab=_85579_/Q }
C {devices/lab_pin.sym} 129500 -13110 0 0 {name=p128874 lab=_53729_/X }
C {devices/lab_pin.sym} 129500 -13070 0 0 {name=p128875 lab=_53731_/Y }
C {devices/lab_pin.sym} 129660 -13110 0 1 {name=p128876 lab=_53732_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -13110 0 0 {name=X_53732_ }
C {devices/lab_pin.sym} 129540 -12970 0 0 {name=p128877 lab=_65718_/A }
C {devices/lab_pin.sym} 129620 -12970 0 1 {name=p128878 lab=_65718_/X }
C {sky130_stdcells/buf_2.sym} 129580 -12970 0 0 {name=X_65718_ }
C {devices/lab_pin.sym} 129490 -12850 0 0 {name=p128879 lab=_84529_/CLK }
C {devices/lab_pin.sym} 129490 -12830 0 0 {name=p128880 lab=_84552_/D }
C {devices/lab_pin.sym} 129670 -12850 0 1 {name=p128881 lab=_84552_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -12840 0 0 {name=X_84552_ }
C {devices/lab_pin.sym} 129500 -12730 0 0 {name=p128882 lab=_86102_/Q }
C {devices/lab_pin.sym} 129500 -12690 0 0 {name=p128883 lab=_50936_/X }
C {devices/lab_pin.sym} 129500 -12650 0 0 {name=p128884 lab=_50943_/Y }
C {devices/lab_pin.sym} 129660 -12690 0 1 {name=p128885 lab=_50944_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -12690 0 0 {name=X_50944_ }
C {devices/lab_pin.sym} 129490 -12550 0 0 {name=p128886 lab=_81783_/CLK }
C {devices/lab_pin.sym} 129490 -12530 0 0 {name=p128887 lab=_75987_/X }
C {devices/lab_pin.sym} 129670 -12550 0 1 {name=p128888 lab=_81764_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -12540 0 0 {name=X_81764_ }
C {devices/lab_pin.sym} 129520 -12420 0 0 {name=p128889 lab=_69612_/A }
C {devices/lab_pin.sym} 129520 -12380 0 0 {name=p128890 lab=_69486_/B }
C {devices/lab_pin.sym} 129640 -12400 0 1 {name=p128891 lab=_69486_/X }
C {sky130_stdcells/and2_4.sym} 129580 -12400 0 0 {name=X_69486_ }
C {devices/lab_pin.sym} 129520 -12280 0 0 {name=p128892 lab=_66651_/A }
C {devices/lab_pin.sym} 129520 -12240 0 0 {name=p128893 lab=_66698_/B }
C {devices/lab_pin.sym} 129640 -12260 0 1 {name=p128894 lab=_66698_/X }
C {sky130_stdcells/and2_4.sym} 129580 -12260 0 0 {name=X_66698_ }
C {devices/lab_pin.sym} 129490 -12130 0 0 {name=p128895 lab=_83498_/CLK }
C {devices/lab_pin.sym} 129490 -12110 0 0 {name=p128896 lab=_83503_/D }
C {devices/lab_pin.sym} 129670 -12130 0 1 {name=p128897 lab=_83503_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -12120 0 0 {name=X_83503_ }
C {devices/lab_pin.sym} 129500 -12010 0 0 {name=p128898 lab=_56159_/X }
C {devices/lab_pin.sym} 129500 -11970 0 0 {name=p128899 lab=_56439_/X }
C {devices/lab_pin.sym} 129500 -11930 0 0 {name=p128900 lab=_56450_/Y }
C {devices/lab_pin.sym} 129660 -11970 0 1 {name=p128901 lab=_85189_/D }
C {sky130_stdcells/o21ai_4.sym} 129580 -11970 0 0 {name=X_56451_ }
C {devices/lab_pin.sym} 129490 -11830 0 0 {name=p128902 lab=_80679_/CLK }
C {devices/lab_pin.sym} 129490 -11810 0 0 {name=p128903 lab=_75901_/X }
C {devices/lab_pin.sym} 129670 -11830 0 1 {name=p128904 lab=_80683_/D }
C {sky130_stdcells/dfxtp_4.sym} 129580 -11820 0 0 {name=X_80715_ }
C {devices/lab_pin.sym} 129520 -11700 0 0 {name=p128905 lab=_68437_/A }
C {devices/lab_pin.sym} 129520 -11660 0 0 {name=p128906 lab=_87344_/Q }
C {devices/lab_pin.sym} 129640 -11680 0 1 {name=p128907 lab=_68437_/X }
C {sky130_stdcells/and2_4.sym} 129580 -11680 0 0 {name=X_68437_ }
C {devices/lab_pin.sym} 129490 -11550 0 0 {name=p128908 lab=_87782_/CLK }
C {devices/lab_pin.sym} 129490 -11530 0 0 {name=p128909 lab=_43780_/Y }
C {devices/lab_pin.sym} 129670 -11550 0 1 {name=p128910 lab=_87271_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -11540 0 0 {name=X_87271_ }
C {devices/lab_pin.sym} 129520 -11420 0 0 {name=p128911 lab=_53662_/X }
C {devices/lab_pin.sym} 129520 -11380 0 0 {name=p128912 lab=_53663_/B }
C {devices/lab_pin.sym} 129640 -11400 0 1 {name=p128913 lab=_53663_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -11400 0 0 {name=X_53663_ }
C {devices/lab_pin.sym} 129540 -11270 0 0 {name=p128914 lab=_65045_/A }
C {devices/lab_pin.sym} 129620 -11270 0 1 {name=p128915 lab=_65802_/B }
C {sky130_stdcells/buf_2.sym} 129580 -11270 0 0 {name=X_65649_ }
C {devices/lab_pin.sym} 129490 -11150 0 0 {name=p128916 lab=_84187_/CLK }
C {devices/lab_pin.sym} 129490 -11130 0 0 {name=p128917 lab=_61416_/Y }
C {devices/lab_pin.sym} 129670 -11150 0 1 {name=p128918 lab=_79151_/B }
C {sky130_stdcells/dfxtp_4.sym} 129580 -11140 0 0 {name=X_84483_ }
C {devices/lab_pin.sym} 129500 -11030 0 0 {name=p128919 lab=_86115_/Q }
C {devices/lab_pin.sym} 129500 -10990 0 0 {name=p128920 lab=_50856_/X }
C {devices/lab_pin.sym} 129500 -10950 0 0 {name=p128921 lab=_50874_/Y }
C {devices/lab_pin.sym} 129660 -10990 0 1 {name=p128922 lab=_50875_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -10990 0 0 {name=X_50875_ }
C {devices/lab_pin.sym} 129490 -10850 0 0 {name=p128923 lab=_81695_/CLK }
C {devices/lab_pin.sym} 129490 -10830 0 0 {name=p128924 lab=_80237_/X }
C {devices/lab_pin.sym} 129670 -10850 0 1 {name=p128925 lab=_81695_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -10840 0 0 {name=X_81695_ }
C {devices/lab_pin.sym} 129520 -10730 0 0 {name=p128926 lab=_55399_/X }
C {devices/lab_pin.sym} 129520 -10690 0 0 {name=p128927 lab=_55400_/Y }
C {devices/lab_pin.sym} 129520 -10650 0 0 {name=p128928 lab=_55181_/B }
C {devices/lab_pin.sym} 129640 -10690 0 1 {name=p128929 lab=_55403_/B }
C {sky130_stdcells/nand3_4.sym} 129580 -10690 0 0 {name=X_55402_ }
C {devices/lab_pin.sym} 129490 -10550 0 0 {name=p128930 lab=_86222_/CLK }
C {devices/lab_pin.sym} 129490 -10530 0 0 {name=p128931 lab=_50332_/Y }
C {devices/lab_pin.sym} 129670 -10550 0 1 {name=p128932 lab=_86222_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -10540 0 0 {name=X_86222_ }
C {devices/lab_pin.sym} 129520 -10440 0 0 {name=p128933 lab=_52614_/A }
C {devices/lab_pin.sym} 129520 -10400 0 0 {name=p128934 lab=_52605_/X }
C {devices/lab_pin.sym} 129520 -10360 0 0 {name=p128935 lab=_52622_/C }
C {devices/lab_pin.sym} 129520 -10320 0 0 {name=p128936 lab=_51787_/D }
C {devices/lab_pin.sym} 129640 -10380 0 1 {name=p128937 lab=_52614_/X }
C {sky130_stdcells/and4_4.sym} 129580 -10380 0 0 {name=X_52614_ }
C {devices/lab_pin.sym} 129500 -10270 0 0 {name=p128938 lab=_59152_/X }
C {devices/lab_pin.sym} 129500 -10230 0 0 {name=p128939 lab=_59167_/Y }
C {devices/lab_pin.sym} 129500 -10190 0 0 {name=p128940 lab=_59168_/Y }
C {devices/lab_pin.sym} 129500 -10150 0 0 {name=p128941 lab=_59169_/X }
C {devices/lab_pin.sym} 129500 -10110 0 0 {name=p128942 lab=_59156_/X }
C {devices/lab_pin.sym} 129660 -10190 0 1 {name=p128943 lab=_59170_/X }
C {sky130_stdcells/o32a_4.sym} 129580 -10190 0 0 {name=X_59170_ }
C {devices/lab_pin.sym} 129490 -10030 0 0 {name=p128944 lab=_83338_/CLK }
C {devices/lab_pin.sym} 129490 -10010 0 0 {name=p128945 lab=_71623_/X }
C {devices/lab_pin.sym} 129670 -10030 0 1 {name=p128946 lab=_83434_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -10020 0 0 {name=X_83434_ }
C {devices/lab_pin.sym} 129500 -9910 0 0 {name=p128947 lab=_56372_/X }
C {devices/lab_pin.sym} 129500 -9870 0 0 {name=p128948 lab=_56016_/X }
C {devices/lab_pin.sym} 129500 -9830 0 0 {name=p128949 lab=_56381_/Y }
C {devices/lab_pin.sym} 129660 -9870 0 1 {name=p128950 lab=_85215_/D }
C {sky130_stdcells/o21ai_4.sym} 129580 -9870 0 0 {name=X_56382_ }
C {devices/lab_pin.sym} 129540 -9720 0 0 {name=p128951 lab=_74777_/Y }
C {devices/lab_pin.sym} 129540 -9680 0 0 {name=p128952 lab=_74710_/Y }
C {devices/lab_pin.sym} 129620 -9720 0 1 {name=p128953 lab=DATA_FROM_HASH[3] }
C {sky130_stdcells/ebufn_2.sym} 129580 -9720 0 0 {name=X_80646_ }
C {devices/lab_pin.sym} 129500 -9620 0 0 {name=p128954 lab=_73554_/A }
C {devices/lab_pin.sym} 129500 -9580 0 0 {name=p128955 lab=_68365_/X }
C {devices/lab_pin.sym} 129500 -9540 0 0 {name=p128956 lab=_68053_/X }
C {devices/lab_pin.sym} 129500 -9500 0 0 {name=p128957 lab=_68367_/Y }
C {devices/lab_pin.sym} 129660 -9560 0 1 {name=p128958 lab=_68368_/X }
C {sky130_stdcells/a211o_4.sym} 129580 -9560 0 0 {name=X_68368_ }
C {devices/lab_pin.sym} 129500 -9430 0 0 {name=p128959 lab=_85606_/Q }
C {devices/lab_pin.sym} 129500 -9390 0 0 {name=p128960 lab=_53586_/X }
C {devices/lab_pin.sym} 129500 -9350 0 0 {name=p128961 lab=_53593_/Y }
C {devices/lab_pin.sym} 129660 -9390 0 1 {name=p128962 lab=_53594_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -9390 0 0 {name=X_53594_ }
C {sky130_stdcells/decap_3.sym} 129580 -9220 0 0 {name=XPHY_204 }
C {devices/lab_pin.sym} 129500 -9090 0 0 {name=p128963 lab=_57997_/X }
C {devices/lab_pin.sym} 129500 -9050 0 0 {name=p128964 lab=_85475_/Q }
C {devices/lab_pin.sym} 129500 -9010 0 0 {name=p128965 lab=_58109_/X }
C {devices/lab_pin.sym} 129660 -9050 0 1 {name=p128966 lab=_58121_/X }
C {sky130_stdcells/o21a_4.sym} 129580 -9050 0 0 {name=X_58121_ }
C {sky130_stdcells/decap_3.sym} 129580 -8880 0 0 {name=XPHY_215 }
C {devices/lab_pin.sym} 129500 -8760 0 0 {name=p128967 lab=_57283_/B }
C {devices/lab_pin.sym} 129500 -8720 0 0 {name=p128968 lab=_44060_/X }
C {devices/lab_pin.sym} 129500 -8680 0 0 {name=p128969 lab=_55301_/X }
C {devices/lab_pin.sym} 129500 -8640 0 0 {name=p128970 lab=_55332_/X }
C {devices/lab_pin.sym} 129660 -8700 0 1 {name=p128971 lab=_55333_/X }
C {sky130_stdcells/a211o_4.sym} 129580 -8700 0 0 {name=X_55333_ }
C {devices/lab_pin.sym} 129540 -8550 0 0 {name=p128972 lab=_67082_/A }
C {devices/lab_pin.sym} 129620 -8550 0 1 {name=p128973 lab=_67320_/A }
C {sky130_stdcells/buf_2.sym} 129580 -8550 0 0 {name=X_67319_ }
C {devices/lab_pin.sym} 129490 -8430 0 0 {name=p128974 lab=_86154_/CLK }
C {devices/lab_pin.sym} 129490 -8410 0 0 {name=p128975 lab=_86153_/D }
C {devices/lab_pin.sym} 129670 -8430 0 1 {name=p128976 lab=_86153_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -8420 0 0 {name=X_86153_ }
C {devices/lab_pin.sym} 129520 -8300 0 0 {name=p128977 lab=_52501_/X }
C {devices/lab_pin.sym} 129520 -8260 0 0 {name=p128978 lab=_52545_/B }
C {devices/lab_pin.sym} 129640 -8280 0 1 {name=p128979 lab=_52545_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -8280 0 0 {name=X_52545_ }
C {sky130_stdcells/decap_3.sym} 129580 -8120 0 0 {name=XPHY_226 }
C {devices/lab_pin.sym} 129490 -7970 0 0 {name=p128980 lab=_83362_/CLK }
C {devices/lab_pin.sym} 129490 -7950 0 0 {name=p128981 lab=_71816_/X }
C {devices/lab_pin.sym} 129670 -7970 0 1 {name=p128982 lab=_83365_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -7960 0 0 {name=X_83365_ }
C {sky130_stdcells/decap_3.sym} 129580 -7800 0 0 {name=XPHY_237 }
C {devices/lab_pin.sym} 129500 -7670 0 0 {name=p128983 lab=_80567_/X }
C {devices/lab_pin.sym} 129500 -7630 0 0 {name=p128984 lab=_80569_/B }
C {devices/lab_pin.sym} 129500 -7590 0 0 {name=p128985 lab=_80576_/Y }
C {devices/lab_pin.sym} 129660 -7630 0 1 {name=p128986 lab=_80596_/A }
C {sky130_stdcells/a21boi_4.sym} 129580 -7630 0 0 {name=X_80577_ }
C {devices/lab_pin.sym} 129540 -7490 0 0 {name=p128987 lab=_68338_/A }
C {devices/lab_pin.sym} 129620 -7490 0 1 {name=p128988 lab=_68299_/X }
C {sky130_stdcells/buf_2.sym} 129580 -7490 0 0 {name=X_68299_ }
C {devices/lab_pin.sym} 129540 -7370 0 0 {name=p128989 lab=clkbuf_6_61_0_CLK/A }
C {devices/lab_pin.sym} 129620 -7370 0 1 {name=p128990 lab=clkbuf_6_60_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 129580 -7370 0 0 {name=Xclkbuf_6_60_0_CLK }
C {sky130_stdcells/decap_3.sym} 129580 -7220 0 0 {name=XPHY_248 }
C {sky130_stdcells/decap_3.sym} 129580 -7040 0 0 {name=XPHY_259 }
C {devices/lab_pin.sym} 129490 -6890 0 0 {name=p128991 lab=_85041_/CLK }
C {devices/lab_pin.sym} 129490 -6870 0 0 {name=p128992 lab=_85104_/D }
C {devices/lab_pin.sym} 129670 -6890 0 1 {name=p128993 lab=_56989_/B }
C {sky130_stdcells/dfxtp_4.sym} 129580 -6880 0 0 {name=X_85104_ }
C {devices/lab_pin.sym} 129500 -6770 0 0 {name=p128994 lab=_57926_/X }
C {devices/lab_pin.sym} 129500 -6730 0 0 {name=p128995 lab=_85993_/Q }
C {devices/lab_pin.sym} 129500 -6690 0 0 {name=p128996 lab=_58051_/X }
C {devices/lab_pin.sym} 129660 -6730 0 1 {name=p128997 lab=_58052_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -6730 0 0 {name=X_58052_ }
C {devices/lab_pin.sym} 129540 -6590 0 0 {name=p128998 lab=_70127_/X }
C {devices/lab_pin.sym} 129620 -6590 0 1 {name=p128999 lab=_70338_/A }
C {sky130_stdcells/buf_2.sym} 129580 -6590 0 0 {name=X_70330_ }
C {devices/lab_pin.sym} 129490 -6470 0 0 {name=p129000 lab=_86758_/CLK }
C {devices/lab_pin.sym} 129490 -6450 0 0 {name=p129001 lab=_77074_/B }
C {devices/lab_pin.sym} 129670 -6470 0 1 {name=p129002 lab=_82316_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -6460 0 0 {name=X_82316_ }
C {devices/lab_pin.sym} 129520 -6350 0 0 {name=p129003 lab=_55264_/A }
C {devices/lab_pin.sym} 129520 -6310 0 0 {name=p129004 lab=_83321_/Q }
C {devices/lab_pin.sym} 129520 -6270 0 0 {name=p129005 lab=_55264_/C }
C {devices/lab_pin.sym} 129640 -6310 0 1 {name=p129006 lab=_55264_/Y }
C {sky130_stdcells/nand3_4.sym} 129580 -6310 0 0 {name=X_55264_ }
C {devices/lab_pin.sym} 129490 -6170 0 0 {name=p129007 lab=_85764_/CLK }
C {devices/lab_pin.sym} 129490 -6150 0 0 {name=p129008 lab=_51046_/Y }
C {devices/lab_pin.sym} 129670 -6170 0 1 {name=p129009 lab=_86084_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -6160 0 0 {name=X_86084_ }
C {devices/lab_pin.sym} 129520 -6040 0 0 {name=p129010 lab=_52476_/A }
C {devices/lab_pin.sym} 129520 -6000 0 0 {name=p129011 lab=_46376_/Y }
C {devices/lab_pin.sym} 129640 -6020 0 1 {name=p129012 lab=_52476_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -6020 0 0 {name=X_52476_ }
C {devices/lab_pin.sym} 129500 -5910 0 0 {name=p129013 lab=_40456_/X }
C {devices/lab_pin.sym} 129500 -5870 0 0 {name=p129014 lab=_41563_/A }
C {devices/lab_pin.sym} 129500 -5830 0 0 {name=p129015 lab=_40489_/X }
C {devices/lab_pin.sym} 129660 -5870 0 1 {name=p129016 lab=_40490_/X }
C {sky130_stdcells/o21a_4.sym} 129580 -5870 0 0 {name=X_40490_ }
C {devices/lab_pin.sym} 129490 -5730 0 0 {name=p129017 lab=_83304_/CLK }
C {devices/lab_pin.sym} 129490 -5710 0 0 {name=p129018 lab=_72045_/Y }
C {devices/lab_pin.sym} 129670 -5730 0 1 {name=p129019 lab=_83296_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -5720 0 0 {name=X_83296_ }
C {devices/lab_pin.sym} 129520 -5620 0 0 {name=p129020 lab=_56738_/X }
C {devices/lab_pin.sym} 129520 -5580 0 0 {name=p129021 lab=_57003_/B }
C {devices/lab_pin.sym} 129520 -5540 0 0 {name=p129022 lab=_56740_/X }
C {devices/lab_pin.sym} 129520 -5500 0 0 {name=p129023 lab=_56994_/D }
C {devices/lab_pin.sym} 129640 -5560 0 1 {name=p129024 lab=_57004_/C }
C {sky130_stdcells/and4_4.sym} 129580 -5560 0 0 {name=X_57003_ }
C {devices/lab_pin.sym} 129520 -5420 0 0 {name=p129025 lab=_54215_/A }
C {devices/lab_pin.sym} 129520 -5380 0 0 {name=p129026 lab=_47442_/Y }
C {devices/lab_pin.sym} 129640 -5400 0 1 {name=p129027 lab=_54215_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -5400 0 0 {name=X_54215_ }
C {devices/lab_pin.sym} 129490 -5270 0 0 {name=p129028 lab=_85031_/CLK }
C {devices/lab_pin.sym} 129490 -5250 0 0 {name=p129029 lab=_85035_/D }
C {devices/lab_pin.sym} 129670 -5270 0 1 {name=p129030 lab=_85035_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -5260 0 0 {name=X_85035_ }
C {devices/lab_pin.sym} 129500 -5150 0 0 {name=p129031 lab=_51425_/Y }
C {devices/lab_pin.sym} 129500 -5110 0 0 {name=p129032 lab=_51420_/X }
C {devices/lab_pin.sym} 129500 -5070 0 0 {name=p129033 lab=_51426_/X }
C {devices/lab_pin.sym} 129660 -5110 0 1 {name=p129034 lab=_86012_/D }
C {sky130_stdcells/a21oi_4.sym} 129580 -5110 0 0 {name=X_51427_ }
C {devices/lab_pin.sym} 129500 -4990 0 0 {name=p129035 lab=_70255_/X }
C {devices/lab_pin.sym} 129500 -4950 0 0 {name=p129036 lab=_74751_/A }
C {devices/lab_pin.sym} 129500 -4910 0 0 {name=p129037 lab=_70260_/X }
C {devices/lab_pin.sym} 129660 -4950 0 1 {name=p129038 lab=_70261_/X }
C {sky130_stdcells/a21o_4.sym} 129580 -4950 0 0 {name=X_70261_ }
C {devices/lab_pin.sym} 129490 -4810 0 0 {name=p129039 lab=_83521_/CLK }
C {devices/lab_pin.sym} 129490 -4790 0 0 {name=p129040 lab=_80355_/X }
C {devices/lab_pin.sym} 129670 -4810 0 1 {name=p129041 lab=_82247_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -4800 0 0 {name=X_82247_ }
C {devices/lab_pin.sym} 129520 -4690 0 0 {name=p129042 lab=_55188_/X }
C {devices/lab_pin.sym} 129520 -4650 0 0 {name=p129043 lab=_83749_/Q }
C {devices/lab_pin.sym} 129520 -4610 0 0 {name=p129044 lab=_55193_/X }
C {devices/lab_pin.sym} 129640 -4650 0 1 {name=p129045 lab=_55196_/B }
C {sky130_stdcells/nand3_4.sym} 129580 -4650 0 0 {name=X_55195_ }
C {devices/lab_pin.sym} 129540 -4510 0 0 {name=p129046 lab=_47003_/A }
C {devices/lab_pin.sym} 129620 -4510 0 1 {name=p129047 lab=_72001_/A }
C {sky130_stdcells/buf_2.sym} 129580 -4510 0 0 {name=X_72000_ }
C {devices/lab_pin.sym} 129540 -4390 0 0 {name=p129048 lab=_42159_/Y }
C {devices/lab_pin.sym} 129620 -4390 0 1 {name=p129049 lab=_88004_/D }
C {sky130_stdcells/inv_2.sym} 129580 -4390 0 0 {name=X_42160_ }
C {devices/lab_pin.sym} 129540 -4270 0 0 {name=p129050 lab=_54254_/A }
C {devices/lab_pin.sym} 129620 -4270 0 1 {name=p129051 lab=_54146_/X }
C {sky130_stdcells/buf_2.sym} 129580 -4270 0 0 {name=X_54146_ }
C {devices/lab_pin.sym} 129540 -4150 0 0 {name=p129052 lab=clkbuf_9_292_0_CLK/X }
C {devices/lab_pin.sym} 129620 -4150 0 1 {name=p129053 lab=_80792_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 129580 -4150 0 0 {name=Xclkbuf_10_584_0_CLK }
C {devices/lab_pin.sym} 129520 -4040 0 0 {name=p129054 lab=_51350_/A }
C {devices/lab_pin.sym} 129520 -4000 0 0 {name=p129055 lab=_51358_/B }
C {devices/lab_pin.sym} 129640 -4020 0 1 {name=p129056 lab=_51358_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -4020 0 0 {name=X_51358_ }
C {devices/lab_pin.sym} 129540 -3890 0 0 {name=p129057 lab=_83842_/Q }
C {devices/lab_pin.sym} 129620 -3890 0 1 {name=p129058 lab=_70192_/Y }
C {sky130_stdcells/inv_2.sym} 129580 -3890 0 0 {name=X_70192_ }
C {devices/lab_pin.sym} 129490 -3770 0 0 {name=p129059 lab=_84951_/CLK }
C {devices/lab_pin.sym} 129490 -3750 0 0 {name=p129060 lab=_82178_/D }
C {devices/lab_pin.sym} 129670 -3770 0 1 {name=p129061 lab=_82178_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -3760 0 0 {name=X_82178_ }
C {devices/lab_pin.sym} 129500 -3660 0 0 {name=p129062 lab=_41108_/X }
C {devices/lab_pin.sym} 129500 -3620 0 0 {name=p129063 lab=_41109_/X }
C {devices/lab_pin.sym} 129500 -3580 0 0 {name=p129064 lab=_69558_/B }
C {devices/lab_pin.sym} 129500 -3540 0 0 {name=p129065 lab=_41110_/X }
C {devices/lab_pin.sym} 129660 -3600 0 1 {name=p129066 lab=_41111_/X }
C {sky130_stdcells/a2bb2o_4.sym} 129580 -3600 0 0 {name=X_41111_ }
C {devices/lab_pin.sym} 129500 -3470 0 0 {name=p129067 lab=_50307_/Y }
C {devices/lab_pin.sym} 129500 -3430 0 0 {name=p129068 lab=_50243_/X }
C {devices/lab_pin.sym} 129500 -3390 0 0 {name=p129069 lab=_50308_/X }
C {devices/lab_pin.sym} 129660 -3430 0 1 {name=p129070 lab=_86226_/D }
C {sky130_stdcells/a21oi_4.sym} 129580 -3430 0 0 {name=X_50309_ }
C {devices/lab_pin.sym} 129490 -3290 0 0 {name=p129071 lab=_81125_/CLK }
C {devices/lab_pin.sym} 129490 -3270 0 0 {name=p129072 lab=_81129_/D }
C {devices/lab_pin.sym} 129670 -3290 0 1 {name=p129073 lab=_40722_/A }
C {sky130_stdcells/dfxtp_4.sym} 129580 -3280 0 0 {name=X_81129_ }
C {devices/lab_pin.sym} 129500 -3190 0 0 {name=p129074 lab=_58864_/X }
C {devices/lab_pin.sym} 129500 -3150 0 0 {name=p129075 lab=_58952_/Y }
C {devices/lab_pin.sym} 129500 -3110 0 0 {name=p129076 lab=_58953_/Y }
C {devices/lab_pin.sym} 129500 -3070 0 0 {name=p129077 lab=_58943_/X }
C {devices/lab_pin.sym} 129500 -3030 0 0 {name=p129078 lab=_58868_/X }
C {devices/lab_pin.sym} 129660 -3110 0 1 {name=p129079 lab=_58954_/X }
C {sky130_stdcells/o32a_4.sym} 129580 -3110 0 0 {name=X_58954_ }
C {devices/lab_pin.sym} 129540 -2950 0 0 {name=p129080 lab=_42090_/Y }
C {devices/lab_pin.sym} 129620 -2950 0 1 {name=p129081 lab=_88039_/D }
C {sky130_stdcells/inv_2.sym} 129580 -2950 0 0 {name=X_42091_ }
C {devices/lab_pin.sym} 129520 -2840 0 0 {name=p129082 lab=_54068_/X }
C {devices/lab_pin.sym} 129520 -2800 0 0 {name=p129083 lab=_54077_/B }
C {devices/lab_pin.sym} 129640 -2820 0 1 {name=p129084 lab=_54077_/Y }
C {sky130_stdcells/nand2_4.sym} 129580 -2820 0 0 {name=X_54077_ }
C {devices/lab_pin.sym} 129540 -2690 0 0 {name=p129085 lab=_51263_/A }
C {devices/lab_pin.sym} 129620 -2690 0 1 {name=p129086 lab=_51289_/X }
C {sky130_stdcells/buf_2.sym} 129580 -2690 0 0 {name=X_51289_ }
C {devices/lab_pin.sym} 129490 -2570 0 0 {name=p129087 lab=_86998_/CLK }
C {devices/lab_pin.sym} 129490 -2550 0 0 {name=p129088 lab=_44724_/Y }
C {devices/lab_pin.sym} 129670 -2570 0 1 {name=p129089 lab=_86986_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -2560 0 0 {name=X_86986_ }
C {devices/lab_pin.sym} 129540 -2430 0 0 {name=p129090 lab=_49140_/B }
C {devices/lab_pin.sym} 129620 -2430 0 1 {name=p129091 lab=_41042_/X }
C {sky130_stdcells/buf_2.sym} 129580 -2430 0 0 {name=X_41042_ }
C {devices/lab_pin.sym} 129540 -2310 0 0 {name=p129092 lab=_53111_/A }
C {devices/lab_pin.sym} 129620 -2310 0 1 {name=p129093 lab=_53028_/X }
C {sky130_stdcells/buf_2.sym} 129580 -2310 0 0 {name=X_53028_ }
C {devices/lab_pin.sym} 129500 -2210 0 0 {name=p129094 lab=_57875_/X }
C {devices/lab_pin.sym} 129500 -2170 0 0 {name=p129095 lab=_85397_/Q }
C {devices/lab_pin.sym} 129500 -2130 0 0 {name=p129096 lab=_57904_/X }
C {devices/lab_pin.sym} 129660 -2170 0 1 {name=p129097 lab=_57905_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -2170 0 0 {name=X_57905_ }
C {devices/lab_pin.sym} 129490 -2030 0 0 {name=p129098 lab=_86096_/CLK }
C {devices/lab_pin.sym} 129490 -2010 0 0 {name=p129099 lab=_51839_/Y }
C {devices/lab_pin.sym} 129670 -2030 0 1 {name=p129100 lab=_85937_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -2020 0 0 {name=X_85937_ }
C {devices/lab_pin.sym} 129520 -1900 0 0 {name=p129101 lab=_73829_/X }
C {devices/lab_pin.sym} 129520 -1860 0 0 {name=p129102 lab=_66143_/B }
C {devices/lab_pin.sym} 129640 -1880 0 1 {name=p129103 lab=_73951_/X }
C {sky130_stdcells/and2_4.sym} 129580 -1880 0 0 {name=X_73951_ }
C {devices/lab_pin.sym} 129500 -1780 0 0 {name=p129104 lab=_84793_/Q }
C {devices/lab_pin.sym} 129500 -1740 0 0 {name=p129105 lab=_58871_/X }
C {devices/lab_pin.sym} 129500 -1700 0 0 {name=p129106 lab=_58875_/X }
C {devices/lab_pin.sym} 129500 -1660 0 0 {name=p129107 lab=_58884_/X }
C {devices/lab_pin.sym} 129660 -1720 0 1 {name=p129108 lab=_58885_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 129580 -1720 0 0 {name=X_58885_ }
C {devices/lab_pin.sym} 129540 -1570 0 0 {name=p129109 lab=clkbuf_9_299_0_CLK/X }
C {devices/lab_pin.sym} 129620 -1570 0 1 {name=p129110 lab=_82234_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 129580 -1570 0 0 {name=Xclkbuf_10_599_0_CLK }
C {devices/lab_pin.sym} 129500 -1470 0 0 {name=p129111 lab=_88334_/Q }
C {devices/lab_pin.sym} 129500 -1430 0 0 {name=p129112 lab=_72900_/X }
C {devices/lab_pin.sym} 129500 -1390 0 0 {name=p129113 lab=_72901_/X }
C {devices/lab_pin.sym} 129660 -1430 0 1 {name=p129114 lab=_72902_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -1430 0 0 {name=X_72902_ }
C {devices/lab_pin.sym} 129540 -1290 0 0 {name=p129115 lab=_63333_/B }
C {devices/lab_pin.sym} 129620 -1290 0 1 {name=p129116 lab=_61676_/A }
C {sky130_stdcells/buf_2.sym} 129580 -1290 0 0 {name=X_45850_ }
C {devices/lab_pin.sym} 129500 -1190 0 0 {name=p129117 lab=_57811_/X }
C {devices/lab_pin.sym} 129500 -1150 0 0 {name=p129118 lab=_85402_/Q }
C {devices/lab_pin.sym} 129500 -1110 0 0 {name=p129119 lab=_57835_/X }
C {devices/lab_pin.sym} 129660 -1150 0 1 {name=p129120 lab=_57836_/Y }
C {sky130_stdcells/o21ai_4.sym} 129580 -1150 0 0 {name=X_57836_ }
C {devices/lab_pin.sym} 129540 -1010 0 0 {name=p129121 lab=_81476_/Q }
C {devices/lab_pin.sym} 129620 -1010 0 1 {name=p129122 lab=_76672_/B }
C {sky130_stdcells/inv_2.sym} 129580 -1010 0 0 {name=X_76670_ }
C {devices/lab_pin.sym} 129500 -910 0 0 {name=p129123 lab=_73879_/X }
C {devices/lab_pin.sym} 129500 -870 0 0 {name=p129124 lab=_73881_/X }
C {devices/lab_pin.sym} 129500 -830 0 0 {name=p129125 lab=_73857_/X }
C {devices/lab_pin.sym} 129660 -870 0 1 {name=p129126 lab=_73885_/A }
C {sky130_stdcells/a21o_4.sym} 129580 -870 0 0 {name=X_73882_ }
C {devices/lab_pin.sym} 129490 -730 0 0 {name=p129127 lab=_83562_/CLK }
C {devices/lab_pin.sym} 129490 -710 0 0 {name=p129128 lab=_85868_/D }
C {devices/lab_pin.sym} 129670 -730 0 1 {name=p129129 lab=_85868_/Q }
C {sky130_stdcells/dfxtp_4.sym} 129580 -720 0 0 {name=X_85868_ }
C {devices/lab_pin.sym} 130420 -42190 0 0 {name=p129130 lab=_44512_/A }
C {devices/lab_pin.sym} 130420 -42150 0 0 {name=p129131 lab=_41887_/A }
C {devices/lab_pin.sym} 130420 -42110 0 0 {name=p129132 lab=_41441_/X }
C {devices/lab_pin.sym} 130420 -42070 0 0 {name=p129133 lab=_86946_/Q }
C {devices/lab_pin.sym} 130420 -42030 0 0 {name=p129134 lab=_44516_/A }
C {devices/lab_pin.sym} 130580 -42110 0 1 {name=p129135 lab=_44802_/A }
C {sky130_stdcells/o32ai_4.sym} 130500 -42110 0 0 {name=X_44801_ }
C {devices/lab_pin.sym} 130440 -41960 0 0 {name=p129136 lab=_75621_/A }
C {devices/lab_pin.sym} 130440 -41920 0 0 {name=p129137 lab=_80775_/D }
C {devices/lab_pin.sym} 130560 -41940 0 1 {name=p129138 lab=_75621_/X }
C {sky130_stdcells/or2_4.sym} 130500 -41940 0 0 {name=X_75621_ }
C {devices/lab_pin.sym} 130410 -41810 0 0 {name=p129139 lab=_87073_/CLK }
C {devices/lab_pin.sym} 130410 -41790 0 0 {name=p129140 lab=_87607_/D }
C {devices/lab_pin.sym} 130590 -41810 0 1 {name=p129141 lab=_87607_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -41800 0 0 {name=X_87607_ }
C {devices/lab_pin.sym} 130420 -41690 0 0 {name=p129142 lab=_72826_/X }
C {devices/lab_pin.sym} 130420 -41650 0 0 {name=p129143 lab=_72832_/X }
C {devices/lab_pin.sym} 130420 -41610 0 0 {name=p129144 lab=_72737_/X }
C {devices/lab_pin.sym} 130580 -41650 0 1 {name=p129145 lab=_72848_/B }
C {sky130_stdcells/a21o_4.sym} 130500 -41650 0 0 {name=X_72833_ }
C {devices/lab_pin.sym} 130410 -41510 0 0 {name=p129146 lab=_83451_/CLK }
C {devices/lab_pin.sym} 130410 -41490 0 0 {name=p129147 lab=_84819_/D }
C {devices/lab_pin.sym} 130590 -41510 0 1 {name=p129148 lab=_84819_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -41500 0 0 {name=X_84819_ }
C {devices/lab_pin.sym} 130420 -41390 0 0 {name=p129149 lab=_85096_/Q }
C {devices/lab_pin.sym} 130420 -41350 0 0 {name=p129150 lab=_44880_/X }
C {devices/lab_pin.sym} 130420 -41310 0 0 {name=p129151 lab=_45780_/X }
C {devices/lab_pin.sym} 130580 -41350 0 1 {name=p129152 lab=_45781_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -41350 0 0 {name=X_45781_ }
C {devices/lab_pin.sym} 130460 -41210 0 0 {name=p129153 lab=_64567_/A }
C {devices/lab_pin.sym} 130540 -41210 0 1 {name=p129154 lab=_58784_/A }
C {sky130_stdcells/buf_2.sym} 130500 -41210 0 0 {name=X_57767_ }
C {devices/lab_pin.sym} 130460 -41090 0 0 {name=p129155 lab=_51949_/A }
C {devices/lab_pin.sym} 130540 -41090 0 1 {name=p129156 lab=_52021_/A }
C {sky130_stdcells/buf_2.sym} 130500 -41090 0 0 {name=X_42993_ }
C {devices/lab_pin.sym} 130440 -41000 0 0 {name=p129157 lab=_54964_/A }
C {devices/lab_pin.sym} 130440 -40960 0 0 {name=p129158 lab=_54978_/X }
C {devices/lab_pin.sym} 130440 -40920 0 0 {name=p129159 lab=_54974_/C }
C {devices/lab_pin.sym} 130440 -40880 0 0 {name=p129160 lab=_47558_/A }
C {devices/lab_pin.sym} 130560 -40940 0 1 {name=p129161 lab=_54979_/X }
C {sky130_stdcells/and4_4.sym} 130500 -40940 0 0 {name=X_54979_ }
C {devices/lab_pin.sym} 130410 -40790 0 0 {name=p129162 lab=_86119_/CLK }
C {devices/lab_pin.sym} 130410 -40770 0 0 {name=p129163 lab=_52554_/Y }
C {devices/lab_pin.sym} 130590 -40790 0 1 {name=p129164 lab=_65270_/B }
C {sky130_stdcells/dfxtp_4.sym} 130500 -40780 0 0 {name=X_85799_ }
C {devices/lab_pin.sym} 130460 -40650 0 0 {name=p129165 lab=_81794_/Q }
C {devices/lab_pin.sym} 130540 -40650 0 1 {name=p129166 lab=_47521_/A }
C {sky130_stdcells/inv_2.sym} 130500 -40650 0 0 {name=X_47520_ }
C {devices/lab_pin.sym} 130440 -40540 0 0 {name=p129167 lab=_63448_/B }
C {devices/lab_pin.sym} 130440 -40500 0 0 {name=p129168 lab=_58230_/A }
C {devices/lab_pin.sym} 130560 -40520 0 1 {name=p129169 lab=_59506_/Y }
C {sky130_stdcells/nor2_4.sym} 130500 -40520 0 0 {name=X_59506_ }
C {devices/lab_pin.sym} 130440 -40400 0 0 {name=p129170 lab=_78325_/B }
C {devices/lab_pin.sym} 130440 -40360 0 0 {name=p129171 lab=_78340_/B }
C {devices/lab_pin.sym} 130560 -40380 0 1 {name=p129172 lab=_82756_/D }
C {sky130_stdcells/xnor2_4.sym} 130500 -40380 0 0 {name=X_78340_ }
C {devices/lab_pin.sym} 130420 -40290 0 0 {name=p129173 lab=_44707_/X }
C {devices/lab_pin.sym} 130420 -40250 0 0 {name=p129174 lab=_44708_/X }
C {devices/lab_pin.sym} 130420 -40210 0 0 {name=p129175 lab=_40729_/A }
C {devices/lab_pin.sym} 130420 -40170 0 0 {name=p129176 lab=_44731_/Y }
C {devices/lab_pin.sym} 130420 -40130 0 0 {name=p129177 lab=_44710_/X }
C {devices/lab_pin.sym} 130580 -40210 0 1 {name=p129178 lab=_86982_/D }
C {sky130_stdcells/o32ai_4.sym} 130500 -40210 0 0 {name=X_44732_ }
C {devices/lab_pin.sym} 130420 -40070 0 0 {name=p129179 lab=_56636_/X }
C {devices/lab_pin.sym} 130420 -40030 0 0 {name=p129180 lab=_56706_/X }
C {devices/lab_pin.sym} 130420 -39990 0 0 {name=p129181 lab=_56717_/Y }
C {devices/lab_pin.sym} 130580 -40030 0 1 {name=p129182 lab=_85136_/D }
C {sky130_stdcells/a21o_4.sym} 130500 -40030 0 0 {name=X_56718_ }
C {devices/lab_pin.sym} 130420 -39910 0 0 {name=p129183 lab=_75517_/Y }
C {devices/lab_pin.sym} 130420 -39870 0 0 {name=p129184 lab=_75519_/X }
C {devices/lab_pin.sym} 130420 -39830 0 0 {name=p129185 lab=_75543_/X }
C {devices/lab_pin.sym} 130580 -39870 0 1 {name=p129186 lab=_75552_/X }
C {sky130_stdcells/a21o_4.sym} 130500 -39870 0 0 {name=X_75552_ }
C {devices/lab_pin.sym} 130410 -39730 0 0 {name=p129187 lab=_88084_/CLK }
C {devices/lab_pin.sym} 130410 -39710 0 0 {name=p129188 lab=_43206_/X }
C {devices/lab_pin.sym} 130590 -39730 0 1 {name=p129189 lab=_87538_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -39720 0 0 {name=X_87538_ }
C {devices/lab_pin.sym} 130460 -39590 0 0 {name=p129190 lab=clkbuf_9_261_0_CLK/X }
C {devices/lab_pin.sym} 130540 -39590 0 1 {name=p129191 lab=_84064_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 130500 -39590 0 0 {name=Xclkbuf_10_522_0_CLK }
C {devices/lab_pin.sym} 130460 -39470 0 0 {name=p129192 lab=_41944_/A }
C {devices/lab_pin.sym} 130540 -39470 0 1 {name=p129193 lab=_41944_/Y }
C {sky130_stdcells/inv_2.sym} 130500 -39470 0 0 {name=X_41944_ }
C {devices/lab_pin.sym} 130440 -39370 0 0 {name=p129194 lab=_72762_/X }
C {devices/lab_pin.sym} 130440 -39330 0 0 {name=p129195 lab=_72738_/X }
C {devices/lab_pin.sym} 130440 -39290 0 0 {name=p129196 lab=_72764_/C }
C {devices/lab_pin.sym} 130560 -39330 0 1 {name=p129197 lab=_72764_/Y }
C {sky130_stdcells/nand3_4.sym} 130500 -39330 0 0 {name=X_72764_ }
C {devices/lab_pin.sym} 130460 -39190 0 0 {name=p129198 lab=clkbuf_5_6_0_CLK/X }
C {devices/lab_pin.sym} 130540 -39190 0 1 {name=p129199 lab=clkbuf_7_26_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 130500 -39190 0 0 {name=Xclkbuf_6_13_0_CLK }
C {devices/lab_pin.sym} 130440 -39080 0 0 {name=p129200 lab=_57698_/A }
C {devices/lab_pin.sym} 130440 -39040 0 0 {name=p129201 lab=_57697_/X }
C {devices/lab_pin.sym} 130560 -39060 0 1 {name=p129202 lab=_57698_/Y }
C {sky130_stdcells/nor2_4.sym} 130500 -39060 0 0 {name=X_57698_ }
C {devices/lab_pin.sym} 130440 -38940 0 0 {name=p129203 lab=_46272_/A }
C {devices/lab_pin.sym} 130440 -38900 0 0 {name=p129204 lab=_48683_/A }
C {devices/lab_pin.sym} 130560 -38920 0 1 {name=p129205 lab=_74503_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -38920 0 0 {name=X_74503_ }
C {devices/lab_pin.sym} 130460 -38790 0 0 {name=p129206 lab=_47451_/A }
C {devices/lab_pin.sym} 130540 -38790 0 1 {name=p129207 lab=_53054_/B }
C {sky130_stdcells/buf_2.sym} 130500 -38790 0 0 {name=X_47451_ }
C {devices/lab_pin.sym} 130460 -38670 0 0 {name=p129208 lab=_71714_/Y }
C {devices/lab_pin.sym} 130540 -38670 0 1 {name=p129209 lab=_71716_/B }
C {sky130_stdcells/buf_2.sym} 130500 -38670 0 0 {name=X_71715_ }
C {devices/lab_pin.sym} 130440 -38560 0 0 {name=p129210 lab=_58548_/A }
C {devices/lab_pin.sym} 130440 -38520 0 0 {name=p129211 lab=_59437_/B }
C {devices/lab_pin.sym} 130560 -38540 0 1 {name=p129212 lab=_59437_/Y }
C {sky130_stdcells/nor2_4.sym} 130500 -38540 0 0 {name=X_59437_ }
C {devices/lab_pin.sym} 130440 -38420 0 0 {name=p129213 lab=_78273_/A }
C {devices/lab_pin.sym} 130440 -38380 0 0 {name=p129214 lab=_78273_/B }
C {devices/lab_pin.sym} 130560 -38400 0 1 {name=p129215 lab=_78271_/X }
C {sky130_stdcells/or2_4.sym} 130500 -38400 0 0 {name=X_78271_ }
C {devices/lab_pin.sym} 130420 -38300 0 0 {name=p129216 lab=_41092_/Y }
C {devices/lab_pin.sym} 130420 -38260 0 0 {name=p129217 lab=_44648_/X }
C {devices/lab_pin.sym} 130420 -38220 0 0 {name=p129218 lab=_87011_/Q }
C {devices/lab_pin.sym} 130420 -38180 0 0 {name=p129219 lab=_44650_/X }
C {devices/lab_pin.sym} 130580 -38240 0 1 {name=p129220 lab=_87011_/D }
C {sky130_stdcells/a2bb2o_4.sym} 130500 -38240 0 0 {name=X_44663_ }
C {devices/lab_pin.sym} 130460 -38090 0 0 {name=p129221 lab=_56593_/A }
C {devices/lab_pin.sym} 130540 -38090 0 1 {name=p129222 lab=_56649_/X }
C {sky130_stdcells/buf_2.sym} 130500 -38090 0 0 {name=X_56649_ }
C {devices/lab_pin.sym} 130440 -37980 0 0 {name=p129223 lab=_75481_/X }
C {devices/lab_pin.sym} 130440 -37940 0 0 {name=p129224 lab=_75482_/Y }
C {devices/lab_pin.sym} 130560 -37960 0 1 {name=p129225 lab=_75506_/D }
C {sky130_stdcells/and2_4.sym} 130500 -37960 0 0 {name=X_75483_ }
C {devices/lab_pin.sym} 130410 -37830 0 0 {name=p129226 lab=_87708_/CLK }
C {devices/lab_pin.sym} 130410 -37810 0 0 {name=p129227 lab=_87469_/D }
C {devices/lab_pin.sym} 130590 -37830 0 1 {name=p129228 lab=_87469_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -37820 0 0 {name=X_87469_ }
C {devices/lab_pin.sym} 130420 -37730 0 0 {name=p129229 lab=_57491_/B }
C {devices/lab_pin.sym} 130420 -37690 0 0 {name=p129230 lab=_50731_/A }
C {devices/lab_pin.sym} 130420 -37650 0 0 {name=p129231 lab=_40573_/X }
C {devices/lab_pin.sym} 130420 -37610 0 0 {name=p129232 lab=_88114_/Q }
C {devices/lab_pin.sym} 130420 -37570 0 0 {name=p129233 lab=_41872_/X }
C {devices/lab_pin.sym} 130580 -37650 0 1 {name=p129234 lab=_41875_/Y }
C {sky130_stdcells/o32ai_4.sym} 130500 -37650 0 0 {name=X_41875_ }
C {devices/lab_pin.sym} 130440 -37510 0 0 {name=p129235 lab=_72697_/A }
C {devices/lab_pin.sym} 130440 -37470 0 0 {name=p129236 lab=_72697_/B }
C {devices/lab_pin.sym} 130440 -37430 0 0 {name=p129237 lab=_55426_/X }
C {devices/lab_pin.sym} 130560 -37470 0 1 {name=p129238 lab=_72695_/Y }
C {sky130_stdcells/nand3_4.sym} 130500 -37470 0 0 {name=X_72695_ }
C {devices/lab_pin.sym} 130460 -37330 0 0 {name=p129239 lab=_48631_/A }
C {devices/lab_pin.sym} 130540 -37330 0 1 {name=p129240 lab=_47904_/A }
C {sky130_stdcells/buf_2.sym} 130500 -37330 0 0 {name=X_46402_ }
C {devices/lab_pin.sym} 130440 -37220 0 0 {name=p129241 lab=_77222_/A }
C {devices/lab_pin.sym} 130440 -37180 0 0 {name=p129242 lab=_77222_/B }
C {devices/lab_pin.sym} 130560 -37200 0 1 {name=p129243 lab=_77222_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -37200 0 0 {name=X_77222_ }
C {devices/lab_pin.sym} 130460 -37070 0 0 {name=p129244 lab=_43614_/A }
C {devices/lab_pin.sym} 130540 -37070 0 1 {name=p129245 lab=_68495_/B }
C {sky130_stdcells/inv_2.sym} 130500 -37070 0 0 {name=X_43614_ }
C {devices/lab_pin.sym} 130420 -36970 0 0 {name=p129246 lab=_83067_/Q }
C {devices/lab_pin.sym} 130420 -36930 0 0 {name=p129247 lab=_74412_/X }
C {devices/lab_pin.sym} 130420 -36890 0 0 {name=p129248 lab=_74433_/Y }
C {devices/lab_pin.sym} 130580 -36930 0 1 {name=p129249 lab=_74434_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -36930 0 0 {name=X_74434_ }
C {devices/lab_pin.sym} 130460 -36790 0 0 {name=p129250 lab=_40826_/A }
C {devices/lab_pin.sym} 130540 -36790 0 1 {name=p129251 lab=_40826_/X }
C {sky130_stdcells/buf_2.sym} 130500 -36790 0 0 {name=X_40826_ }
C {devices/lab_pin.sym} 130460 -36670 0 0 {name=p129252 lab=_47382_/A }
C {devices/lab_pin.sym} 130540 -36670 0 1 {name=p129253 lab=_47382_/X }
C {sky130_stdcells/buf_2.sym} 130500 -36670 0 0 {name=X_47382_ }
C {devices/lab_pin.sym} 130440 -36570 0 0 {name=p129254 lab=_71241_/A }
C {devices/lab_pin.sym} 130440 -36530 0 0 {name=p129255 lab=_71261_/B }
C {devices/lab_pin.sym} 130440 -36490 0 0 {name=p129256 lab=_71644_/C }
C {devices/lab_pin.sym} 130560 -36530 0 1 {name=p129257 lab=_71646_/Y }
C {sky130_stdcells/nand3_4.sym} 130500 -36530 0 0 {name=X_71646_ }
C {devices/lab_pin.sym} 130460 -36390 0 0 {name=p129258 lab=_59085_/A }
C {devices/lab_pin.sym} 130540 -36390 0 1 {name=p129259 lab=_59368_/X }
C {sky130_stdcells/buf_2.sym} 130500 -36390 0 0 {name=X_59368_ }
C {devices/lab_pin.sym} 130460 -36270 0 0 {name=p129260 lab=_44530_/A }
C {devices/lab_pin.sym} 130540 -36270 0 1 {name=p129261 lab=_44594_/X }
C {sky130_stdcells/buf_2.sym} 130500 -36270 0 0 {name=X_44594_ }
C {devices/lab_pin.sym} 130460 -36150 0 0 {name=p129262 lab=_49121_/A }
C {devices/lab_pin.sym} 130540 -36150 0 1 {name=p129263 lab=_53902_/B }
C {sky130_stdcells/buf_2.sym} 130500 -36150 0 0 {name=X_49121_ }
C {devices/lab_pin.sym} 130460 -36030 0 0 {name=p129264 lab=_83650_/Q }
C {devices/lab_pin.sym} 130540 -36030 0 1 {name=p129265 lab=_53976_/B }
C {sky130_stdcells/inv_2.sym} 130500 -36030 0 0 {name=X_46333_ }
C {devices/lab_pin.sym} 130460 -35910 0 0 {name=p129266 lab=clkbuf_9_268_0_CLK/X }
C {devices/lab_pin.sym} 130540 -35910 0 1 {name=p129267 lab=_84079_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 130500 -35910 0 0 {name=Xclkbuf_10_537_0_CLK }
C {devices/lab_pin.sym} 130460 -35790 0 0 {name=p129268 lab=_58319_/A }
C {devices/lab_pin.sym} 130540 -35790 0 1 {name=p129269 lab=_58320_/A }
C {sky130_stdcells/inv_2.sym} 130500 -35790 0 0 {name=X_58319_ }
C {devices/lab_pin.sym} 130440 -35680 0 0 {name=p129270 lab=_77174_/B }
C {devices/lab_pin.sym} 130440 -35640 0 0 {name=p129271 lab=_81920_/Q }
C {devices/lab_pin.sym} 130560 -35660 0 1 {name=p129272 lab=_77173_/A }
C {sky130_stdcells/xor2_4.sym} 130500 -35660 0 0 {name=X_77153_ }
C {devices/lab_pin.sym} 130460 -35530 0 0 {name=p129273 lab=clkbuf_6_29_0_CLK/A }
C {devices/lab_pin.sym} 130540 -35530 0 1 {name=p129274 lab=clkbuf_7_57_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 130500 -35530 0 0 {name=Xclkbuf_6_28_0_CLK }
C {devices/lab_pin.sym} 130460 -35410 0 0 {name=p129275 lab=_43166_/A }
C {devices/lab_pin.sym} 130540 -35410 0 1 {name=p129276 lab=_43760_/A }
C {sky130_stdcells/buf_2.sym} 130500 -35410 0 0 {name=X_43545_ }
C {devices/lab_pin.sym} 130460 -35290 0 0 {name=p129277 lab=_71964_/A }
C {devices/lab_pin.sym} 130540 -35290 0 1 {name=p129278 lab=_74366_/C }
C {sky130_stdcells/buf_2.sym} 130500 -35290 0 0 {name=X_74365_ }
C {devices/lab_pin.sym} 130420 -35200 0 0 {name=p129279 lab=_40753_/X }
C {devices/lab_pin.sym} 130420 -35160 0 0 {name=p129280 lab=_40754_/X }
C {devices/lab_pin.sym} 130420 -35120 0 0 {name=p129281 lab=_88341_/Q }
C {devices/lab_pin.sym} 130420 -35080 0 0 {name=p129282 lab=_40756_/X }
C {devices/lab_pin.sym} 130580 -35140 0 1 {name=p129283 lab=_88341_/D }
C {sky130_stdcells/a2bb2o_4.sym} 130500 -35140 0 0 {name=X_40757_ }
C {devices/lab_pin.sym} 130440 -35000 0 0 {name=p129284 lab=_59238_/X }
C {devices/lab_pin.sym} 130440 -34960 0 0 {name=p129285 lab=_86345_/Q }
C {devices/lab_pin.sym} 130560 -34980 0 1 {name=p129286 lab=_59299_/Y }
C {sky130_stdcells/nor2_4.sym} 130500 -34980 0 0 {name=X_59299_ }
C {devices/lab_pin.sym} 130440 -34870 0 0 {name=p129287 lab=_71576_/X }
C {devices/lab_pin.sym} 130440 -34830 0 0 {name=p129288 lab=_71583_/B }
C {devices/lab_pin.sym} 130440 -34790 0 0 {name=p129289 lab=_71574_/C }
C {devices/lab_pin.sym} 130560 -34830 0 1 {name=p129290 lab=_71577_/Y }
C {sky130_stdcells/nor3_4.sym} 130500 -34830 0 0 {name=X_71577_ }
C {devices/lab_pin.sym} 130440 -34700 0 0 {name=p129291 lab=_81531_/Q }
C {devices/lab_pin.sym} 130440 -34660 0 0 {name=p129292 lab=_76104_/B }
C {devices/lab_pin.sym} 130560 -34680 0 1 {name=p129293 lab=_76104_/X }
C {sky130_stdcells/xor2_4.sym} 130500 -34680 0 0 {name=X_76104_ }
C {devices/lab_pin.sym} 130460 -34550 0 0 {name=p129294 lab=_49052_/A }
C {devices/lab_pin.sym} 130540 -34550 0 1 {name=p129295 lab=_49052_/X }
C {sky130_stdcells/buf_2.sym} 130500 -34550 0 0 {name=X_49052_ }
C {devices/lab_pin.sym} 130460 -34430 0 0 {name=p129296 lab=_84856_/Q }
C {devices/lab_pin.sym} 130540 -34430 0 1 {name=p129297 lab=_61330_/X }
C {sky130_stdcells/buf_2.sym} 130500 -34430 0 0 {name=X_61330_ }
C {devices/lab_pin.sym} 130420 -34330 0 0 {name=p129298 lab=_73314_/X }
C {devices/lab_pin.sym} 130420 -34290 0 0 {name=p129299 lab=_73315_/Y }
C {devices/lab_pin.sym} 130420 -34250 0 0 {name=p129300 lab=_73221_/X }
C {devices/lab_pin.sym} 130580 -34290 0 1 {name=p129301 lab=_73316_/Y }
C {sky130_stdcells/a21oi_4.sym} 130500 -34290 0 0 {name=X_73316_ }
C {devices/lab_pin.sym} 130460 -34150 0 0 {name=p129302 lab=_70410_/Y }
C {devices/lab_pin.sym} 130540 -34150 0 1 {name=p129303 lab=_71507_/A }
C {sky130_stdcells/buf_2.sym} 130500 -34150 0 0 {name=X_70528_ }
C {devices/lab_pin.sym} 130460 -34030 0 0 {name=p129304 lab=_46349_/A }
C {devices/lab_pin.sym} 130540 -34030 0 1 {name=p129305 lab=_46328_/B }
C {sky130_stdcells/buf_2.sym} 130500 -34030 0 0 {name=X_46264_ }
C {devices/lab_pin.sym} 130440 -33920 0 0 {name=p129306 lab=_77084_/A }
C {devices/lab_pin.sym} 130440 -33880 0 0 {name=p129307 lab=_77083_/X }
C {devices/lab_pin.sym} 130560 -33900 0 1 {name=p129308 lab=_77084_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -33900 0 0 {name=X_77084_ }
C {devices/lab_pin.sym} 130420 -33810 0 0 {name=p129309 lab=_43472_/X }
C {devices/lab_pin.sym} 130420 -33770 0 0 {name=p129310 lab=_43475_/X }
C {devices/lab_pin.sym} 130420 -33730 0 0 {name=p129311 lab=_41676_/X }
C {devices/lab_pin.sym} 130420 -33690 0 0 {name=p129312 lab=_87403_/Q }
C {devices/lab_pin.sym} 130420 -33650 0 0 {name=p129313 lab=_43456_/X }
C {devices/lab_pin.sym} 130580 -33730 0 1 {name=p129314 lab=_43477_/A }
C {sky130_stdcells/o32ai_4.sym} 130500 -33730 0 0 {name=X_43476_ }
C {devices/lab_pin.sym} 130420 -33590 0 0 {name=p129315 lab=_70277_/C }
C {devices/lab_pin.sym} 130420 -33550 0 0 {name=p129316 lab=_74288_/X }
C {devices/lab_pin.sym} 130420 -33510 0 0 {name=p129317 lab=_74295_/Y }
C {devices/lab_pin.sym} 130580 -33550 0 1 {name=p129318 lab=_74296_/X }
C {sky130_stdcells/a21bo_4.sym} 130500 -33550 0 0 {name=X_74296_ }
C {devices/lab_pin.sym} 130460 -33410 0 0 {name=p129319 lab=_40836_/A }
C {devices/lab_pin.sym} 130540 -33410 0 1 {name=p129320 lab=_40688_/X }
C {sky130_stdcells/buf_2.sym} 130500 -33410 0 0 {name=X_40688_ }
C {devices/lab_pin.sym} 130460 -33290 0 0 {name=p129321 lab=_53535_/B }
C {devices/lab_pin.sym} 130540 -33290 0 1 {name=p129322 lab=_50310_/B }
C {sky130_stdcells/buf_2.sym} 130500 -33290 0 0 {name=X_48003_ }
C {devices/lab_pin.sym} 130460 -33170 0 0 {name=p129323 lab=_45215_/A }
C {devices/lab_pin.sym} 130540 -33170 0 1 {name=p129324 lab=_45216_/A }
C {sky130_stdcells/inv_2.sym} 130500 -33170 0 0 {name=X_45215_ }
C {devices/lab_pin.sym} 130440 -33060 0 0 {name=p129325 lab=_76023_/Y }
C {devices/lab_pin.sym} 130440 -33020 0 0 {name=p129326 lab=_76034_/X }
C {devices/lab_pin.sym} 130560 -33040 0 1 {name=p129327 lab=_76038_/A }
C {sky130_stdcells/nand2_4.sym} 130500 -33040 0 0 {name=X_76035_ }
C {devices/lab_pin.sym} 130460 -32910 0 0 {name=p129328 lab=_42427_/A }
C {devices/lab_pin.sym} 130540 -32910 0 1 {name=p129329 lab=_42427_/Y }
C {sky130_stdcells/inv_2.sym} 130500 -32910 0 0 {name=X_42427_ }
C {devices/lab_pin.sym} 130460 -32790 0 0 {name=p129330 lab=_72564_/A }
C {devices/lab_pin.sym} 130540 -32790 0 1 {name=p129331 lab=_72544_/B }
C {sky130_stdcells/buf_2.sym} 130500 -32790 0 0 {name=X_61261_ }
C {devices/lab_pin.sym} 130440 -32680 0 0 {name=p129332 lab=_73247_/A }
C {devices/lab_pin.sym} 130440 -32640 0 0 {name=p129333 lab=_73196_/B }
C {devices/lab_pin.sym} 130560 -32660 0 1 {name=p129334 lab=_73247_/Y }
C {sky130_stdcells/nor2_4.sym} 130500 -32660 0 0 {name=X_73247_ }
C {devices/lab_pin.sym} 130440 -32560 0 0 {name=p129335 lab=_46195_/A }
C {devices/lab_pin.sym} 130440 -32520 0 0 {name=p129336 lab=_46162_/C }
C {devices/lab_pin.sym} 130440 -32480 0 0 {name=p129337 lab=_46217_/B }
C {devices/lab_pin.sym} 130440 -32440 0 0 {name=p129338 lab=_46195_/D }
C {devices/lab_pin.sym} 130560 -32500 0 1 {name=p129339 lab=_46195_/Y }
C {sky130_stdcells/nand4_4.sym} 130500 -32500 0 0 {name=X_46195_ }
C {devices/lab_pin.sym} 130460 -32350 0 0 {name=p129340 lab=_70455_/Y }
C {devices/lab_pin.sym} 130540 -32350 0 1 {name=p129341 lab=_71337_/A }
C {sky130_stdcells/buf_2.sym} 130500 -32350 0 0 {name=X_70459_ }
C {devices/lab_pin.sym} 130420 -32260 0 0 {name=p129342 lab=_59450_/Y }
C {devices/lab_pin.sym} 130420 -32220 0 0 {name=p129343 lab=_62999_/X }
C {devices/lab_pin.sym} 130420 -32180 0 0 {name=p129344 lab=_61315_/A }
C {devices/lab_pin.sym} 130420 -32140 0 0 {name=p129345 lab=_60555_/A }
C {devices/lab_pin.sym} 130580 -32200 0 1 {name=p129346 lab=_63000_/X }
C {sky130_stdcells/a2bb2o_4.sym} 130500 -32200 0 0 {name=X_63000_ }
C {devices/lab_pin.sym} 130460 -32050 0 0 {name=p129347 lab=_60212_/A }
C {devices/lab_pin.sym} 130540 -32050 0 1 {name=p129348 lab=_60300_/B }
C {sky130_stdcells/buf_2.sym} 130500 -32050 0 0 {name=X_60212_ }
C {devices/lab_pin.sym} 130420 -31950 0 0 {name=p129349 lab=_45138_/X }
C {devices/lab_pin.sym} 130420 -31910 0 0 {name=p129350 lab=_45142_/Y }
C {devices/lab_pin.sym} 130420 -31870 0 0 {name=p129351 lab=_45145_/Y }
C {devices/lab_pin.sym} 130580 -31910 0 1 {name=p129352 lab=_45146_/Y }
C {sky130_stdcells/a21oi_4.sym} 130500 -31910 0 0 {name=X_45146_ }
C {devices/lab_pin.sym} 130420 -31800 0 0 {name=p129353 lab=_41731_/X }
C {devices/lab_pin.sym} 130420 -31760 0 0 {name=p129354 lab=_42356_/X }
C {devices/lab_pin.sym} 130420 -31720 0 0 {name=p129355 lab=_87904_/Q }
C {devices/lab_pin.sym} 130420 -31680 0 0 {name=p129356 lab=_42357_/X }
C {devices/lab_pin.sym} 130580 -31740 0 1 {name=p129357 lab=_87904_/D }
C {sky130_stdcells/a2bb2o_4.sym} 130500 -31740 0 0 {name=X_42358_ }
C {devices/lab_pin.sym} 130440 -31610 0 0 {name=p129358 lab=_61234_/A }
C {devices/lab_pin.sym} 130440 -31570 0 0 {name=p129359 lab=_61165_/B }
C {devices/lab_pin.sym} 130440 -31530 0 0 {name=p129360 lab=_61192_/C }
C {devices/lab_pin.sym} 130560 -31570 0 1 {name=p129361 lab=_61192_/Y }
C {sky130_stdcells/nor3_4.sym} 130500 -31570 0 0 {name=X_61192_ }
C {devices/lab_pin.sym} 130420 -31460 0 0 {name=p129362 lab=_69780_/B }
C {devices/lab_pin.sym} 130420 -31420 0 0 {name=p129363 lab=_73227_/A }
C {devices/lab_pin.sym} 130420 -31380 0 0 {name=p129364 lab=_72979_/X }
C {devices/lab_pin.sym} 130420 -31340 0 0 {name=p129365 lab=_73177_/Y }
C {devices/lab_pin.sym} 130580 -31400 0 1 {name=p129366 lab=_73178_/X }
C {sky130_stdcells/a211o_4.sym} 130500 -31400 0 0 {name=X_73178_ }
C {devices/lab_pin.sym} 130420 -31280 0 0 {name=p129367 lab=_41306_/X }
C {devices/lab_pin.sym} 130420 -31240 0 0 {name=p129368 lab=_41307_/X }
C {devices/lab_pin.sym} 130420 -31200 0 0 {name=p129369 lab=_67444_/B }
C {devices/lab_pin.sym} 130420 -31160 0 0 {name=p129370 lab=_41308_/X }
C {devices/lab_pin.sym} 130580 -31220 0 1 {name=p129371 lab=_41309_/X }
C {sky130_stdcells/a2bb2o_4.sym} 130500 -31220 0 0 {name=X_41309_ }
C {devices/lab_pin.sym} 130420 -31110 0 0 {name=p129372 lab=_60042_/A }
C {devices/lab_pin.sym} 130420 -31070 0 0 {name=p129373 lab=_59988_/Y }
C {devices/lab_pin.sym} 130420 -31030 0 0 {name=p129374 lab=_60141_/Y }
C {devices/lab_pin.sym} 130420 -30990 0 0 {name=p129375 lab=_79937_/A }
C {devices/lab_pin.sym} 130420 -30950 0 0 {name=p129376 lab=_59802_/X }
C {devices/lab_pin.sym} 130580 -31030 0 1 {name=p129377 lab=_60143_/X }
C {sky130_stdcells/a32o_4.sym} 130500 -31030 0 0 {name=X_60143_ }
C {devices/lab_pin.sym} 130440 -30880 0 0 {name=p129378 lab=_72129_/A }
C {devices/lab_pin.sym} 130440 -30840 0 0 {name=p129379 lab=_72193_/B }
C {devices/lab_pin.sym} 130560 -30860 0 1 {name=p129380 lab=_72129_/Y }
C {sky130_stdcells/nor2_4.sym} 130500 -30860 0 0 {name=X_72129_ }
C {devices/lab_pin.sym} 130420 -30750 0 0 {name=p129381 lab=_49950_/Y }
C {devices/lab_pin.sym} 130420 -30710 0 0 {name=p129382 lab=_49951_/X }
C {devices/lab_pin.sym} 130420 -30670 0 0 {name=p129383 lab=_49953_/X }
C {devices/lab_pin.sym} 130580 -30710 0 1 {name=p129384 lab=_86293_/D }
C {sky130_stdcells/a21oi_4.sym} 130500 -30710 0 0 {name=X_49954_ }
C {devices/lab_pin.sym} 130420 -30590 0 0 {name=p129385 lab=_85206_/Q }
C {devices/lab_pin.sym} 130420 -30550 0 0 {name=p129386 lab=_45027_/X }
C {devices/lab_pin.sym} 130420 -30510 0 0 {name=p129387 lab=_45076_/X }
C {devices/lab_pin.sym} 130580 -30550 0 1 {name=p129388 lab=_45077_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -30550 0 0 {name=X_45077_ }
C {devices/lab_pin.sym} 130460 -30410 0 0 {name=p129389 lab=_51584_/A }
C {devices/lab_pin.sym} 130540 -30410 0 1 {name=p129390 lab=_42290_/A }
C {sky130_stdcells/buf_2.sym} 130500 -30410 0 0 {name=X_42289_ }
C {devices/lab_pin.sym} 130440 -30300 0 0 {name=p129391 lab=_82254_/Q }
C {devices/lab_pin.sym} 130440 -30260 0 0 {name=p129392 lab=_81966_/Q }
C {devices/lab_pin.sym} 130560 -30280 0 1 {name=p129393 lab=_77999_/B }
C {sky130_stdcells/xnor2_4.sym} 130500 -30280 0 0 {name=X_77986_ }
C {devices/lab_pin.sym} 130440 -30160 0 0 {name=p129394 lab=_81215_/Q }
C {devices/lab_pin.sym} 130440 -30120 0 0 {name=p129395 lab=_48976_/A }
C {devices/lab_pin.sym} 130560 -30140 0 1 {name=p129396 lab=_48905_/Y }
C {sky130_stdcells/nor2_4.sym} 130500 -30140 0 0 {name=X_48905_ }
C {devices/lab_pin.sym} 130460 -30010 0 0 {name=p129397 lab=_69654_/A }
C {devices/lab_pin.sym} 130540 -30010 0 1 {name=p129398 lab=_64731_/A }
C {sky130_stdcells/buf_2.sym} 130500 -30010 0 0 {name=X_44028_ }
C {devices/lab_pin.sym} 130440 -29900 0 0 {name=p129399 lab=_79702_/X }
C {devices/lab_pin.sym} 130440 -29860 0 0 {name=p129400 lab=_79715_/X }
C {devices/lab_pin.sym} 130560 -29880 0 1 {name=p129401 lab=_79725_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -29880 0 0 {name=X_79725_ }
C {devices/lab_pin.sym} 130440 -29760 0 0 {name=p129402 lab=_64924_/A }
C {devices/lab_pin.sym} 130440 -29720 0 0 {name=p129403 lab=_64951_/B }
C {devices/lab_pin.sym} 130560 -29740 0 1 {name=p129404 lab=_64951_/X }
C {sky130_stdcells/and2_4.sym} 130500 -29740 0 0 {name=X_64951_ }
C {devices/lab_pin.sym} 130460 -29610 0 0 {name=p129405 lab=_59508_/X }
C {devices/lab_pin.sym} 130540 -29610 0 1 {name=p129406 lab=_60074_/X }
C {sky130_stdcells/buf_2.sym} 130500 -29610 0 0 {name=X_60074_ }
C {devices/lab_pin.sym} 130420 -29510 0 0 {name=p129407 lab=_76932_/Y }
C {devices/lab_pin.sym} 130420 -29470 0 0 {name=p129408 lab=_76914_/B }
C {devices/lab_pin.sym} 130420 -29430 0 0 {name=p129409 lab=_76936_/Y }
C {devices/lab_pin.sym} 130580 -29470 0 1 {name=p129410 lab=_76938_/B }
C {sky130_stdcells/o21ai_4.sym} 130500 -29470 0 0 {name=X_76937_ }
C {devices/lab_pin.sym} 130420 -29350 0 0 {name=p129411 lab=_49883_/Y }
C {devices/lab_pin.sym} 130420 -29310 0 0 {name=p129412 lab=_49870_/X }
C {devices/lab_pin.sym} 130420 -29270 0 0 {name=p129413 lab=_49884_/X }
C {devices/lab_pin.sym} 130580 -29310 0 1 {name=p129414 lab=_49885_/Y }
C {sky130_stdcells/a21oi_4.sym} 130500 -29310 0 0 {name=X_49885_ }
C {devices/lab_pin.sym} 130440 -29200 0 0 {name=p129415 lab=_57660_/X }
C {devices/lab_pin.sym} 130440 -29160 0 0 {name=p129416 lab=_63902_/B }
C {devices/lab_pin.sym} 130440 -29120 0 0 {name=p129417 lab=_63902_/C }
C {devices/lab_pin.sym} 130440 -29080 0 0 {name=p129418 lab=_63902_/D }
C {devices/lab_pin.sym} 130560 -29140 0 1 {name=p129419 lab=_63903_/D }
C {sky130_stdcells/nand4_4.sym} 130500 -29140 0 0 {name=X_63902_ }
C {devices/lab_pin.sym} 130460 -28990 0 0 {name=p129420 lab=_48836_/A }
C {devices/lab_pin.sym} 130540 -28990 0 1 {name=p129421 lab=_48836_/X }
C {sky130_stdcells/buf_2.sym} 130500 -28990 0 0 {name=X_48836_ }
C {devices/lab_pin.sym} 130460 -28870 0 0 {name=p129422 lab=_67550_/X }
C {devices/lab_pin.sym} 130540 -28870 0 1 {name=p129423 lab=_67670_/X }
C {sky130_stdcells/buf_2.sym} 130500 -28870 0 0 {name=X_67670_ }
C {devices/lab_pin.sym} 130420 -28770 0 0 {name=p129424 lab=_79648_/X }
C {devices/lab_pin.sym} 130420 -28730 0 0 {name=p129425 lab=_79650_/B }
C {devices/lab_pin.sym} 130420 -28690 0 0 {name=p129426 lab=_79655_/Y }
C {devices/lab_pin.sym} 130580 -28730 0 1 {name=p129427 lab=_79660_/A }
C {sky130_stdcells/a21boi_4.sym} 130500 -28730 0 0 {name=X_79656_ }
C {devices/lab_pin.sym} 130420 -28620 0 0 {name=p129428 lab=_64752_/X }
C {devices/lab_pin.sym} 130420 -28580 0 0 {name=p129429 lab=_86167_/Q }
C {devices/lab_pin.sym} 130420 -28540 0 0 {name=p129430 lab=_64716_/X }
C {devices/lab_pin.sym} 130420 -28500 0 0 {name=p129431 lab=_64881_/X }
C {devices/lab_pin.sym} 130580 -28560 0 1 {name=p129432 lab=_64882_/X }
C {sky130_stdcells/a211o_4.sym} 130500 -28560 0 0 {name=X_64882_ }
C {devices/lab_pin.sym} 130420 -28440 0 0 {name=p129433 lab=_76858_/A }
C {devices/lab_pin.sym} 130420 -28400 0 0 {name=p129434 lab=_76857_/Y }
C {devices/lab_pin.sym} 130420 -28360 0 0 {name=p129435 lab=_81496_/Q }
C {devices/lab_pin.sym} 130420 -28320 0 0 {name=p129436 lab=_81368_/D }
C {devices/lab_pin.sym} 130580 -28380 0 1 {name=p129437 lab=_76868_/X }
C {sky130_stdcells/a2bb2o_4.sym} 130500 -28380 0 0 {name=X_76868_ }
C {devices/lab_pin.sym} 130440 -28240 0 0 {name=p129438 lab=_69853_/A }
C {devices/lab_pin.sym} 130440 -28200 0 0 {name=p129439 lab=_66621_/B }
C {devices/lab_pin.sym} 130560 -28220 0 1 {name=p129440 lab=_66621_/X }
C {sky130_stdcells/and2_4.sym} 130500 -28220 0 0 {name=X_66621_ }
C {devices/lab_pin.sym} 130440 -28100 0 0 {name=p129441 lab=_82518_/Q }
C {devices/lab_pin.sym} 130440 -28060 0 0 {name=p129442 lab=_82774_/D }
C {devices/lab_pin.sym} 130560 -28080 0 1 {name=p129443 lab=_82486_/D }
C {sky130_stdcells/xor2_4.sym} 130500 -28080 0 0 {name=X_78607_ }
C {devices/lab_pin.sym} 130440 -27960 0 0 {name=p129444 lab=_75817_/Y }
C {devices/lab_pin.sym} 130440 -27920 0 0 {name=p129445 lab=_75818_/A }
C {devices/lab_pin.sym} 130560 -27940 0 1 {name=p129446 lab=_75820_/A }
C {sky130_stdcells/nand2_4.sym} 130500 -27940 0 0 {name=X_75819_ }
C {devices/lab_pin.sym} 130460 -27810 0 0 {name=p129447 lab=_63578_/A }
C {devices/lab_pin.sym} 130540 -27810 0 1 {name=p129448 lab=_63833_/X }
C {sky130_stdcells/buf_2.sym} 130500 -27810 0 0 {name=X_63833_ }
C {devices/lab_pin.sym} 130420 -27710 0 0 {name=p129449 lab=_48764_/Y }
C {devices/lab_pin.sym} 130420 -27670 0 0 {name=p129450 lab=_48760_/X }
C {devices/lab_pin.sym} 130420 -27630 0 0 {name=p129451 lab=_48766_/X }
C {devices/lab_pin.sym} 130580 -27670 0 1 {name=p129452 lab=_86487_/D }
C {sky130_stdcells/a21oi_4.sym} 130500 -27670 0 0 {name=X_48767_ }
C {devices/lab_pin.sym} 130440 -27540 0 0 {name=p129453 lab=_79587_/A }
C {devices/lab_pin.sym} 130440 -27500 0 0 {name=p129454 lab=_79587_/B }
C {devices/lab_pin.sym} 130560 -27520 0 1 {name=p129455 lab=_79594_/B }
C {sky130_stdcells/nand2_4.sym} 130500 -27520 0 0 {name=X_79587_ }
C {devices/lab_pin.sym} 130420 -27420 0 0 {name=p129456 lab=_40417_/Y }
C {devices/lab_pin.sym} 130420 -27380 0 0 {name=p129457 lab=_45974_/X }
C {devices/lab_pin.sym} 130420 -27340 0 0 {name=p129458 lab=_86829_/Q }
C {devices/lab_pin.sym} 130420 -27300 0 0 {name=p129459 lab=_45976_/X }
C {devices/lab_pin.sym} 130580 -27360 0 1 {name=p129460 lab=_86829_/D }
C {sky130_stdcells/a2bb2o_4.sym} 130500 -27360 0 0 {name=X_45979_ }
C {devices/lab_pin.sym} 130420 -27230 0 0 {name=p129461 lab=_81489_/Q }
C {devices/lab_pin.sym} 130420 -27190 0 0 {name=p129462 lab=_81361_/D }
C {devices/lab_pin.sym} 130420 -27150 0 0 {name=p129463 lab=_76798_/X }
C {devices/lab_pin.sym} 130580 -27190 0 1 {name=p129464 lab=_76800_/B }
C {sky130_stdcells/o21ai_4.sym} 130500 -27190 0 0 {name=X_76799_ }
C {devices/lab_pin.sym} 130460 -27050 0 0 {name=p129465 lab=_64789_/A }
C {devices/lab_pin.sym} 130540 -27050 0 1 {name=p129466 lab=_69340_/X }
C {sky130_stdcells/buf_2.sym} 130500 -27050 0 0 {name=X_69340_ }
C {devices/lab_pin.sym} 130440 -26940 0 0 {name=p129467 lab=_47715_/X }
C {devices/lab_pin.sym} 130440 -26900 0 0 {name=p129468 lab=_53205_/B }
C {devices/lab_pin.sym} 130560 -26920 0 1 {name=p129469 lab=_47718_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -26920 0 0 {name=X_47718_ }
C {devices/lab_pin.sym} 130460 -26790 0 0 {name=p129470 lab=_69183_/A }
C {devices/lab_pin.sym} 130540 -26790 0 1 {name=p129471 lab=_66552_/X }
C {sky130_stdcells/buf_2.sym} 130500 -26790 0 0 {name=X_66552_ }
C {devices/lab_pin.sym} 130440 -26680 0 0 {name=p129472 lab=_78529_/Y }
C {devices/lab_pin.sym} 130440 -26640 0 0 {name=p129473 lab=_78511_/X }
C {devices/lab_pin.sym} 130560 -26660 0 1 {name=p129474 lab=_78538_/X }
C {sky130_stdcells/and2_4.sym} 130500 -26660 0 0 {name=X_78538_ }
C {devices/lab_pin.sym} 130460 -26530 0 0 {name=p129475 lab=_64184_/C }
C {devices/lab_pin.sym} 130540 -26530 0 1 {name=p129476 lab=_63765_/C }
C {sky130_stdcells/buf_2.sym} 130500 -26530 0 0 {name=X_63764_ }
C {devices/lab_pin.sym} 130420 -26430 0 0 {name=p129477 lab=_60954_/X }
C {devices/lab_pin.sym} 130420 -26390 0 0 {name=p129478 lab=_61012_/C }
C {devices/lab_pin.sym} 130420 -26350 0 0 {name=p129479 lab=_61012_/A }
C {devices/lab_pin.sym} 130580 -26390 0 1 {name=p129480 lab=_60976_/Y }
C {sky130_stdcells/a21boi_4.sym} 130500 -26390 0 0 {name=X_60976_ }
C {devices/lab_pin.sym} 130460 -26250 0 0 {name=p129481 lab=_48631_/A }
C {devices/lab_pin.sym} 130540 -26250 0 1 {name=p129482 lab=_48699_/B }
C {sky130_stdcells/buf_2.sym} 130500 -26250 0 0 {name=X_48698_ }
C {devices/lab_pin.sym} 130460 -26130 0 0 {name=p129483 lab=_64828_/A }
C {devices/lab_pin.sym} 130540 -26130 0 1 {name=p129484 lab=_65503_/X }
C {sky130_stdcells/buf_2.sym} 130500 -26130 0 0 {name=X_65503_ }
C {devices/lab_pin.sym} 130440 -26030 0 0 {name=p129485 lab=_62727_/A }
C {devices/lab_pin.sym} 130440 -25990 0 0 {name=p129486 lab=_62727_/B }
C {devices/lab_pin.sym} 130440 -25950 0 0 {name=p129487 lab=_61811_/X }
C {devices/lab_pin.sym} 130560 -25990 0 1 {name=p129488 lab=_62715_/Y }
C {sky130_stdcells/nand3_4.sym} 130500 -25990 0 0 {name=X_62715_ }
C {devices/lab_pin.sym} 130440 -25860 0 0 {name=p129489 lab=_69191_/A }
C {devices/lab_pin.sym} 130440 -25820 0 0 {name=p129490 lab=_87785_/Q }
C {devices/lab_pin.sym} 130560 -25840 0 1 {name=p129491 lab=_69271_/X }
C {sky130_stdcells/and2_4.sym} 130500 -25840 0 0 {name=X_69271_ }
C {devices/lab_pin.sym} 130440 -25720 0 0 {name=p129492 lab=_47649_/A }
C {devices/lab_pin.sym} 130440 -25680 0 0 {name=p129493 lab=_53167_/B }
C {devices/lab_pin.sym} 130560 -25700 0 1 {name=p129494 lab=_47649_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -25700 0 0 {name=X_47649_ }
C {devices/lab_pin.sym} 130460 -25570 0 0 {name=p129495 lab=_66377_/A }
C {devices/lab_pin.sym} 130540 -25570 0 1 {name=p129496 lab=_66483_/X }
C {sky130_stdcells/buf_2.sym} 130500 -25570 0 0 {name=X_66483_ }
C {devices/lab_pin.sym} 130440 -25460 0 0 {name=p129497 lab=_78469_/A }
C {devices/lab_pin.sym} 130440 -25420 0 0 {name=p129498 lab=_82765_/D }
C {devices/lab_pin.sym} 130560 -25440 0 1 {name=p129499 lab=_78469_/X }
C {sky130_stdcells/xor2_4.sym} 130500 -25440 0 0 {name=X_78469_ }
C {devices/lab_pin.sym} 130420 -25340 0 0 {name=p129500 lab=_59439_/Y }
C {devices/lab_pin.sym} 130420 -25300 0 0 {name=p129501 lab=_63626_/X }
C {devices/lab_pin.sym} 130420 -25260 0 0 {name=p129502 lab=_61676_/A }
C {devices/lab_pin.sym} 130420 -25220 0 0 {name=p129503 lab=_63627_/X }
C {devices/lab_pin.sym} 130580 -25280 0 1 {name=p129504 lab=_63695_/X }
C {sky130_stdcells/a2bb2o_4.sym} 130500 -25280 0 0 {name=X_63695_ }
C {devices/lab_pin.sym} 130440 -25140 0 0 {name=p129505 lab=_80482_/Y }
C {devices/lab_pin.sym} 130440 -25100 0 0 {name=p129506 lab=_80485_/Y }
C {devices/lab_pin.sym} 130560 -25120 0 1 {name=p129507 lab=_80500_/X }
C {sky130_stdcells/or2_4.sym} 130500 -25120 0 0 {name=X_80500_ }
C {devices/lab_pin.sym} 130420 -25010 0 0 {name=p129508 lab=_67372_/X }
C {devices/lab_pin.sym} 130420 -24970 0 0 {name=p129509 lab=_67374_/X }
C {devices/lab_pin.sym} 130420 -24930 0 0 {name=p129510 lab=_68209_/X }
C {devices/lab_pin.sym} 130580 -24970 0 1 {name=p129511 lab=_68222_/Y }
C {sky130_stdcells/a21oi_4.sym} 130500 -24970 0 0 {name=X_68222_ }
C {devices/lab_pin.sym} 130460 -24830 0 0 {name=p129512 lab=_64967_/X }
C {devices/lab_pin.sym} 130540 -24830 0 1 {name=p129513 lab=_65449_/A }
C {sky130_stdcells/buf_2.sym} 130500 -24830 0 0 {name=X_65434_ }
C {devices/lab_pin.sym} 130440 -24730 0 0 {name=p129514 lab=_52355_/A }
C {devices/lab_pin.sym} 130440 -24690 0 0 {name=p129515 lab=_50651_/X }
C {devices/lab_pin.sym} 130440 -24650 0 0 {name=p129516 lab=_50668_/C }
C {devices/lab_pin.sym} 130560 -24690 0 1 {name=p129517 lab=_50660_/X }
C {sky130_stdcells/and3_4.sym} 130500 -24690 0 0 {name=X_50660_ }
C {devices/lab_pin.sym} 130440 -24580 0 0 {name=p129518 lab=_61301_/X }
C {devices/lab_pin.sym} 130440 -24540 0 0 {name=p129519 lab=_62646_/B }
C {devices/lab_pin.sym} 130440 -24500 0 0 {name=p129520 lab=_60291_/C }
C {devices/lab_pin.sym} 130440 -24460 0 0 {name=p129521 lab=_60227_/A }
C {devices/lab_pin.sym} 130560 -24520 0 1 {name=p129522 lab=_62646_/Y }
C {sky130_stdcells/nand4_4.sym} 130500 -24520 0 0 {name=X_62646_ }
C {devices/lab_pin.sym} 130410 -24370 0 0 {name=p129523 lab=_81344_/CLK }
C {devices/lab_pin.sym} 130410 -24350 0 0 {name=p129524 lab=_84048_/Q }
C {devices/lab_pin.sym} 130590 -24370 0 1 {name=p129525 lab=_76709_/B }
C {sky130_stdcells/dfxtp_4.sym} 130500 -24360 0 0 {name=X_81480_ }
C {devices/lab_pin.sym} 130420 -24250 0 0 {name=p129526 lab=_49315_/Y }
C {devices/lab_pin.sym} 130420 -24210 0 0 {name=p129527 lab=_49316_/X }
C {devices/lab_pin.sym} 130420 -24170 0 0 {name=p129528 lab=_49318_/X }
C {devices/lab_pin.sym} 130580 -24210 0 1 {name=p129529 lab=_86411_/D }
C {sky130_stdcells/a21oi_4.sym} 130500 -24210 0 0 {name=X_49319_ }
C {devices/lab_pin.sym} 130420 -24090 0 0 {name=p129530 lab=_59229_/Y }
C {devices/lab_pin.sym} 130420 -24050 0 0 {name=p129531 lab=_66193_/C }
C {devices/lab_pin.sym} 130420 -24010 0 0 {name=p129532 lab=_80430_/Y }
C {devices/lab_pin.sym} 130580 -24050 0 1 {name=p129533 lab=_80448_/B }
C {sky130_stdcells/o21a_4.sym} 130500 -24050 0 0 {name=X_80431_ }
C {devices/lab_pin.sym} 130420 -23940 0 0 {name=p129534 lab=_68097_/X }
C {devices/lab_pin.sym} 130420 -23900 0 0 {name=p129535 lab=_66958_/Y }
C {devices/lab_pin.sym} 130420 -23860 0 0 {name=p129536 lab=_68148_/X }
C {devices/lab_pin.sym} 130420 -23820 0 0 {name=p129537 lab=_68152_/Y }
C {devices/lab_pin.sym} 130580 -23880 0 1 {name=p129538 lab=_68153_/X }
C {sky130_stdcells/a211o_4.sym} 130500 -23880 0 0 {name=X_68153_ }
C {devices/lab_pin.sym} 130420 -23760 0 0 {name=p129539 lab=_65362_/X }
C {devices/lab_pin.sym} 130420 -23720 0 0 {name=p129540 lab=_85508_/Q }
C {devices/lab_pin.sym} 130420 -23680 0 0 {name=p129541 lab=_65363_/X }
C {devices/lab_pin.sym} 130420 -23640 0 0 {name=p129542 lab=_65364_/X }
C {devices/lab_pin.sym} 130580 -23700 0 1 {name=p129543 lab=_65365_/X }
C {sky130_stdcells/a211o_4.sym} 130500 -23700 0 0 {name=X_65365_ }
C {devices/lab_pin.sym} 130420 -23570 0 0 {name=p129544 lab=_86171_/Q }
C {devices/lab_pin.sym} 130420 -23530 0 0 {name=p129545 lab=_50499_/X }
C {devices/lab_pin.sym} 130420 -23490 0 0 {name=p129546 lab=_50590_/Y }
C {devices/lab_pin.sym} 130580 -23530 0 1 {name=p129547 lab=_50591_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -23530 0 0 {name=X_50591_ }
C {devices/lab_pin.sym} 130460 -23390 0 0 {name=p129548 lab=_45308_/A }
C {devices/lab_pin.sym} 130540 -23390 0 1 {name=p129549 lab=_62577_/Y }
C {sky130_stdcells/inv_2.sym} 130500 -23390 0 0 {name=X_62577_ }
C {devices/lab_pin.sym} 130440 -23280 0 0 {name=p129550 lab=_67131_/A }
C {devices/lab_pin.sym} 130440 -23240 0 0 {name=p129551 lab=_67104_/B }
C {devices/lab_pin.sym} 130560 -23260 0 1 {name=p129552 lab=_67104_/X }
C {sky130_stdcells/and2_4.sym} 130500 -23260 0 0 {name=X_67104_ }
C {devices/lab_pin.sym} 130440 -23140 0 0 {name=p129553 lab=_52334_/A }
C {devices/lab_pin.sym} 130440 -23100 0 0 {name=p129554 lab=_49015_/X }
C {devices/lab_pin.sym} 130560 -23120 0 1 {name=p129555 lab=_52330_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -23120 0 0 {name=X_52330_ }
C {devices/lab_pin.sym} 130440 -23000 0 0 {name=p129556 lab=_59392_/A }
C {devices/lab_pin.sym} 130440 -22960 0 0 {name=p129557 lab=_64316_/B }
C {devices/lab_pin.sym} 130560 -22980 0 1 {name=p129558 lab=_64316_/Y }
C {sky130_stdcells/nor2_4.sym} 130500 -22980 0 0 {name=X_64316_ }
C {devices/lab_pin.sym} 130410 -22850 0 0 {name=p129559 lab=_86218_/CLK }
C {devices/lab_pin.sym} 130410 -22830 0 0 {name=p129560 lab=_83150_/D }
C {devices/lab_pin.sym} 130590 -22850 0 1 {name=p129561 lab=_83150_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -22840 0 0 {name=X_83150_ }
C {devices/lab_pin.sym} 130440 -22740 0 0 {name=p129562 lab=_61528_/A }
C {devices/lab_pin.sym} 130440 -22700 0 0 {name=p129563 lab=_61542_/B }
C {devices/lab_pin.sym} 130440 -22660 0 0 {name=p129564 lab=_61542_/C }
C {devices/lab_pin.sym} 130440 -22620 0 0 {name=p129565 lab=_61512_/X }
C {devices/lab_pin.sym} 130560 -22680 0 1 {name=p129566 lab=_61528_/Y }
C {sky130_stdcells/nand4_4.sym} 130500 -22680 0 0 {name=X_61528_ }
C {devices/lab_pin.sym} 130460 -22530 0 0 {name=p129567 lab=_80362_/A }
C {devices/lab_pin.sym} 130540 -22530 0 1 {name=p129568 lab=_80366_/A }
C {sky130_stdcells/inv_2.sym} 130500 -22530 0 0 {name=X_80362_ }
C {devices/lab_pin.sym} 130420 -22440 0 0 {name=p129569 lab=_87136_/Q }
C {devices/lab_pin.sym} 130420 -22400 0 0 {name=p129570 lab=_68059_/X }
C {devices/lab_pin.sym} 130420 -22360 0 0 {name=p129571 lab=_67991_/X }
C {devices/lab_pin.sym} 130420 -22320 0 0 {name=p129572 lab=_68083_/X }
C {devices/lab_pin.sym} 130580 -22380 0 1 {name=p129573 lab=_68084_/X }
C {sky130_stdcells/a211o_4.sym} 130500 -22380 0 0 {name=X_68084_ }
C {devices/lab_pin.sym} 130460 -22230 0 0 {name=p129574 lab=_65296_/A }
C {devices/lab_pin.sym} 130540 -22230 0 1 {name=p129575 lab=_65296_/X }
C {sky130_stdcells/buf_2.sym} 130500 -22230 0 0 {name=X_65296_ }
C {devices/lab_pin.sym} 130410 -22110 0 0 {name=p129576 lab=_82047_/CLK }
C {devices/lab_pin.sym} 130410 -22090 0 0 {name=p129577 lab=_82101_/D }
C {devices/lab_pin.sym} 130590 -22110 0 1 {name=p129578 lab=_82101_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -22100 0 0 {name=X_82101_ }
C {devices/lab_pin.sym} 130460 -21970 0 0 {name=p129579 lab=_66915_/A }
C {devices/lab_pin.sym} 130540 -21970 0 1 {name=p129580 lab=_67035_/X }
C {sky130_stdcells/buf_2.sym} 130500 -21970 0 0 {name=X_67035_ }
C {devices/lab_pin.sym} 130460 -21850 0 0 {name=p129581 lab=_52618_/A }
C {devices/lab_pin.sym} 130540 -21850 0 1 {name=p129582 lab=_52262_/A }
C {sky130_stdcells/buf_2.sym} 130500 -21850 0 0 {name=X_52261_ }
C {devices/lab_pin.sym} 130460 -21730 0 0 {name=p129583 lab=_64306_/A }
C {devices/lab_pin.sym} 130540 -21730 0 1 {name=p129584 lab=_64248_/B }
C {sky130_stdcells/buf_2.sym} 130500 -21730 0 0 {name=X_64247_ }
C {devices/lab_pin.sym} 130410 -21610 0 0 {name=p129585 lab=_86525_/CLK }
C {devices/lab_pin.sym} 130410 -21590 0 0 {name=p129586 lab=_83081_/D }
C {devices/lab_pin.sym} 130590 -21610 0 1 {name=p129587 lab=_83081_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -21600 0 0 {name=X_83081_ }
C {devices/lab_pin.sym} 130460 -21470 0 0 {name=p129588 lab=_72561_/C }
C {devices/lab_pin.sym} 130540 -21470 0 1 {name=p129589 lab=_61459_/X }
C {sky130_stdcells/buf_2.sym} 130500 -21470 0 0 {name=X_61459_ }
C {devices/lab_pin.sym} 130460 -21350 0 0 {name=p129590 lab=_80293_/A }
C {devices/lab_pin.sym} 130540 -21350 0 1 {name=p129591 lab=_80293_/Y }
C {sky130_stdcells/inv_2.sym} 130500 -21350 0 0 {name=X_80293_ }
C {devices/lab_pin.sym} 130440 -21240 0 0 {name=p129592 lab=_53991_/A }
C {devices/lab_pin.sym} 130440 -21200 0 0 {name=p129593 lab=_52480_/B }
C {devices/lab_pin.sym} 130560 -21220 0 1 {name=p129594 lab=_54000_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -21220 0 0 {name=X_54000_ }
C {devices/lab_pin.sym} 130440 -21100 0 0 {name=p129595 lab=_51212_/A }
C {devices/lab_pin.sym} 130440 -21060 0 0 {name=p129596 lab=_47184_/X }
C {devices/lab_pin.sym} 130560 -21080 0 1 {name=p129597 lab=_51212_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -21080 0 0 {name=X_51212_ }
C {devices/lab_pin.sym} 130410 -20950 0 0 {name=p129598 lab=_82005_/CLK }
C {devices/lab_pin.sym} 130410 -20930 0 0 {name=p129599 lab=_77862_/B }
C {devices/lab_pin.sym} 130590 -20950 0 1 {name=p129600 lab=_82032_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -20940 0 0 {name=X_82032_ }
C {devices/lab_pin.sym} 130460 -20810 0 0 {name=p129601 lab=_50537_/A }
C {devices/lab_pin.sym} 130540 -20810 0 1 {name=p129602 lab=_52247_/A }
C {sky130_stdcells/buf_2.sym} 130500 -20810 0 0 {name=X_52192_ }
C {devices/lab_pin.sym} 130440 -20720 0 0 {name=p129603 lab=_63703_/B }
C {devices/lab_pin.sym} 130440 -20680 0 0 {name=p129604 lab=_64190_/B }
C {devices/lab_pin.sym} 130440 -20640 0 0 {name=p129605 lab=_64178_/C }
C {devices/lab_pin.sym} 130440 -20600 0 0 {name=p129606 lab=_64190_/D }
C {devices/lab_pin.sym} 130560 -20660 0 1 {name=p129607 lab=_64181_/B }
C {sky130_stdcells/nand4_4.sym} 130500 -20660 0 0 {name=X_64178_ }
C {devices/lab_pin.sym} 130420 -20530 0 0 {name=p129608 lab=_51140_/Y }
C {devices/lab_pin.sym} 130420 -20490 0 0 {name=p129609 lab=_51119_/X }
C {devices/lab_pin.sym} 130420 -20450 0 0 {name=p129610 lab=_51142_/X }
C {devices/lab_pin.sym} 130580 -20490 0 1 {name=p129611 lab=_86066_/D }
C {sky130_stdcells/a21oi_4.sym} 130500 -20490 0 0 {name=X_51143_ }
C {devices/lab_pin.sym} 130420 -20370 0 0 {name=p129612 lab=_84351_/Q }
C {devices/lab_pin.sym} 130420 -20330 0 0 {name=p129613 lab=_63072_/X }
C {devices/lab_pin.sym} 130420 -20290 0 0 {name=p129614 lab=_63128_/Y }
C {devices/lab_pin.sym} 130580 -20330 0 1 {name=p129615 lab=_84351_/D }
C {sky130_stdcells/a21o_4.sym} 130500 -20330 0 0 {name=X_63129_ }
C {devices/lab_pin.sym} 130410 -20190 0 0 {name=p129616 lab=_86841_/CLK }
C {devices/lab_pin.sym} 130410 -20170 0 0 {name=p129617 lab=_86840_/D }
C {devices/lab_pin.sym} 130590 -20190 0 1 {name=p129618 lab=_86840_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -20180 0 0 {name=X_86840_ }
C {devices/lab_pin.sym} 130440 -20060 0 0 {name=p129619 lab=_68982_/X }
C {devices/lab_pin.sym} 130440 -20020 0 0 {name=p129620 lab=_68985_/X }
C {devices/lab_pin.sym} 130560 -20040 0 1 {name=p129621 lab=_68986_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -20040 0 0 {name=X_68986_ }
C {devices/lab_pin.sym} 130460 -19910 0 0 {name=p129622 lab=_51074_/A }
C {devices/lab_pin.sym} 130540 -19910 0 1 {name=p129623 lab=_51129_/A }
C {sky130_stdcells/buf_2.sym} 130500 -19910 0 0 {name=X_51074_ }
C {devices/lab_pin.sym} 130420 -19810 0 0 {name=p129624 lab=_55948_/X }
C {devices/lab_pin.sym} 130420 -19770 0 0 {name=p129625 lab=_55950_/X }
C {devices/lab_pin.sym} 130420 -19730 0 0 {name=p129626 lab=_55615_/A }
C {devices/lab_pin.sym} 130580 -19770 0 1 {name=p129627 lab=_55954_/A }
C {sky130_stdcells/a21o_4.sym} 130500 -19770 0 0 {name=X_55951_ }
C {devices/lab_pin.sym} 130420 -19660 0 0 {name=p129628 lab=_87962_/Q }
C {devices/lab_pin.sym} 130420 -19620 0 0 {name=p129629 lab=_67888_/X }
C {devices/lab_pin.sym} 130420 -19580 0 0 {name=p129630 lab=_67865_/X }
C {devices/lab_pin.sym} 130420 -19540 0 0 {name=p129631 lab=_67936_/X }
C {devices/lab_pin.sym} 130580 -19600 0 1 {name=p129632 lab=_67937_/X }
C {sky130_stdcells/a211o_4.sym} 130500 -19600 0 0 {name=X_67937_ }
C {devices/lab_pin.sym} 130410 -19450 0 0 {name=p129633 lab=_84276_/CLK }
C {devices/lab_pin.sym} 130410 -19430 0 0 {name=p129634 lab=_86771_/D }
C {devices/lab_pin.sym} 130590 -19450 0 1 {name=p129635 lab=_43175_/B }
C {sky130_stdcells/dfxtp_4.sym} 130500 -19440 0 0 {name=X_86771_ }
C {devices/lab_pin.sym} 130410 -19310 0 0 {name=p129636 lab=_87671_/CLK }
C {devices/lab_pin.sym} 130410 -19290 0 0 {name=p129637 lab=_83983_/D }
C {devices/lab_pin.sym} 130590 -19310 0 1 {name=p129638 lab=_83983_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -19300 0 0 {name=X_83983_ }
C {devices/lab_pin.sym} 130440 -19200 0 0 {name=p129639 lab=_50025_/A }
C {devices/lab_pin.sym} 130440 -19160 0 0 {name=p129640 lab=_50040_/B }
C {devices/lab_pin.sym} 130440 -19120 0 0 {name=p129641 lab=_50025_/C }
C {devices/lab_pin.sym} 130440 -19080 0 0 {name=p129642 lab=_53238_/D }
C {devices/lab_pin.sym} 130560 -19140 0 1 {name=p129643 lab=_50025_/X }
C {sky130_stdcells/and4_4.sym} 130500 -19140 0 0 {name=X_50025_ }
C {devices/lab_pin.sym} 130420 -19010 0 0 {name=p129644 lab=_54899_/Y }
C {devices/lab_pin.sym} 130420 -18970 0 0 {name=p129645 lab=_54882_/X }
C {devices/lab_pin.sym} 130420 -18930 0 0 {name=p129646 lab=_54901_/X }
C {devices/lab_pin.sym} 130580 -18970 0 1 {name=p129647 lab=_85357_/D }
C {sky130_stdcells/a21oi_4.sym} 130500 -18970 0 0 {name=X_54902_ }
C {devices/lab_pin.sym} 130410 -18830 0 0 {name=p129648 lab=_84746_/CLK }
C {devices/lab_pin.sym} 130410 -18810 0 0 {name=p129649 lab=_85722_/D }
C {devices/lab_pin.sym} 130590 -18830 0 1 {name=p129650 lab=_85722_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -18820 0 0 {name=X_85722_ }
C {devices/lab_pin.sym} 130420 -18710 0 0 {name=p129651 lab=_58666_/Y }
C {devices/lab_pin.sym} 130420 -18670 0 0 {name=p129652 lab=_58669_/Y }
C {devices/lab_pin.sym} 130420 -18630 0 0 {name=p129653 lab=_58646_/X }
C {devices/lab_pin.sym} 130580 -18670 0 1 {name=p129654 lab=_58670_/X }
C {sky130_stdcells/a21o_4.sym} 130500 -18670 0 0 {name=X_58670_ }
C {devices/lab_pin.sym} 130410 -18530 0 0 {name=p129655 lab=_82933_/CLK }
C {devices/lab_pin.sym} 130410 -18510 0 0 {name=p129656 lab=_78278_/X }
C {devices/lab_pin.sym} 130590 -18530 0 1 {name=p129657 lab=_46380_/A }
C {sky130_stdcells/dfxtp_4.sym} 130500 -18520 0 0 {name=X_82934_ }
C {devices/lab_pin.sym} 130460 -18390 0 0 {name=p129658 lab=_67987_/A }
C {devices/lab_pin.sym} 130540 -18390 0 1 {name=p129659 lab=_67868_/X }
C {sky130_stdcells/buf_2.sym} 130500 -18390 0 0 {name=X_67868_ }
C {devices/lab_pin.sym} 130460 -18270 0 0 {name=p129660 lab=_55882_/A }
C {devices/lab_pin.sym} 130540 -18270 0 1 {name=p129661 lab=_74317_/C }
C {sky130_stdcells/buf_2.sym} 130500 -18270 0 0 {name=X_55882_ }
C {devices/lab_pin.sym} 130440 -18160 0 0 {name=p129662 lab=_57630_/A }
C {devices/lab_pin.sym} 130440 -18120 0 0 {name=p129663 lab=_53588_/B }
C {devices/lab_pin.sym} 130560 -18140 0 1 {name=p129664 lab=_57621_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -18140 0 0 {name=X_57621_ }
C {devices/lab_pin.sym} 130460 -18010 0 0 {name=p129665 lab=_69607_/A }
C {devices/lab_pin.sym} 130540 -18010 0 1 {name=p129666 lab=_69607_/X }
C {sky130_stdcells/buf_2.sym} 130500 -18010 0 0 {name=X_69607_ }
C {devices/lab_pin.sym} 130440 -17900 0 0 {name=p129667 lab=_54823_/A }
C {devices/lab_pin.sym} 130440 -17860 0 0 {name=p129668 lab=_47598_/A }
C {devices/lab_pin.sym} 130560 -17880 0 1 {name=p129669 lab=_54833_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -17880 0 0 {name=X_54833_ }
C {devices/lab_pin.sym} 130410 -17750 0 0 {name=p129670 lab=_85431_/CLK }
C {devices/lab_pin.sym} 130410 -17730 0 0 {name=p129671 lab=_53335_/Y }
C {devices/lab_pin.sym} 130590 -17750 0 1 {name=p129672 lab=_85653_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -17740 0 0 {name=X_85653_ }
C {devices/lab_pin.sym} 130440 -17620 0 0 {name=p129673 lab=_66819_/A }
C {devices/lab_pin.sym} 130440 -17580 0 0 {name=p129674 lab=_66819_/B }
C {devices/lab_pin.sym} 130560 -17600 0 1 {name=p129675 lab=_66819_/X }
C {sky130_stdcells/and2_4.sym} 130500 -17600 0 0 {name=X_66819_ }
C {devices/lab_pin.sym} 130410 -17470 0 0 {name=p129676 lab=_82859_/CLK }
C {devices/lab_pin.sym} 130410 -17450 0 0 {name=p129677 lab=_82489_/Q }
C {devices/lab_pin.sym} 130590 -17470 0 1 {name=p129678 lab=_82865_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -17460 0 0 {name=X_82865_ }
C {devices/lab_pin.sym} 130460 -17330 0 0 {name=p129679 lab=_68429_/A }
C {devices/lab_pin.sym} 130540 -17330 0 1 {name=p129680 lab=_67799_/X }
C {sky130_stdcells/buf_2.sym} 130500 -17330 0 0 {name=X_67799_ }
C {devices/lab_pin.sym} 130410 -17210 0 0 {name=p129681 lab=_84333_/CLK }
C {devices/lab_pin.sym} 130410 -17190 0 0 {name=p129682 lab=_60537_/Y }
C {devices/lab_pin.sym} 130590 -17210 0 1 {name=p129683 lab=_79144_/A }
C {sky130_stdcells/dfxtp_4.sym} 130500 -17200 0 0 {name=X_84604_ }
C {devices/lab_pin.sym} 130460 -17070 0 0 {name=p129684 lab=_72017_/A }
C {devices/lab_pin.sym} 130540 -17070 0 1 {name=p129685 lab=_57552_/X }
C {sky130_stdcells/buf_2.sym} 130500 -17070 0 0 {name=X_57552_ }
C {devices/lab_pin.sym} 130410 -16950 0 0 {name=p129686 lab=_81696_/CLK }
C {devices/lab_pin.sym} 130410 -16930 0 0 {name=p129687 lab=_81624_/Q }
C {devices/lab_pin.sym} 130590 -16950 0 1 {name=p129688 lab=_81816_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -16940 0 0 {name=X_81816_ }
C {devices/lab_pin.sym} 130420 -16830 0 0 {name=p129689 lab=_69535_/X }
C {devices/lab_pin.sym} 130420 -16790 0 0 {name=p129690 lab=_69537_/X }
C {devices/lab_pin.sym} 130420 -16750 0 0 {name=p129691 lab=_69433_/X }
C {devices/lab_pin.sym} 130580 -16790 0 1 {name=p129692 lab=_69538_/Y }
C {sky130_stdcells/a21oi_4.sym} 130500 -16790 0 0 {name=X_69538_ }
C {devices/lab_pin.sym} 130410 -16650 0 0 {name=p129693 lab=_87416_/CLK }
C {devices/lab_pin.sym} 130410 -16630 0 0 {name=p129694 lab=_40549_/X }
C {devices/lab_pin.sym} 130590 -16650 0 1 {name=p129695 lab=_88372_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -16640 0 0 {name=X_88372_ }
C {devices/lab_pin.sym} 130420 -16530 0 0 {name=p129696 lab=_85382_/Q }
C {devices/lab_pin.sym} 130420 -16490 0 0 {name=p129697 lab=_54757_/X }
C {devices/lab_pin.sym} 130420 -16450 0 0 {name=p129698 lab=_54763_/Y }
C {devices/lab_pin.sym} 130580 -16490 0 1 {name=p129699 lab=_54764_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -16490 0 0 {name=X_54764_ }
C {devices/lab_pin.sym} 130410 -16350 0 0 {name=p129700 lab=_83562_/CLK }
C {devices/lab_pin.sym} 130410 -16330 0 0 {name=p129701 lab=_85584_/D }
C {devices/lab_pin.sym} 130590 -16350 0 1 {name=p129702 lab=_85584_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -16340 0 0 {name=X_85584_ }
C {devices/lab_pin.sym} 130420 -16230 0 0 {name=p129703 lab=_66022_/B }
C {devices/lab_pin.sym} 130420 -16190 0 0 {name=p129704 lab=_51960_/X }
C {devices/lab_pin.sym} 130420 -16150 0 0 {name=p129705 lab=_51975_/Y }
C {devices/lab_pin.sym} 130580 -16190 0 1 {name=p129706 lab=_51976_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -16190 0 0 {name=X_51976_ }
C {devices/lab_pin.sym} 130410 -16050 0 0 {name=p129707 lab=_82463_/CLK }
C {devices/lab_pin.sym} 130410 -16030 0 0 {name=p129708 lab=_82828_/Q }
C {devices/lab_pin.sym} 130590 -16050 0 1 {name=p129709 lab=_82796_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -16040 0 0 {name=X_82796_ }
C {devices/lab_pin.sym} 130440 -15930 0 0 {name=p129710 lab=_56510_/A }
C {devices/lab_pin.sym} 130440 -15890 0 0 {name=p129711 lab=_56507_/B }
C {devices/lab_pin.sym} 130440 -15850 0 0 {name=p129712 lab=_55857_/B }
C {devices/lab_pin.sym} 130560 -15890 0 1 {name=p129713 lab=_56503_/Y }
C {sky130_stdcells/nand3_4.sym} 130500 -15890 0 0 {name=X_56503_ }
C {devices/lab_pin.sym} 130410 -15750 0 0 {name=p129714 lab=_88327_/CLK }
C {devices/lab_pin.sym} 130410 -15730 0 0 {name=p129715 lab=_43663_/Y }
C {devices/lab_pin.sym} 130590 -15750 0 1 {name=p129716 lab=_43660_/A }
C {sky130_stdcells/dfxtp_4.sym} 130500 -15740 0 0 {name=X_87323_ }
C {devices/lab_pin.sym} 130460 -15610 0 0 {name=p129717 lab=_53747_/A }
C {devices/lab_pin.sym} 130540 -15610 0 1 {name=p129718 lab=_53715_/X }
C {sky130_stdcells/buf_2.sym} 130500 -15610 0 0 {name=X_53715_ }
C {devices/lab_pin.sym} 130410 -15490 0 0 {name=p129719 lab=_84534_/CLK }
C {devices/lab_pin.sym} 130410 -15470 0 0 {name=p129720 lab=_84535_/D }
C {devices/lab_pin.sym} 130590 -15490 0 1 {name=p129721 lab=_76983_/A }
C {sky130_stdcells/dfxtp_4.sym} 130500 -15480 0 0 {name=X_84535_ }
C {devices/lab_pin.sym} 130420 -15370 0 0 {name=p129722 lab=_86105_/Q }
C {devices/lab_pin.sym} 130420 -15330 0 0 {name=p129723 lab=_50910_/X }
C {devices/lab_pin.sym} 130420 -15290 0 0 {name=p129724 lab=_50926_/Y }
C {devices/lab_pin.sym} 130580 -15330 0 1 {name=p129725 lab=_50927_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -15330 0 0 {name=X_50927_ }
C {devices/lab_pin.sym} 130410 -15190 0 0 {name=p129726 lab=_81756_/CLK }
C {devices/lab_pin.sym} 130410 -15170 0 0 {name=p129727 lab=_81747_/D }
C {devices/lab_pin.sym} 130590 -15190 0 1 {name=p129728 lab=_41703_/B }
C {sky130_stdcells/dfxtp_4.sym} 130500 -15180 0 0 {name=X_81747_ }
C {devices/lab_pin.sym} 130440 -15070 0 0 {name=p129729 lab=_44282_/X }
C {devices/lab_pin.sym} 130440 -15030 0 0 {name=p129730 lab=_55219_/B }
C {devices/lab_pin.sym} 130440 -14990 0 0 {name=p129731 lab=_57440_/A }
C {devices/lab_pin.sym} 130560 -15030 0 1 {name=p129732 lab=_57485_/B }
C {sky130_stdcells/or3_4.sym} 130500 -15030 0 0 {name=X_57483_ }
C {devices/lab_pin.sym} 130440 -14900 0 0 {name=p129733 lab=_69305_/A }
C {devices/lab_pin.sym} 130440 -14860 0 0 {name=p129734 lab=_69469_/B }
C {devices/lab_pin.sym} 130560 -14880 0 1 {name=p129735 lab=_69469_/X }
C {sky130_stdcells/and2_4.sym} 130500 -14880 0 0 {name=X_69469_ }
C {devices/lab_pin.sym} 130440 -14780 0 0 {name=p129736 lab=_54674_/A }
C {devices/lab_pin.sym} 130440 -14740 0 0 {name=p129737 lab=_54707_/B }
C {devices/lab_pin.sym} 130440 -14700 0 0 {name=p129738 lab=_54674_/C }
C {devices/lab_pin.sym} 130440 -14660 0 0 {name=p129739 lab=_47355_/Y }
C {devices/lab_pin.sym} 130560 -14720 0 1 {name=p129740 lab=_54695_/X }
C {sky130_stdcells/and4_4.sym} 130500 -14720 0 0 {name=X_54695_ }
C {devices/lab_pin.sym} 130440 -14590 0 0 {name=p129741 lab=_71500_/A }
C {devices/lab_pin.sym} 130440 -14550 0 0 {name=p129742 lab=_71256_/B }
C {devices/lab_pin.sym} 130440 -14510 0 0 {name=p129743 lab=_71500_/C }
C {devices/lab_pin.sym} 130560 -14550 0 1 {name=p129744 lab=_71500_/Y }
C {sky130_stdcells/nand3_4.sym} 130500 -14550 0 0 {name=X_71500_ }
C {devices/lab_pin.sym} 130420 -14430 0 0 {name=p129745 lab=_59208_/X }
C {devices/lab_pin.sym} 130420 -14390 0 0 {name=p129746 lab=_86063_/Q }
C {devices/lab_pin.sym} 130420 -14350 0 0 {name=p129747 lab=_59221_/X }
C {devices/lab_pin.sym} 130580 -14390 0 1 {name=p129748 lab=_59222_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -14390 0 0 {name=X_59222_ }
C {devices/lab_pin.sym} 130420 -14270 0 0 {name=p129749 lab=_56130_/X }
C {devices/lab_pin.sym} 130420 -14230 0 0 {name=p129750 lab=_56426_/X }
C {devices/lab_pin.sym} 130420 -14190 0 0 {name=p129751 lab=_56433_/Y }
C {devices/lab_pin.sym} 130580 -14230 0 1 {name=p129752 lab=_85195_/D }
C {sky130_stdcells/o21ai_4.sym} 130500 -14230 0 0 {name=X_56434_ }
C {devices/lab_pin.sym} 130460 -14090 0 0 {name=p129753 lab=_41482_/A }
C {devices/lab_pin.sym} 130540 -14090 0 1 {name=p129754 lab=_41660_/X }
C {sky130_stdcells/buf_2.sym} 130500 -14090 0 0 {name=X_41660_ }
C {devices/lab_pin.sym} 130410 -13970 0 0 {name=p129755 lab=_87790_/CLK }
C {devices/lab_pin.sym} 130410 -13950 0 0 {name=p129756 lab=_43815_/X }
C {devices/lab_pin.sym} 130590 -13970 0 1 {name=p129757 lab=_87254_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -13960 0 0 {name=X_87254_ }
C {devices/lab_pin.sym} 130420 -13850 0 0 {name=p129758 lab=_53644_/Y }
C {devices/lab_pin.sym} 130420 -13810 0 0 {name=p129759 lab=_53603_/X }
C {devices/lab_pin.sym} 130420 -13770 0 0 {name=p129760 lab=_53645_/Y }
C {devices/lab_pin.sym} 130580 -13810 0 1 {name=p129761 lab=_85596_/D }
C {sky130_stdcells/a21boi_4.sym} 130500 -13810 0 0 {name=X_53646_ }
C {devices/lab_pin.sym} 130420 -13690 0 0 {name=p129762 lab=_65308_/X }
C {devices/lab_pin.sym} 130420 -13650 0 0 {name=p129763 lab=_85666_/Q }
C {devices/lab_pin.sym} 130420 -13610 0 0 {name=p129764 lab=_72422_/X }
C {devices/lab_pin.sym} 130580 -13650 0 1 {name=p129765 lab=_72480_/X }
C {sky130_stdcells/o21a_4.sym} 130500 -13650 0 0 {name=X_72480_ }
C {devices/lab_pin.sym} 130410 -13510 0 0 {name=p129766 lab=_84469_/CLK }
C {devices/lab_pin.sym} 130410 -13490 0 0 {name=p129767 lab=_61616_/Y }
C {devices/lab_pin.sym} 130590 -13510 0 1 {name=p129768 lab=_79134_/B }
C {sky130_stdcells/dfxtp_4.sym} 130500 -13500 0 0 {name=X_84466_ }
C {devices/lab_pin.sym} 130440 -13380 0 0 {name=p129769 lab=_50857_/X }
C {devices/lab_pin.sym} 130440 -13340 0 0 {name=p129770 lab=_50858_/B }
C {devices/lab_pin.sym} 130560 -13360 0 1 {name=p129771 lab=_50858_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -13360 0 0 {name=X_50858_ }
C {devices/lab_pin.sym} 130410 -13230 0 0 {name=p129772 lab=_81259_/CLK }
C {devices/lab_pin.sym} 130410 -13210 0 0 {name=p129773 lab=_80056_/X }
C {devices/lab_pin.sym} 130590 -13230 0 1 {name=p129774 lab=_76907_/A }
C {sky130_stdcells/dfxtp_4.sym} 130500 -13220 0 0 {name=X_81678_ }
C {devices/lab_pin.sym} 130410 -13090 0 0 {name=p129775 lab=_85884_/CLK }
C {devices/lab_pin.sym} 130410 -13070 0 0 {name=p129776 lab=_86205_/D }
C {devices/lab_pin.sym} 130590 -13090 0 1 {name=p129777 lab=_86205_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -13080 0 0 {name=X_86205_ }
C {devices/lab_pin.sym} 130460 -12950 0 0 {name=p129778 lab=_40568_/A }
C {devices/lab_pin.sym} 130540 -12950 0 1 {name=p129779 lab=_40832_/A }
C {sky130_stdcells/buf_2.sym} 130500 -12950 0 0 {name=X_40611_ }
C {devices/lab_pin.sym} 130460 -12830 0 0 {name=p129780 lab=_59238_/A }
C {devices/lab_pin.sym} 130540 -12830 0 1 {name=p129781 lab=_59154_/A }
C {sky130_stdcells/buf_2.sym} 130500 -12830 0 0 {name=X_59153_ }
C {devices/lab_pin.sym} 130420 -12730 0 0 {name=p129782 lab=_71420_/X }
C {devices/lab_pin.sym} 130420 -12690 0 0 {name=p129783 lab=_83502_/Q }
C {devices/lab_pin.sym} 130420 -12650 0 0 {name=p129784 lab=_71430_/X }
C {devices/lab_pin.sym} 130580 -12690 0 1 {name=p129785 lab=_83502_/D }
C {sky130_stdcells/a21o_4.sym} 130500 -12690 0 0 {name=X_71431_ }
C {devices/lab_pin.sym} 130410 -12550 0 0 {name=p129786 lab=_83415_/CLK }
C {devices/lab_pin.sym} 130410 -12530 0 0 {name=p129787 lab=_71673_/Y }
C {devices/lab_pin.sym} 130590 -12550 0 1 {name=p129788 lab=_83417_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -12540 0 0 {name=X_83417_ }
C {devices/lab_pin.sym} 130440 -12430 0 0 {name=p129789 lab=_56360_/A }
C {devices/lab_pin.sym} 130440 -12390 0 0 {name=p129790 lab=_56363_/B }
C {devices/lab_pin.sym} 130440 -12350 0 0 {name=p129791 lab=_55713_/B }
C {devices/lab_pin.sym} 130560 -12390 0 1 {name=p129792 lab=_56365_/Y }
C {sky130_stdcells/nand3_4.sym} 130500 -12390 0 0 {name=X_56365_ }
C {devices/lab_pin.sym} 130440 -12260 0 0 {name=p129793 lab=_80629_/A }
C {devices/lab_pin.sym} 130440 -12220 0 0 {name=p129794 lab=_80629_/B }
C {devices/lab_pin.sym} 130560 -12240 0 1 {name=p129795 lab=_80630_/B }
C {sky130_stdcells/xor2_4.sym} 130500 -12240 0 0 {name=X_80629_ }
C {devices/lab_pin.sym} 130410 -12110 0 0 {name=p129796 lab=_83753_/CLK }
C {devices/lab_pin.sym} 130410 -12090 0 0 {name=p129797 lab=_87185_/D }
C {devices/lab_pin.sym} 130590 -12110 0 1 {name=p129798 lab=_44160_/B }
C {sky130_stdcells/dfxtp_4.sym} 130500 -12100 0 0 {name=X_87185_ }
C {devices/lab_pin.sym} 130440 -11980 0 0 {name=p129799 lab=_53548_/A }
C {devices/lab_pin.sym} 130440 -11940 0 0 {name=p129800 lab=_48081_/Y }
C {devices/lab_pin.sym} 130560 -11960 0 1 {name=p129801 lab=_53577_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -11960 0 0 {name=X_53577_ }
C {devices/lab_pin.sym} 130420 -11850 0 0 {name=p129802 lab=_41588_/X }
C {devices/lab_pin.sym} 130420 -11810 0 0 {name=p129803 lab=_82312_/Q }
C {devices/lab_pin.sym} 130420 -11770 0 0 {name=p129804 lab=_41590_/X }
C {devices/lab_pin.sym} 130580 -11810 0 1 {name=p129805 lab=_41591_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -11810 0 0 {name=X_41591_ }
C {devices/lab_pin.sym} 130410 -11670 0 0 {name=p129806 lab=_84393_/CLK }
C {devices/lab_pin.sym} 130410 -11650 0 0 {name=p129807 lab=_84397_/D }
C {devices/lab_pin.sym} 130590 -11670 0 1 {name=p129808 lab=_62606_/C }
C {sky130_stdcells/dfxtp_4.sym} 130500 -11660 0 0 {name=X_84397_ }
C {devices/lab_pin.sym} 130420 -11550 0 0 {name=p129809 lab=_50786_/Y }
C {devices/lab_pin.sym} 130420 -11510 0 0 {name=p129810 lab=_50768_/X }
C {devices/lab_pin.sym} 130420 -11470 0 0 {name=p129811 lab=_50788_/Y }
C {devices/lab_pin.sym} 130580 -11510 0 1 {name=p129812 lab=_86133_/D }
C {sky130_stdcells/a21boi_4.sym} 130500 -11510 0 0 {name=X_50789_ }
C {devices/lab_pin.sym} 130460 -11370 0 0 {name=p129813 lab=clkbuf_4_3_0_CLK/X }
C {devices/lab_pin.sym} 130540 -11370 0 1 {name=p129814 lab=clkbuf_5_7_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 130500 -11370 0 0 {name=Xclkbuf_4_3_1_CLK }
C {devices/lab_pin.sym} 130420 -11270 0 0 {name=p129815 lab=_58043_/X }
C {devices/lab_pin.sym} 130420 -11230 0 0 {name=p129816 lab=_85989_/Q }
C {devices/lab_pin.sym} 130420 -11190 0 0 {name=p129817 lab=_58103_/X }
C {devices/lab_pin.sym} 130580 -11230 0 1 {name=p129818 lab=_58104_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -11230 0 0 {name=X_58104_ }
C {devices/lab_pin.sym} 130420 -11110 0 0 {name=p129819 lab=_55310_/X }
C {devices/lab_pin.sym} 130420 -11070 0 0 {name=p129820 lab=_55315_/X }
C {devices/lab_pin.sym} 130420 -11030 0 0 {name=p129821 lab=_83751_/Q }
C {devices/lab_pin.sym} 130580 -11070 0 1 {name=p129822 lab=_55316_/X }
C {sky130_stdcells/a21o_4.sym} 130500 -11070 0 0 {name=X_55316_ }
C {devices/lab_pin.sym} 130460 -10930 0 0 {name=p129823 lab=_43329_/X }
C {devices/lab_pin.sym} 130540 -10930 0 1 {name=p129824 lab=_43330_/X }
C {sky130_stdcells/buf_2.sym} 130500 -10930 0 0 {name=X_43330_ }
C {devices/lab_pin.sym} 130440 -10820 0 0 {name=p129825 lab=_74232_/A }
C {devices/lab_pin.sym} 130440 -10780 0 0 {name=p129826 lab=_85896_/Q }
C {devices/lab_pin.sym} 130560 -10800 0 1 {name=p129827 lab=_74150_/X }
C {sky130_stdcells/and2_4.sym} 130500 -10800 0 0 {name=X_74150_ }
C {devices/lab_pin.sym} 130410 -10670 0 0 {name=p129828 lab=_85529_/CLK }
C {devices/lab_pin.sym} 130410 -10650 0 0 {name=p129829 lab=_86136_/D }
C {devices/lab_pin.sym} 130590 -10670 0 1 {name=p129830 lab=_86136_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -10660 0 0 {name=X_86136_ }
C {devices/lab_pin.sym} 130460 -10530 0 0 {name=p129831 lab=_40541_/Y }
C {devices/lab_pin.sym} 130540 -10530 0 1 {name=p129832 lab=_40542_/X }
C {sky130_stdcells/buf_2.sym} 130500 -10530 0 0 {name=X_40542_ }
C {devices/lab_pin.sym} 130440 -10430 0 0 {name=p129833 lab=_52528_/A }
C {devices/lab_pin.sym} 130440 -10390 0 0 {name=p129834 lab=_52509_/B }
C {devices/lab_pin.sym} 130440 -10350 0 0 {name=p129835 lab=_52498_/C }
C {devices/lab_pin.sym} 130560 -10390 0 1 {name=p129836 lab=_52528_/X }
C {sky130_stdcells/and3_4.sym} 130500 -10390 0 0 {name=X_52528_ }
C {devices/lab_pin.sym} 130460 -10250 0 0 {name=p129837 lab=_64621_/A }
C {devices/lab_pin.sym} 130540 -10250 0 1 {name=p129838 lab=_59085_/A }
C {sky130_stdcells/buf_2.sym} 130500 -10250 0 0 {name=X_59084_ }
C {devices/lab_pin.sym} 130420 -10150 0 0 {name=p129839 lab=_71344_/X }
C {devices/lab_pin.sym} 130420 -10110 0 0 {name=p129840 lab=_83525_/Q }
C {devices/lab_pin.sym} 130420 -10070 0 0 {name=p129841 lab=_71361_/X }
C {devices/lab_pin.sym} 130580 -10110 0 1 {name=p129842 lab=_71362_/X }
C {sky130_stdcells/a21o_4.sym} 130500 -10110 0 0 {name=X_71362_ }
C {devices/lab_pin.sym} 130410 -9970 0 0 {name=p129843 lab=_82251_/CLK }
C {devices/lab_pin.sym} 130410 -9950 0 0 {name=p129844 lab=_83348_/D }
C {devices/lab_pin.sym} 130590 -9970 0 1 {name=p129845 lab=_83348_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -9960 0 0 {name=X_83348_ }
C {devices/lab_pin.sym} 130440 -9850 0 0 {name=p129846 lab=_56296_/A }
C {devices/lab_pin.sym} 130440 -9810 0 0 {name=p129847 lab=_56270_/B }
C {devices/lab_pin.sym} 130440 -9770 0 0 {name=p129848 lab=_55958_/B }
C {devices/lab_pin.sym} 130560 -9810 0 1 {name=p129849 lab=_56296_/Y }
C {sky130_stdcells/nand3_4.sym} 130500 -9810 0 0 {name=X_56296_ }
C {devices/lab_pin.sym} 130440 -9690 0 0 {name=p129850 lab=_73099_/X }
C {devices/lab_pin.sym} 130440 -9650 0 0 {name=p129851 lab=_73101_/B }
C {devices/lab_pin.sym} 130440 -9610 0 0 {name=p129852 lab=_73101_/C }
C {devices/lab_pin.sym} 130560 -9650 0 1 {name=p129853 lab=_73101_/Y }
C {sky130_stdcells/nand3_4.sym} 130500 -9650 0 0 {name=X_73101_ }
C {devices/lab_pin.sym} 130460 -9510 0 0 {name=p129854 lab=_58610_/A }
C {devices/lab_pin.sym} 130540 -9510 0 1 {name=p129855 lab=_58035_/X }
C {sky130_stdcells/buf_2.sym} 130500 -9510 0 0 {name=X_58035_ }
C {devices/lab_pin.sym} 130440 -9420 0 0 {name=p129856 lab=_70328_/A }
C {devices/lab_pin.sym} 130440 -9380 0 0 {name=p129857 lab=_70328_/B }
C {devices/lab_pin.sym} 130440 -9340 0 0 {name=p129858 lab=_70313_/C }
C {devices/lab_pin.sym} 130440 -9300 0 0 {name=p129859 lab=_70328_/D }
C {devices/lab_pin.sym} 130560 -9360 0 1 {name=p129860 lab=_70313_/X }
C {sky130_stdcells/and4_4.sym} 130500 -9360 0 0 {name=X_70313_ }
C {devices/lab_pin.sym} 130420 -9250 0 0 {name=p129861 lab=_43260_/X }
C {devices/lab_pin.sym} 130420 -9210 0 0 {name=p129862 lab=_43244_/X }
C {devices/lab_pin.sym} 130420 -9170 0 0 {name=p129863 lab=_41087_/X }
C {devices/lab_pin.sym} 130420 -9130 0 0 {name=p129864 lab=_87512_/Q }
C {devices/lab_pin.sym} 130420 -9090 0 0 {name=p129865 lab=_43250_/X }
C {devices/lab_pin.sym} 130580 -9170 0 1 {name=p129866 lab=_43261_/Y }
C {sky130_stdcells/o32ai_4.sym} 130500 -9170 0 0 {name=X_43261_ }
C {devices/lab_pin.sym} 130420 -9040 0 0 {name=p129867 lab=_85096_/Q }
C {devices/lab_pin.sym} 130420 -9000 0 0 {name=p129868 lab=_55272_/A }
C {devices/lab_pin.sym} 130420 -8960 0 0 {name=p129869 lab=_44044_/X }
C {devices/lab_pin.sym} 130420 -8920 0 0 {name=p129870 lab=_55246_/X }
C {devices/lab_pin.sym} 130580 -8980 0 1 {name=p129871 lab=_55247_/X }
C {sky130_stdcells/a211o_4.sym} 130500 -8980 0 0 {name=X_55247_ }
C {devices/lab_pin.sym} 130440 -8840 0 0 {name=p129872 lab=_73583_/A }
C {devices/lab_pin.sym} 130440 -8800 0 0 {name=p129873 lab=_85899_/Q }
C {devices/lab_pin.sym} 130560 -8820 0 1 {name=p129874 lab=_74081_/X }
C {sky130_stdcells/and2_4.sym} 130500 -8820 0 0 {name=X_74081_ }
C {devices/lab_pin.sym} 130410 -8690 0 0 {name=p129875 lab=_85748_/CLK }
C {devices/lab_pin.sym} 130410 -8670 0 0 {name=p129876 lab=_51138_/Y }
C {devices/lab_pin.sym} 130590 -8690 0 1 {name=p129877 lab=_86067_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -8680 0 0 {name=X_86067_ }
C {devices/lab_pin.sym} 130420 -8570 0 0 {name=p129878 lab=_40456_/X }
C {devices/lab_pin.sym} 130420 -8530 0 0 {name=p129879 lab=_81168_/Q }
C {devices/lab_pin.sym} 130420 -8490 0 0 {name=p129880 lab=_40472_/X }
C {devices/lab_pin.sym} 130580 -8530 0 1 {name=p129881 lab=_40473_/X }
C {sky130_stdcells/o21a_4.sym} 130500 -8530 0 0 {name=X_40473_ }
C {devices/lab_pin.sym} 130420 -8410 0 0 {name=p129882 lab=_52457_/Y }
C {devices/lab_pin.sym} 130420 -8370 0 0 {name=p129883 lab=_52430_/X }
C {devices/lab_pin.sym} 130420 -8330 0 0 {name=p129884 lab=_52458_/Y }
C {devices/lab_pin.sym} 130580 -8370 0 1 {name=p129885 lab=_85818_/D }
C {sky130_stdcells/a21boi_4.sym} 130500 -8370 0 0 {name=X_52459_ }
C {devices/lab_pin.sym} 130460 -8230 0 0 {name=p129886 lab=_71308_/A }
C {devices/lab_pin.sym} 130540 -8230 0 1 {name=p129887 lab=_71303_/A }
C {sky130_stdcells/buf_2.sym} 130500 -8230 0 0 {name=X_71293_ }
C {devices/lab_pin.sym} 130410 -8110 0 0 {name=p129888 lab=_86301_/CLK }
C {devices/lab_pin.sym} 130410 -8090 0 0 {name=p129889 lab=_83279_/D }
C {devices/lab_pin.sym} 130590 -8110 0 1 {name=p129890 lab=_83279_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -8100 0 0 {name=X_83279_ }
C {devices/lab_pin.sym} 130420 -7990 0 0 {name=p129891 lab=_56208_/C }
C {devices/lab_pin.sym} 130420 -7950 0 0 {name=p129892 lab=_44998_/X }
C {devices/lab_pin.sym} 130420 -7910 0 0 {name=p129893 lab=_44999_/X }
C {devices/lab_pin.sym} 130580 -7950 0 1 {name=p129894 lab=_45000_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -7950 0 0 {name=X_45000_ }
C {devices/lab_pin.sym} 130420 -7850 0 0 {name=p129895 lab=_42205_/X }
C {devices/lab_pin.sym} 130420 -7810 0 0 {name=p129896 lab=_42200_/X }
C {devices/lab_pin.sym} 130420 -7770 0 0 {name=p129897 lab=_41332_/X }
C {devices/lab_pin.sym} 130420 -7730 0 0 {name=p129898 lab=_87978_/Q }
C {devices/lab_pin.sym} 130420 -7690 0 0 {name=p129899 lab=_42201_/X }
C {devices/lab_pin.sym} 130580 -7770 0 1 {name=p129900 lab=_42212_/Y }
C {sky130_stdcells/o32ai_4.sym} 130500 -7770 0 0 {name=X_42212_ }
C {devices/lab_pin.sym} 130460 -7610 0 0 {name=p129901 lab=_44305_/X }
C {devices/lab_pin.sym} 130540 -7610 0 1 {name=p129902 lab=_73372_/B }
C {sky130_stdcells/buf_2.sym} 130500 -7610 0 0 {name=X_73032_ }
C {devices/lab_pin.sym} 130410 -7490 0 0 {name=p129903 lab=_85049_/CLK }
C {devices/lab_pin.sym} 130410 -7470 0 0 {name=p129904 lab=_85018_/D }
C {devices/lab_pin.sym} 130590 -7490 0 1 {name=p129905 lab=_85018_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -7480 0 0 {name=X_85018_ }
C {devices/lab_pin.sym} 130420 -7370 0 0 {name=p129906 lab=_70238_/X }
C {devices/lab_pin.sym} 130420 -7330 0 0 {name=p129907 lab=_74797_/A }
C {devices/lab_pin.sym} 130420 -7290 0 0 {name=p129908 lab=_70243_/X }
C {devices/lab_pin.sym} 130580 -7330 0 1 {name=p129909 lab=_83824_/D }
C {sky130_stdcells/a21o_4.sym} 130500 -7330 0 0 {name=X_70244_ }
C {devices/lab_pin.sym} 130460 -7190 0 0 {name=p129910 lab=_87545_/Q }
C {devices/lab_pin.sym} 130540 -7190 0 1 {name=p129911 lab=_43192_/Y }
C {sky130_stdcells/inv_2.sym} 130500 -7190 0 0 {name=X_43192_ }
C {devices/lab_pin.sym} 130420 -7100 0 0 {name=p129912 lab=_45727_/A }
C {devices/lab_pin.sym} 130420 -7060 0 0 {name=p129913 lab=_44059_/X }
C {devices/lab_pin.sym} 130420 -7020 0 0 {name=p129914 lab=_55172_/X }
C {devices/lab_pin.sym} 130420 -6980 0 0 {name=p129915 lab=_55177_/Y }
C {devices/lab_pin.sym} 130580 -7040 0 1 {name=p129916 lab=_55178_/X }
C {sky130_stdcells/a211o_4.sym} 130500 -7040 0 0 {name=X_55178_ }
C {devices/lab_pin.sym} 130420 -6930 0 0 {name=p129917 lab=_42120_/X }
C {devices/lab_pin.sym} 130420 -6890 0 0 {name=p129918 lab=_42141_/X }
C {devices/lab_pin.sym} 130420 -6850 0 0 {name=p129919 lab=_41139_/X }
C {devices/lab_pin.sym} 130420 -6810 0 0 {name=p129920 lab=_88014_/Q }
C {devices/lab_pin.sym} 130420 -6770 0 0 {name=p129921 lab=_42142_/X }
C {devices/lab_pin.sym} 130580 -6850 0 1 {name=p129922 lab=_42143_/Y }
C {sky130_stdcells/o32ai_4.sym} 130500 -6850 0 0 {name=X_42143_ }
C {devices/lab_pin.sym} 130420 -6710 0 0 {name=p129923 lab=_54126_/Y }
C {devices/lab_pin.sym} 130420 -6670 0 0 {name=p129924 lab=_54117_/X }
C {devices/lab_pin.sym} 130420 -6630 0 0 {name=p129925 lab=_54128_/X }
C {devices/lab_pin.sym} 130580 -6670 0 1 {name=p129926 lab=_85499_/D }
C {sky130_stdcells/a21oi_4.sym} 130500 -6670 0 0 {name=X_54129_ }
C {devices/lab_pin.sym} 130420 -6550 0 0 {name=p129927 lab=_77825_/A }
C {devices/lab_pin.sym} 130420 -6510 0 0 {name=p129928 lab=_81933_/D }
C {devices/lab_pin.sym} 130420 -6470 0 0 {name=p129929 lab=_77839_/X }
C {devices/lab_pin.sym} 130580 -6510 0 1 {name=p129930 lab=_77840_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -6510 0 0 {name=X_77840_ }
C {devices/lab_pin.sym} 130460 -6370 0 0 {name=p129931 lab=_70233_/A }
C {devices/lab_pin.sym} 130540 -6370 0 1 {name=p129932 lab=_70183_/D }
C {sky130_stdcells/buf_2.sym} 130500 -6370 0 0 {name=X_70175_ }
C {devices/lab_pin.sym} 130460 -6250 0 0 {name=p129933 lab=_59943_/X }
C {devices/lab_pin.sym} 130540 -6250 0 1 {name=p129934 lab=_62609_/D }
C {sky130_stdcells/buf_2.sym} 130500 -6250 0 0 {name=X_59986_ }
C {devices/lab_pin.sym} 130460 -6130 0 0 {name=p129935 lab=_82398_/Q }
C {devices/lab_pin.sym} 130540 -6130 0 1 {name=p129936 lab=_46952_/A }
C {sky130_stdcells/inv_2.sym} 130500 -6130 0 0 {name=X_46951_ }
C {devices/lab_pin.sym} 130420 -6040 0 0 {name=p129937 lab=_40964_/X }
C {devices/lab_pin.sym} 130420 -6000 0 0 {name=p129938 lab=_42072_/X }
C {devices/lab_pin.sym} 130420 -5960 0 0 {name=p129939 lab=_88046_/Q }
C {devices/lab_pin.sym} 130420 -5920 0 0 {name=p129940 lab=_42073_/X }
C {devices/lab_pin.sym} 130580 -5980 0 1 {name=p129941 lab=_42074_/X }
C {sky130_stdcells/a2bb2o_4.sym} 130500 -5980 0 0 {name=X_42074_ }
C {devices/lab_pin.sym} 130420 -5850 0 0 {name=p129942 lab=_58846_/X }
C {devices/lab_pin.sym} 130420 -5810 0 0 {name=p129943 lab=_85764_/Q }
C {devices/lab_pin.sym} 130420 -5770 0 0 {name=p129944 lab=_58847_/X }
C {devices/lab_pin.sym} 130580 -5810 0 1 {name=p129945 lab=_58937_/X }
C {sky130_stdcells/o21a_4.sym} 130500 -5810 0 0 {name=X_58937_ }
C {devices/lab_pin.sym} 130440 -5680 0 0 {name=p129946 lab=_81926_/D }
C {devices/lab_pin.sym} 130440 -5640 0 0 {name=p129947 lab=_77771_/B }
C {devices/lab_pin.sym} 130560 -5660 0 1 {name=p129948 lab=_77771_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -5660 0 0 {name=X_77771_ }
C {devices/lab_pin.sym} 130420 -5550 0 0 {name=p129949 lab=_74988_/A }
C {devices/lab_pin.sym} 130420 -5510 0 0 {name=p129950 lab=_74987_/A }
C {devices/lab_pin.sym} 130420 -5470 0 0 {name=p129951 lab=_74982_/Y }
C {devices/lab_pin.sym} 130580 -5510 0 1 {name=p129952 lab=_74983_/Y }
C {sky130_stdcells/a21boi_4.sym} 130500 -5510 0 0 {name=X_74983_ }
C {devices/lab_pin.sym} 130410 -5370 0 0 {name=p129953 lab=_87397_/CLK }
C {devices/lab_pin.sym} 130410 -5350 0 0 {name=p129954 lab=_86969_/D }
C {devices/lab_pin.sym} 130590 -5370 0 1 {name=p129955 lab=_86969_/Q }
C {sky130_stdcells/dfxtp_4.sym} 130500 -5360 0 0 {name=X_86969_ }
C {devices/lab_pin.sym} 130440 -5240 0 0 {name=p129956 lab=_79510_/A }
C {devices/lab_pin.sym} 130440 -5200 0 0 {name=p129957 lab=_79510_/B }
C {devices/lab_pin.sym} 130560 -5220 0 1 {name=p129958 lab=_79510_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -5220 0 0 {name=X_79510_ }
C {devices/lab_pin.sym} 130460 -5090 0 0 {name=p129959 lab=_45901_/X }
C {devices/lab_pin.sym} 130540 -5090 0 1 {name=p129960 lab=_45902_/Y }
C {sky130_stdcells/inv_2.sym} 130500 -5090 0 0 {name=X_45902_ }
C {devices/lab_pin.sym} 130460 -4970 0 0 {name=p129961 lab=_40932_/A }
C {devices/lab_pin.sym} 130540 -4970 0 1 {name=p129962 lab=_41091_/B }
C {sky130_stdcells/buf_2.sym} 130500 -4970 0 0 {name=X_41025_ }
C {devices/lab_pin.sym} 130420 -4870 0 0 {name=p129963 lab=_76720_/X }
C {devices/lab_pin.sym} 130420 -4830 0 0 {name=p129964 lab=_76709_/X }
C {devices/lab_pin.sym} 130420 -4790 0 0 {name=p129965 lab=_76721_/X }
C {devices/lab_pin.sym} 130580 -4830 0 1 {name=p129966 lab=_76722_/X }
C {sky130_stdcells/a21o_4.sym} 130500 -4830 0 0 {name=X_76722_ }
C {devices/lab_pin.sym} 130420 -4710 0 0 {name=p129967 lab=_49667_/Y }
C {devices/lab_pin.sym} 130420 -4670 0 0 {name=p129968 lab=_49650_/X }
C {devices/lab_pin.sym} 130420 -4630 0 0 {name=p129969 lab=_49669_/X }
C {devices/lab_pin.sym} 130580 -4670 0 1 {name=p129970 lab=_86345_/D }
C {sky130_stdcells/a21oi_4.sym} 130500 -4670 0 0 {name=X_49670_ }
C {devices/lab_pin.sym} 130440 -4540 0 0 {name=p129971 lab=_53531_/B }
C {devices/lab_pin.sym} 130440 -4500 0 0 {name=p129972 lab=_73933_/Y }
C {devices/lab_pin.sym} 130560 -4520 0 1 {name=p129973 lab=_73935_/B }
C {sky130_stdcells/xor2_4.sym} 130500 -4520 0 0 {name=X_73934_ }
C {devices/lab_pin.sym} 130460 -4390 0 0 {name=p129974 lab=_82949_/Q }
C {devices/lab_pin.sym} 130540 -4390 0 1 {name=p129975 lab=_54423_/D }
C {sky130_stdcells/inv_2.sym} 130500 -4390 0 0 {name=X_46882_ }
C {devices/lab_pin.sym} 130460 -4270 0 0 {name=p129976 lab=_58868_/A }
C {devices/lab_pin.sym} 130540 -4270 0 1 {name=p129977 lab=_58868_/X }
C {sky130_stdcells/buf_2.sym} 130500 -4270 0 0 {name=X_58868_ }
C {devices/lab_pin.sym} 130460 -4150 0 0 {name=p129978 lab=_48621_/A }
C {devices/lab_pin.sym} 130540 -4150 0 1 {name=p129979 lab=_52218_/A }
C {sky130_stdcells/buf_2.sym} 130500 -4150 0 0 {name=X_48621_ }
C {devices/lab_pin.sym} 130420 -4050 0 0 {name=p129980 lab=_79429_/A }
C {devices/lab_pin.sym} 130420 -4010 0 0 {name=p129981 lab=_79428_/Y }
C {devices/lab_pin.sym} 130420 -3970 0 0 {name=p129982 lab=_79440_/X }
C {devices/lab_pin.sym} 130580 -4010 0 1 {name=p129983 lab=_79441_/X }
C {sky130_stdcells/a21o_4.sym} 130500 -4010 0 0 {name=X_79441_ }
C {devices/lab_pin.sym} 130420 -3890 0 0 {name=p129984 lab=_45830_/X }
C {devices/lab_pin.sym} 130420 -3850 0 0 {name=p129985 lab=_45832_/Y }
C {devices/lab_pin.sym} 130420 -3810 0 0 {name=p129986 lab=_45803_/X }
C {devices/lab_pin.sym} 130580 -3850 0 1 {name=p129987 lab=_45833_/Y }
C {sky130_stdcells/a21oi_4.sym} 130500 -3850 0 0 {name=X_45833_ }
C {devices/lab_pin.sym} 130460 -3710 0 0 {name=p129988 lab=_57896_/A }
C {devices/lab_pin.sym} 130540 -3710 0 1 {name=p129989 lab=_57819_/X }
C {sky130_stdcells/buf_2.sym} 130500 -3710 0 0 {name=X_57819_ }
C {devices/lab_pin.sym} 130440 -3600 0 0 {name=p129990 lab=_76652_/Y }
C {devices/lab_pin.sym} 130440 -3560 0 0 {name=p129991 lab=_81394_/Q }
C {devices/lab_pin.sym} 130560 -3580 0 1 {name=p129992 lab=_76653_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -3580 0 0 {name=X_76653_ }
C {devices/lab_pin.sym} 130420 -3470 0 0 {name=p129993 lab=_73866_/B }
C {devices/lab_pin.sym} 130420 -3430 0 0 {name=p129994 lab=_73866_/C }
C {devices/lab_pin.sym} 130420 -3390 0 0 {name=p129995 lab=_73864_/X }
C {devices/lab_pin.sym} 130580 -3430 0 1 {name=p129996 lab=_73865_/X }
C {sky130_stdcells/a21o_4.sym} 130500 -3430 0 0 {name=X_73865_ }
C {devices/lab_pin.sym} 130460 -3290 0 0 {name=p129997 lab=clkbuf_9_230_0_CLK/X }
C {devices/lab_pin.sym} 130540 -3290 0 1 {name=p129998 lab=_85688_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 130500 -3290 0 0 {name=Xclkbuf_10_461_0_CLK }
C {devices/lab_pin.sym} 130420 -3190 0 0 {name=p129999 lab=_58795_/Y }
C {devices/lab_pin.sym} 130420 -3150 0 0 {name=p130000 lab=_58798_/Y }
C {devices/lab_pin.sym} 130420 -3110 0 0 {name=p130001 lab=_58761_/X }
C {devices/lab_pin.sym} 130580 -3150 0 1 {name=p130002 lab=_58799_/X }
C {sky130_stdcells/a21o_4.sym} 130500 -3150 0 0 {name=X_58799_ }
C {devices/lab_pin.sym} 130440 -3020 0 0 {name=p130003 lab=_80997_/Q }
C {devices/lab_pin.sym} 130440 -2980 0 0 {name=p130004 lab=_75604_/B }
C {devices/lab_pin.sym} 130560 -3000 0 1 {name=p130005 lab=_75604_/X }
C {sky130_stdcells/xor2_4.sym} 130500 -3000 0 0 {name=X_75604_ }
C {devices/lab_pin.sym} 130440 -2880 0 0 {name=p130006 lab=_49212_/A }
C {devices/lab_pin.sym} 130440 -2840 0 0 {name=p130007 lab=_48551_/X }
C {devices/lab_pin.sym} 130560 -2860 0 1 {name=p130008 lab=_48552_/Y }
C {sky130_stdcells/nand2_4.sym} 130500 -2860 0 0 {name=X_48552_ }
C {devices/lab_pin.sym} 130420 -2770 0 0 {name=p130009 lab=_60812_/Y }
C {devices/lab_pin.sym} 130420 -2730 0 0 {name=p130010 lab=_60702_/Y }
C {devices/lab_pin.sym} 130420 -2690 0 0 {name=p130011 lab=_59654_/X }
C {devices/lab_pin.sym} 130420 -2650 0 0 {name=p130012 lab=_60820_/B }
C {devices/lab_pin.sym} 130420 -2620 0 0 {name=p130013 lab=_60829_/Y }
C {devices/lab_pin.sym} 130580 -2690 0 1 {name=p130014 lab=_60830_/X }
C {sky130_stdcells/a41o_4.sym} 130500 -2690 0 0 {name=X_60830_ }
C {devices/lab_pin.sym} 130460 -2530 0 0 {name=p130015 lab=_73516_/A }
C {devices/lab_pin.sym} 130540 -2530 0 1 {name=p130016 lab=_72816_/X }
C {sky130_stdcells/buf_2.sym} 130500 -2530 0 0 {name=X_72816_ }
C {devices/lab_pin.sym} 130440 -2420 0 0 {name=p130017 lab=_79372_/A }
C {devices/lab_pin.sym} 130440 -2380 0 0 {name=p130018 lab=_79372_/B }
C {devices/lab_pin.sym} 130560 -2400 0 1 {name=p130019 lab=_79373_/B }
C {sky130_stdcells/xor2_4.sym} 130500 -2400 0 0 {name=X_79372_ }
C {devices/lab_pin.sym} 130460 -2270 0 0 {name=p130020 lab=_45369_/A }
C {devices/lab_pin.sym} 130540 -2270 0 1 {name=p130021 lab=_45765_/A }
C {sky130_stdcells/buf_2.sym} 130500 -2270 0 0 {name=X_45764_ }
C {devices/lab_pin.sym} 130440 -2180 0 0 {name=p130022 lab=_76584_/A }
C {devices/lab_pin.sym} 130440 -2140 0 0 {name=p130023 lab=_76517_/A }
C {devices/lab_pin.sym} 130440 -2100 0 0 {name=p130024 lab=_76584_/C }
C {devices/lab_pin.sym} 130440 -2060 0 0 {name=p130025 lab=_76584_/D }
C {devices/lab_pin.sym} 130560 -2120 0 1 {name=p130026 lab=_76584_/X }
C {sky130_stdcells/and4_4.sym} 130500 -2120 0 0 {name=X_76584_ }
C {devices/lab_pin.sym} 130460 -1970 0 0 {name=p130027 lab=_42488_/A }
C {devices/lab_pin.sym} 130540 -1970 0 1 {name=p130028 lab=_42976_/X }
C {sky130_stdcells/buf_2.sym} 130500 -1970 0 0 {name=X_42976_ }
C {devices/lab_pin.sym} 130420 -1880 0 0 {name=p130029 lab=_41920_/Y }
C {devices/lab_pin.sym} 130420 -1840 0 0 {name=p130030 lab=_73529_/X }
C {devices/lab_pin.sym} 130420 -1800 0 0 {name=p130031 lab=_73698_/X }
C {devices/lab_pin.sym} 130420 -1760 0 0 {name=p130032 lab=_73795_/Y }
C {devices/lab_pin.sym} 130580 -1820 0 1 {name=p130033 lab=_73796_/X }
C {sky130_stdcells/a211o_4.sym} 130500 -1820 0 0 {name=X_73796_ }
C {devices/lab_pin.sym} 130440 -1700 0 0 {name=p130034 lab=_47513_/A }
C {devices/lab_pin.sym} 130440 -1660 0 0 {name=p130035 lab=_47463_/X }
C {devices/lab_pin.sym} 130440 -1620 0 0 {name=p130036 lab=_47513_/C }
C {devices/lab_pin.sym} 130440 -1580 0 0 {name=p130037 lab=_53084_/D }
C {devices/lab_pin.sym} 130560 -1640 0 1 {name=p130038 lab=_47503_/X }
C {sky130_stdcells/and4_4.sym} 130500 -1640 0 0 {name=X_47503_ }
C {devices/lab_pin.sym} 130420 -1510 0 0 {name=p130039 lab=_78317_/X }
C {devices/lab_pin.sym} 130420 -1470 0 0 {name=p130040 lab=_78335_/A }
C {devices/lab_pin.sym} 130420 -1430 0 0 {name=p130041 lab=_78324_/B }
C {devices/lab_pin.sym} 130580 -1470 0 1 {name=p130042 lab=_78323_/X }
C {sky130_stdcells/a21o_4.sym} 130500 -1470 0 0 {name=X_78323_ }
C {devices/lab_pin.sym} 130420 -1370 0 0 {name=p130043 lab=_44712_/X }
C {devices/lab_pin.sym} 130420 -1330 0 0 {name=p130044 lab=_44713_/X }
C {devices/lab_pin.sym} 130420 -1290 0 0 {name=p130045 lab=_40682_/X }
C {devices/lab_pin.sym} 130420 -1250 0 0 {name=p130046 lab=_86990_/Q }
C {devices/lab_pin.sym} 130420 -1210 0 0 {name=p130047 lab=_44714_/X }
C {devices/lab_pin.sym} 130580 -1290 0 1 {name=p130048 lab=_44716_/A }
C {sky130_stdcells/o32ai_4.sym} 130500 -1290 0 0 {name=X_44715_ }
C {devices/lab_pin.sym} 130440 -1140 0 0 {name=p130049 lab=_75535_/A }
C {devices/lab_pin.sym} 130440 -1100 0 0 {name=p130050 lab=_75535_/B }
C {devices/lab_pin.sym} 130560 -1120 0 1 {name=p130051 lab=_75535_/Y }
C {sky130_stdcells/nor2_4.sym} 130500 -1120 0 0 {name=X_75535_ }
C {devices/lab_pin.sym} 130460 -990 0 0 {name=p130052 lab=_42024_/A }
C {devices/lab_pin.sym} 130540 -990 0 1 {name=p130053 lab=_41927_/X }
C {sky130_stdcells/buf_2.sym} 130500 -990 0 0 {name=X_41927_ }
C {devices/lab_pin.sym} 130420 -890 0 0 {name=p130054 lab=_73070_/B }
C {devices/lab_pin.sym} 130420 -850 0 0 {name=p130055 lab=_48478_/X }
C {devices/lab_pin.sym} 130420 -810 0 0 {name=p130056 lab=_48482_/Y }
C {devices/lab_pin.sym} 130580 -850 0 1 {name=p130057 lab=_48483_/Y }
C {sky130_stdcells/o21ai_4.sym} 130500 -850 0 0 {name=X_48483_ }
C {devices/lab_pin.sym} 130440 -730 0 0 {name=p130058 lab=_60761_/A }
C {devices/lab_pin.sym} 130440 -690 0 0 {name=p130059 lab=_60761_/B }
C {devices/lab_pin.sym} 130440 -650 0 0 {name=p130060 lab=_84573_/Q }
C {devices/lab_pin.sym} 130560 -690 0 1 {name=p130061 lab=_60761_/Y }
C {sky130_stdcells/nor3_4.sym} 130500 -690 0 0 {name=X_60761_ }
C {devices/lab_pin.sym} 131380 -42150 0 0 {name=p130062 lab=_73183_/A }
C {devices/lab_pin.sym} 131460 -42150 0 1 {name=p130063 lab=_72929_/A }
C {sky130_stdcells/buf_2.sym} 131420 -42150 0 0 {name=X_72747_ }
C {devices/lab_pin.sym} 131340 -42050 0 0 {name=p130064 lab=_85134_/Q }
C {devices/lab_pin.sym} 131340 -42010 0 0 {name=p130065 lab=_45556_/X }
C {devices/lab_pin.sym} 131340 -41970 0 0 {name=p130066 lab=_45651_/X }
C {devices/lab_pin.sym} 131500 -42010 0 1 {name=p130067 lab=_45695_/X }
C {sky130_stdcells/o21a_4.sym} 131420 -42010 0 0 {name=X_45695_ }
C {devices/lab_pin.sym} 131360 -41900 0 0 {name=p130068 lab=_62487_/X }
C {devices/lab_pin.sym} 131360 -41860 0 0 {name=p130069 lab=_83245_/Q }
C {devices/lab_pin.sym} 131360 -41820 0 0 {name=p130070 lab=_62628_/C }
C {devices/lab_pin.sym} 131360 -41780 0 0 {name=p130071 lab=_62219_/X }
C {devices/lab_pin.sym} 131480 -41840 0 1 {name=p130072 lab=_62500_/X }
C {sky130_stdcells/and4_4.sym} 131420 -41840 0 0 {name=X_62500_ }
C {devices/lab_pin.sym} 131340 -41710 0 0 {name=p130073 lab=_86635_/Q }
C {devices/lab_pin.sym} 131340 -41670 0 0 {name=p130074 lab=_47429_/X }
C {devices/lab_pin.sym} 131340 -41630 0 0 {name=p130075 lab=_47433_/Y }
C {devices/lab_pin.sym} 131500 -41670 0 1 {name=p130076 lab=_47434_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -41670 0 0 {name=X_47434_ }
C {devices/lab_pin.sym} 131360 -41540 0 0 {name=p130077 lab=_78254_/A }
C {devices/lab_pin.sym} 131360 -41500 0 0 {name=p130078 lab=_78252_/C }
C {devices/lab_pin.sym} 131480 -41520 0 1 {name=p130079 lab=_78254_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -41520 0 0 {name=X_78254_ }
C {devices/lab_pin.sym} 131380 -41390 0 0 {name=p130080 lab=clkbuf_9_238_0_CLK/X }
C {devices/lab_pin.sym} 131460 -41390 0 1 {name=p130081 lab=_86089_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 131420 -41390 0 0 {name=Xclkbuf_10_476_0_CLK }
C {devices/lab_pin.sym} 131340 -41310 0 0 {name=p130082 lab=_44638_/X }
C {devices/lab_pin.sym} 131340 -41270 0 0 {name=p130083 lab=_44639_/X }
C {devices/lab_pin.sym} 131340 -41230 0 0 {name=p130084 lab=_41053_/X }
C {devices/lab_pin.sym} 131340 -41190 0 0 {name=p130085 lab=_87018_/Q }
C {devices/lab_pin.sym} 131340 -41150 0 0 {name=p130086 lab=_44640_/X }
C {devices/lab_pin.sym} 131500 -41230 0 1 {name=p130087 lab=_44647_/A }
C {sky130_stdcells/o32ai_4.sym} 131420 -41230 0 0 {name=X_44646_ }
C {devices/lab_pin.sym} 131360 -41100 0 0 {name=p130088 lab=_59392_/A }
C {devices/lab_pin.sym} 131360 -41060 0 0 {name=p130089 lab=_63491_/B }
C {devices/lab_pin.sym} 131360 -41020 0 0 {name=p130090 lab=_63465_/C }
C {devices/lab_pin.sym} 131360 -40980 0 0 {name=p130091 lab=_63491_/D }
C {devices/lab_pin.sym} 131480 -41040 0 1 {name=p130092 lab=_63480_/Y }
C {sky130_stdcells/nand4_4.sym} 131420 -41040 0 0 {name=X_63480_ }
C {devices/lab_pin.sym} 131360 -40900 0 0 {name=p130093 lab=_75466_/A }
C {devices/lab_pin.sym} 131360 -40860 0 0 {name=p130094 lab=_75466_/B }
C {devices/lab_pin.sym} 131480 -40880 0 1 {name=p130095 lab=_75466_/X }
C {sky130_stdcells/and2_4.sym} 131420 -40880 0 0 {name=X_75466_ }
C {devices/lab_pin.sym} 131380 -40750 0 0 {name=p130096 lab=_48164_/A }
C {devices/lab_pin.sym} 131460 -40750 0 1 {name=p130097 lab=_48226_/A }
C {sky130_stdcells/buf_2.sym} 131420 -40750 0 0 {name=X_41858_ }
C {devices/lab_pin.sym} 131380 -40630 0 0 {name=p130098 lab=_60727_/A }
C {devices/lab_pin.sym} 131460 -40630 0 1 {name=p130099 lab=_60692_/X }
C {sky130_stdcells/buf_2.sym} 131420 -40630 0 0 {name=X_60692_ }
C {devices/lab_pin.sym} 131340 -40530 0 0 {name=p130100 lab=_70219_/C }
C {devices/lab_pin.sym} 131340 -40490 0 0 {name=p130101 lab=_72672_/X }
C {devices/lab_pin.sym} 131340 -40450 0 0 {name=p130102 lab=_72677_/Y }
C {devices/lab_pin.sym} 131500 -40490 0 1 {name=p130103 lab=_83193_/D }
C {sky130_stdcells/a21bo_4.sym} 131420 -40490 0 0 {name=X_72678_ }
C {devices/lab_pin.sym} 131360 -40370 0 0 {name=p130104 lab=_77205_/A }
C {devices/lab_pin.sym} 131360 -40330 0 0 {name=p130105 lab=_77202_/C }
C {devices/lab_pin.sym} 131360 -40290 0 0 {name=p130106 lab=_77204_/Y }
C {devices/lab_pin.sym} 131480 -40330 0 1 {name=p130107 lab=_77205_/X }
C {sky130_stdcells/and3_4.sym} 131420 -40330 0 0 {name=X_77205_ }
C {devices/lab_pin.sym} 131360 -40220 0 0 {name=p130108 lab=_61513_/A }
C {devices/lab_pin.sym} 131360 -40180 0 0 {name=p130109 lab=_62472_/B }
C {devices/lab_pin.sym} 131360 -40140 0 0 {name=p130110 lab=_62490_/C }
C {devices/lab_pin.sym} 131360 -40100 0 0 {name=p130111 lab=_62431_/D }
C {devices/lab_pin.sym} 131480 -40160 0 1 {name=p130112 lab=_62435_/B }
C {sky130_stdcells/nand4_4.sym} 131420 -40160 0 0 {name=X_62431_ }
C {devices/lab_pin.sym} 131340 -40030 0 0 {name=p130113 lab=_74415_/Y }
C {devices/lab_pin.sym} 131340 -39990 0 0 {name=p130114 lab=_74405_/X }
C {devices/lab_pin.sym} 131340 -39950 0 0 {name=p130115 lab=_74416_/X }
C {devices/lab_pin.sym} 131500 -39990 0 1 {name=p130116 lab=_83071_/D }
C {sky130_stdcells/a21oi_4.sym} 131420 -39990 0 0 {name=X_74417_ }
C {devices/lab_pin.sym} 131340 -39870 0 0 {name=p130117 lab=_40773_/X }
C {devices/lab_pin.sym} 131340 -39830 0 0 {name=p130118 lab=_82296_/Q }
C {devices/lab_pin.sym} 131340 -39790 0 0 {name=p130119 lab=_40808_/X }
C {devices/lab_pin.sym} 131500 -39830 0 1 {name=p130120 lab=_40810_/A }
C {sky130_stdcells/o21ai_4.sym} 131420 -39830 0 0 {name=X_40809_ }
C {devices/lab_pin.sym} 131380 -39690 0 0 {name=p130121 lab=_46612_/A }
C {devices/lab_pin.sym} 131460 -39690 0 1 {name=p130122 lab=_49504_/A }
C {sky130_stdcells/buf_2.sym} 131420 -39690 0 0 {name=X_47365_ }
C {devices/lab_pin.sym} 131380 -39570 0 0 {name=p130123 lab=_71527_/Y }
C {devices/lab_pin.sym} 131460 -39570 0 1 {name=p130124 lab=_71655_/A }
C {sky130_stdcells/inv_2.sym} 131420 -39570 0 0 {name=X_71629_ }
C {devices/lab_pin.sym} 131360 -39460 0 0 {name=p130125 lab=_78191_/B }
C {devices/lab_pin.sym} 131360 -39420 0 0 {name=p130126 lab=_78191_/C }
C {devices/lab_pin.sym} 131480 -39440 0 1 {name=p130127 lab=_78188_/A }
C {sky130_stdcells/nand2_4.sym} 131420 -39440 0 0 {name=X_78185_ }
C {devices/lab_pin.sym} 131380 -39310 0 0 {name=p130128 lab=_87048_/Q }
C {devices/lab_pin.sym} 131460 -39310 0 1 {name=p130129 lab=_44577_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -39310 0 0 {name=X_44577_ }
C {devices/lab_pin.sym} 131340 -39210 0 0 {name=p130130 lab=_75393_/Y }
C {devices/lab_pin.sym} 131340 -39170 0 0 {name=p130131 lab=_75396_/C }
C {devices/lab_pin.sym} 131340 -39130 0 0 {name=p130132 lab=_75396_/A }
C {devices/lab_pin.sym} 131500 -39170 0 1 {name=p130133 lab=_75397_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -39170 0 0 {name=X_75397_ }
C {devices/lab_pin.sym} 131360 -39040 0 0 {name=p130134 lab=_82882_/Q }
C {devices/lab_pin.sym} 131360 -39000 0 0 {name=p130135 lab=_48946_/A }
C {devices/lab_pin.sym} 131480 -39020 0 1 {name=p130136 lab=_41789_/X }
C {sky130_stdcells/or2_4.sym} 131420 -39020 0 0 {name=X_41789_ }
C {devices/lab_pin.sym} 131380 -38890 0 0 {name=p130137 lab=_49052_/A }
C {devices/lab_pin.sym} 131460 -38890 0 1 {name=p130138 lab=_49104_/X }
C {sky130_stdcells/buf_2.sym} 131420 -38890 0 0 {name=X_49104_ }
C {devices/lab_pin.sym} 131340 -38790 0 0 {name=p130139 lab=_86748_/Q }
C {devices/lab_pin.sym} 131340 -38750 0 0 {name=p130140 lab=_46292_/X }
C {devices/lab_pin.sym} 131340 -38710 0 0 {name=p130141 lab=_46315_/Y }
C {devices/lab_pin.sym} 131500 -38750 0 1 {name=p130142 lab=_46316_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -38750 0 0 {name=X_46316_ }
C {devices/lab_pin.sym} 131380 -38610 0 0 {name=p130143 lab=_58784_/A }
C {devices/lab_pin.sym} 131460 -38610 0 1 {name=p130144 lab=_65673_/A }
C {sky130_stdcells/buf_2.sym} 131420 -38610 0 0 {name=X_65150_ }
C {devices/lab_pin.sym} 131340 -38510 0 0 {name=p130145 lab=_77130_/A }
C {devices/lab_pin.sym} 131340 -38470 0 0 {name=p130146 lab=_77129_/X }
C {devices/lab_pin.sym} 131340 -38430 0 0 {name=p130147 lab=_77141_/A }
C {devices/lab_pin.sym} 131500 -38470 0 1 {name=p130148 lab=_77136_/Y }
C {sky130_stdcells/a21boi_4.sym} 131420 -38470 0 0 {name=X_77136_ }
C {devices/lab_pin.sym} 131380 -38330 0 0 {name=p130149 lab=_43528_/A }
C {devices/lab_pin.sym} 131460 -38330 0 1 {name=p130150 lab=_43528_/X }
C {sky130_stdcells/buf_2.sym} 131420 -38330 0 0 {name=X_43528_ }
C {devices/lab_pin.sym} 131360 -38240 0 0 {name=p130151 lab=_62362_/A }
C {devices/lab_pin.sym} 131360 -38200 0 0 {name=p130152 lab=_62358_/Y }
C {devices/lab_pin.sym} 131360 -38160 0 0 {name=p130153 lab=_62359_/Y }
C {devices/lab_pin.sym} 131360 -38120 0 0 {name=p130154 lab=_62361_/Y }
C {devices/lab_pin.sym} 131480 -38180 0 1 {name=p130155 lab=_62362_/Y }
C {sky130_stdcells/nand4_4.sym} 131420 -38180 0 0 {name=X_62362_ }
C {devices/lab_pin.sym} 131340 -38050 0 0 {name=p130156 lab=_83089_/Q }
C {devices/lab_pin.sym} 131340 -38010 0 0 {name=p130157 lab=_74340_/X }
C {devices/lab_pin.sym} 131340 -37970 0 0 {name=p130158 lab=_74347_/Y }
C {devices/lab_pin.sym} 131500 -38010 0 1 {name=p130159 lab=_83089_/D }
C {sky130_stdcells/a21bo_4.sym} 131420 -38010 0 0 {name=X_74348_ }
C {devices/lab_pin.sym} 131340 -37890 0 0 {name=p130160 lab=_47291_/Y }
C {devices/lab_pin.sym} 131340 -37850 0 0 {name=p130161 lab=_47271_/X }
C {devices/lab_pin.sym} 131340 -37810 0 0 {name=p130162 lab=_47295_/X }
C {devices/lab_pin.sym} 131500 -37850 0 1 {name=p130163 lab=_86650_/D }
C {sky130_stdcells/a21oi_4.sym} 131420 -37850 0 0 {name=X_47296_ }
C {devices/lab_pin.sym} 131340 -37730 0 0 {name=p130164 lab=_64099_/X }
C {devices/lab_pin.sym} 131340 -37690 0 0 {name=p130165 lab=_64073_/X }
C {devices/lab_pin.sym} 131340 -37650 0 0 {name=p130166 lab=_64100_/Y }
C {devices/lab_pin.sym} 131500 -37690 0 1 {name=p130167 lab=_64101_/Y }
C {sky130_stdcells/a21oi_4.sym} 131420 -37690 0 0 {name=X_64101_ }
C {devices/lab_pin.sym} 131380 -37550 0 0 {name=p130168 lab=_53856_/B }
C {devices/lab_pin.sym} 131460 -37550 0 1 {name=p130169 lab=_52338_/B }
C {sky130_stdcells/buf_2.sym} 131420 -37550 0 0 {name=X_49035_ }
C {devices/lab_pin.sym} 131380 -37430 0 0 {name=p130170 lab=_61313_/A }
C {devices/lab_pin.sym} 131460 -37430 0 1 {name=p130171 lab=_72550_/C }
C {sky130_stdcells/buf_2.sym} 131420 -37430 0 0 {name=X_61313_ }
C {devices/lab_pin.sym} 131380 -37310 0 0 {name=p130172 lab=_46247_/A }
C {devices/lab_pin.sym} 131460 -37310 0 1 {name=p130173 lab=_46247_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -37310 0 0 {name=X_46247_ }
C {sky130_stdcells/decap_3.sym} 131420 -37160 0 0 {name=XPHY_590 }
C {devices/lab_pin.sym} 131360 -37030 0 0 {name=p130174 lab=_65078_/X }
C {devices/lab_pin.sym} 131360 -36990 0 0 {name=p130175 lab=_65056_/B }
C {devices/lab_pin.sym} 131360 -36950 0 0 {name=p130176 lab=_65080_/X }
C {devices/lab_pin.sym} 131480 -36990 0 1 {name=p130177 lab=_65090_/A }
C {sky130_stdcells/nand3_4.sym} 131420 -36990 0 0 {name=X_65081_ }
C {devices/lab_pin.sym} 131360 -36860 0 0 {name=p130178 lab=_77067_/A }
C {devices/lab_pin.sym} 131360 -36820 0 0 {name=p130179 lab=_77067_/B }
C {devices/lab_pin.sym} 131480 -36840 0 1 {name=p130180 lab=_77068_/B }
C {sky130_stdcells/and2_4.sym} 131420 -36840 0 0 {name=X_77067_ }
C {devices/lab_pin.sym} 131340 -36740 0 0 {name=p130181 lab=_41626_/X }
C {devices/lab_pin.sym} 131340 -36700 0 0 {name=p130182 lab=_43446_/X }
C {devices/lab_pin.sym} 131340 -36660 0 0 {name=p130183 lab=_87412_/Q }
C {devices/lab_pin.sym} 131340 -36620 0 0 {name=p130184 lab=_43447_/X }
C {devices/lab_pin.sym} 131500 -36680 0 1 {name=p130185 lab=_87412_/D }
C {sky130_stdcells/a2bb2o_4.sym} 131420 -36680 0 0 {name=X_43459_ }
C {devices/lab_pin.sym} 131360 -36560 0 0 {name=p130186 lab=_61390_/A }
C {devices/lab_pin.sym} 131360 -36520 0 0 {name=p130187 lab=_62247_/X }
C {devices/lab_pin.sym} 131360 -36480 0 0 {name=p130188 lab=_62259_/X }
C {devices/lab_pin.sym} 131360 -36440 0 0 {name=p130189 lab=_62631_/D }
C {devices/lab_pin.sym} 131480 -36500 0 1 {name=p130190 lab=_62293_/Y }
C {sky130_stdcells/nand4_4.sym} 131420 -36500 0 0 {name=X_62293_ }
C {devices/lab_pin.sym} 131360 -36360 0 0 {name=p130191 lab=_48153_/A }
C {devices/lab_pin.sym} 131360 -36320 0 0 {name=p130192 lab=_74278_/Y }
C {devices/lab_pin.sym} 131480 -36340 0 1 {name=p130193 lab=_74279_/X }
C {sky130_stdcells/xor2_4.sym} 131420 -36340 0 0 {name=X_74279_ }
C {devices/lab_pin.sym} 131380 -36210 0 0 {name=p130194 lab=_64032_/A }
C {devices/lab_pin.sym} 131460 -36210 0 1 {name=p130195 lab=_64095_/B }
C {sky130_stdcells/buf_2.sym} 131420 -36210 0 0 {name=X_64032_ }
C {devices/lab_pin.sym} 131360 -36100 0 0 {name=p130196 lab=_76010_/A }
C {devices/lab_pin.sym} 131360 -36060 0 0 {name=p130197 lab=_76015_/A }
C {devices/lab_pin.sym} 131480 -36080 0 1 {name=p130198 lab=_76019_/B }
C {sky130_stdcells/and2_4.sym} 131420 -36080 0 0 {name=X_76018_ }
C {devices/lab_pin.sym} 131380 -35950 0 0 {name=p130199 lab=_72543_/A }
C {devices/lab_pin.sym} 131460 -35950 0 1 {name=p130200 lab=_61262_/A }
C {sky130_stdcells/buf_2.sym} 131420 -35950 0 0 {name=X_61244_ }
C {devices/lab_pin.sym} 131380 -35830 0 0 {name=p130201 lab=_44253_/X }
C {devices/lab_pin.sym} 131460 -35830 0 1 {name=p130202 lab=_46178_/X }
C {sky130_stdcells/buf_2.sym} 131420 -35830 0 0 {name=X_46178_ }
C {devices/lab_pin.sym} 131340 -35730 0 0 {name=p130203 lab=_45127_/X }
C {devices/lab_pin.sym} 131340 -35690 0 0 {name=p130204 lab=_61499_/B }
C {devices/lab_pin.sym} 131340 -35650 0 0 {name=p130205 lab=_45070_/X }
C {devices/lab_pin.sym} 131500 -35690 0 1 {name=p130206 lab=_45129_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -35690 0 0 {name=X_45129_ }
C {devices/lab_pin.sym} 131340 -35580 0 0 {name=p130207 lab=_87584_/Q }
C {devices/lab_pin.sym} 131340 -35540 0 0 {name=p130208 lab=_68463_/X }
C {devices/lab_pin.sym} 131340 -35500 0 0 {name=p130209 lab=_68613_/X }
C {devices/lab_pin.sym} 131340 -35460 0 0 {name=p130210 lab=_68839_/X }
C {devices/lab_pin.sym} 131500 -35520 0 1 {name=p130211 lab=_68840_/X }
C {sky130_stdcells/a211o_4.sym} 131420 -35520 0 0 {name=X_68840_ }
C {devices/lab_pin.sym} 131380 -35370 0 0 {name=p130212 lab=clkbuf_9_207_0_CLK/X }
C {devices/lab_pin.sym} 131460 -35370 0 1 {name=p130213 lab=_83627_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 131420 -35370 0 0 {name=Xclkbuf_10_414_0_CLK }
C {devices/lab_pin.sym} 131340 -35290 0 0 {name=p130214 lab=_61086_/X }
C {devices/lab_pin.sym} 131340 -35250 0 0 {name=p130215 lab=_61162_/X }
C {devices/lab_pin.sym} 131340 -35210 0 0 {name=p130216 lab=_61170_/Y }
C {devices/lab_pin.sym} 131340 -35170 0 0 {name=p130217 lab=_61173_/Y }
C {devices/lab_pin.sym} 131340 -35140 0 0 {name=p130218 lab=_61174_/Y }
C {devices/lab_pin.sym} 131500 -35210 0 1 {name=p130219 lab=_84514_/D }
C {sky130_stdcells/a41oi_4.sym} 131420 -35210 0 0 {name=X_61175_ }
C {devices/lab_pin.sym} 131340 -35090 0 0 {name=p130220 lab=_60119_/Y }
C {devices/lab_pin.sym} 131340 -35050 0 0 {name=p130221 lab=_60095_/X }
C {devices/lab_pin.sym} 131340 -35010 0 0 {name=p130222 lab=_60155_/D }
C {devices/lab_pin.sym} 131340 -34970 0 0 {name=p130223 lab=_60123_/Y }
C {devices/lab_pin.sym} 131340 -34940 0 0 {name=p130224 lab=_60125_/Y }
C {devices/lab_pin.sym} 131500 -35010 0 1 {name=p130225 lab=_60126_/Y }
C {sky130_stdcells/a41oi_4.sym} 131420 -35010 0 0 {name=X_60126_ }
C {devices/lab_pin.sym} 131340 -34870 0 0 {name=p130226 lab=_72232_/B }
C {devices/lab_pin.sym} 131340 -34830 0 0 {name=p130227 lab=_49934_/X }
C {devices/lab_pin.sym} 131340 -34790 0 0 {name=p130228 lab=_49936_/Y }
C {devices/lab_pin.sym} 131500 -34830 0 1 {name=p130229 lab=_49937_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -34830 0 0 {name=X_49937_ }
C {devices/lab_pin.sym} 131360 -34700 0 0 {name=p130230 lab=_68770_/X }
C {devices/lab_pin.sym} 131360 -34660 0 0 {name=p130231 lab=_87235_/Q }
C {devices/lab_pin.sym} 131480 -34680 0 1 {name=p130232 lab=_68771_/X }
C {sky130_stdcells/and2_4.sym} 131420 -34680 0 0 {name=X_68771_ }
C {devices/lab_pin.sym} 131360 -34560 0 0 {name=p130233 lab=_65983_/A }
C {devices/lab_pin.sym} 131360 -34520 0 0 {name=p130234 lab=_65982_/X }
C {devices/lab_pin.sym} 131480 -34540 0 1 {name=p130235 lab=_65983_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -34540 0 0 {name=X_65983_ }
C {devices/lab_pin.sym} 131380 -34410 0 0 {name=p130236 lab=_77968_/X }
C {devices/lab_pin.sym} 131460 -34410 0 1 {name=p130237 lab=_77970_/B }
C {sky130_stdcells/buf_2.sym} 131420 -34410 0 0 {name=X_77969_ }
C {devices/lab_pin.sym} 131380 -34290 0 0 {name=p130238 lab=_68742_/A }
C {devices/lab_pin.sym} 131460 -34290 0 1 {name=p130239 lab=_68644_/A }
C {sky130_stdcells/buf_2.sym} 131420 -34290 0 0 {name=X_67722_ }
C {devices/lab_pin.sym} 131340 -34190 0 0 {name=p130240 lab=_79686_/Y }
C {devices/lab_pin.sym} 131340 -34150 0 0 {name=p130241 lab=_79704_/X }
C {devices/lab_pin.sym} 131340 -34110 0 0 {name=p130242 lab=_79707_/Y }
C {devices/lab_pin.sym} 131500 -34150 0 1 {name=p130243 lab=_79708_/Y }
C {sky130_stdcells/a21oi_4.sym} 131420 -34150 0 0 {name=X_79708_ }
C {devices/lab_pin.sym} 131380 -34010 0 0 {name=p130244 lab=_64809_/A }
C {devices/lab_pin.sym} 131460 -34010 0 1 {name=p130245 lab=_64934_/X }
C {sky130_stdcells/buf_2.sym} 131420 -34010 0 0 {name=X_64934_ }
C {devices/lab_pin.sym} 131380 -33890 0 0 {name=p130246 lab=_63055_/A }
C {devices/lab_pin.sym} 131460 -33890 0 1 {name=p130247 lab=_60528_/A }
C {sky130_stdcells/buf_2.sym} 131420 -33890 0 0 {name=X_60057_ }
C {devices/lab_pin.sym} 131360 -33780 0 0 {name=p130248 lab=_49864_/A }
C {devices/lab_pin.sym} 131360 -33740 0 0 {name=p130249 lab=_53080_/B }
C {devices/lab_pin.sym} 131480 -33760 0 1 {name=p130250 lab=_49868_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -33760 0 0 {name=X_49868_ }
C {devices/lab_pin.sym} 131330 -33630 0 0 {name=p130251 lab=_80962_/CLK }
C {devices/lab_pin.sym} 131330 -33610 0 0 {name=p130252 lab=_80980_/D }
C {devices/lab_pin.sym} 131510 -33630 0 1 {name=p130253 lab=_75151_/B }
C {sky130_stdcells/dfxtp_4.sym} 131420 -33620 0 0 {name=X_80980_ }
C {devices/lab_pin.sym} 131380 -33490 0 0 {name=p130254 lab=clkbuf_9_214_0_CLK/X }
C {devices/lab_pin.sym} 131460 -33490 0 1 {name=p130255 lab=_83167_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 131420 -33490 0 0 {name=Xclkbuf_10_429_0_CLK }
C {devices/lab_pin.sym} 131340 -33390 0 0 {name=p130256 lab=_48817_/Y }
C {devices/lab_pin.sym} 131340 -33350 0 0 {name=p130257 lab=_48813_/X }
C {devices/lab_pin.sym} 131340 -33310 0 0 {name=p130258 lab=_48818_/X }
C {devices/lab_pin.sym} 131500 -33350 0 1 {name=p130259 lab=_86477_/D }
C {sky130_stdcells/a21oi_4.sym} 131420 -33350 0 0 {name=X_48819_ }
C {devices/lab_pin.sym} 131340 -33240 0 0 {name=p130260 lab=_87910_/Q }
C {devices/lab_pin.sym} 131340 -33200 0 0 {name=p130261 lab=_67651_/X }
C {devices/lab_pin.sym} 131340 -33160 0 0 {name=p130262 lab=_67625_/X }
C {devices/lab_pin.sym} 131340 -33120 0 0 {name=p130263 lab=_67652_/X }
C {devices/lab_pin.sym} 131500 -33180 0 1 {name=p130264 lab=_67653_/X }
C {sky130_stdcells/a211o_4.sym} 131420 -33180 0 0 {name=X_67653_ }
C {devices/lab_pin.sym} 131360 -33040 0 0 {name=p130265 lab=_79652_/A }
C {devices/lab_pin.sym} 131360 -33000 0 0 {name=p130266 lab=_79638_/Y }
C {devices/lab_pin.sym} 131480 -33020 0 1 {name=p130267 lab=_79639_/X }
C {sky130_stdcells/xor2_4.sym} 131420 -33020 0 0 {name=X_79639_ }
C {devices/lab_pin.sym} 131360 -32900 0 0 {name=p130268 lab=_64810_/A }
C {devices/lab_pin.sym} 131360 -32860 0 0 {name=p130269 lab=_86424_/Q }
C {devices/lab_pin.sym} 131480 -32880 0 1 {name=p130270 lab=_64865_/X }
C {sky130_stdcells/and2_4.sym} 131420 -32880 0 0 {name=X_64865_ }
C {devices/lab_pin.sym} 131380 -32750 0 0 {name=p130271 lab=_49688_/X }
C {devices/lab_pin.sym} 131460 -32750 0 1 {name=p130272 lab=_49809_/A }
C {sky130_stdcells/buf_2.sym} 131420 -32750 0 0 {name=X_49799_ }
C {devices/lab_pin.sym} 131380 -32630 0 0 {name=p130273 lab=_44012_/A }
C {devices/lab_pin.sym} 131460 -32630 0 1 {name=p130274 lab=_68389_/A }
C {sky130_stdcells/buf_2.sym} 131420 -32630 0 0 {name=X_66604_ }
C {devices/lab_pin.sym} 131360 -32520 0 0 {name=p130275 lab=_51820_/A }
C {devices/lab_pin.sym} 131360 -32480 0 0 {name=p130276 lab=_46758_/X }
C {devices/lab_pin.sym} 131480 -32500 0 1 {name=p130277 lab=_51830_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -32500 0 0 {name=X_51830_ }
C {devices/lab_pin.sym} 131340 -32410 0 0 {name=p130278 lab=_63809_/X }
C {devices/lab_pin.sym} 131340 -32370 0 0 {name=p130279 lab=_63810_/X }
C {devices/lab_pin.sym} 131340 -32330 0 0 {name=p130280 lab=_63812_/Y }
C {devices/lab_pin.sym} 131340 -32290 0 0 {name=p130281 lab=_63814_/Y }
C {devices/lab_pin.sym} 131340 -32260 0 0 {name=p130282 lab=_63815_/X }
C {devices/lab_pin.sym} 131500 -32330 0 1 {name=p130283 lab=_63816_/X }
C {sky130_stdcells/a41o_4.sym} 131420 -32330 0 0 {name=X_63816_ }
C {devices/lab_pin.sym} 131330 -32170 0 0 {name=p130284 lab=_81755_/CLK }
C {devices/lab_pin.sym} 131330 -32150 0 0 {name=p130285 lab=_84002_/Q }
C {devices/lab_pin.sym} 131510 -32170 0 1 {name=p130286 lab=_79021_/A }
C {sky130_stdcells/dfxtp_4.sym} 131420 -32160 0 0 {name=X_82650_ }
C {devices/lab_pin.sym} 131340 -32050 0 0 {name=p130287 lab=_67580_/X }
C {devices/lab_pin.sym} 131340 -32010 0 0 {name=p130288 lab=_67583_/X }
C {devices/lab_pin.sym} 131340 -31970 0 0 {name=p130289 lab=_67561_/X }
C {devices/lab_pin.sym} 131500 -32010 0 1 {name=p130290 lab=_67584_/X }
C {sky130_stdcells/a21o_4.sym} 131420 -32010 0 0 {name=X_67584_ }
C {devices/lab_pin.sym} 131340 -31890 0 0 {name=p130291 lab=_64793_/X }
C {devices/lab_pin.sym} 131340 -31850 0 0 {name=p130292 lab=_64795_/X }
C {devices/lab_pin.sym} 131340 -31810 0 0 {name=p130293 lab=_64619_/X }
C {devices/lab_pin.sym} 131500 -31850 0 1 {name=p130294 lab=_64800_/A }
C {sky130_stdcells/a21o_4.sym} 131420 -31850 0 0 {name=X_64796_ }
C {devices/lab_pin.sym} 131330 -31710 0 0 {name=p130295 lab=_83940_/CLK }
C {devices/lab_pin.sym} 131330 -31690 0 0 {name=p130296 lab=_84201_/Q }
C {devices/lab_pin.sym} 131510 -31710 0 1 {name=p130297 lab=_81601_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -31700 0 0 {name=X_81601_ }
C {devices/lab_pin.sym} 131340 -31600 0 0 {name=p130298 lab=_87026_/Q }
C {devices/lab_pin.sym} 131340 -31560 0 0 {name=p130299 lab=_69277_/X }
C {devices/lab_pin.sym} 131340 -31520 0 0 {name=p130300 lab=_69278_/X }
C {devices/lab_pin.sym} 131340 -31480 0 0 {name=p130301 lab=_69322_/X }
C {devices/lab_pin.sym} 131500 -31540 0 1 {name=p130302 lab=_69323_/X }
C {sky130_stdcells/a211o_4.sym} 131420 -31540 0 0 {name=X_69323_ }
C {devices/lab_pin.sym} 131360 -31400 0 0 {name=p130303 lab=_69633_/A }
C {devices/lab_pin.sym} 131360 -31360 0 0 {name=p130304 lab=_66535_/B }
C {devices/lab_pin.sym} 131480 -31380 0 1 {name=p130305 lab=_66535_/X }
C {sky130_stdcells/and2_4.sym} 131420 -31380 0 0 {name=X_66535_ }
C {devices/lab_pin.sym} 131360 -31280 0 0 {name=p130306 lab=_51768_/A }
C {devices/lab_pin.sym} 131360 -31240 0 0 {name=p130307 lab=_51782_/B }
C {devices/lab_pin.sym} 131360 -31200 0 0 {name=p130308 lab=_51755_/X }
C {devices/lab_pin.sym} 131360 -31160 0 0 {name=p130309 lab=_51761_/D }
C {devices/lab_pin.sym} 131480 -31220 0 1 {name=p130310 lab=_51761_/X }
C {sky130_stdcells/and4_4.sym} 131420 -31220 0 0 {name=X_51761_ }
C {devices/lab_pin.sym} 131360 -31100 0 0 {name=p130311 lab=_61338_/A }
C {devices/lab_pin.sym} 131360 -31060 0 0 {name=p130312 lab=_60870_/X }
C {devices/lab_pin.sym} 131360 -31020 0 0 {name=p130313 lab=_63721_/C }
C {devices/lab_pin.sym} 131360 -30980 0 0 {name=p130314 lab=_61012_/A }
C {devices/lab_pin.sym} 131480 -31040 0 1 {name=p130315 lab=_63747_/Y }
C {sky130_stdcells/nand4_4.sym} 131420 -31040 0 0 {name=X_63747_ }
C {devices/lab_pin.sym} 131330 -30890 0 0 {name=p130316 lab=_82491_/CLK }
C {devices/lab_pin.sym} 131330 -30870 0 0 {name=p130317 lab=_82613_/Q }
C {devices/lab_pin.sym} 131510 -30890 0 1 {name=p130318 lab=_78213_/A }
C {sky130_stdcells/dfxtp_4.sym} 131420 -30880 0 0 {name=X_82581_ }
C {devices/lab_pin.sym} 131360 -30770 0 0 {name=p130319 lab=_60610_/A }
C {devices/lab_pin.sym} 131360 -30730 0 0 {name=p130320 lab=_60835_/X }
C {devices/lab_pin.sym} 131360 -30690 0 0 {name=p130321 lab=_60959_/C }
C {devices/lab_pin.sym} 131480 -30730 0 1 {name=p130322 lab=_60959_/X }
C {sky130_stdcells/or3_4.sym} 131420 -30730 0 0 {name=X_60959_ }
C {devices/lab_pin.sym} 131340 -30610 0 0 {name=p130323 lab=_53496_/Y }
C {devices/lab_pin.sym} 131340 -30570 0 0 {name=p130324 lab=_53498_/X }
C {devices/lab_pin.sym} 131340 -30530 0 0 {name=p130325 lab=_53499_/Y }
C {devices/lab_pin.sym} 131500 -30570 0 1 {name=p130326 lab=_53500_/Y }
C {sky130_stdcells/a21boi_4.sym} 131420 -30570 0 0 {name=X_53500_ }
C {devices/lab_pin.sym} 131330 -30430 0 0 {name=p130327 lab=_84321_/CLK }
C {devices/lab_pin.sym} 131330 -30410 0 0 {name=p130328 lab=_63483_/Y }
C {devices/lab_pin.sym} 131510 -30430 0 1 {name=p130329 lab=_80526_/B }
C {sky130_stdcells/dfxtp_4.sym} 131420 -30420 0 0 {name=X_84320_ }
C {devices/lab_pin.sym} 131360 -30300 0 0 {name=p130330 lab=_50738_/A }
C {devices/lab_pin.sym} 131360 -30260 0 0 {name=p130331 lab=_50712_/B }
C {devices/lab_pin.sym} 131480 -30280 0 1 {name=p130332 lab=_50712_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -30280 0 0 {name=X_50712_ }
C {devices/lab_pin.sym} 131330 -30150 0 0 {name=p130333 lab=_81532_/CLK }
C {devices/lab_pin.sym} 131330 -30130 0 0 {name=p130334 lab=_76533_/B }
C {devices/lab_pin.sym} 131510 -30150 0 1 {name=p130335 lab=_76113_/A }
C {sky130_stdcells/dfxtp_4.sym} 131420 -30140 0 0 {name=X_81532_ }
C {devices/lab_pin.sym} 131340 -30040 0 0 {name=p130336 lab=_87031_/Q }
C {devices/lab_pin.sym} 131340 -30000 0 0 {name=p130337 lab=_69182_/X }
C {devices/lab_pin.sym} 131340 -29960 0 0 {name=p130338 lab=_69183_/X }
C {devices/lab_pin.sym} 131340 -29920 0 0 {name=p130339 lab=_69253_/X }
C {devices/lab_pin.sym} 131500 -29980 0 1 {name=p130340 lab=_69254_/X }
C {sky130_stdcells/a211o_4.sym} 131420 -29980 0 0 {name=X_69254_ }
C {devices/lab_pin.sym} 131380 -29830 0 0 {name=p130341 lab=_54344_/A }
C {devices/lab_pin.sym} 131460 -29830 0 1 {name=p130342 lab=_54481_/A }
C {sky130_stdcells/buf_2.sym} 131420 -29830 0 0 {name=X_54480_ }
C {devices/lab_pin.sym} 131360 -29730 0 0 {name=p130343 lab=_66200_/X }
C {devices/lab_pin.sym} 131360 -29690 0 0 {name=p130344 lab=_66397_/X }
C {devices/lab_pin.sym} 131360 -29650 0 0 {name=p130345 lab=_66203_/C }
C {devices/lab_pin.sym} 131480 -29690 0 1 {name=p130346 lab=_66466_/Y }
C {sky130_stdcells/nand3_4.sym} 131420 -29690 0 0 {name=X_66466_ }
C {devices/lab_pin.sym} 131340 -29570 0 0 {name=p130347 lab=_85963_/Q }
C {devices/lab_pin.sym} 131340 -29530 0 0 {name=p130348 lab=_51675_/X }
C {devices/lab_pin.sym} 131340 -29490 0 0 {name=p130349 lab=_51691_/Y }
C {devices/lab_pin.sym} 131500 -29530 0 1 {name=p130350 lab=_51692_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -29530 0 0 {name=X_51692_ }
C {devices/lab_pin.sym} 131340 -29430 0 0 {name=p130351 lab=_63624_/X }
C {devices/lab_pin.sym} 131340 -29390 0 0 {name=p130352 lab=_63672_/X }
C {devices/lab_pin.sym} 131340 -29350 0 0 {name=p130353 lab=_63673_/X }
C {devices/lab_pin.sym} 131340 -29310 0 0 {name=p130354 lab=_63676_/X }
C {devices/lab_pin.sym} 131340 -29270 0 0 {name=p130355 lab=_63677_/Y }
C {devices/lab_pin.sym} 131500 -29350 0 1 {name=p130356 lab=_63678_/Y }
C {sky130_stdcells/o41ai_4.sym} 131420 -29350 0 0 {name=X_63678_ }
C {devices/lab_pin.sym} 131340 -29220 0 0 {name=p130357 lab=_68196_/X }
C {devices/lab_pin.sym} 131340 -29180 0 0 {name=p130358 lab=_67268_/Y }
C {devices/lab_pin.sym} 131340 -29140 0 0 {name=p130359 lab=_68189_/X }
C {devices/lab_pin.sym} 131340 -29100 0 0 {name=p130360 lab=_68204_/Y }
C {devices/lab_pin.sym} 131500 -29160 0 1 {name=p130361 lab=_68205_/X }
C {sky130_stdcells/a211o_4.sym} 131420 -29160 0 0 {name=X_68205_ }
C {devices/lab_pin.sym} 131380 -29010 0 0 {name=p130362 lab=_53351_/A }
C {devices/lab_pin.sym} 131460 -29010 0 1 {name=p130363 lab=_53431_/X }
C {sky130_stdcells/buf_2.sym} 131420 -29010 0 0 {name=X_53431_ }
C {devices/lab_pin.sym} 131360 -28900 0 0 {name=p130364 lab=_65416_/X }
C {devices/lab_pin.sym} 131360 -28860 0 0 {name=p130365 lab=_86402_/Q }
C {devices/lab_pin.sym} 131480 -28880 0 1 {name=p130366 lab=_65417_/X }
C {sky130_stdcells/and2_4.sym} 131420 -28880 0 0 {name=X_65417_ }
C {devices/lab_pin.sym} 131330 -28750 0 0 {name=p130367 lab=_84877_/CLK }
C {devices/lab_pin.sym} 131330 -28730 0 0 {name=p130368 lab=_64388_/X }
C {devices/lab_pin.sym} 131510 -28750 0 1 {name=p130369 lab=_79733_/B }
C {sky130_stdcells/dfxtp_4.sym} 131420 -28740 0 0 {name=X_84251_ }
C {devices/lab_pin.sym} 131340 -28630 0 0 {name=p130370 lab=_86161_/Q }
C {devices/lab_pin.sym} 131340 -28590 0 0 {name=p130371 lab=_50626_/X }
C {devices/lab_pin.sym} 131340 -28550 0 0 {name=p130372 lab=_50642_/Y }
C {devices/lab_pin.sym} 131500 -28590 0 1 {name=p130373 lab=_50643_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -28590 0 0 {name=X_50643_ }
C {devices/lab_pin.sym} 131380 -28450 0 0 {name=p130374 lab=_62629_/A }
C {devices/lab_pin.sym} 131460 -28450 0 1 {name=p130375 lab=_62629_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -28450 0 0 {name=X_62629_ }
C {devices/lab_pin.sym} 131330 -28330 0 0 {name=p130376 lab=_81431_/CLK }
C {devices/lab_pin.sym} 131330 -28310 0 0 {name=p130377 lab=_76845_/B }
C {devices/lab_pin.sym} 131510 -28330 0 1 {name=p130378 lab=_81463_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -28320 0 0 {name=X_81463_ }
C {devices/lab_pin.sym} 131340 -28220 0 0 {name=p130379 lab=_87036_/Q }
C {devices/lab_pin.sym} 131340 -28180 0 0 {name=p130380 lab=_69182_/X }
C {devices/lab_pin.sym} 131340 -28140 0 0 {name=p130381 lab=_69183_/X }
C {devices/lab_pin.sym} 131340 -28100 0 0 {name=p130382 lab=_69184_/X }
C {devices/lab_pin.sym} 131500 -28160 0 1 {name=p130383 lab=_69186_/B }
C {sky130_stdcells/a211o_4.sym} 131420 -28160 0 0 {name=X_69185_ }
C {devices/lab_pin.sym} 131380 -28010 0 0 {name=p130384 lab=_66104_/A }
C {devices/lab_pin.sym} 131460 -28010 0 1 {name=p130385 lab=_66397_/X }
C {sky130_stdcells/buf_2.sym} 131420 -28010 0 0 {name=X_66397_ }
C {devices/lab_pin.sym} 131330 -27890 0 0 {name=p130386 lab=_83843_/CLK }
C {devices/lab_pin.sym} 131330 -27870 0 0 {name=p130387 lab=_83202_/D }
C {devices/lab_pin.sym} 131510 -27890 0 1 {name=p130388 lab=_70193_/A }
C {sky130_stdcells/dfxtp_4.sym} 131420 -27880 0 0 {name=X_83202_ }
C {devices/lab_pin.sym} 131360 -27760 0 0 {name=p130389 lab=_80412_/X }
C {devices/lab_pin.sym} 131360 -27720 0 0 {name=p130390 lab=_80413_/X }
C {devices/lab_pin.sym} 131480 -27740 0 1 {name=p130391 lab=_80414_/Y }
C {sky130_stdcells/xnor2_4.sym} 131420 -27740 0 0 {name=X_80414_ }
C {devices/lab_pin.sym} 131360 -27630 0 0 {name=p130392 lab=_56140_/A }
C {devices/lab_pin.sym} 131360 -27590 0 0 {name=p130393 lab=_56150_/B }
C {devices/lab_pin.sym} 131360 -27550 0 0 {name=p130394 lab=_55761_/B }
C {devices/lab_pin.sym} 131480 -27590 0 1 {name=p130395 lab=_56150_/Y }
C {sky130_stdcells/nand3_4.sym} 131420 -27590 0 0 {name=X_56150_ }
C {devices/lab_pin.sym} 131340 -27470 0 0 {name=p130396 lab=_82070_/D }
C {devices/lab_pin.sym} 131340 -27430 0 0 {name=p130397 lab=_68120_/X }
C {devices/lab_pin.sym} 131340 -27390 0 0 {name=p130398 lab=_68135_/X }
C {devices/lab_pin.sym} 131500 -27430 0 1 {name=p130399 lab=_68136_/X }
C {sky130_stdcells/a21bo_4.sym} 131420 -27430 0 0 {name=X_68136_ }
C {devices/lab_pin.sym} 131360 -27320 0 0 {name=p130400 lab=_53339_/A }
C {devices/lab_pin.sym} 131360 -27280 0 0 {name=p130401 lab=_53371_/B }
C {devices/lab_pin.sym} 131360 -27240 0 0 {name=p130402 lab=_53371_/C }
C {devices/lab_pin.sym} 131360 -27200 0 0 {name=p130403 lab=_52846_/D }
C {devices/lab_pin.sym} 131480 -27260 0 1 {name=p130404 lab=_53362_/X }
C {sky130_stdcells/and4_4.sym} 131420 -27260 0 0 {name=X_53362_ }
C {devices/lab_pin.sym} 131360 -27130 0 0 {name=p130405 lab=_65268_/A }
C {devices/lab_pin.sym} 131360 -27090 0 0 {name=p130406 lab=_65294_/B }
C {devices/lab_pin.sym} 131360 -27050 0 0 {name=p130407 lab=_65348_/C }
C {devices/lab_pin.sym} 131480 -27090 0 1 {name=p130408 lab=_65348_/X }
C {sky130_stdcells/and3_4.sym} 131420 -27090 0 0 {name=X_65348_ }
C {devices/lab_pin.sym} 131330 -26950 0 0 {name=p130409 lab=_83507_/CLK }
C {devices/lab_pin.sym} 131330 -26930 0 0 {name=p130410 lab=_84182_/D }
C {devices/lab_pin.sym} 131510 -26950 0 1 {name=p130411 lab=_84182_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -26940 0 0 {name=X_84182_ }
C {devices/lab_pin.sym} 131340 -26830 0 0 {name=p130412 lab=_50571_/Y }
C {devices/lab_pin.sym} 131340 -26790 0 0 {name=p130413 lab=_50474_/X }
C {devices/lab_pin.sym} 131340 -26750 0 0 {name=p130414 lab=_50573_/Y }
C {devices/lab_pin.sym} 131500 -26790 0 1 {name=p130415 lab=_86175_/D }
C {sky130_stdcells/a21boi_4.sym} 131420 -26790 0 0 {name=X_50574_ }
C {devices/lab_pin.sym} 131330 -26650 0 0 {name=p130416 lab=_83932_/CLK }
C {devices/lab_pin.sym} 131330 -26630 0 0 {name=p130417 lab=_83930_/Q }
C {devices/lab_pin.sym} 131510 -26650 0 1 {name=p130418 lab=_81394_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -26640 0 0 {name=X_81394_ }
C {devices/lab_pin.sym} 131340 -26530 0 0 {name=p130419 lab=_85318_/Q }
C {devices/lab_pin.sym} 131340 -26490 0 0 {name=p130420 lab=_55098_/X }
C {devices/lab_pin.sym} 131340 -26450 0 0 {name=p130421 lab=_55100_/Y }
C {devices/lab_pin.sym} 131500 -26490 0 1 {name=p130422 lab=_55101_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -26490 0 0 {name=X_55101_ }
C {devices/lab_pin.sym} 131340 -26370 0 0 {name=p130423 lab=_85847_/Q }
C {devices/lab_pin.sym} 131340 -26330 0 0 {name=p130424 lab=_52297_/X }
C {devices/lab_pin.sym} 131340 -26290 0 0 {name=p130425 lab=_52312_/Y }
C {devices/lab_pin.sym} 131500 -26330 0 1 {name=p130426 lab=_52313_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -26330 0 0 {name=X_52313_ }
C {devices/lab_pin.sym} 131330 -26190 0 0 {name=p130427 lab=_83133_/CLK }
C {devices/lab_pin.sym} 131330 -26170 0 0 {name=p130428 lab=_73868_/Y }
C {devices/lab_pin.sym} 131510 -26190 0 1 {name=p130429 lab=_83133_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -26180 0 0 {name=X_83133_ }
C {devices/lab_pin.sym} 131340 -26070 0 0 {name=p130430 lab=_56058_/X }
C {devices/lab_pin.sym} 131340 -26030 0 0 {name=p130431 lab=_56079_/X }
C {devices/lab_pin.sym} 131340 -25990 0 0 {name=p130432 lab=_56080_/Y }
C {devices/lab_pin.sym} 131500 -26030 0 1 {name=p130433 lab=_85299_/D }
C {sky130_stdcells/o21ai_4.sym} 131420 -26030 0 0 {name=X_56081_ }
C {devices/lab_pin.sym} 131360 -25900 0 0 {name=p130434 lab=_84751_/Q }
C {devices/lab_pin.sym} 131360 -25860 0 0 {name=p130435 lab=_84143_/Q }
C {devices/lab_pin.sym} 131480 -25880 0 1 {name=p130436 lab=_80360_/B }
C {sky130_stdcells/nand2_4.sym} 131420 -25880 0 0 {name=X_80345_ }
C {devices/lab_pin.sym} 131360 -25760 0 0 {name=p130437 lab=_68437_/A }
C {devices/lab_pin.sym} 131360 -25720 0 0 {name=p130438 lab=_68067_/B }
C {devices/lab_pin.sym} 131480 -25740 0 1 {name=p130439 lab=_68067_/X }
C {sky130_stdcells/and2_4.sym} 131420 -25740 0 0 {name=X_68067_ }
C {devices/lab_pin.sym} 131360 -25640 0 0 {name=p130440 lab=_53293_/A }
C {devices/lab_pin.sym} 131360 -25600 0 0 {name=p130441 lab=_53293_/B }
C {devices/lab_pin.sym} 131360 -25560 0 0 {name=p130442 lab=_53293_/C }
C {devices/lab_pin.sym} 131360 -25520 0 0 {name=p130443 lab=_52779_/D }
C {devices/lab_pin.sym} 131480 -25580 0 1 {name=p130444 lab=_53293_/X }
C {sky130_stdcells/and4_4.sym} 131420 -25580 0 0 {name=X_53293_ }
C {devices/lab_pin.sym} 131360 -25440 0 0 {name=p130445 lab=_65206_/A }
C {devices/lab_pin.sym} 131360 -25400 0 0 {name=p130446 lab=_65279_/B }
C {devices/lab_pin.sym} 131480 -25420 0 1 {name=p130447 lab=_65279_/X }
C {sky130_stdcells/and2_4.sym} 131420 -25420 0 0 {name=X_65279_ }
C {devices/lab_pin.sym} 131340 -25310 0 0 {name=p130448 lab=_55029_/Y }
C {devices/lab_pin.sym} 131340 -25270 0 0 {name=p130449 lab=_55024_/X }
C {devices/lab_pin.sym} 131340 -25230 0 0 {name=p130450 lab=_55031_/X }
C {devices/lab_pin.sym} 131500 -25270 0 1 {name=p130451 lab=_85332_/D }
C {sky130_stdcells/a21oi_4.sym} 131420 -25270 0 0 {name=X_55032_ }
C {devices/lab_pin.sym} 131340 -25150 0 0 {name=p130452 lab=_80911_/D }
C {devices/lab_pin.sym} 131340 -25110 0 0 {name=p130453 lab=_66971_/X }
C {devices/lab_pin.sym} 131340 -25070 0 0 {name=p130454 lab=_67017_/X }
C {devices/lab_pin.sym} 131500 -25110 0 1 {name=p130455 lab=_84087_/D }
C {sky130_stdcells/a21bo_4.sym} 131420 -25110 0 0 {name=X_67018_ }
C {devices/lab_pin.sym} 131340 -24990 0 0 {name=p130456 lab=_52242_/Y }
C {devices/lab_pin.sym} 131340 -24950 0 0 {name=p130457 lab=_52232_/X }
C {devices/lab_pin.sym} 131340 -24910 0 0 {name=p130458 lab=_52243_/X }
C {devices/lab_pin.sym} 131500 -24950 0 1 {name=p130459 lab=_85861_/D }
C {sky130_stdcells/a21oi_4.sym} 131420 -24950 0 0 {name=X_52244_ }
C {devices/lab_pin.sym} 131330 -24810 0 0 {name=p130460 lab=_86498_/CLK }
C {devices/lab_pin.sym} 131330 -24790 0 0 {name=p130461 lab=_83064_/D }
C {devices/lab_pin.sym} 131510 -24810 0 1 {name=p130462 lab=_83064_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -24800 0 0 {name=X_83064_ }
C {devices/lab_pin.sym} 131330 -24670 0 0 {name=p130463 lab=_88387_/CLK }
C {devices/lab_pin.sym} 131330 -24650 0 0 {name=p130464 lab=_87941_/D }
C {devices/lab_pin.sym} 131510 -24670 0 1 {name=p130465 lab=_87941_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -24660 0 0 {name=X_87941_ }
C {devices/lab_pin.sym} 131380 -24530 0 0 {name=p130466 lab=_80279_/B }
C {devices/lab_pin.sym} 131460 -24530 0 1 {name=p130467 lab=_80276_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -24530 0 0 {name=X_80276_ }
C {devices/lab_pin.sym} 131330 -24410 0 0 {name=p130468 lab=_82015_/CLK }
C {devices/lab_pin.sym} 131330 -24390 0 0 {name=p130469 lab=_82015_/D }
C {devices/lab_pin.sym} 131510 -24410 0 1 {name=p130470 lab=_77217_/A }
C {sky130_stdcells/dfxtp_4.sym} 131420 -24400 0 0 {name=X_82015_ }
C {devices/lab_pin.sym} 131380 -24270 0 0 {name=p130471 lab=_59840_/A }
C {devices/lab_pin.sym} 131460 -24270 0 1 {name=p130472 lab=_59840_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -24270 0 0 {name=X_59840_ }
C {devices/lab_pin.sym} 131360 -24170 0 0 {name=p130473 lab=_52175_/A }
C {devices/lab_pin.sym} 131360 -24130 0 0 {name=p130474 lab=_52194_/B }
C {devices/lab_pin.sym} 131360 -24090 0 0 {name=p130475 lab=_52182_/C }
C {devices/lab_pin.sym} 131480 -24130 0 1 {name=p130476 lab=_52175_/X }
C {sky130_stdcells/and3_4.sym} 131420 -24130 0 0 {name=X_52175_ }
C {devices/lab_pin.sym} 131330 -23990 0 0 {name=p130477 lab=_88128_/CLK }
C {devices/lab_pin.sym} 131330 -23970 0 0 {name=p130478 lab=_87872_/D }
C {devices/lab_pin.sym} 131510 -23990 0 1 {name=p130479 lab=_87872_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -23980 0 0 {name=X_87872_ }
C {devices/lab_pin.sym} 131380 -23850 0 0 {name=p130480 lab=clkbuf_8_41_0_CLK/A }
C {devices/lab_pin.sym} 131460 -23850 0 1 {name=p130481 lab=clkbuf_9_83_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 131420 -23850 0 0 {name=Xclkbuf_8_41_0_CLK }
C {devices/lab_pin.sym} 131340 -23750 0 0 {name=p130482 lab=_51124_/Y }
C {devices/lab_pin.sym} 131340 -23710 0 0 {name=p130483 lab=_51119_/X }
C {devices/lab_pin.sym} 131340 -23670 0 0 {name=p130484 lab=_51125_/X }
C {devices/lab_pin.sym} 131500 -23710 0 1 {name=p130485 lab=_51126_/Y }
C {sky130_stdcells/a21oi_4.sym} 131420 -23710 0 0 {name=X_51126_ }
C {devices/lab_pin.sym} 131330 -23570 0 0 {name=p130486 lab=_88245_/CLK }
C {devices/lab_pin.sym} 131330 -23550 0 0 {name=p130487 lab=_86823_/D }
C {devices/lab_pin.sym} 131510 -23570 0 1 {name=p130488 lab=_66938_/B }
C {sky130_stdcells/dfxtp_4.sym} 131420 -23560 0 0 {name=X_86823_ }
C {devices/lab_pin.sym} 131380 -23430 0 0 {name=p130489 lab=_65044_/A }
C {devices/lab_pin.sym} 131460 -23430 0 1 {name=p130490 lab=_59771_/X }
C {sky130_stdcells/buf_2.sym} 131420 -23430 0 0 {name=X_59771_ }
C {devices/lab_pin.sym} 131380 -23310 0 0 {name=p130491 lab=_56684_/C }
C {devices/lab_pin.sym} 131460 -23310 0 1 {name=p130492 lab=_57149_/B }
C {sky130_stdcells/buf_2.sym} 131420 -23310 0 0 {name=X_56983_ }
C {devices/lab_pin.sym} 131340 -23210 0 0 {name=p130493 lab=_68966_/X }
C {devices/lab_pin.sym} 131340 -23170 0 0 {name=p130494 lab=_68968_/X }
C {devices/lab_pin.sym} 131340 -23130 0 0 {name=p130495 lab=_68922_/X }
C {devices/lab_pin.sym} 131500 -23170 0 1 {name=p130496 lab=_68969_/X }
C {sky130_stdcells/a21o_4.sym} 131420 -23170 0 0 {name=X_68969_ }
C {devices/lab_pin.sym} 131360 -23040 0 0 {name=p130497 lab=_58722_/A }
C {devices/lab_pin.sym} 131360 -23000 0 0 {name=p130498 lab=_58764_/B }
C {devices/lab_pin.sym} 131480 -23020 0 1 {name=p130499 lab=_58722_/Y }
C {sky130_stdcells/nor2_4.sym} 131420 -23020 0 0 {name=X_58722_ }
C {devices/lab_pin.sym} 131340 -22910 0 0 {name=p130500 lab=_51054_/Y }
C {devices/lab_pin.sym} 131340 -22870 0 0 {name=p130501 lab=_51039_/X }
C {devices/lab_pin.sym} 131340 -22830 0 0 {name=p130502 lab=_51056_/X }
C {devices/lab_pin.sym} 131500 -22870 0 1 {name=p130503 lab=_51057_/Y }
C {sky130_stdcells/a21oi_4.sym} 131420 -22870 0 0 {name=X_51057_ }
C {devices/lab_pin.sym} 131360 -22740 0 0 {name=p130504 lab=_44085_/C }
C {devices/lab_pin.sym} 131360 -22700 0 0 {name=p130505 lab=_55934_/B }
C {devices/lab_pin.sym} 131480 -22720 0 1 {name=p130506 lab=_55934_/X }
C {sky130_stdcells/and2_4.sym} 131420 -22720 0 0 {name=X_55934_ }
C {devices/lab_pin.sym} 131330 -22590 0 0 {name=p130507 lab=_83115_/CLK }
C {devices/lab_pin.sym} 131330 -22570 0 0 {name=p130508 lab=_86754_/D }
C {devices/lab_pin.sym} 131510 -22590 0 1 {name=p130509 lab=_86754_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -22580 0 0 {name=X_86754_ }
C {devices/lab_pin.sym} 131340 -22470 0 0 {name=p130510 lab=_71977_/Y }
C {devices/lab_pin.sym} 131340 -22430 0 0 {name=p130511 lab=_71978_/X }
C {devices/lab_pin.sym} 131340 -22390 0 0 {name=p130512 lab=_71979_/X }
C {devices/lab_pin.sym} 131500 -22430 0 1 {name=p130513 lab=_71980_/Y }
C {sky130_stdcells/a21oi_4.sym} 131420 -22430 0 0 {name=X_71980_ }
C {devices/lab_pin.sym} 131330 -22290 0 0 {name=p130514 lab=_81994_/CLK }
C {devices/lab_pin.sym} 131330 -22270 0 0 {name=p130515 lab=_83966_/D }
C {devices/lab_pin.sym} 131510 -22290 0 1 {name=p130516 lab=_80822_/D }
C {sky130_stdcells/dfxtp_4.sym} 131420 -22280 0 0 {name=X_83966_ }
C {devices/lab_pin.sym} 131340 -22170 0 0 {name=p130517 lab=_72400_/B }
C {devices/lab_pin.sym} 131340 -22130 0 0 {name=p130518 lab=_49986_/X }
C {devices/lab_pin.sym} 131340 -22090 0 0 {name=p130519 lab=_50007_/Y }
C {devices/lab_pin.sym} 131500 -22130 0 1 {name=p130520 lab=_50008_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -22130 0 0 {name=X_50008_ }
C {devices/lab_pin.sym} 131330 -21990 0 0 {name=p130521 lab=_86686_/CLK }
C {devices/lab_pin.sym} 131330 -21970 0 0 {name=p130522 lab=_53059_/Y }
C {devices/lab_pin.sym} 131510 -21990 0 1 {name=p130523 lab=_85705_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -21980 0 0 {name=X_85705_ }
C {devices/lab_pin.sym} 131340 -21870 0 0 {name=p130524 lab=_46912_/X }
C {devices/lab_pin.sym} 131340 -21830 0 0 {name=p130525 lab=_70909_/A }
C {devices/lab_pin.sym} 131340 -21790 0 0 {name=p130526 lab=_70930_/Y }
C {devices/lab_pin.sym} 131500 -21830 0 1 {name=p130527 lab=_70931_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -21830 0 0 {name=X_70931_ }
C {devices/lab_pin.sym} 131380 -21690 0 0 {name=p130528 lab=_58653_/A }
C {devices/lab_pin.sym} 131460 -21690 0 1 {name=p130529 lab=_58653_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -21690 0 0 {name=X_58653_ }
C {devices/lab_pin.sym} 131380 -21570 0 0 {name=p130530 lab=clkbuf_8_57_0_CLK/A }
C {devices/lab_pin.sym} 131460 -21570 0 1 {name=p130531 lab=clkbuf_8_56_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 131420 -21570 0 0 {name=Xclkbuf_8_56_0_CLK }
C {devices/lab_pin.sym} 131330 -21450 0 0 {name=p130532 lab=_82931_/CLK }
C {devices/lab_pin.sym} 131330 -21430 0 0 {name=p130533 lab=_78153_/X }
C {devices/lab_pin.sym} 131510 -21450 0 1 {name=p130534 lab=_46567_/A }
C {sky130_stdcells/dfxtp_4.sym} 131420 -21440 0 0 {name=X_82917_ }
C {devices/lab_pin.sym} 131360 -21320 0 0 {name=p130535 lab=_55549_/A }
C {devices/lab_pin.sym} 131360 -21280 0 0 {name=p130536 lab=_55865_/B }
C {devices/lab_pin.sym} 131480 -21300 0 1 {name=p130537 lab=_55865_/X }
C {sky130_stdcells/and2_4.sym} 131420 -21300 0 0 {name=X_55865_ }
C {devices/lab_pin.sym} 131330 -21170 0 0 {name=p130538 lab=_86686_/CLK }
C {devices/lab_pin.sym} 131330 -21150 0 0 {name=p130539 lab=_86685_/D }
C {devices/lab_pin.sym} 131510 -21170 0 1 {name=p130540 lab=_86685_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -21160 0 0 {name=X_86685_ }
C {devices/lab_pin.sym} 131330 -21030 0 0 {name=p130541 lab=_82299_/CLK }
C {devices/lab_pin.sym} 131330 -21010 0 0 {name=p130542 lab=_83897_/D }
C {devices/lab_pin.sym} 131510 -21030 0 1 {name=p130543 lab=_81969_/D }
C {sky130_stdcells/dfxtp_4.sym} 131420 -21020 0 0 {name=X_83897_ }
C {devices/lab_pin.sym} 131380 -20890 0 0 {name=p130544 lab=_72017_/A }
C {devices/lab_pin.sym} 131460 -20890 0 1 {name=p130545 lab=_57630_/A }
C {sky130_stdcells/buf_2.sym} 131420 -20890 0 0 {name=X_57604_ }
C {devices/lab_pin.sym} 131360 -20800 0 0 {name=p130546 lab=_54825_/A }
C {devices/lab_pin.sym} 131360 -20760 0 0 {name=p130547 lab=_54816_/B }
C {devices/lab_pin.sym} 131360 -20720 0 0 {name=p130548 lab=_54831_/C }
C {devices/lab_pin.sym} 131360 -20680 0 0 {name=p130549 lab=_53125_/D }
C {devices/lab_pin.sym} 131480 -20740 0 1 {name=p130550 lab=_54816_/X }
C {sky130_stdcells/and4_4.sym} 131420 -20740 0 0 {name=X_54816_ }
C {devices/lab_pin.sym} 131380 -20590 0 0 {name=p130551 lab=_42820_/X }
C {devices/lab_pin.sym} 131460 -20590 0 1 {name=p130552 lab=_42830_/X }
C {sky130_stdcells/buf_2.sym} 131420 -20590 0 0 {name=X_42830_ }
C {devices/lab_pin.sym} 131360 -20480 0 0 {name=p130553 lab=_73650_/A }
C {devices/lab_pin.sym} 131360 -20440 0 0 {name=p130554 lab=_73649_/X }
C {devices/lab_pin.sym} 131480 -20460 0 1 {name=p130555 lab=_73650_/Y }
C {sky130_stdcells/nor2_4.sym} 131420 -20460 0 0 {name=X_73650_ }
C {devices/lab_pin.sym} 131330 -20330 0 0 {name=p130556 lab=_86054_/CLK }
C {devices/lab_pin.sym} 131330 -20310 0 0 {name=p130557 lab=_53425_/Y }
C {devices/lab_pin.sym} 131510 -20330 0 1 {name=p130558 lab=_85636_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -20320 0 0 {name=X_85636_ }
C {devices/lab_pin.sym} 131380 -20190 0 0 {name=p130559 lab=_70862_/A }
C {devices/lab_pin.sym} 131460 -20190 0 1 {name=p130560 lab=_70869_/D }
C {sky130_stdcells/buf_2.sym} 131420 -20190 0 0 {name=X_70862_ }
C {devices/lab_pin.sym} 131340 -20100 0 0 {name=p130561 lab=_84816_/Q }
C {devices/lab_pin.sym} 131340 -20060 0 0 {name=p130562 lab=_58095_/X }
C {devices/lab_pin.sym} 131340 -20020 0 0 {name=p130563 lab=_58578_/X }
C {devices/lab_pin.sym} 131340 -19980 0 0 {name=p130564 lab=_58583_/X }
C {devices/lab_pin.sym} 131500 -20040 0 1 {name=p130565 lab=_58584_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 131420 -20040 0 0 {name=X_58584_ }
C {devices/lab_pin.sym} 131330 -19890 0 0 {name=p130566 lab=_82152_/CLK }
C {devices/lab_pin.sym} 131330 -19870 0 0 {name=p130567 lab=_82848_/D }
C {devices/lab_pin.sym} 131510 -19890 0 1 {name=p130568 lab=_82848_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -19880 0 0 {name=X_82848_ }
C {devices/lab_pin.sym} 131340 -19770 0 0 {name=p130569 lab=_55793_/X }
C {devices/lab_pin.sym} 131340 -19730 0 0 {name=p130570 lab=_55795_/X }
C {devices/lab_pin.sym} 131340 -19690 0 0 {name=p130571 lab=_44110_/X }
C {devices/lab_pin.sym} 131500 -19730 0 1 {name=p130572 lab=_55796_/X }
C {sky130_stdcells/a21o_4.sym} 131420 -19730 0 0 {name=X_55796_ }
C {devices/lab_pin.sym} 131340 -19620 0 0 {name=p130573 lab=_83221_/Q }
C {devices/lab_pin.sym} 131340 -19580 0 0 {name=p130574 lab=_72445_/X }
C {devices/lab_pin.sym} 131340 -19540 0 0 {name=p130575 lab=_72588_/Y }
C {devices/lab_pin.sym} 131340 -19500 0 0 {name=p130576 lab=_72600_/Y }
C {devices/lab_pin.sym} 131500 -19560 0 1 {name=p130577 lab=_72601_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 131420 -19560 0 0 {name=X_72601_ }
C {devices/lab_pin.sym} 131360 -19420 0 0 {name=p130578 lab=_57531_/A }
C {devices/lab_pin.sym} 131360 -19380 0 0 {name=p130579 lab=_53504_/B }
C {devices/lab_pin.sym} 131480 -19400 0 1 {name=p130580 lab=_57535_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -19400 0 0 {name=X_57535_ }
C {devices/lab_pin.sym} 131340 -19310 0 0 {name=p130581 lab=_42739_/X }
C {devices/lab_pin.sym} 131340 -19270 0 0 {name=p130582 lab=_42740_/X }
C {devices/lab_pin.sym} 131340 -19230 0 0 {name=p130583 lab=_41277_/X }
C {devices/lab_pin.sym} 131340 -19190 0 0 {name=p130584 lab=_87733_/Q }
C {devices/lab_pin.sym} 131340 -19150 0 0 {name=p130585 lab=_42750_/X }
C {devices/lab_pin.sym} 131500 -19230 0 1 {name=p130586 lab=_42762_/A }
C {sky130_stdcells/o32ai_4.sym} 131420 -19230 0 0 {name=X_42761_ }
C {devices/lab_pin.sym} 131330 -19070 0 0 {name=p130587 lab=_88363_/CLK }
C {devices/lab_pin.sym} 131330 -19050 0 0 {name=p130588 lab=_88355_/D }
C {devices/lab_pin.sym} 131510 -19070 0 1 {name=p130589 lab=_88355_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -19060 0 0 {name=X_88355_ }
C {devices/lab_pin.sym} 131380 -18930 0 0 {name=p130590 lab=_54693_/X }
C {devices/lab_pin.sym} 131460 -18930 0 1 {name=p130591 lab=_54747_/X }
C {sky130_stdcells/buf_2.sym} 131420 -18930 0 0 {name=X_54747_ }
C {devices/lab_pin.sym} 131340 -18830 0 0 {name=p130592 lab=_87006_/Q }
C {devices/lab_pin.sym} 131340 -18790 0 0 {name=p130593 lab=_57092_/X }
C {devices/lab_pin.sym} 131340 -18750 0 0 {name=p130594 lab=_73580_/X }
C {devices/lab_pin.sym} 131500 -18790 0 1 {name=p130595 lab=_73581_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -18790 0 0 {name=X_73581_ }
C {devices/lab_pin.sym} 131330 -18650 0 0 {name=p130596 lab=_83307_/CLK }
C {devices/lab_pin.sym} 131330 -18630 0 0 {name=p130597 lab=_85567_/D }
C {devices/lab_pin.sym} 131510 -18650 0 1 {name=p130598 lab=_85567_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -18640 0 0 {name=X_85567_ }
C {devices/lab_pin.sym} 131340 -18530 0 0 {name=p130599 lab=_51955_/Y }
C {devices/lab_pin.sym} 131340 -18490 0 0 {name=p130600 lab=_51951_/X }
C {devices/lab_pin.sym} 131340 -18450 0 0 {name=p130601 lab=_51958_/X }
C {devices/lab_pin.sym} 131500 -18490 0 1 {name=p130602 lab=_51959_/Y }
C {sky130_stdcells/a21oi_4.sym} 131420 -18490 0 0 {name=X_51959_ }
C {devices/lab_pin.sym} 131380 -18350 0 0 {name=p130603 lab=_70824_/A }
C {devices/lab_pin.sym} 131460 -18350 0 1 {name=p130604 lab=_70905_/A }
C {sky130_stdcells/buf_2.sym} 131420 -18350 0 0 {name=X_70793_ }
C {devices/lab_pin.sym} 131330 -18230 0 0 {name=p130605 lab=_82206_/CLK }
C {devices/lab_pin.sym} 131330 -18210 0 0 {name=p130606 lab=_82779_/D }
C {devices/lab_pin.sym} 131510 -18230 0 1 {name=p130607 lab=_82779_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -18220 0 0 {name=X_82779_ }
C {devices/lab_pin.sym} 131380 -18090 0 0 {name=p130608 lab=_44500_/A }
C {devices/lab_pin.sym} 131460 -18090 0 1 {name=p130609 lab=_44500_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -18090 0 0 {name=X_44500_ }
C {devices/lab_pin.sym} 131360 -17980 0 0 {name=p130610 lab=_75320_/A }
C {devices/lab_pin.sym} 131360 -17940 0 0 {name=p130611 lab=_81075_/Q }
C {devices/lab_pin.sym} 131480 -17960 0 1 {name=p130612 lab=_75320_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -17960 0 0 {name=X_75320_ }
C {devices/lab_pin.sym} 131330 -17830 0 0 {name=p130613 lab=_83158_/CLK }
C {devices/lab_pin.sym} 131330 -17810 0 0 {name=p130614 lab=_87306_/D }
C {devices/lab_pin.sym} 131510 -17830 0 1 {name=p130615 lab=_87306_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -17820 0 0 {name=X_87306_ }
C {devices/lab_pin.sym} 131380 -17690 0 0 {name=p130616 lab=_41712_/A }
C {devices/lab_pin.sym} 131460 -17690 0 1 {name=p130617 lab=_41712_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -17690 0 0 {name=X_41712_ }
C {devices/lab_pin.sym} 131340 -17590 0 0 {name=p130618 lab=_72569_/A }
C {devices/lab_pin.sym} 131340 -17550 0 0 {name=p130619 lab=_72531_/Y }
C {devices/lab_pin.sym} 131340 -17510 0 0 {name=p130620 lab=_61202_/A }
C {devices/lab_pin.sym} 131500 -17550 0 1 {name=p130621 lab=_72532_/X }
C {sky130_stdcells/a21o_4.sym} 131420 -17550 0 0 {name=X_72532_ }
C {devices/lab_pin.sym} 131330 -17410 0 0 {name=p130622 lab=_84518_/CLK }
C {devices/lab_pin.sym} 131330 -17390 0 0 {name=p130623 lab=_61139_/Y }
C {devices/lab_pin.sym} 131510 -17410 0 1 {name=p130624 lab=_84518_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -17400 0 0 {name=X_84518_ }
C {devices/lab_pin.sym} 131340 -17290 0 0 {name=p130625 lab=_85148_/Q }
C {devices/lab_pin.sym} 131340 -17250 0 0 {name=p130626 lab=_45464_/X }
C {devices/lab_pin.sym} 131340 -17210 0 0 {name=p130627 lab=_44919_/X }
C {devices/lab_pin.sym} 131500 -17250 0 1 {name=p130628 lab=_45480_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -17250 0 0 {name=X_45480_ }
C {devices/lab_pin.sym} 131340 -17130 0 0 {name=p130629 lab=_57440_/X }
C {devices/lab_pin.sym} 131340 -17090 0 0 {name=p130630 lab=_57464_/X }
C {devices/lab_pin.sym} 131340 -17050 0 0 {name=p130631 lab=_57465_/X }
C {devices/lab_pin.sym} 131500 -17090 0 1 {name=p130632 lab=_57466_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -17090 0 0 {name=X_57466_ }
C {devices/lab_pin.sym} 131330 -16950 0 0 {name=p130633 lab=_87253_/CLK }
C {devices/lab_pin.sym} 131330 -16930 0 0 {name=p130634 lab=_41056_/Y }
C {devices/lab_pin.sym} 131510 -16950 0 1 {name=p130635 lab=_69431_/B }
C {sky130_stdcells/dfxtp_4.sym} 131420 -16940 0 0 {name=X_88286_ }
C {devices/lab_pin.sym} 131380 -16810 0 0 {name=p130636 lab=_42692_/A }
C {devices/lab_pin.sym} 131460 -16810 0 1 {name=p130637 lab=_42692_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -16810 0 0 {name=X_42692_ }
C {devices/lab_pin.sym} 131360 -16700 0 0 {name=p130638 lab=_54682_/A }
C {devices/lab_pin.sym} 131360 -16660 0 0 {name=p130639 lab=_47324_/A }
C {devices/lab_pin.sym} 131480 -16680 0 1 {name=p130640 lab=_54678_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -16680 0 0 {name=X_54678_ }
C {devices/lab_pin.sym} 131330 -16550 0 0 {name=p130641 lab=_83745_/CLK }
C {devices/lab_pin.sym} 131330 -16530 0 0 {name=p130642 lab=_85498_/D }
C {devices/lab_pin.sym} 131510 -16550 0 1 {name=p130643 lab=_85498_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -16540 0 0 {name=X_85498_ }
C {devices/lab_pin.sym} 131380 -16410 0 0 {name=p130644 lab=_59081_/A }
C {devices/lab_pin.sym} 131460 -16410 0 1 {name=p130645 lab=_59205_/X }
C {sky130_stdcells/buf_2.sym} 131420 -16410 0 0 {name=X_59205_ }
C {devices/lab_pin.sym} 131380 -16290 0 0 {name=p130646 lab=_44363_/X }
C {devices/lab_pin.sym} 131460 -16290 0 1 {name=p130647 lab=_44431_/X }
C {sky130_stdcells/buf_2.sym} 131420 -16290 0 0 {name=X_44431_ }
C {devices/lab_pin.sym} 131340 -16190 0 0 {name=p130648 lab=_56085_/X }
C {devices/lab_pin.sym} 131340 -16150 0 0 {name=p130649 lab=_56409_/X }
C {devices/lab_pin.sym} 131340 -16110 0 0 {name=p130650 lab=_56416_/Y }
C {devices/lab_pin.sym} 131500 -16150 0 1 {name=p130651 lab=_56417_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -16150 0 0 {name=X_56417_ }
C {devices/lab_pin.sym} 131360 -16020 0 0 {name=p130652 lab=_75251_/A }
C {devices/lab_pin.sym} 131360 -15980 0 0 {name=p130653 lab=_81070_/Q }
C {devices/lab_pin.sym} 131480 -16000 0 1 {name=p130654 lab=_75251_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -16000 0 0 {name=X_75251_ }
C {devices/lab_pin.sym} 131330 -15870 0 0 {name=p130655 lab=_88012_/CLK }
C {devices/lab_pin.sym} 131330 -15850 0 0 {name=p130656 lab=_87237_/D }
C {devices/lab_pin.sym} 131510 -15870 0 1 {name=p130657 lab=_68718_/B }
C {sky130_stdcells/dfxtp_4.sym} 131420 -15860 0 0 {name=X_87237_ }
C {devices/lab_pin.sym} 131380 -15730 0 0 {name=p130658 lab=_41642_/Y }
C {devices/lab_pin.sym} 131460 -15730 0 1 {name=p130659 lab=_41643_/X }
C {sky130_stdcells/buf_2.sym} 131420 -15730 0 0 {name=X_41643_ }
C {devices/lab_pin.sym} 131340 -15630 0 0 {name=p130660 lab=_85599_/Q }
C {devices/lab_pin.sym} 131340 -15590 0 0 {name=p130661 lab=_53626_/X }
C {devices/lab_pin.sym} 131340 -15550 0 0 {name=p130662 lab=_53628_/Y }
C {devices/lab_pin.sym} 131500 -15590 0 1 {name=p130663 lab=_53629_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -15590 0 0 {name=X_53629_ }
C {devices/lab_pin.sym} 131340 -15490 0 0 {name=p130664 lab=_57800_/X }
C {devices/lab_pin.sym} 131340 -15450 0 0 {name=p130665 lab=_72461_/Y }
C {devices/lab_pin.sym} 131340 -15410 0 0 {name=p130666 lab=_72462_/Y }
C {devices/lab_pin.sym} 131340 -15370 0 0 {name=p130667 lab=_64761_/B }
C {devices/lab_pin.sym} 131340 -15330 0 0 {name=p130668 lab=_59833_/X }
C {devices/lab_pin.sym} 131500 -15410 0 1 {name=p130669 lab=_72463_/X }
C {sky130_stdcells/o32a_4.sym} 131420 -15410 0 0 {name=X_72463_ }
C {devices/lab_pin.sym} 131330 -15250 0 0 {name=p130670 lab=_84449_/CLK }
C {devices/lab_pin.sym} 131330 -15230 0 0 {name=p130671 lab=_61866_/Y }
C {devices/lab_pin.sym} 131510 -15250 0 1 {name=p130672 lab=_78072_/B }
C {sky130_stdcells/dfxtp_4.sym} 131420 -15240 0 0 {name=X_84449_ }
C {devices/lab_pin.sym} 131360 -15130 0 0 {name=p130673 lab=_57359_/A }
C {devices/lab_pin.sym} 131360 -15090 0 0 {name=p130674 lab=_57397_/B }
C {devices/lab_pin.sym} 131360 -15050 0 0 {name=p130675 lab=_57372_/X }
C {devices/lab_pin.sym} 131480 -15090 0 1 {name=p130676 lab=_57397_/Y }
C {sky130_stdcells/nor3_4.sym} 131420 -15090 0 0 {name=X_57397_ }
C {devices/lab_pin.sym} 131360 -14960 0 0 {name=p130677 lab=_74202_/A }
C {devices/lab_pin.sym} 131360 -14920 0 0 {name=p130678 lab=_74201_/Y }
C {devices/lab_pin.sym} 131480 -14940 0 1 {name=p130679 lab=_74202_/Y }
C {sky130_stdcells/nor2_4.sym} 131420 -14940 0 0 {name=X_74202_ }
C {devices/lab_pin.sym} 131360 -14820 0 0 {name=p130680 lab=_47150_/A }
C {devices/lab_pin.sym} 131360 -14780 0 0 {name=p130681 lab=_52881_/B }
C {devices/lab_pin.sym} 131480 -14800 0 1 {name=p130682 lab=_47150_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -14800 0 0 {name=X_47150_ }
C {devices/lab_pin.sym} 131340 -14690 0 0 {name=p130683 lab=_59135_/X }
C {devices/lab_pin.sym} 131340 -14650 0 0 {name=p130684 lab=_85654_/Q }
C {devices/lab_pin.sym} 131340 -14610 0 0 {name=p130685 lab=_59070_/X }
C {devices/lab_pin.sym} 131500 -14650 0 1 {name=p130686 lab=_59136_/X }
C {sky130_stdcells/o21a_4.sym} 131420 -14650 0 0 {name=X_59136_ }
C {devices/lab_pin.sym} 131340 -14530 0 0 {name=p130687 lab=_71396_/Y }
C {devices/lab_pin.sym} 131340 -14490 0 0 {name=p130688 lab=_83507_/Q }
C {devices/lab_pin.sym} 131340 -14450 0 0 {name=p130689 lab=_71413_/Y }
C {devices/lab_pin.sym} 131500 -14490 0 1 {name=p130690 lab=_71414_/X }
C {sky130_stdcells/a21o_4.sym} 131420 -14490 0 0 {name=X_71414_ }
C {devices/lab_pin.sym} 131380 -14350 0 0 {name=p130691 lab=_44362_/A }
C {devices/lab_pin.sym} 131460 -14350 0 1 {name=p130692 lab=_46298_/A }
C {sky130_stdcells/buf_2.sym} 131420 -14350 0 0 {name=X_44362_ }
C {devices/lab_pin.sym} 131360 -14250 0 0 {name=p130693 lab=_56358_/A }
C {devices/lab_pin.sym} 131360 -14210 0 0 {name=p130694 lab=_56345_/B }
C {devices/lab_pin.sym} 131360 -14170 0 0 {name=p130695 lab=_55774_/B }
C {devices/lab_pin.sym} 131480 -14210 0 1 {name=p130696 lab=_56348_/Y }
C {sky130_stdcells/nand3_4.sym} 131420 -14210 0 0 {name=X_56348_ }
C {devices/lab_pin.sym} 131360 -14080 0 0 {name=p130697 lab=_75182_/A }
C {devices/lab_pin.sym} 131360 -14040 0 0 {name=p130698 lab=_75181_/Y }
C {devices/lab_pin.sym} 131480 -14060 0 1 {name=p130699 lab=_81033_/D }
C {sky130_stdcells/xnor2_4.sym} 131420 -14060 0 0 {name=X_75182_ }
C {devices/lab_pin.sym} 131380 -13930 0 0 {name=p130700 lab=_41573_/X }
C {devices/lab_pin.sym} 131460 -13930 0 1 {name=p130701 lab=_41574_/X }
C {sky130_stdcells/buf_2.sym} 131420 -13930 0 0 {name=X_41574_ }
C {devices/lab_pin.sym} 131330 -13810 0 0 {name=p130702 lab=_87169_/CLK }
C {devices/lab_pin.sym} 131330 -13790 0 0 {name=p130703 lab=_44320_/Y }
C {devices/lab_pin.sym} 131510 -13810 0 1 {name=p130704 lab=_43950_/A }
C {sky130_stdcells/dfxtp_4.sym} 131420 -13800 0 0 {name=X_87168_ }
C {devices/lab_pin.sym} 131380 -13670 0 0 {name=p130705 lab=_72394_/A }
C {devices/lab_pin.sym} 131460 -13670 0 1 {name=p130706 lab=_72394_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -13670 0 0 {name=X_72394_ }
C {devices/lab_pin.sym} 131380 -13550 0 0 {name=p130707 lab=_46101_/A }
C {devices/lab_pin.sym} 131460 -13550 0 1 {name=p130708 lab=_46214_/D }
C {sky130_stdcells/buf_2.sym} 131420 -13550 0 0 {name=X_46101_ }
C {devices/lab_pin.sym} 131340 -13470 0 0 {name=p130709 lab=_43296_/X }
C {devices/lab_pin.sym} 131340 -13430 0 0 {name=p130710 lab=_43305_/X }
C {devices/lab_pin.sym} 131340 -13390 0 0 {name=p130711 lab=_41225_/X }
C {devices/lab_pin.sym} 131340 -13350 0 0 {name=p130712 lab=_87486_/Q }
C {devices/lab_pin.sym} 131340 -13310 0 0 {name=p130713 lab=_43308_/X }
C {devices/lab_pin.sym} 131500 -13390 0 1 {name=p130714 lab=_43314_/A }
C {sky130_stdcells/o32ai_4.sym} 131420 -13390 0 0 {name=X_43313_ }
C {devices/lab_pin.sym} 131340 -13260 0 0 {name=p130715 lab=_73566_/X }
C {devices/lab_pin.sym} 131340 -13220 0 0 {name=p130716 lab=_84969_/Q }
C {devices/lab_pin.sym} 131340 -13180 0 0 {name=p130717 lab=_74087_/X }
C {devices/lab_pin.sym} 131340 -13140 0 0 {name=p130718 lab=_74132_/X }
C {devices/lab_pin.sym} 131500 -13200 0 1 {name=p130719 lab=_74133_/X }
C {sky130_stdcells/a211o_4.sym} 131420 -13200 0 0 {name=X_74133_ }
C {devices/lab_pin.sym} 131330 -13050 0 0 {name=p130720 lab=_86119_/CLK }
C {devices/lab_pin.sym} 131330 -13030 0 0 {name=p130721 lab=_86119_/D }
C {devices/lab_pin.sym} 131510 -13050 0 1 {name=p130722 lab=_86119_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -13040 0 0 {name=X_86119_ }
C {devices/lab_pin.sym} 131340 -12940 0 0 {name=p130723 lab=_40524_/X }
C {devices/lab_pin.sym} 131340 -12900 0 0 {name=p130724 lab=_40508_/X }
C {devices/lab_pin.sym} 131340 -12860 0 0 {name=p130725 lab=_88377_/Q }
C {devices/lab_pin.sym} 131340 -12820 0 0 {name=p130726 lab=_40510_/X }
C {devices/lab_pin.sym} 131500 -12880 0 1 {name=p130727 lab=_88377_/D }
C {sky130_stdcells/a2bb2o_4.sym} 131420 -12880 0 0 {name=X_40525_ }
C {devices/lab_pin.sym} 131380 -12730 0 0 {name=p130728 lab=_47081_/A }
C {devices/lab_pin.sym} 131460 -12730 0 1 {name=p130729 lab=_47081_/X }
C {sky130_stdcells/buf_2.sym} 131420 -12730 0 0 {name=X_47081_ }
C {devices/lab_pin.sym} 131380 -12610 0 0 {name=p130730 lab=_58897_/A }
C {devices/lab_pin.sym} 131460 -12610 0 1 {name=p130731 lab=_59068_/B }
C {sky130_stdcells/buf_2.sym} 131420 -12610 0 0 {name=X_59067_ }
C {devices/lab_pin.sym} 131380 -12490 0 0 {name=p130732 lab=_71462_/B }
C {devices/lab_pin.sym} 131460 -12490 0 1 {name=p130733 lab=_71418_/B }
C {sky130_stdcells/buf_2.sym} 131420 -12490 0 0 {name=X_71345_ }
C {devices/lab_pin.sym} 131360 -12390 0 0 {name=p130734 lab=_44268_/A }
C {devices/lab_pin.sym} 131360 -12350 0 0 {name=p130735 lab=_44293_/B }
C {devices/lab_pin.sym} 131360 -12310 0 0 {name=p130736 lab=_72498_/B }
C {devices/lab_pin.sym} 131480 -12350 0 1 {name=p130737 lab=_44293_/Y }
C {sky130_stdcells/nand3_4.sym} 131420 -12350 0 0 {name=X_44293_ }
C {devices/lab_pin.sym} 131360 -12230 0 0 {name=p130738 lab=_56279_/A }
C {devices/lab_pin.sym} 131360 -12190 0 0 {name=p130739 lab=_57223_/D }
C {devices/lab_pin.sym} 131360 -12150 0 0 {name=p130740 lab=_56174_/X }
C {devices/lab_pin.sym} 131480 -12190 0 1 {name=p130741 lab=_56281_/A }
C {sky130_stdcells/nand3_4.sym} 131420 -12190 0 0 {name=X_56279_ }
C {devices/lab_pin.sym} 131360 -12060 0 0 {name=p130742 lab=_79964_/Y }
C {devices/lab_pin.sym} 131360 -12020 0 0 {name=p130743 lab=_79982_/A }
C {devices/lab_pin.sym} 131480 -12040 0 1 {name=p130744 lab=_79990_/Y }
C {sky130_stdcells/nor2_4.sym} 131420 -12040 0 0 {name=X_79990_ }
C {devices/lab_pin.sym} 131330 -11910 0 0 {name=p130745 lab=_88272_/CLK }
C {devices/lab_pin.sym} 131330 -11890 0 0 {name=p130746 lab=_44459_/X }
C {devices/lab_pin.sym} 131510 -11910 0 1 {name=p130747 lab=_87099_/Q }
C {sky130_stdcells/dfxtp_4.sym} 131420 -11900 0 0 {name=X_87099_ }
C {devices/lab_pin.sym} 131380 -11770 0 0 {name=p130748 lab=_43030_/A }
C {devices/lab_pin.sym} 131460 -11770 0 1 {name=p130749 lab=_46032_/X }
C {sky130_stdcells/buf_2.sym} 131420 -11770 0 0 {name=X_46032_ }
C {devices/lab_pin.sym} 131340 -11670 0 0 {name=p130750 lab=_57903_/X }
C {devices/lab_pin.sym} 131340 -11630 0 0 {name=p130751 lab=_85484_/Q }
C {devices/lab_pin.sym} 131340 -11590 0 0 {name=p130752 lab=_57962_/X }
C {devices/lab_pin.sym} 131500 -11630 0 1 {name=p130753 lab=_58018_/X }
C {sky130_stdcells/o21a_4.sym} 131420 -11630 0 0 {name=X_58018_ }
C {devices/lab_pin.sym} 131380 -11490 0 0 {name=p130754 lab=_43167_/A }
C {devices/lab_pin.sym} 131460 -11490 0 1 {name=p130755 lab=_43244_/X }
C {sky130_stdcells/buf_2.sym} 131420 -11490 0 0 {name=X_43244_ }
C {devices/lab_pin.sym} 131340 -11400 0 0 {name=p130756 lab=_72730_/X }
C {devices/lab_pin.sym} 131340 -11360 0 0 {name=p130757 lab=_84972_/Q }
C {devices/lab_pin.sym} 131340 -11320 0 0 {name=p130758 lab=_74021_/X }
C {devices/lab_pin.sym} 131340 -11280 0 0 {name=p130759 lab=_74063_/X }
C {devices/lab_pin.sym} 131500 -11340 0 1 {name=p130760 lab=_74065_/B }
C {sky130_stdcells/a211o_4.sym} 131420 -11340 0 0 {name=X_74064_ }
C {devices/lab_pin.sym} 131360 -11200 0 0 {name=p130761 lab=_82849_/Q }
C {devices/lab_pin.sym} 131360 -11160 0 0 {name=p130762 lab=_82561_/Q }
C {devices/lab_pin.sym} 131480 -11180 0 1 {name=p130763 lab=_78953_/A }
C {sky130_stdcells/xnor2_4.sym} 131420 -11180 0 0 {name=X_78941_ }
C {devices/lab_pin.sym} 131380 -11050 0 0 {name=p130764 lab=_40783_/A }
C {devices/lab_pin.sym} 131460 -11050 0 1 {name=p130765 lab=_40456_/X }
C {sky130_stdcells/buf_2.sym} 131420 -11050 0 0 {name=X_40456_ }
C {devices/lab_pin.sym} 131360 -10960 0 0 {name=p130766 lab=_71175_/A }
C {devices/lab_pin.sym} 131360 -10920 0 0 {name=p130767 lab=_71276_/B }
C {devices/lab_pin.sym} 131360 -10880 0 0 {name=p130768 lab=_71276_/C }
C {devices/lab_pin.sym} 131360 -10840 0 0 {name=p130769 lab=_71276_/D }
C {devices/lab_pin.sym} 131480 -10900 0 1 {name=p130770 lab=_71276_/Y }
C {sky130_stdcells/nand4_4.sym} 131420 -10900 0 0 {name=X_71276_ }
C {devices/lab_pin.sym} 131380 -10750 0 0 {name=p130771 lab=_73238_/A }
C {devices/lab_pin.sym} 131460 -10750 0 1 {name=p130772 lab=_73015_/X }
C {sky130_stdcells/buf_2.sym} 131420 -10750 0 0 {name=X_73015_ }
C {devices/lab_pin.sym} 131360 -10660 0 0 {name=p130773 lab=_70229_/A }
C {devices/lab_pin.sym} 131360 -10620 0 0 {name=p130774 lab=_70229_/B }
C {devices/lab_pin.sym} 131360 -10580 0 0 {name=p130775 lab=_83190_/Q }
C {devices/lab_pin.sym} 131360 -10540 0 0 {name=p130776 lab=_70229_/D }
C {devices/lab_pin.sym} 131480 -10600 0 1 {name=p130777 lab=_70227_/X }
C {sky130_stdcells/and4_4.sym} 131420 -10600 0 0 {name=X_70227_ }
C {devices/lab_pin.sym} 131360 -10470 0 0 {name=p130778 lab=_43175_/A }
C {devices/lab_pin.sym} 131360 -10430 0 0 {name=p130779 lab=_43175_/B }
C {devices/lab_pin.sym} 131360 -10390 0 0 {name=p130780 lab=_43175_/C }
C {devices/lab_pin.sym} 131480 -10430 0 1 {name=p130781 lab=_43175_/X }
C {sky130_stdcells/and3_4.sym} 131420 -10430 0 0 {name=X_43175_ }
C {devices/lab_pin.sym} 131360 -10300 0 0 {name=p130782 lab=_78886_/A }
C {devices/lab_pin.sym} 131360 -10260 0 0 {name=p130783 lab=_78896_/A }
C {devices/lab_pin.sym} 131480 -10280 0 1 {name=p130784 lab=_78881_/A }
C {sky130_stdcells/xor2_4.sym} 131420 -10280 0 0 {name=X_78872_ }
C {devices/lab_pin.sym} 131380 -10150 0 0 {name=p130785 lab=_40386_/Y }
C {devices/lab_pin.sym} 131460 -10150 0 1 {name=p130786 lab=_40387_/X }
C {sky130_stdcells/buf_2.sym} 131420 -10150 0 0 {name=X_40387_ }
C {devices/lab_pin.sym} 131380 -10030 0 0 {name=p130787 lab=_41912_/A }
C {devices/lab_pin.sym} 131460 -10030 0 1 {name=p130788 lab=_42126_/X }
C {sky130_stdcells/buf_2.sym} 131420 -10030 0 0 {name=X_42126_ }
C {devices/lab_pin.sym} 131360 -9920 0 0 {name=p130789 lab=_77835_/A }
C {devices/lab_pin.sym} 131360 -9880 0 0 {name=p130790 lab=_77822_/Y }
C {devices/lab_pin.sym} 131480 -9900 0 1 {name=p130791 lab=_77824_/B }
C {sky130_stdcells/xor2_4.sym} 131420 -9900 0 0 {name=X_77823_ }
C {devices/lab_pin.sym} 131380 -9770 0 0 {name=p130792 lab=_83849_/Q }
C {devices/lab_pin.sym} 131460 -9770 0 1 {name=p130793 lab=_70158_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -9770 0 0 {name=X_70158_ }
C {devices/lab_pin.sym} 131340 -9670 0 0 {name=p130794 lab=_47971_/X }
C {devices/lab_pin.sym} 131340 -9630 0 0 {name=p130795 lab=_82931_/Q }
C {devices/lab_pin.sym} 131340 -9590 0 0 {name=p130796 lab=_47982_/X }
C {devices/lab_pin.sym} 131500 -9630 0 1 {name=p130797 lab=_47984_/B }
C {sky130_stdcells/o21ai_4.sym} 131420 -9630 0 0 {name=X_47983_ }
C {devices/lab_pin.sym} 131380 -9490 0 0 {name=p130798 lab=_59968_/X }
C {devices/lab_pin.sym} 131460 -9490 0 1 {name=p130799 lab=_59969_/X }
C {sky130_stdcells/buf_2.sym} 131420 -9490 0 0 {name=X_59969_ }
C {devices/lab_pin.sym} 131340 -9390 0 0 {name=p130800 lab=_57731_/B }
C {devices/lab_pin.sym} 131340 -9350 0 0 {name=p130801 lab=_49715_/X }
C {devices/lab_pin.sym} 131340 -9310 0 0 {name=p130802 lab=_49721_/Y }
C {devices/lab_pin.sym} 131500 -9350 0 1 {name=p130803 lab=_49722_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -9350 0 0 {name=X_49722_ }
C {devices/lab_pin.sym} 131360 -9240 0 0 {name=p130804 lab=_46915_/X }
C {devices/lab_pin.sym} 131360 -9200 0 0 {name=p130805 lab=_46896_/B }
C {devices/lab_pin.sym} 131360 -9160 0 0 {name=p130806 lab=_46926_/C }
C {devices/lab_pin.sym} 131360 -9120 0 0 {name=p130807 lab=_52758_/D }
C {devices/lab_pin.sym} 131480 -9180 0 1 {name=p130808 lab=_46934_/X }
C {sky130_stdcells/and4_4.sym} 131420 -9180 0 0 {name=X_46934_ }
C {devices/lab_pin.sym} 131380 -9030 0 0 {name=p130809 lab=_42057_/A }
C {devices/lab_pin.sym} 131460 -9030 0 1 {name=p130810 lab=_42057_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -9030 0 0 {name=X_42057_ }
C {devices/lab_pin.sym} 131360 -8920 0 0 {name=p130811 lab=_82148_/Q }
C {devices/lab_pin.sym} 131360 -8880 0 0 {name=p130812 lab=_77754_/B }
C {devices/lab_pin.sym} 131480 -8900 0 1 {name=p130813 lab=_82116_/D }
C {sky130_stdcells/xor2_4.sym} 131420 -8900 0 0 {name=X_77754_ }
C {devices/lab_pin.sym} 131340 -8810 0 0 {name=p130814 lab=_58210_/X }
C {devices/lab_pin.sym} 131340 -8770 0 0 {name=p130815 lab=_62924_/C }
C {devices/lab_pin.sym} 131340 -8730 0 0 {name=p130816 lab=_60220_/A }
C {devices/lab_pin.sym} 131340 -8690 0 0 {name=p130817 lab=_62644_/X }
C {devices/lab_pin.sym} 131340 -8660 0 0 {name=p130818 lab=_62979_/X }
C {devices/lab_pin.sym} 131500 -8730 0 1 {name=p130819 lab=_62980_/Y }
C {sky130_stdcells/a41oi_4.sym} 131420 -8730 0 0 {name=X_62980_ }
C {devices/lab_pin.sym} 131360 -8580 0 0 {name=p130820 lab=_80762_/Q }
C {devices/lab_pin.sym} 131360 -8540 0 0 {name=p130821 lab=_74957_/B }
C {devices/lab_pin.sym} 131480 -8560 0 1 {name=p130822 lab=_74966_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -8560 0 0 {name=X_74966_ }
C {devices/lab_pin.sym} 131340 -8450 0 0 {name=p130823 lab=_69071_/X }
C {devices/lab_pin.sym} 131340 -8410 0 0 {name=p130824 lab=_69074_/X }
C {devices/lab_pin.sym} 131340 -8370 0 0 {name=p130825 lab=_69156_/X }
C {devices/lab_pin.sym} 131500 -8410 0 1 {name=p130826 lab=_70089_/Y }
C {sky130_stdcells/a21oi_4.sym} 131420 -8410 0 0 {name=X_70089_ }
C {devices/lab_pin.sym} 131340 -8290 0 0 {name=p130827 lab=_40429_/X }
C {devices/lab_pin.sym} 131340 -8250 0 0 {name=p130828 lab=_40829_/B }
C {devices/lab_pin.sym} 131340 -8210 0 0 {name=p130829 lab=_41007_/X }
C {devices/lab_pin.sym} 131500 -8250 0 1 {name=p130830 lab=_41009_/A }
C {sky130_stdcells/o21a_4.sym} 131420 -8250 0 0 {name=X_41008_ }
C {devices/lab_pin.sym} 131360 -8120 0 0 {name=p130831 lab=_76697_/Y }
C {devices/lab_pin.sym} 131360 -8080 0 0 {name=p130832 lab=_76704_/Y }
C {devices/lab_pin.sym} 131480 -8100 0 1 {name=p130833 lab=_81448_/D }
C {sky130_stdcells/xor2_4.sym} 131420 -8100 0 0 {name=X_76705_ }
C {devices/lab_pin.sym} 131340 -7990 0 0 {name=p130834 lab=_49649_/Y }
C {devices/lab_pin.sym} 131340 -7950 0 0 {name=p130835 lab=_49650_/X }
C {devices/lab_pin.sym} 131340 -7910 0 0 {name=p130836 lab=_49652_/X }
C {devices/lab_pin.sym} 131500 -7950 0 1 {name=p130837 lab=_86348_/D }
C {sky130_stdcells/a21oi_4.sym} 131420 -7950 0 0 {name=X_49653_ }
C {devices/lab_pin.sym} 131360 -7840 0 0 {name=p130838 lab=_61949_/A }
C {devices/lab_pin.sym} 131360 -7800 0 0 {name=p130839 lab=_61949_/B }
C {devices/lab_pin.sym} 131360 -7760 0 0 {name=p130840 lab=_61949_/C }
C {devices/lab_pin.sym} 131360 -7720 0 0 {name=p130841 lab=_63158_/B }
C {devices/lab_pin.sym} 131480 -7780 0 1 {name=p130842 lab=_61931_/X }
C {sky130_stdcells/and4_4.sym} 131420 -7780 0 0 {name=X_61931_ }
C {devices/lab_pin.sym} 131340 -7650 0 0 {name=p130843 lab=_68750_/B }
C {devices/lab_pin.sym} 131340 -7610 0 0 {name=p130844 lab=_56939_/X }
C {devices/lab_pin.sym} 131340 -7570 0 0 {name=p130845 lab=_72741_/X }
C {devices/lab_pin.sym} 131500 -7610 0 1 {name=p130846 lab=_73917_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -7610 0 0 {name=X_73917_ }
C {devices/lab_pin.sym} 131380 -7470 0 0 {name=p130847 lab=_46915_/A }
C {devices/lab_pin.sym} 131460 -7470 0 1 {name=p130848 lab=_46868_/A }
C {sky130_stdcells/buf_2.sym} 131420 -7470 0 0 {name=X_46865_ }
C {devices/lab_pin.sym} 131360 -7360 0 0 {name=p130849 lab=_77688_/B }
C {devices/lab_pin.sym} 131360 -7320 0 0 {name=p130850 lab=_77688_/A }
C {devices/lab_pin.sym} 131480 -7340 0 1 {name=p130851 lab=_77685_/X }
C {sky130_stdcells/xor2_4.sym} 131420 -7340 0 0 {name=X_77685_ }
C {devices/lab_pin.sym} 131360 -7240 0 0 {name=p130852 lab=_74897_/A }
C {devices/lab_pin.sym} 131360 -7200 0 0 {name=p130853 lab=_74897_/B }
C {devices/lab_pin.sym} 131360 -7160 0 0 {name=p130854 lab=_74899_/A }
C {devices/lab_pin.sym} 131360 -7120 0 0 {name=p130855 lab=_74894_/A }
C {devices/lab_pin.sym} 131480 -7180 0 1 {name=p130856 lab=_74897_/X }
C {sky130_stdcells/and4_4.sym} 131420 -7180 0 0 {name=X_74897_ }
C {devices/lab_pin.sym} 131360 -7040 0 0 {name=p130857 lab=_48604_/A }
C {devices/lab_pin.sym} 131360 -7000 0 0 {name=p130858 lab=_50508_/B }
C {devices/lab_pin.sym} 131480 -7020 0 1 {name=p130859 lab=_48604_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -7020 0 0 {name=X_48604_ }
C {devices/lab_pin.sym} 131360 -6900 0 0 {name=p130860 lab=_84808_/Q }
C {devices/lab_pin.sym} 131360 -6860 0 0 {name=p130861 lab=_66415_/C }
C {devices/lab_pin.sym} 131480 -6880 0 1 {name=p130862 lab=_79424_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -6880 0 0 {name=X_79424_ }
C {devices/lab_pin.sym} 131380 -6750 0 0 {name=p130863 lab=_82982_/Q }
C {devices/lab_pin.sym} 131460 -6750 0 1 {name=p130864 lab=_74694_/B }
C {sky130_stdcells/inv_2.sym} 131420 -6750 0 0 {name=X_45816_ }
C {devices/lab_pin.sym} 131380 -6630 0 0 {name=p130865 lab=_64817_/A }
C {devices/lab_pin.sym} 131460 -6630 0 1 {name=p130866 lab=_64650_/X }
C {sky130_stdcells/buf_2.sym} 131420 -6630 0 0 {name=X_64650_ }
C {devices/lab_pin.sym} 131360 -6520 0 0 {name=p130867 lab=_76636_/A }
C {devices/lab_pin.sym} 131360 -6480 0 0 {name=p130868 lab=_76635_/X }
C {devices/lab_pin.sym} 131480 -6500 0 1 {name=p130869 lab=_76637_/B }
C {sky130_stdcells/xnor2_4.sym} 131420 -6500 0 0 {name=X_76636_ }
C {devices/lab_pin.sym} 131340 -6390 0 0 {name=p130870 lab=_49582_/Y }
C {devices/lab_pin.sym} 131340 -6350 0 0 {name=p130871 lab=_49570_/X }
C {devices/lab_pin.sym} 131340 -6310 0 0 {name=p130872 lab=_49583_/X }
C {devices/lab_pin.sym} 131500 -6350 0 1 {name=p130873 lab=_86361_/D }
C {sky130_stdcells/a21oi_4.sym} 131420 -6350 0 0 {name=X_49584_ }
C {devices/lab_pin.sym} 131360 -6240 0 0 {name=p130874 lab=_61861_/X }
C {devices/lab_pin.sym} 131360 -6200 0 0 {name=p130875 lab=_61846_/B }
C {devices/lab_pin.sym} 131360 -6160 0 0 {name=p130876 lab=_61846_/C }
C {devices/lab_pin.sym} 131360 -6120 0 0 {name=p130877 lab=_61846_/D }
C {devices/lab_pin.sym} 131480 -6180 0 1 {name=p130878 lab=_61862_/Y }
C {sky130_stdcells/nand4_4.sym} 131420 -6180 0 0 {name=X_61862_ }
C {devices/lab_pin.sym} 131340 -6050 0 0 {name=p130879 lab=_88359_/Q }
C {devices/lab_pin.sym} 131340 -6010 0 0 {name=p130880 lab=_73777_/X }
C {devices/lab_pin.sym} 131340 -5970 0 0 {name=p130881 lab=_73656_/X }
C {devices/lab_pin.sym} 131500 -6010 0 1 {name=p130882 lab=_73848_/X }
C {sky130_stdcells/o21a_4.sym} 131420 -6010 0 0 {name=X_73848_ }
C {devices/lab_pin.sym} 131360 -5880 0 0 {name=p130883 lab=_46806_/A }
C {devices/lab_pin.sym} 131360 -5840 0 0 {name=p130884 lab=_50987_/B }
C {devices/lab_pin.sym} 131480 -5860 0 1 {name=p130885 lab=_46796_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -5860 0 0 {name=X_46796_ }
C {devices/lab_pin.sym} 131380 -5730 0 0 {name=p130886 lab=_63540_/A }
C {devices/lab_pin.sym} 131460 -5730 0 1 {name=p130887 lab=_63661_/D }
C {sky130_stdcells/buf_2.sym} 131420 -5730 0 0 {name=X_63601_ }
C {devices/lab_pin.sym} 131380 -5610 0 0 {name=p130888 lab=_48535_/A }
C {devices/lab_pin.sym} 131460 -5610 0 1 {name=p130889 lab=_48612_/A }
C {sky130_stdcells/buf_2.sym} 131420 -5610 0 0 {name=X_48535_ }
C {devices/lab_pin.sym} 131360 -5510 0 0 {name=p130890 lab=_60792_/A }
C {devices/lab_pin.sym} 131360 -5470 0 0 {name=p130891 lab=_60810_/B }
C {devices/lab_pin.sym} 131360 -5430 0 0 {name=p130892 lab=_84560_/Q }
C {devices/lab_pin.sym} 131480 -5470 0 1 {name=p130893 lab=_60813_/Y }
C {sky130_stdcells/nor3_4.sym} 131420 -5470 0 0 {name=X_60813_ }
C {devices/lab_pin.sym} 131360 -5340 0 0 {name=p130894 lab=_79332_/X }
C {devices/lab_pin.sym} 131360 -5300 0 0 {name=p130895 lab=_79355_/B }
C {devices/lab_pin.sym} 131480 -5320 0 1 {name=p130896 lab=_79355_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -5320 0 0 {name=X_79355_ }
C {devices/lab_pin.sym} 131340 -5210 0 0 {name=p130897 lab=_45744_/X }
C {devices/lab_pin.sym} 131340 -5170 0 0 {name=p130898 lab=_45746_/Y }
C {devices/lab_pin.sym} 131340 -5130 0 0 {name=p130899 lab=_45714_/X }
C {devices/lab_pin.sym} 131500 -5170 0 1 {name=p130900 lab=_45747_/Y }
C {sky130_stdcells/a21oi_4.sym} 131420 -5170 0 0 {name=X_45747_ }
C {devices/lab_pin.sym} 131340 -5060 0 0 {name=p130901 lab=_64577_/X }
C {devices/lab_pin.sym} 131340 -5020 0 0 {name=p130902 lab=_86753_/Q }
C {devices/lab_pin.sym} 131340 -4980 0 0 {name=p130903 lab=_64579_/X }
C {devices/lab_pin.sym} 131340 -4940 0 0 {name=p130904 lab=_64580_/X }
C {devices/lab_pin.sym} 131500 -5000 0 1 {name=p130905 lab=_64582_/B }
C {sky130_stdcells/a211o_4.sym} 131420 -5000 0 0 {name=X_64581_ }
C {devices/lab_pin.sym} 131360 -4860 0 0 {name=p130906 lab=_76563_/X }
C {devices/lab_pin.sym} 131360 -4820 0 0 {name=p130907 lab=_76562_/Y }
C {devices/lab_pin.sym} 131480 -4840 0 1 {name=p130908 lab=_76567_/Y }
C {sky130_stdcells/nand2_4.sym} 131420 -4840 0 0 {name=X_76567_ }
C {devices/lab_pin.sym} 131340 -4750 0 0 {name=p130909 lab=_42944_/X }
C {devices/lab_pin.sym} 131340 -4710 0 0 {name=p130910 lab=_42945_/X }
C {devices/lab_pin.sym} 131340 -4670 0 0 {name=p130911 lab=_40395_/X }
C {devices/lab_pin.sym} 131340 -4630 0 0 {name=p130912 lab=_66698_/B }
C {devices/lab_pin.sym} 131340 -4590 0 0 {name=p130913 lab=_42954_/X }
C {devices/lab_pin.sym} 131500 -4670 0 1 {name=p130914 lab=_42960_/A }
C {sky130_stdcells/o32ai_4.sym} 131420 -4670 0 0 {name=X_42959_ }
C {devices/lab_pin.sym} 131380 -4510 0 0 {name=p130915 lab=_61736_/A }
C {devices/lab_pin.sym} 131460 -4510 0 1 {name=p130916 lab=_61863_/A }
C {sky130_stdcells/buf_2.sym} 131420 -4510 0 0 {name=X_61793_ }
C {devices/lab_pin.sym} 131340 -4410 0 0 {name=p130917 lab=_86998_/Q }
C {devices/lab_pin.sym} 131340 -4370 0 0 {name=p130918 lab=_73776_/X }
C {devices/lab_pin.sym} 131340 -4330 0 0 {name=p130919 lab=_73778_/X }
C {devices/lab_pin.sym} 131500 -4370 0 1 {name=p130920 lab=_73779_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -4370 0 0 {name=X_73779_ }
C {devices/lab_pin.sym} 131340 -4250 0 0 {name=p130921 lab=_66317_/Y }
C {devices/lab_pin.sym} 131340 -4210 0 0 {name=p130922 lab=_66278_/X }
C {devices/lab_pin.sym} 131340 -4170 0 0 {name=p130923 lab=_66319_/X }
C {devices/lab_pin.sym} 131500 -4210 0 1 {name=p130924 lab=_84141_/D }
C {sky130_stdcells/a21o_4.sym} 131420 -4210 0 0 {name=X_66320_ }
C {devices/lab_pin.sym} 131360 -4090 0 0 {name=p130925 lab=_78302_/A }
C {devices/lab_pin.sym} 131360 -4050 0 0 {name=p130926 lab=_78302_/B }
C {devices/lab_pin.sym} 131360 -4010 0 0 {name=p130927 lab=_78306_/C }
C {devices/lab_pin.sym} 131480 -4050 0 1 {name=p130928 lab=_78309_/C }
C {sky130_stdcells/nand3_4.sym} 131420 -4050 0 0 {name=X_78306_ }
C {devices/lab_pin.sym} 131380 -3910 0 0 {name=p130929 lab=_63471_/A }
C {devices/lab_pin.sym} 131460 -3910 0 1 {name=p130930 lab=_63546_/D }
C {sky130_stdcells/buf_2.sym} 131420 -3910 0 0 {name=X_63532_ }
C {devices/lab_pin.sym} 131380 -3790 0 0 {name=p130931 lab=_75517_/Y }
C {devices/lab_pin.sym} 131460 -3790 0 1 {name=p130932 lab=_75519_/C }
C {sky130_stdcells/inv_2.sym} 131420 -3790 0 0 {name=X_75518_ }
C {devices/lab_pin.sym} 131360 -3690 0 0 {name=p130933 lab=_60700_/A }
C {devices/lab_pin.sym} 131360 -3650 0 0 {name=p130934 lab=_60752_/B }
C {devices/lab_pin.sym} 131360 -3610 0 0 {name=p130935 lab=_60744_/C }
C {devices/lab_pin.sym} 131480 -3650 0 1 {name=p130936 lab=_60744_/Y }
C {sky130_stdcells/nor3_4.sym} 131420 -3650 0 0 {name=X_60744_ }
C {devices/lab_pin.sym} 131340 -3530 0 0 {name=p130937 lab=_48457_/Y }
C {devices/lab_pin.sym} 131340 -3490 0 0 {name=p130938 lab=_48459_/X }
C {devices/lab_pin.sym} 131340 -3450 0 0 {name=p130939 lab=_48465_/X }
C {devices/lab_pin.sym} 131500 -3490 0 1 {name=p130940 lab=_86520_/D }
C {sky130_stdcells/a21oi_4.sym} 131420 -3490 0 0 {name=X_48466_ }
C {devices/lab_pin.sym} 131340 -3370 0 0 {name=p130941 lab=_58843_/Y }
C {devices/lab_pin.sym} 131340 -3330 0 0 {name=p130942 lab=_66478_/Y }
C {devices/lab_pin.sym} 131340 -3290 0 0 {name=p130943 lab=_79285_/Y }
C {devices/lab_pin.sym} 131500 -3330 0 1 {name=p130944 lab=_79286_/X }
C {sky130_stdcells/o21a_4.sym} 131420 -3330 0 0 {name=X_79286_ }
C {devices/lab_pin.sym} 131380 -3190 0 0 {name=p130945 lab=_45678_/A }
C {devices/lab_pin.sym} 131460 -3190 0 1 {name=p130946 lab=_45678_/X }
C {sky130_stdcells/buf_2.sym} 131420 -3190 0 0 {name=X_45678_ }
C {devices/lab_pin.sym} 131340 -3090 0 0 {name=p130947 lab=_76485_/A }
C {devices/lab_pin.sym} 131340 -3050 0 0 {name=p130948 lab=_76484_/Y }
C {devices/lab_pin.sym} 131340 -3010 0 0 {name=p130949 lab=_76513_/C }
C {devices/lab_pin.sym} 131500 -3050 0 1 {name=p130950 lab=_76498_/Y }
C {sky130_stdcells/o21ai_4.sym} 131420 -3050 0 0 {name=X_76498_ }
C {devices/lab_pin.sym} 131380 -2910 0 0 {name=p130951 lab=_47417_/A }
C {devices/lab_pin.sym} 131460 -2910 0 1 {name=p130952 lab=_53036_/D }
C {sky130_stdcells/buf_2.sym} 131420 -2910 0 0 {name=X_47417_ }
C {devices/lab_pin.sym} 131380 -2790 0 0 {name=p130953 lab=_65976_/A }
C {devices/lab_pin.sym} 131460 -2790 0 1 {name=p130954 lab=_66251_/X }
C {sky130_stdcells/buf_2.sym} 131420 -2790 0 0 {name=X_66251_ }
C {devices/lab_pin.sym} 131340 -2690 0 0 {name=p130955 lab=_78228_/Y }
C {devices/lab_pin.sym} 131340 -2650 0 0 {name=p130956 lab=_78235_/Y }
C {devices/lab_pin.sym} 131340 -2610 0 0 {name=p130957 lab=_78236_/Y }
C {devices/lab_pin.sym} 131500 -2650 0 1 {name=p130958 lab=_78237_/X }
C {sky130_stdcells/o21a_4.sym} 131420 -2650 0 0 {name=X_78237_ }
C {devices/lab_pin.sym} 131380 -2510 0 0 {name=p130959 lab=_44628_/Y }
C {devices/lab_pin.sym} 131460 -2510 0 1 {name=p130960 lab=_44629_/Y }
C {sky130_stdcells/inv_2.sym} 131420 -2510 0 0 {name=X_44629_ }
C {devices/lab_pin.sym} 131360 -2410 0 0 {name=p130961 lab=_63463_/A }
C {devices/lab_pin.sym} 131360 -2370 0 0 {name=p130962 lab=_84961_/Q }
C {devices/lab_pin.sym} 131360 -2330 0 0 {name=p130963 lab=_63463_/C }
C {devices/lab_pin.sym} 131480 -2370 0 1 {name=p130964 lab=_63463_/X }
C {sky130_stdcells/and3_4.sym} 131420 -2370 0 0 {name=X_63463_ }
C {devices/lab_pin.sym} 131360 -2240 0 0 {name=p130965 lab=_75441_/X }
C {devices/lab_pin.sym} 131360 -2200 0 0 {name=p130966 lab=_75467_/A }
C {devices/lab_pin.sym} 131480 -2220 0 1 {name=p130967 lab=_75466_/A }
C {sky130_stdcells/xnor2_4.sym} 131420 -2220 0 0 {name=X_75449_ }
C {devices/lab_pin.sym} 131360 -2110 0 0 {name=p130968 lab=_53636_/A }
C {devices/lab_pin.sym} 131360 -2070 0 0 {name=p130969 lab=_48364_/X }
C {devices/lab_pin.sym} 131360 -2030 0 0 {name=p130970 lab=_48354_/X }
C {devices/lab_pin.sym} 131480 -2070 0 1 {name=p130971 lab=_48397_/X }
C {sky130_stdcells/and3_4.sym} 131420 -2070 0 0 {name=X_48397_ }
C {devices/lab_pin.sym} 131340 -1970 0 0 {name=p130972 lab=_60694_/B }
C {devices/lab_pin.sym} 131340 -1930 0 0 {name=p130973 lab=_60654_/X }
C {devices/lab_pin.sym} 131340 -1890 0 0 {name=p130974 lab=_60697_/B }
C {devices/lab_pin.sym} 131340 -1850 0 0 {name=p130975 lab=_60804_/B }
C {devices/lab_pin.sym} 131340 -1820 0 0 {name=p130976 lab=_59512_/X }
C {devices/lab_pin.sym} 131500 -1890 0 1 {name=p130977 lab=_60675_/Y }
C {sky130_stdcells/a41oi_4.sym} 131420 -1890 0 0 {name=X_60675_ }
C {devices/lab_pin.sym} 131340 -1760 0 0 {name=p130978 lab=_65199_/X }
C {devices/lab_pin.sym} 131340 -1720 0 0 {name=p130979 lab=_86154_/Q }
C {devices/lab_pin.sym} 131340 -1680 0 0 {name=p130980 lab=_65022_/X }
C {devices/lab_pin.sym} 131340 -1640 0 0 {name=p130981 lab=_65201_/X }
C {devices/lab_pin.sym} 131500 -1700 0 1 {name=p130982 lab=_65202_/X }
C {sky130_stdcells/a211o_4.sym} 131420 -1700 0 0 {name=X_65202_ }
C {devices/lab_pin.sym} 131340 -1570 0 0 {name=p130983 lab=_62410_/Y }
C {devices/lab_pin.sym} 131340 -1530 0 0 {name=p130984 lab=_62396_/X }
C {devices/lab_pin.sym} 131340 -1490 0 0 {name=p130985 lab=_62413_/Y }
C {devices/lab_pin.sym} 131500 -1530 0 1 {name=p130986 lab=_84412_/D }
C {sky130_stdcells/a21oi_4.sym} 131420 -1530 0 0 {name=X_62414_ }
C {devices/lab_pin.sym} 131380 -1390 0 0 {name=p130987 lab=_47348_/A }
C {devices/lab_pin.sym} 131460 -1390 0 1 {name=p130988 lab=_52997_/D }
C {sky130_stdcells/buf_2.sym} 131420 -1390 0 0 {name=X_47348_ }
C {devices/lab_pin.sym} 131340 -1300 0 0 {name=p130989 lab=_66125_/X }
C {devices/lab_pin.sym} 131340 -1260 0 0 {name=p130990 lab=_86222_/Q }
C {devices/lab_pin.sym} 131340 -1220 0 0 {name=p130991 lab=_66180_/X }
C {devices/lab_pin.sym} 131340 -1180 0 0 {name=p130992 lab=_66181_/X }
C {devices/lab_pin.sym} 131500 -1240 0 1 {name=p130993 lab=_66182_/X }
C {sky130_stdcells/a211o_4.sym} 131420 -1240 0 0 {name=X_66182_ }
C {devices/lab_pin.sym} 131360 -1100 0 0 {name=p130994 lab=_82670_/Q }
C {devices/lab_pin.sym} 131360 -1060 0 0 {name=p130995 lab=_78168_/B }
C {devices/lab_pin.sym} 131480 -1080 0 1 {name=p130996 lab=_78168_/X }
C {sky130_stdcells/xor2_4.sym} 131420 -1080 0 0 {name=X_78168_ }
C {devices/lab_pin.sym} 131380 -950 0 0 {name=p130997 lab=_60720_/A }
C {devices/lab_pin.sym} 131460 -950 0 1 {name=p130998 lab=_63458_/A }
C {sky130_stdcells/buf_2.sym} 131420 -950 0 0 {name=X_63394_ }
C {devices/lab_pin.sym} 131340 -860 0 0 {name=p130999 lab=_65035_/X }
C {devices/lab_pin.sym} 131340 -820 0 0 {name=p131000 lab=_85549_/Q }
C {devices/lab_pin.sym} 131340 -780 0 0 {name=p131001 lab=_65036_/X }
C {devices/lab_pin.sym} 131340 -740 0 0 {name=p131002 lab=_65132_/X }
C {devices/lab_pin.sym} 131500 -800 0 1 {name=p131003 lab=_65133_/X }
C {sky130_stdcells/a211o_4.sym} 131420 -800 0 0 {name=X_65133_ }
C {devices/lab_pin.sym} 131360 -660 0 0 {name=p131004 lab=_77127_/A }
C {devices/lab_pin.sym} 131360 -620 0 0 {name=p131005 lab=_77127_/B }
C {devices/lab_pin.sym} 131480 -640 0 1 {name=p131006 lab=_77122_/A }
C {sky130_stdcells/xor2_4.sym} 131420 -640 0 0 {name=X_77119_ }
C {devices/lab_pin.sym} 132280 -42180 0 0 {name=p131007 lab=_62344_/X }
C {devices/lab_pin.sym} 132280 -42140 0 0 {name=p131008 lab=_57656_/X }
C {devices/lab_pin.sym} 132280 -42100 0 0 {name=p131009 lab=_62315_/C }
C {devices/lab_pin.sym} 132280 -42060 0 0 {name=p131010 lab=_62286_/X }
C {devices/lab_pin.sym} 132400 -42120 0 1 {name=p131011 lab=_62345_/X }
C {sky130_stdcells/and4_4.sym} 132340 -42120 0 0 {name=X_62345_ }
C {devices/lab_pin.sym} 132280 -41980 0 0 {name=p131012 lab=_47241_/X }
C {devices/lab_pin.sym} 132280 -41940 0 0 {name=p131013 lab=_52959_/B }
C {devices/lab_pin.sym} 132400 -41960 0 1 {name=p131014 lab=_47279_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -41960 0 0 {name=X_47279_ }
C {devices/lab_pin.sym} 132260 -41850 0 0 {name=p131015 lab=_78093_/Y }
C {devices/lab_pin.sym} 132260 -41810 0 0 {name=p131016 lab=_78098_/Y }
C {devices/lab_pin.sym} 132260 -41770 0 0 {name=p131017 lab=_78090_/B }
C {devices/lab_pin.sym} 132420 -41810 0 1 {name=p131018 lab=_78099_/Y }
C {sky130_stdcells/a21oi_4.sym} 132340 -41810 0 0 {name=X_78099_ }
C {devices/lab_pin.sym} 132300 -41670 0 0 {name=p131019 lab=_48946_/A }
C {devices/lab_pin.sym} 132380 -41670 0 1 {name=p131020 lab=_49018_/X }
C {sky130_stdcells/buf_2.sym} 132340 -41670 0 0 {name=X_49018_ }
C {devices/lab_pin.sym} 132280 -41560 0 0 {name=p131021 lab=_84941_/Q }
C {devices/lab_pin.sym} 132280 -41520 0 0 {name=p131022 lab=_84189_/Q }
C {devices/lab_pin.sym} 132400 -41540 0 1 {name=p131023 lab=_80130_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -41540 0 0 {name=X_80130_ }
C {devices/lab_pin.sym} 132300 -41410 0 0 {name=p131024 lab=_64834_/A }
C {devices/lab_pin.sym} 132380 -41410 0 1 {name=p131025 lab=_65192_/B }
C {sky130_stdcells/buf_2.sym} 132340 -41410 0 0 {name=X_65064_ }
C {devices/lab_pin.sym} 132260 -41320 0 0 {name=p131026 lab=_69832_/X }
C {devices/lab_pin.sym} 132260 -41280 0 0 {name=p131027 lab=_69937_/Y }
C {devices/lab_pin.sym} 132260 -41240 0 0 {name=p131028 lab=_69938_/X }
C {devices/lab_pin.sym} 132260 -41200 0 0 {name=p131029 lab=_69940_/Y }
C {devices/lab_pin.sym} 132420 -41260 0 1 {name=p131030 lab=_69941_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -41260 0 0 {name=X_69941_ }
C {devices/lab_pin.sym} 132260 -41130 0 0 {name=p131031 lab=_86230_/Q }
C {devices/lab_pin.sym} 132260 -41090 0 0 {name=p131032 lab=_50282_/X }
C {devices/lab_pin.sym} 132260 -41050 0 0 {name=p131033 lab=_50289_/Y }
C {devices/lab_pin.sym} 132420 -41090 0 1 {name=p131034 lab=_50290_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -41090 0 0 {name=X_50290_ }
C {devices/lab_pin.sym} 132300 -40950 0 0 {name=p131035 lab=_59923_/Y }
C {devices/lab_pin.sym} 132380 -40950 0 1 {name=p131036 lab=_62276_/X }
C {sky130_stdcells/buf_2.sym} 132340 -40950 0 0 {name=X_62276_ }
C {devices/lab_pin.sym} 132300 -40830 0 0 {name=p131037 lab=clkbuf_9_176_0_CLK/X }
C {devices/lab_pin.sym} 132380 -40830 0 1 {name=p131038 lab=_86640_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 132340 -40830 0 0 {name=Xclkbuf_10_353_0_CLK }
C {devices/lab_pin.sym} 132280 -40740 0 0 {name=p131039 lab=_64411_/B }
C {devices/lab_pin.sym} 132280 -40700 0 0 {name=p131040 lab=_64029_/B }
C {devices/lab_pin.sym} 132280 -40660 0 0 {name=p131041 lab=_64029_/C }
C {devices/lab_pin.sym} 132280 -40620 0 0 {name=p131042 lab=_64015_/D }
C {devices/lab_pin.sym} 132400 -40680 0 1 {name=p131043 lab=_64017_/C }
C {sky130_stdcells/nand4_4.sym} 132340 -40680 0 0 {name=X_64015_ }
C {devices/lab_pin.sym} 132300 -40530 0 0 {name=p131044 lab=_61226_/X }
C {devices/lab_pin.sym} 132380 -40530 0 1 {name=p131045 lab=_64454_/B }
C {sky130_stdcells/buf_2.sym} 132340 -40530 0 0 {name=X_61227_ }
C {devices/lab_pin.sym} 132300 -40410 0 0 {name=p131046 lab=clkbuf_9_491_0_CLK/X }
C {devices/lab_pin.sym} 132380 -40410 0 1 {name=p131047 lab=_83303_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 132340 -40410 0 0 {name=Xclkbuf_10_983_0_CLK }
C {devices/lab_pin.sym} 132280 -40300 0 0 {name=p131048 lab=_80059_/X }
C {devices/lab_pin.sym} 132280 -40260 0 0 {name=p131049 lab=_80060_/X }
C {devices/lab_pin.sym} 132400 -40280 0 1 {name=p131050 lab=_80074_/B }
C {sky130_stdcells/xnor2_4.sym} 132340 -40280 0 0 {name=X_80061_ }
C {devices/lab_pin.sym} 132260 -40180 0 0 {name=p131051 lab=_42041_/A }
C {devices/lab_pin.sym} 132260 -40140 0 0 {name=p131052 lab=_68463_/X }
C {devices/lab_pin.sym} 132260 -40100 0 0 {name=p131053 lab=_69478_/X }
C {devices/lab_pin.sym} 132260 -40060 0 0 {name=p131054 lab=_69871_/Y }
C {devices/lab_pin.sym} 132420 -40120 0 1 {name=p131055 lab=_69872_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -40120 0 0 {name=X_69872_ }
C {devices/lab_pin.sym} 132300 -39970 0 0 {name=p131056 lab=_68823_/A }
C {devices/lab_pin.sym} 132380 -39970 0 1 {name=p131057 lab=_68823_/X }
C {sky130_stdcells/buf_2.sym} 132340 -39970 0 0 {name=X_68823_ }
C {devices/lab_pin.sym} 132260 -39890 0 0 {name=p131058 lab=_60933_/X }
C {devices/lab_pin.sym} 132260 -39850 0 0 {name=p131059 lab=_61149_/X }
C {devices/lab_pin.sym} 132260 -39810 0 0 {name=p131060 lab=_61154_/X }
C {devices/lab_pin.sym} 132260 -39770 0 0 {name=p131061 lab=_61156_/X }
C {devices/lab_pin.sym} 132260 -39740 0 0 {name=p131062 lab=_61157_/Y }
C {devices/lab_pin.sym} 132420 -39810 0 1 {name=p131063 lab=_84517_/D }
C {sky130_stdcells/a41oi_4.sym} 132340 -39810 0 0 {name=X_61158_ }
C {devices/lab_pin.sym} 132300 -39650 0 0 {name=p131064 lab=clkbuf_9_475_0_CLK/A }
C {devices/lab_pin.sym} 132380 -39650 0 1 {name=p131065 lab=clkbuf_9_474_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 132340 -39650 0 0 {name=Xclkbuf_9_474_0_CLK }
C {devices/lab_pin.sym} 132300 -39530 0 0 {name=p131066 lab=_60109_/A }
C {devices/lab_pin.sym} 132380 -39530 0 1 {name=p131067 lab=_65607_/A }
C {sky130_stdcells/buf_2.sym} 132340 -39530 0 0 {name=X_60109_ }
C {devices/lab_pin.sym} 132250 -39410 0 0 {name=p131068 lab=_83820_/CLK }
C {devices/lab_pin.sym} 132250 -39390 0 0 {name=p131069 lab=_83820_/D }
C {devices/lab_pin.sym} 132430 -39410 0 1 {name=p131070 lab=_74764_/B }
C {sky130_stdcells/dfxtp_4.sym} 132340 -39400 0 0 {name=X_83820_ }
C {devices/lab_pin.sym} 132300 -39270 0 0 {name=p131071 lab=clkbuf_9_184_0_CLK/X }
C {devices/lab_pin.sym} 132380 -39270 0 1 {name=p131072 lab=_86359_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 132340 -39270 0 0 {name=Xclkbuf_10_368_0_CLK }
C {devices/lab_pin.sym} 132300 -39150 0 0 {name=p131073 lab=_69233_/A }
C {devices/lab_pin.sym} 132380 -39150 0 1 {name=p131074 lab=_68779_/A }
C {sky130_stdcells/buf_2.sym} 132340 -39150 0 0 {name=X_68754_ }
C {devices/lab_pin.sym} 132280 -39040 0 0 {name=p131075 lab=_53956_/X }
C {devices/lab_pin.sym} 132280 -39000 0 0 {name=p131076 lab=_53980_/B }
C {devices/lab_pin.sym} 132400 -39020 0 1 {name=p131077 lab=_53980_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -39020 0 0 {name=X_53980_ }
C {devices/lab_pin.sym} 132260 -38920 0 0 {name=p131078 lab=_65308_/X }
C {devices/lab_pin.sym} 132260 -38880 0 0 {name=p131079 lab=_84989_/Q }
C {devices/lab_pin.sym} 132260 -38840 0 0 {name=p131080 lab=_65309_/X }
C {devices/lab_pin.sym} 132260 -38800 0 0 {name=p131081 lab=_65965_/X }
C {devices/lab_pin.sym} 132420 -38860 0 1 {name=p131082 lab=_65966_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -38860 0 0 {name=X_65966_ }
C {devices/lab_pin.sym} 132280 -38730 0 0 {name=p131083 lab=_72592_/A }
C {devices/lab_pin.sym} 132280 -38690 0 0 {name=p131084 lab=_61414_/A }
C {devices/lab_pin.sym} 132280 -38650 0 0 {name=p131085 lab=_61089_/C }
C {devices/lab_pin.sym} 132400 -38690 0 1 {name=p131086 lab=_61089_/Y }
C {sky130_stdcells/nor3_4.sym} 132340 -38690 0 0 {name=X_61089_ }
C {devices/lab_pin.sym} 132300 -38550 0 0 {name=p131087 lab=clkbuf_9_499_0_CLK/X }
C {devices/lab_pin.sym} 132380 -38550 0 1 {name=p131088 lab=_83584_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 132340 -38550 0 0 {name=Xclkbuf_10_998_0_CLK }
C {devices/lab_pin.sym} 132260 -38450 0 0 {name=p131089 lab=_67701_/X }
C {devices/lab_pin.sym} 132260 -38410 0 0 {name=p131090 lab=_67704_/X }
C {devices/lab_pin.sym} 132260 -38370 0 0 {name=p131091 lab=_67681_/X }
C {devices/lab_pin.sym} 132420 -38410 0 1 {name=p131092 lab=_67705_/X }
C {sky130_stdcells/a21o_4.sym} 132340 -38410 0 0 {name=X_67705_ }
C {devices/lab_pin.sym} 132280 -38280 0 0 {name=p131093 lab=_52944_/A }
C {devices/lab_pin.sym} 132280 -38240 0 0 {name=p131094 lab=_52931_/B }
C {devices/lab_pin.sym} 132400 -38260 0 1 {name=p131095 lab=_52931_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -38260 0 0 {name=X_52931_ }
C {devices/lab_pin.sym} 132260 -38160 0 0 {name=p131096 lab=_64666_/X }
C {devices/lab_pin.sym} 132260 -38120 0 0 {name=p131097 lab=_86133_/Q }
C {devices/lab_pin.sym} 132260 -38080 0 0 {name=p131098 lab=_64766_/X }
C {devices/lab_pin.sym} 132260 -38040 0 0 {name=p131099 lab=_64916_/X }
C {devices/lab_pin.sym} 132420 -38100 0 1 {name=p131100 lab=_64917_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -38100 0 0 {name=X_64917_ }
C {devices/lab_pin.sym} 132250 -37950 0 0 {name=p131101 lab=_83753_/CLK }
C {devices/lab_pin.sym} 132250 -37930 0 0 {name=p131102 lab=_83751_/D }
C {devices/lab_pin.sym} 132430 -37950 0 1 {name=p131103 lab=_83751_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -37940 0 0 {name=X_83751_ }
C {devices/lab_pin.sym} 132250 -37810 0 0 {name=p131104 lab=_81985_/CLK }
C {devices/lab_pin.sym} 132250 -37790 0 0 {name=p131105 lab=_75587_/X }
C {devices/lab_pin.sym} 132430 -37810 0 1 {name=p131106 lab=_75376_/B }
C {sky130_stdcells/dfxtp_4.sym} 132340 -37800 0 0 {name=X_80963_ }
C {devices/lab_pin.sym} 132260 -37690 0 0 {name=p131107 lab=_68680_/X }
C {devices/lab_pin.sym} 132260 -37650 0 0 {name=p131108 lab=_68682_/X }
C {devices/lab_pin.sym} 132260 -37610 0 0 {name=p131109 lab=_68684_/X }
C {devices/lab_pin.sym} 132420 -37650 0 1 {name=p131110 lab=_68685_/X }
C {sky130_stdcells/a21o_4.sym} 132340 -37650 0 0 {name=X_68685_ }
C {devices/lab_pin.sym} 132260 -37540 0 0 {name=p131111 lab=_65811_/X }
C {devices/lab_pin.sym} 132260 -37500 0 0 {name=p131112 lab=_83050_/Q }
C {devices/lab_pin.sym} 132260 -37460 0 0 {name=p131113 lab=_65865_/X }
C {devices/lab_pin.sym} 132260 -37420 0 0 {name=p131114 lab=_65896_/X }
C {devices/lab_pin.sym} 132420 -37480 0 1 {name=p131115 lab=_65897_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -37480 0 0 {name=X_65897_ }
C {devices/lab_pin.sym} 132250 -37330 0 0 {name=p131116 lab=_82702_/CLK }
C {devices/lab_pin.sym} 132250 -37310 0 0 {name=p131117 lab=_78920_/X }
C {devices/lab_pin.sym} 132430 -37330 0 1 {name=p131118 lab=_82658_/D }
C {sky130_stdcells/dfxtp_4.sym} 132340 -37320 0 0 {name=X_82702_ }
C {devices/lab_pin.sym} 132300 -37190 0 0 {name=p131119 lab=clkbuf_9_489_0_CLK/A }
C {devices/lab_pin.sym} 132380 -37190 0 1 {name=p131120 lab=clkbuf_9_489_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 132340 -37190 0 0 {name=Xclkbuf_9_489_0_CLK }
C {devices/lab_pin.sym} 132280 -37080 0 0 {name=p131121 lab=_55650_/A }
C {devices/lab_pin.sym} 132280 -37040 0 0 {name=p131122 lab=_55649_/Y }
C {devices/lab_pin.sym} 132400 -37060 0 1 {name=p131123 lab=_74539_/A }
C {sky130_stdcells/nand2_4.sym} 132340 -37060 0 0 {name=X_55650_ }
C {devices/lab_pin.sym} 132300 -36930 0 0 {name=p131124 lab=_45923_/X }
C {devices/lab_pin.sym} 132380 -36930 0 1 {name=p131125 lab=_68129_/A }
C {sky130_stdcells/buf_2.sym} 132340 -36930 0 0 {name=X_67636_ }
C {devices/lab_pin.sym} 132250 -36810 0 0 {name=p131126 lab=_86470_/CLK }
C {devices/lab_pin.sym} 132250 -36790 0 0 {name=p131127 lab=_48855_/Y }
C {devices/lab_pin.sym} 132430 -36810 0 1 {name=p131128 lab=_86470_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -36800 0 0 {name=X_86470_ }
C {devices/lab_pin.sym} 132260 -36690 0 0 {name=p131129 lab=_52860_/Y }
C {devices/lab_pin.sym} 132260 -36650 0 0 {name=p131130 lab=_52839_/X }
C {devices/lab_pin.sym} 132260 -36610 0 0 {name=p131131 lab=_52861_/X }
C {devices/lab_pin.sym} 132420 -36650 0 1 {name=p131132 lab=_52862_/Y }
C {sky130_stdcells/a21oi_4.sym} 132340 -36650 0 0 {name=X_52862_ }
C {devices/lab_pin.sym} 132280 -36520 0 0 {name=p131133 lab=_64948_/A }
C {devices/lab_pin.sym} 132280 -36480 0 0 {name=p131134 lab=_86264_/Q }
C {devices/lab_pin.sym} 132400 -36500 0 1 {name=p131135 lab=_64848_/X }
C {sky130_stdcells/and2_4.sym} 132340 -36500 0 0 {name=X_64848_ }
C {devices/lab_pin.sym} 132250 -36370 0 0 {name=p131136 lab=_83681_/CLK }
C {devices/lab_pin.sym} 132250 -36350 0 0 {name=p131137 lab=_70853_/Y }
C {devices/lab_pin.sym} 132430 -36370 0 1 {name=p131138 lab=_83682_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -36360 0 0 {name=X_83682_ }
C {devices/lab_pin.sym} 132250 -36230 0 0 {name=p131139 lab=_80961_/CLK }
C {devices/lab_pin.sym} 132250 -36210 0 0 {name=p131140 lab=_80894_/D }
C {devices/lab_pin.sym} 132430 -36230 0 1 {name=p131141 lab=_80894_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -36220 0 0 {name=X_80894_ }
C {devices/lab_pin.sym} 132260 -36110 0 0 {name=p131142 lab=_85412_/Q }
C {devices/lab_pin.sym} 132260 -36070 0 0 {name=p131143 lab=_54593_/X }
C {devices/lab_pin.sym} 132260 -36030 0 0 {name=p131144 lab=_54600_/Y }
C {devices/lab_pin.sym} 132420 -36070 0 1 {name=p131145 lab=_54601_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -36070 0 0 {name=X_54601_ }
C {devices/lab_pin.sym} 132250 -35930 0 0 {name=p131146 lab=_85645_/CLK }
C {devices/lab_pin.sym} 132250 -35910 0 0 {name=p131147 lab=_54554_/Y }
C {devices/lab_pin.sym} 132430 -35930 0 1 {name=p131148 lab=_85421_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -35920 0 0 {name=X_85421_ }
C {devices/lab_pin.sym} 132260 -35810 0 0 {name=p131149 lab=_85941_/Q }
C {devices/lab_pin.sym} 132260 -35770 0 0 {name=p131150 lab=_51789_/X }
C {devices/lab_pin.sym} 132260 -35730 0 0 {name=p131151 lab=_51812_/Y }
C {devices/lab_pin.sym} 132420 -35770 0 1 {name=p131152 lab=_51813_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -35770 0 0 {name=X_51813_ }
C {devices/lab_pin.sym} 132250 -35630 0 0 {name=p131153 lab=_82301_/CLK }
C {devices/lab_pin.sym} 132250 -35610 0 0 {name=p131154 lab=_82633_/D }
C {devices/lab_pin.sym} 132430 -35630 0 1 {name=p131155 lab=_78877_/B }
C {sky130_stdcells/dfxtp_4.sym} 132340 -35620 0 0 {name=X_82633_ }
C {devices/lab_pin.sym} 132300 -35490 0 0 {name=p131156 lab=_55580_/X }
C {devices/lab_pin.sym} 132380 -35490 0 1 {name=p131157 lab=_72648_/C }
C {sky130_stdcells/buf_2.sym} 132340 -35490 0 0 {name=X_55581_ }
C {devices/lab_pin.sym} 132300 -35370 0 0 {name=p131158 lab=clkbuf_9_460_0_CLK/X }
C {devices/lab_pin.sym} 132380 -35370 0 1 {name=p131159 lab=_83115_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 132340 -35370 0 0 {name=Xclkbuf_10_921_0_CLK }
C {devices/lab_pin.sym} 132260 -35270 0 0 {name=p131160 lab=_84064_/Q }
C {devices/lab_pin.sym} 132260 -35230 0 0 {name=p131161 lab=_67449_/X }
C {devices/lab_pin.sym} 132260 -35190 0 0 {name=p131162 lab=_67566_/X }
C {devices/lab_pin.sym} 132420 -35230 0 1 {name=p131163 lab=_67567_/X }
C {sky130_stdcells/a21bo_4.sym} 132340 -35230 0 0 {name=X_67567_ }
C {devices/lab_pin.sym} 132300 -35090 0 0 {name=p131164 lab=_52767_/A }
C {devices/lab_pin.sym} 132380 -35090 0 1 {name=p131165 lab=_52803_/A }
C {sky130_stdcells/buf_2.sym} 132340 -35090 0 0 {name=X_52793_ }
C {devices/lab_pin.sym} 132260 -35000 0 0 {name=p131166 lab=_64650_/X }
C {devices/lab_pin.sym} 132260 -34960 0 0 {name=p131167 lab=_86139_/Q }
C {devices/lab_pin.sym} 132260 -34920 0 0 {name=p131168 lab=_64776_/X }
C {devices/lab_pin.sym} 132260 -34880 0 0 {name=p131169 lab=_64778_/X }
C {devices/lab_pin.sym} 132420 -34940 0 1 {name=p131170 lab=_64779_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -34940 0 0 {name=X_64779_ }
C {devices/lab_pin.sym} 132260 -34820 0 0 {name=p131171 lab=_57318_/Y }
C {devices/lab_pin.sym} 132260 -34780 0 0 {name=p131172 lab=_56808_/Y }
C {devices/lab_pin.sym} 132260 -34740 0 0 {name=p131173 lab=_58981_/A }
C {devices/lab_pin.sym} 132260 -34700 0 0 {name=p131174 lab=_57319_/X }
C {devices/lab_pin.sym} 132420 -34760 0 1 {name=p131175 lab=_57320_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -34760 0 0 {name=X_57320_ }
C {devices/lab_pin.sym} 132260 -34640 0 0 {name=p131176 lab=_87527_/Q }
C {devices/lab_pin.sym} 132260 -34600 0 0 {name=p131177 lab=_69205_/X }
C {devices/lab_pin.sym} 132260 -34560 0 0 {name=p131178 lab=_69113_/X }
C {devices/lab_pin.sym} 132260 -34520 0 0 {name=p131179 lab=_69305_/X }
C {devices/lab_pin.sym} 132420 -34580 0 1 {name=p131180 lab=_69306_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -34580 0 0 {name=X_69306_ }
C {devices/lab_pin.sym} 132250 -34430 0 0 {name=p131181 lab=_88144_/CLK }
C {devices/lab_pin.sym} 132250 -34410 0 0 {name=p131182 lab=_88140_/D }
C {devices/lab_pin.sym} 132430 -34430 0 1 {name=p131183 lab=_88140_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -34420 0 0 {name=X_88140_ }
C {devices/lab_pin.sym} 132260 -34310 0 0 {name=p131184 lab=_54529_/Y }
C {devices/lab_pin.sym} 132260 -34270 0 0 {name=p131185 lab=_54530_/X }
C {devices/lab_pin.sym} 132260 -34230 0 0 {name=p131186 lab=_54531_/X }
C {devices/lab_pin.sym} 132420 -34270 0 1 {name=p131187 lab=_54532_/Y }
C {sky130_stdcells/a21oi_4.sym} 132340 -34270 0 0 {name=X_54532_ }
C {devices/lab_pin.sym} 132280 -34150 0 0 {name=p131188 lab=_65379_/X }
C {devices/lab_pin.sym} 132280 -34110 0 0 {name=p131189 lab=_66518_/B }
C {devices/lab_pin.sym} 132280 -34070 0 0 {name=p131190 lab=_65383_/C }
C {devices/lab_pin.sym} 132400 -34110 0 1 {name=p131191 lab=_66518_/Y }
C {sky130_stdcells/nand3_4.sym} 132340 -34110 0 0 {name=X_66518_ }
C {devices/lab_pin.sym} 132250 -33970 0 0 {name=p131192 lab=_85351_/CLK }
C {devices/lab_pin.sym} 132250 -33950 0 0 {name=p131193 lab=_85352_/D }
C {devices/lab_pin.sym} 132430 -33970 0 1 {name=p131194 lab=_85352_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -33960 0 0 {name=X_85352_ }
C {devices/lab_pin.sym} 132280 -33840 0 0 {name=p131195 lab=_51758_/A }
C {devices/lab_pin.sym} 132280 -33800 0 0 {name=p131196 lab=_51744_/B }
C {devices/lab_pin.sym} 132400 -33820 0 1 {name=p131197 lab=_51744_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -33820 0 0 {name=X_51744_ }
C {devices/lab_pin.sym} 132250 -33690 0 0 {name=p131198 lab=_82596_/CLK }
C {devices/lab_pin.sym} 132250 -33670 0 0 {name=p131199 lab=_82564_/D }
C {devices/lab_pin.sym} 132430 -33690 0 1 {name=p131200 lab=_78088_/A }
C {sky130_stdcells/dfxtp_4.sym} 132340 -33680 0 0 {name=X_82564_ }
C {devices/lab_pin.sym} 132300 -33550 0 0 {name=p131201 lab=clkbuf_9_413_0_CLK/A }
C {devices/lab_pin.sym} 132380 -33550 0 1 {name=p131202 lab=clkbuf_9_412_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 132340 -33550 0 0 {name=Xclkbuf_9_412_0_CLK }
C {sky130_stdcells/decap_3.sym} 132340 -33400 0 0 {name=XPHY_13 }
C {devices/lab_pin.sym} 132260 -33280 0 0 {name=p131203 lab=_87916_/Q }
C {devices/lab_pin.sym} 132260 -33240 0 0 {name=p131204 lab=_67473_/X }
C {devices/lab_pin.sym} 132260 -33200 0 0 {name=p131205 lab=_67405_/X }
C {devices/lab_pin.sym} 132260 -33160 0 0 {name=p131206 lab=_67497_/X }
C {devices/lab_pin.sym} 132420 -33220 0 1 {name=p131207 lab=_67498_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -33220 0 0 {name=X_67498_ }
C {sky130_stdcells/decap_3.sym} 132340 -33040 0 0 {name=XPHY_24 }
C {sky130_stdcells/decap_3.sym} 132340 -32860 0 0 {name=XPHY_35 }
C {devices/lab_pin.sym} 132250 -32710 0 0 {name=p131208 lab=_84308_/CLK }
C {devices/lab_pin.sym} 132250 -32690 0 0 {name=p131209 lab=_84303_/D }
C {devices/lab_pin.sym} 132430 -32710 0 1 {name=p131210 lab=_80347_/B }
C {sky130_stdcells/dfxtp_4.sym} 132340 -32700 0 0 {name=X_84303_ }
C {devices/lab_pin.sym} 132260 -32590 0 0 {name=p131211 lab=_56600_/X }
C {devices/lab_pin.sym} 132260 -32550 0 0 {name=p131212 lab=_57247_/Y }
C {devices/lab_pin.sym} 132260 -32510 0 0 {name=p131213 lab=_57250_/Y }
C {devices/lab_pin.sym} 132420 -32550 0 1 {name=p131214 lab=_85051_/D }
C {sky130_stdcells/a21oi_4.sym} 132340 -32550 0 0 {name=X_57251_ }
C {devices/lab_pin.sym} 132250 -32410 0 0 {name=p131215 lab=_81514_/CLK }
C {devices/lab_pin.sym} 132250 -32390 0 0 {name=p131216 lab=_81515_/D }
C {devices/lab_pin.sym} 132430 -32410 0 1 {name=p131217 lab=_81515_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -32400 0 0 {name=X_81515_ }
C {sky130_stdcells/decap_3.sym} 132340 -32240 0 0 {name=XPHY_46 }
C {devices/lab_pin.sym} 132260 -32120 0 0 {name=p131218 lab=_87532_/Q }
C {devices/lab_pin.sym} 132260 -32080 0 0 {name=p131219 lab=_69098_/X }
C {devices/lab_pin.sym} 132260 -32040 0 0 {name=p131220 lab=_69124_/X }
C {devices/lab_pin.sym} 132260 -32000 0 0 {name=p131221 lab=_69236_/X }
C {devices/lab_pin.sym} 132420 -32060 0 1 {name=p131222 lab=_69237_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -32060 0 0 {name=X_69237_ }
C {devices/lab_pin.sym} 132250 -31910 0 0 {name=p131223 lab=_87553_/CLK }
C {devices/lab_pin.sym} 132250 -31890 0 0 {name=p131224 lab=_88071_/D }
C {devices/lab_pin.sym} 132430 -31910 0 1 {name=p131225 lab=_73081_/A }
C {sky130_stdcells/dfxtp_4.sym} 132340 -31900 0 0 {name=X_88071_ }
C {devices/lab_pin.sym} 132260 -31790 0 0 {name=p131226 lab=_54461_/Y }
C {devices/lab_pin.sym} 132260 -31750 0 0 {name=p131227 lab=_54448_/X }
C {devices/lab_pin.sym} 132260 -31710 0 0 {name=p131228 lab=_54462_/X }
C {devices/lab_pin.sym} 132420 -31750 0 1 {name=p131229 lab=_85438_/D }
C {sky130_stdcells/a21oi_4.sym} 132340 -31750 0 0 {name=X_54463_ }
C {devices/lab_pin.sym} 132300 -31610 0 0 {name=p131230 lab=_66377_/A }
C {devices/lab_pin.sym} 132380 -31610 0 1 {name=p131231 lab=_66449_/X }
C {sky130_stdcells/buf_2.sym} 132340 -31610 0 0 {name=X_66449_ }
C {devices/lab_pin.sym} 132300 -31490 0 0 {name=p131232 lab=clkbuf_9_153_0_CLK/X }
C {devices/lab_pin.sym} 132380 -31490 0 1 {name=p131233 lab=_83338_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 132340 -31490 0 0 {name=Xclkbuf_10_306_0_CLK }
C {devices/lab_pin.sym} 132250 -31370 0 0 {name=p131234 lab=_83012_/CLK }
C {devices/lab_pin.sym} 132250 -31350 0 0 {name=p131235 lab=_85283_/D }
C {devices/lab_pin.sym} 132430 -31370 0 1 {name=p131236 lab=_85283_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -31360 0 0 {name=X_85283_ }
C {devices/lab_pin.sym} 132300 -31230 0 0 {name=p131237 lab=_51621_/A }
C {devices/lab_pin.sym} 132380 -31230 0 1 {name=p131238 lab=_51675_/X }
C {sky130_stdcells/buf_2.sym} 132340 -31230 0 0 {name=X_51675_ }
C {sky130_stdcells/decap_3.sym} 132340 -31080 0 0 {name=XPHY_57 }
C {devices/lab_pin.sym} 132250 -30930 0 0 {name=p131239 lab=_82692_/CLK }
C {devices/lab_pin.sym} 132250 -30910 0 0 {name=p131240 lab=_78769_/Y }
C {devices/lab_pin.sym} 132430 -30930 0 1 {name=p131241 lab=_82495_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -30920 0 0 {name=X_82495_ }
C {sky130_stdcells/decap_3.sym} 132340 -30760 0 0 {name=XPHY_68 }
C {sky130_stdcells/decap_3.sym} 132340 -30580 0 0 {name=XPHY_79 }
C {devices/lab_pin.sym} 132260 -30450 0 0 {name=p131242 lab=_56020_/X }
C {devices/lab_pin.sym} 132260 -30410 0 0 {name=p131243 lab=_56195_/X }
C {devices/lab_pin.sym} 132260 -30370 0 0 {name=p131244 lab=_56201_/Y }
C {devices/lab_pin.sym} 132420 -30410 0 1 {name=p131245 lab=_85278_/D }
C {sky130_stdcells/o21ai_4.sym} 132340 -30410 0 0 {name=X_56202_ }
C {devices/lab_pin.sym} 132250 -30270 0 0 {name=p131246 lab=_87022_/CLK }
C {devices/lab_pin.sym} 132250 -30250 0 0 {name=p131247 lab=_87022_/D }
C {devices/lab_pin.sym} 132430 -30270 0 1 {name=p131248 lab=_87022_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -30260 0 0 {name=X_87022_ }
C {devices/lab_pin.sym} 132280 -30160 0 0 {name=p131249 lab=_53397_/A }
C {devices/lab_pin.sym} 132280 -30120 0 0 {name=p131250 lab=_53402_/B }
C {devices/lab_pin.sym} 132280 -30080 0 0 {name=p131251 lab=_53410_/C }
C {devices/lab_pin.sym} 132280 -30040 0 0 {name=p131252 lab=_52900_/D }
C {devices/lab_pin.sym} 132400 -30100 0 1 {name=p131253 lab=_53414_/X }
C {sky130_stdcells/and4_4.sym} 132340 -30100 0 0 {name=X_53414_ }
C {devices/lab_pin.sym} 132300 -29950 0 0 {name=p131254 lab=clkbuf_9_468_0_CLK/X }
C {devices/lab_pin.sym} 132380 -29950 0 1 {name=p131255 lab=_87814_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 132340 -29950 0 0 {name=Xclkbuf_10_936_0_CLK }
C {devices/lab_pin.sym} 132250 -29830 0 0 {name=p131256 lab=_84624_/CLK }
C {devices/lab_pin.sym} 132250 -29810 0 0 {name=p131257 lab=_64560_/Y }
C {devices/lab_pin.sym} 132430 -29830 0 1 {name=p131258 lab=_79529_/B }
C {sky130_stdcells/dfxtp_4.sym} 132340 -29820 0 0 {name=X_84234_ }
C {devices/lab_pin.sym} 132300 -29690 0 0 {name=p131259 lab=_50594_/A }
C {devices/lab_pin.sym} 132380 -29690 0 1 {name=p131260 lab=_50626_/X }
C {sky130_stdcells/buf_2.sym} 132340 -29690 0 0 {name=X_50626_ }
C {devices/lab_pin.sym} 132280 -29600 0 0 {name=p131261 lab=_56755_/X }
C {devices/lab_pin.sym} 132280 -29560 0 0 {name=p131262 lab=_57023_/X }
C {devices/lab_pin.sym} 132280 -29520 0 0 {name=p131263 lab=_56759_/X }
C {devices/lab_pin.sym} 132280 -29480 0 0 {name=p131264 lab=_56877_/X }
C {devices/lab_pin.sym} 132400 -29540 0 1 {name=p131265 lab=_57182_/X }
C {sky130_stdcells/and4_4.sym} 132340 -29540 0 0 {name=X_57182_ }
C {devices/lab_pin.sym} 132250 -29390 0 0 {name=p131266 lab=_82053_/CLK }
C {devices/lab_pin.sym} 132250 -29370 0 0 {name=p131267 lab=_81446_/D }
C {devices/lab_pin.sym} 132430 -29390 0 1 {name=p131268 lab=_81446_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -29380 0 0 {name=X_81446_ }
C {devices/lab_pin.sym} 132300 -29250 0 0 {name=p131269 lab=_44245_/A }
C {devices/lab_pin.sym} 132380 -29250 0 1 {name=p131270 lab=_69168_/X }
C {sky130_stdcells/buf_2.sym} 132340 -29250 0 0 {name=X_69168_ }
C {devices/lab_pin.sym} 132300 -29130 0 0 {name=p131271 lab=_54366_/A }
C {devices/lab_pin.sym} 132380 -29130 0 1 {name=p131272 lab=_54394_/X }
C {sky130_stdcells/buf_2.sym} 132340 -29130 0 0 {name=X_54394_ }
C {devices/lab_pin.sym} 132260 -29030 0 0 {name=p131273 lab=_82074_/D }
C {devices/lab_pin.sym} 132260 -28990 0 0 {name=p131274 lab=_68101_/X }
C {devices/lab_pin.sym} 132260 -28950 0 0 {name=p131275 lab=_68118_/X }
C {devices/lab_pin.sym} 132420 -28990 0 1 {name=p131276 lab=_68119_/X }
C {sky130_stdcells/a21bo_4.sym} 132340 -28990 0 0 {name=X_68119_ }
C {devices/lab_pin.sym} 132280 -28860 0 0 {name=p131277 lab=_55801_/B }
C {devices/lab_pin.sym} 132280 -28820 0 0 {name=p131278 lab=_55801_/A }
C {devices/lab_pin.sym} 132400 -28840 0 1 {name=p131279 lab=_56134_/A }
C {sky130_stdcells/xnor2_4.sym} 132340 -28840 0 0 {name=X_56133_ }
C {devices/lab_pin.sym} 132280 -28720 0 0 {name=p131280 lab=_53332_/A }
C {devices/lab_pin.sym} 132280 -28680 0 0 {name=p131281 lab=_53345_/B }
C {devices/lab_pin.sym} 132400 -28700 0 1 {name=p131282 lab=_53345_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -28700 0 0 {name=X_53345_ }
C {devices/lab_pin.sym} 132300 -28570 0 0 {name=p131283 lab=clkbuf_9_427_0_CLK/A }
C {devices/lab_pin.sym} 132380 -28570 0 1 {name=p131284 lab=clkbuf_9_427_0_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 132340 -28570 0 0 {name=Xclkbuf_9_427_0_CLK }
C {devices/lab_pin.sym} 132250 -28450 0 0 {name=p131285 lab=_84166_/CLK }
C {devices/lab_pin.sym} 132250 -28430 0 0 {name=p131286 lab=_84165_/D }
C {devices/lab_pin.sym} 132430 -28450 0 1 {name=p131287 lab=_65970_/C }
C {sky130_stdcells/dfxtp_4.sym} 132340 -28440 0 0 {name=X_84165_ }
C {devices/lab_pin.sym} 132260 -28330 0 0 {name=p131288 lab=_50555_/Y }
C {devices/lab_pin.sym} 132260 -28290 0 0 {name=p131289 lab=_50474_/X }
C {devices/lab_pin.sym} 132260 -28250 0 0 {name=p131290 lab=_50556_/Y }
C {devices/lab_pin.sym} 132420 -28290 0 1 {name=p131291 lab=_50557_/Y }
C {sky130_stdcells/a21boi_4.sym} 132340 -28290 0 0 {name=X_50557_ }
C {devices/lab_pin.sym} 132250 -28150 0 0 {name=p131292 lab=_83940_/CLK }
C {devices/lab_pin.sym} 132250 -28130 0 0 {name=p131293 lab=_76949_/X }
C {devices/lab_pin.sym} 132430 -28150 0 1 {name=p131294 lab=_81377_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -28140 0 0 {name=X_81377_ }
C {devices/lab_pin.sym} 132300 -28010 0 0 {name=p131295 lab=_69357_/A }
C {devices/lab_pin.sym} 132380 -28010 0 1 {name=p131296 lab=_69236_/A }
C {sky130_stdcells/buf_2.sym} 132340 -28010 0 0 {name=X_69099_ }
C {devices/lab_pin.sym} 132260 -27910 0 0 {name=p131297 lab=_50712_/B }
C {devices/lab_pin.sym} 132260 -27870 0 0 {name=p131298 lab=_71117_/A }
C {devices/lab_pin.sym} 132260 -27830 0 0 {name=p131299 lab=_71129_/Y }
C {devices/lab_pin.sym} 132420 -27870 0 1 {name=p131300 lab=_83596_/D }
C {sky130_stdcells/o21ai_4.sym} 132340 -27870 0 0 {name=X_71130_ }
C {devices/lab_pin.sym} 132250 -27730 0 0 {name=p131301 lab=_85895_/CLK }
C {devices/lab_pin.sym} 132250 -27710 0 0 {name=p131302 lab=_74243_/X }
C {devices/lab_pin.sym} 132430 -27730 0 1 {name=p131303 lab=_70130_/B }
C {sky130_stdcells/dfxtp_4.sym} 132340 -27720 0 0 {name=X_83116_ }
C {devices/lab_pin.sym} 132300 -27590 0 0 {name=p131304 lab=_56063_/Y }
C {devices/lab_pin.sym} 132380 -27590 0 1 {name=p131305 lab=_56064_/X }
C {sky130_stdcells/buf_2.sym} 132340 -27590 0 0 {name=X_56064_ }
C {devices/lab_pin.sym} 132280 -27480 0 0 {name=p131306 lab=_80326_/X }
C {devices/lab_pin.sym} 132280 -27440 0 0 {name=p131307 lab=_80327_/Y }
C {devices/lab_pin.sym} 132400 -27460 0 1 {name=p131308 lab=_80328_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -27460 0 0 {name=X_80328_ }
C {devices/lab_pin.sym} 132300 -27330 0 0 {name=p131309 lab=_41143_/A }
C {devices/lab_pin.sym} 132380 -27330 0 1 {name=p131310 lab=_41290_/X }
C {sky130_stdcells/buf_2.sym} 132340 -27330 0 0 {name=X_41290_ }
C {devices/lab_pin.sym} 132280 -27220 0 0 {name=p131311 lab=_53276_/A }
C {devices/lab_pin.sym} 132280 -27180 0 0 {name=p131312 lab=_54451_/B }
C {devices/lab_pin.sym} 132400 -27200 0 1 {name=p131313 lab=_53276_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -27200 0 0 {name=X_53276_ }
C {devices/lab_pin.sym} 132250 -27070 0 0 {name=p131314 lab=_81169_/CLK }
C {devices/lab_pin.sym} 132250 -27050 0 0 {name=p131315 lab=_66806_/X }
C {devices/lab_pin.sym} 132430 -27070 0 1 {name=p131316 lab=_84096_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -27060 0 0 {name=X_84096_ }
C {devices/lab_pin.sym} 132260 -26950 0 0 {name=p131317 lab=_50486_/Y }
C {devices/lab_pin.sym} 132260 -26910 0 0 {name=p131318 lab=_50455_/X }
C {devices/lab_pin.sym} 132260 -26870 0 0 {name=p131319 lab=_50487_/X }
C {devices/lab_pin.sym} 132420 -26910 0 1 {name=p131320 lab=_50488_/Y }
C {sky130_stdcells/a21oi_4.sym} 132340 -26910 0 0 {name=X_50488_ }
C {devices/lab_pin.sym} 132280 -26780 0 0 {name=p131321 lab=_55011_/A }
C {devices/lab_pin.sym} 132280 -26740 0 0 {name=p131322 lab=_47632_/A }
C {devices/lab_pin.sym} 132400 -26760 0 1 {name=p131323 lab=_55015_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -26760 0 0 {name=X_55015_ }
C {devices/lab_pin.sym} 132300 -26630 0 0 {name=p131324 lab=_52198_/A }
C {devices/lab_pin.sym} 132380 -26630 0 1 {name=p131325 lab=_52248_/B }
C {sky130_stdcells/buf_2.sym} 132340 -26630 0 0 {name=X_52227_ }
C {devices/lab_pin.sym} 132260 -26530 0 0 {name=p131326 lab=_48922_/B }
C {devices/lab_pin.sym} 132260 -26490 0 0 {name=p131327 lab=_71047_/X }
C {devices/lab_pin.sym} 132260 -26450 0 0 {name=p131328 lab=_71060_/Y }
C {devices/lab_pin.sym} 132420 -26490 0 1 {name=p131329 lab=_83621_/D }
C {sky130_stdcells/o21ai_4.sym} 132340 -26490 0 0 {name=X_71061_ }
C {devices/lab_pin.sym} 132250 -26350 0 0 {name=p131330 lab=_83049_/CLK }
C {devices/lab_pin.sym} 132250 -26330 0 0 {name=p131331 lab=_74524_/Y }
C {devices/lab_pin.sym} 132430 -26350 0 1 {name=p131332 lab=_83047_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -26340 0 0 {name=X_83047_ }
C {devices/lab_pin.sym} 132250 -26210 0 0 {name=p131333 lab=_88180_/CLK }
C {devices/lab_pin.sym} 132250 -26190 0 0 {name=p131334 lab=_42317_/X }
C {devices/lab_pin.sym} 132430 -26210 0 1 {name=p131335 lab=_87924_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -26200 0 0 {name=X_87924_ }
C {devices/lab_pin.sym} 132280 -26080 0 0 {name=p131336 lab=_80259_/A }
C {devices/lab_pin.sym} 132280 -26040 0 0 {name=p131337 lab=_80259_/B }
C {devices/lab_pin.sym} 132400 -26060 0 1 {name=p131338 lab=_80261_/A }
C {sky130_stdcells/nand2_4.sym} 132340 -26060 0 0 {name=X_80259_ }
C {devices/lab_pin.sym} 132300 -25930 0 0 {name=p131339 lab=_70012_/A }
C {devices/lab_pin.sym} 132380 -25930 0 1 {name=p131340 lab=_70012_/X }
C {sky130_stdcells/buf_2.sym} 132340 -25930 0 0 {name=X_70012_ }
C {devices/lab_pin.sym} 132300 -25810 0 0 {name=p131341 lab=_59664_/A }
C {devices/lab_pin.sym} 132380 -25810 0 1 {name=p131342 lab=_59823_/X }
C {sky130_stdcells/buf_2.sym} 132340 -25810 0 0 {name=X_59823_ }
C {devices/lab_pin.sym} 132280 -25700 0 0 {name=p131343 lab=_52168_/A }
C {devices/lab_pin.sym} 132280 -25660 0 0 {name=p131344 lab=_52158_/B }
C {devices/lab_pin.sym} 132400 -25680 0 1 {name=p131345 lab=_52158_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -25680 0 0 {name=X_52158_ }
C {devices/lab_pin.sym} 132250 -25550 0 0 {name=p131346 lab=_88345_/CLK }
C {devices/lab_pin.sym} 132250 -25530 0 0 {name=p131347 lab=_87855_/D }
C {devices/lab_pin.sym} 132430 -25550 0 1 {name=p131348 lab=_87855_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -25540 0 0 {name=X_87855_ }
C {devices/lab_pin.sym} 132300 -25410 0 0 {name=p131349 lab=_51191_/A }
C {devices/lab_pin.sym} 132380 -25410 0 1 {name=p131350 lab=_51115_/A }
C {sky130_stdcells/buf_2.sym} 132340 -25410 0 0 {name=X_51109_ }
C {devices/lab_pin.sym} 132300 -25290 0 0 {name=p131351 lab=_74831_/A }
C {devices/lab_pin.sym} 132380 -25290 0 1 {name=p131352 lab=_74829_/A }
C {sky130_stdcells/buf_2.sym} 132340 -25290 0 0 {name=X_74820_ }
C {devices/lab_pin.sym} 132250 -25170 0 0 {name=p131353 lab=_87888_/CLK }
C {devices/lab_pin.sym} 132250 -25150 0 0 {name=p131354 lab=_46027_/X }
C {devices/lab_pin.sym} 132430 -25170 0 1 {name=p131355 lab=_66544_/B }
C {sky130_stdcells/dfxtp_4.sym} 132340 -25160 0 0 {name=X_86806_ }
C {devices/lab_pin.sym} 132280 -25060 0 0 {name=p131356 lab=_59754_/A }
C {devices/lab_pin.sym} 132280 -25020 0 0 {name=p131357 lab=_59731_/Y }
C {devices/lab_pin.sym} 132280 -24980 0 0 {name=p131358 lab=_59754_/C }
C {devices/lab_pin.sym} 132280 -24940 0 0 {name=p131359 lab=_59754_/D }
C {devices/lab_pin.sym} 132400 -25000 0 1 {name=p131360 lab=_59754_/X }
C {sky130_stdcells/and4_4.sym} 132340 -25000 0 0 {name=X_59754_ }
C {devices/lab_pin.sym} 132300 -24850 0 0 {name=p131361 lab=_52152_/A }
C {devices/lab_pin.sym} 132380 -24850 0 1 {name=p131362 lab=_52089_/X }
C {sky130_stdcells/buf_2.sym} 132340 -24850 0 0 {name=X_52089_ }
C {devices/lab_pin.sym} 132260 -24750 0 0 {name=p131363 lab=_85244_/Q }
C {devices/lab_pin.sym} 132260 -24710 0 0 {name=p131364 lab=_44979_/X }
C {devices/lab_pin.sym} 132260 -24670 0 0 {name=p131365 lab=_44926_/X }
C {devices/lab_pin.sym} 132420 -24710 0 1 {name=p131366 lab=_44980_/X }
C {sky130_stdcells/o21a_4.sym} 132340 -24710 0 0 {name=X_44980_ }
C {devices/lab_pin.sym} 132300 -24570 0 0 {name=p131367 lab=_57019_/A }
C {devices/lab_pin.sym} 132380 -24570 0 1 {name=p131368 lab=_56966_/X }
C {sky130_stdcells/buf_2.sym} 132340 -24570 0 0 {name=X_56966_ }
C {devices/lab_pin.sym} 132250 -24450 0 0 {name=p131369 lab=_87789_/CLK }
C {devices/lab_pin.sym} 132250 -24430 0 0 {name=p131370 lab=_42654_/X }
C {devices/lab_pin.sym} 132430 -24450 0 1 {name=p131371 lab=_87786_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -24440 0 0 {name=X_87786_ }
C {devices/lab_pin.sym} 132250 -24310 0 0 {name=p131372 lab=_84998_/CLK }
C {devices/lab_pin.sym} 132250 -24290 0 0 {name=p131373 lab=_84998_/D }
C {devices/lab_pin.sym} 132430 -24310 0 1 {name=p131374 lab=_57468_/A }
C {sky130_stdcells/dfxtp_4.sym} 132340 -24300 0 0 {name=X_84998_ }
C {devices/lab_pin.sym} 132260 -24190 0 0 {name=p131375 lab=_58703_/X }
C {devices/lab_pin.sym} 132260 -24150 0 0 {name=p131376 lab=_85462_/Q }
C {devices/lab_pin.sym} 132260 -24110 0 0 {name=p131377 lab=_58704_/X }
C {devices/lab_pin.sym} 132420 -24150 0 1 {name=p131378 lab=_58705_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -24150 0 0 {name=X_58705_ }
C {devices/lab_pin.sym} 132260 -24050 0 0 {name=p131379 lab=_43916_/X }
C {devices/lab_pin.sym} 132260 -24010 0 0 {name=p131380 lab=_43924_/X }
C {devices/lab_pin.sym} 132260 -23970 0 0 {name=p131381 lab=_41424_/X }
C {devices/lab_pin.sym} 132260 -23930 0 0 {name=p131382 lab=_67939_/B }
C {devices/lab_pin.sym} 132260 -23890 0 0 {name=p131383 lab=_43917_/X }
C {devices/lab_pin.sym} 132420 -23970 0 1 {name=p131384 lab=_43932_/A }
C {sky130_stdcells/o32ai_4.sym} 132340 -23970 0 0 {name=X_43931_ }
C {devices/lab_pin.sym} 132280 -23840 0 0 {name=p131385 lab=_74751_/A }
C {devices/lab_pin.sym} 132280 -23800 0 0 {name=p131386 lab=_74804_/A }
C {devices/lab_pin.sym} 132280 -23760 0 0 {name=p131387 lab=_74797_/C }
C {devices/lab_pin.sym} 132280 -23720 0 0 {name=p131388 lab=_71738_/X }
C {devices/lab_pin.sym} 132400 -23780 0 1 {name=p131389 lab=_74751_/Y }
C {sky130_stdcells/nand4_4.sym} 132340 -23780 0 0 {name=X_74751_ }
C {devices/lab_pin.sym} 132280 -23660 0 0 {name=p131390 lab=_55907_/X }
C {devices/lab_pin.sym} 132280 -23620 0 0 {name=p131391 lab=_55912_/X }
C {devices/lab_pin.sym} 132280 -23580 0 0 {name=p131392 lab=_55914_/X }
C {devices/lab_pin.sym} 132280 -23540 0 0 {name=p131393 lab=_55916_/X }
C {devices/lab_pin.sym} 132400 -23600 0 1 {name=p131394 lab=_55918_/A }
C {sky130_stdcells/and4_4.sym} 132340 -23600 0 0 {name=X_55917_ }
C {devices/lab_pin.sym} 132250 -23450 0 0 {name=p131395 lab=_85815_/CLK }
C {devices/lab_pin.sym} 132250 -23430 0 0 {name=p131396 lab=_46440_/Y }
C {devices/lab_pin.sym} 132430 -23450 0 1 {name=p131397 lab=_86737_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -23440 0 0 {name=X_86737_ }
C {devices/lab_pin.sym} 132260 -23330 0 0 {name=p131398 lab=_83312_/Q }
C {devices/lab_pin.sym} 132260 -23290 0 0 {name=p131399 lab=_57615_/X }
C {devices/lab_pin.sym} 132260 -23250 0 0 {name=p131400 lab=_71962_/Y }
C {devices/lab_pin.sym} 132420 -23290 0 1 {name=p131401 lab=_71963_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -23290 0 0 {name=X_71963_ }
C {devices/lab_pin.sym} 132250 -23150 0 0 {name=p131402 lab=_80776_/CLK }
C {devices/lab_pin.sym} 132250 -23130 0 0 {name=p131403 lab=_83949_/D }
C {devices/lab_pin.sym} 132430 -23150 0 1 {name=p131404 lab=_83949_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -23140 0 0 {name=X_83949_ }
C {devices/lab_pin.sym} 132300 -23010 0 0 {name=p131405 lab=_59684_/X }
C {devices/lab_pin.sym} 132380 -23010 0 1 {name=p131406 lab=_59699_/A }
C {sky130_stdcells/buf_2.sym} 132340 -23010 0 0 {name=X_59685_ }
C {devices/lab_pin.sym} 132280 -22900 0 0 {name=p131407 lab=_56892_/Y }
C {devices/lab_pin.sym} 132280 -22860 0 0 {name=p131408 lab=_56897_/B }
C {devices/lab_pin.sym} 132400 -22880 0 1 {name=p131409 lab=_85125_/D }
C {sky130_stdcells/nand2_4.sym} 132340 -22880 0 0 {name=X_56897_ }
C {devices/lab_pin.sym} 132260 -22780 0 0 {name=p131410 lab=_43041_/Y }
C {devices/lab_pin.sym} 132260 -22740 0 0 {name=p131411 lab=_73627_/X }
C {devices/lab_pin.sym} 132260 -22700 0 0 {name=p131412 lab=_73652_/X }
C {devices/lab_pin.sym} 132260 -22660 0 0 {name=p131413 lab=_73701_/Y }
C {devices/lab_pin.sym} 132420 -22720 0 1 {name=p131414 lab=_73702_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -22720 0 0 {name=X_73702_ }
C {devices/lab_pin.sym} 132300 -22570 0 0 {name=p131415 lab=_46650_/A }
C {devices/lab_pin.sym} 132380 -22570 0 1 {name=p131416 lab=_51770_/B }
C {sky130_stdcells/buf_2.sym} 132340 -22570 0 0 {name=X_46650_ }
C {devices/lab_pin.sym} 132280 -22480 0 0 {name=p131417 lab=_70860_/A }
C {devices/lab_pin.sym} 132280 -22440 0 0 {name=p131418 lab=_70914_/B }
C {devices/lab_pin.sym} 132280 -22400 0 0 {name=p131419 lab=_70914_/C }
C {devices/lab_pin.sym} 132280 -22360 0 0 {name=p131420 lab=_70914_/D }
C {devices/lab_pin.sym} 132400 -22420 0 1 {name=p131421 lab=_70914_/Y }
C {sky130_stdcells/nand4_4.sym} 132340 -22420 0 0 {name=X_70914_ }
C {devices/lab_pin.sym} 132300 -22270 0 0 {name=p131422 lab=_58868_/A }
C {devices/lab_pin.sym} 132380 -22270 0 1 {name=p131423 lab=_58636_/X }
C {sky130_stdcells/buf_2.sym} 132340 -22270 0 0 {name=X_58636_ }
C {devices/lab_pin.sym} 132280 -22160 0 0 {name=p131424 lab=_77471_/A }
C {devices/lab_pin.sym} 132280 -22120 0 0 {name=p131425 lab=_77471_/B }
C {devices/lab_pin.sym} 132400 -22140 0 1 {name=p131426 lab=_77475_/A }
C {sky130_stdcells/nor2_4.sym} 132340 -22140 0 0 {name=X_77470_ }
C {devices/lab_pin.sym} 132300 -22010 0 0 {name=p131427 lab=_43810_/A }
C {devices/lab_pin.sym} 132380 -22010 0 1 {name=p131428 lab=_43862_/X }
C {sky130_stdcells/buf_2.sym} 132340 -22010 0 0 {name=X_43862_ }
C {devices/lab_pin.sym} 132280 -21900 0 0 {name=p131429 lab=_44079_/X }
C {devices/lab_pin.sym} 132280 -21860 0 0 {name=p131430 lab=_55848_/B }
C {devices/lab_pin.sym} 132400 -21880 0 1 {name=p131431 lab=_55848_/X }
C {sky130_stdcells/and2_4.sym} 132340 -21880 0 0 {name=X_55848_ }
C {devices/lab_pin.sym} 132280 -21760 0 0 {name=p131432 lab=_74679_/A }
C {devices/lab_pin.sym} 132280 -21720 0 0 {name=p131433 lab=_45761_/A }
C {devices/lab_pin.sym} 132400 -21740 0 1 {name=p131434 lab=_74682_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -21740 0 0 {name=X_74682_ }
C {devices/lab_pin.sym} 132250 -21610 0 0 {name=p131435 lab=_86351_/CLK }
C {devices/lab_pin.sym} 132250 -21590 0 0 {name=p131436 lab=_47122_/Y }
C {devices/lab_pin.sym} 132430 -21610 0 1 {name=p131437 lab=_86668_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -21600 0 0 {name=X_86668_ }
C {devices/lab_pin.sym} 132300 -21470 0 0 {name=p131438 lab=_70530_/Y }
C {devices/lab_pin.sym} 132380 -21470 0 1 {name=p131439 lab=_71894_/Y }
C {sky130_stdcells/inv_2.sym} 132340 -21470 0 0 {name=X_71894_ }
C {devices/lab_pin.sym} 132260 -21380 0 0 {name=p131440 lab=_45599_/Y }
C {devices/lab_pin.sym} 132260 -21340 0 0 {name=p131441 lab=_45570_/X }
C {devices/lab_pin.sym} 132260 -21300 0 0 {name=p131442 lab=_45520_/X }
C {devices/lab_pin.sym} 132260 -21260 0 0 {name=p131443 lab=_45600_/Y }
C {devices/lab_pin.sym} 132420 -21320 0 1 {name=p131444 lab=_45601_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -21320 0 0 {name=X_45601_ }
C {devices/lab_pin.sym} 132260 -21190 0 0 {name=p131445 lab=_76404_/X }
C {devices/lab_pin.sym} 132260 -21150 0 0 {name=p131446 lab=_76400_/X }
C {devices/lab_pin.sym} 132260 -21110 0 0 {name=p131447 lab=_76401_/X }
C {devices/lab_pin.sym} 132420 -21150 0 1 {name=p131448 lab=_76421_/Y }
C {sky130_stdcells/a21oi_4.sym} 132340 -21150 0 0 {name=X_76421_ }
C {devices/lab_pin.sym} 132260 -21040 0 0 {name=p131449 lab=_41429_/X }
C {devices/lab_pin.sym} 132260 -21000 0 0 {name=p131450 lab=_42802_/X }
C {devices/lab_pin.sym} 132260 -20960 0 0 {name=p131451 lab=_87705_/Q }
C {devices/lab_pin.sym} 132260 -20920 0 0 {name=p131452 lab=_42803_/X }
C {devices/lab_pin.sym} 132420 -20980 0 1 {name=p131453 lab=_87705_/D }
C {sky130_stdcells/a2bb2o_4.sym} 132340 -20980 0 0 {name=X_42813_ }
C {devices/lab_pin.sym} 132300 -20830 0 0 {name=p131454 lab=_74244_/B }
C {devices/lab_pin.sym} 132380 -20830 0 1 {name=p131455 lab=_73633_/X }
C {sky130_stdcells/buf_2.sym} 132340 -20830 0 0 {name=X_73633_ }
C {devices/lab_pin.sym} 132250 -20710 0 0 {name=p131456 lab=_86549_/CLK }
C {devices/lab_pin.sym} 132250 -20690 0 0 {name=p131457 lab=_53530_/Y }
C {devices/lab_pin.sym} 132430 -20710 0 1 {name=p131458 lab=_85619_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -20700 0 0 {name=X_85619_ }
C {devices/lab_pin.sym} 132260 -20590 0 0 {name=p131459 lab=_51770_/B }
C {devices/lab_pin.sym} 132260 -20550 0 0 {name=p131460 lab=_70831_/X }
C {devices/lab_pin.sym} 132260 -20510 0 0 {name=p131461 lab=_70844_/Y }
C {devices/lab_pin.sym} 132420 -20550 0 1 {name=p131462 lab=_70845_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -20550 0 0 {name=X_70845_ }
C {devices/lab_pin.sym} 132260 -20450 0 0 {name=p131463 lab=_58079_/X }
C {devices/lab_pin.sym} 132260 -20410 0 0 {name=p131464 lab=_58564_/Y }
C {devices/lab_pin.sym} 132260 -20370 0 0 {name=p131465 lab=_58566_/Y }
C {devices/lab_pin.sym} 132260 -20330 0 0 {name=p131466 lab=_58098_/X }
C {devices/lab_pin.sym} 132260 -20290 0 0 {name=p131467 lab=_58083_/X }
C {devices/lab_pin.sym} 132420 -20370 0 1 {name=p131468 lab=_58567_/X }
C {sky130_stdcells/o32a_4.sym} 132340 -20370 0 0 {name=X_58567_ }
C {devices/lab_pin.sym} 132260 -20230 0 0 {name=p131469 lab=_46578_/X }
C {devices/lab_pin.sym} 132260 -20190 0 0 {name=p131470 lab=_49179_/A }
C {devices/lab_pin.sym} 132260 -20150 0 0 {name=p131471 lab=_46580_/X }
C {devices/lab_pin.sym} 132420 -20190 0 1 {name=p131472 lab=_51384_/B }
C {sky130_stdcells/o21ai_4.sym} 132340 -20190 0 0 {name=X_46581_ }
C {devices/lab_pin.sym} 132300 -20050 0 0 {name=p131473 lab=_43792_/Y }
C {devices/lab_pin.sym} 132380 -20050 0 1 {name=p131474 lab=_87265_/D }
C {sky130_stdcells/inv_2.sym} 132340 -20050 0 0 {name=X_43793_ }
C {devices/lab_pin.sym} 132280 -19940 0 0 {name=p131475 lab=_55761_/A }
C {devices/lab_pin.sym} 132280 -19900 0 0 {name=p131476 lab=_85290_/Q }
C {devices/lab_pin.sym} 132400 -19920 0 1 {name=p131477 lab=_55779_/X }
C {sky130_stdcells/and2_4.sym} 132340 -19920 0 0 {name=X_55779_ }
C {devices/lab_pin.sym} 132250 -19790 0 0 {name=p131478 lab=_85961_/CLK }
C {devices/lab_pin.sym} 132250 -19770 0 0 {name=p131479 lab=_86599_/D }
C {devices/lab_pin.sym} 132430 -19790 0 1 {name=p131480 lab=_72428_/A }
C {sky130_stdcells/dfxtp_4.sym} 132340 -19780 0 0 {name=X_86599_ }
C {devices/lab_pin.sym} 132260 -19670 0 0 {name=p131481 lab=_74177_/B }
C {devices/lab_pin.sym} 132260 -19630 0 0 {name=p131482 lab=_48293_/X }
C {devices/lab_pin.sym} 132260 -19590 0 0 {name=p131483 lab=_48319_/Y }
C {devices/lab_pin.sym} 132420 -19630 0 1 {name=p131484 lab=_48320_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -19630 0 0 {name=X_48320_ }
C {devices/lab_pin.sym} 132280 -19500 0 0 {name=p131485 lab=_79140_/A }
C {devices/lab_pin.sym} 132280 -19460 0 0 {name=p131486 lab=_61546_/C }
C {devices/lab_pin.sym} 132400 -19480 0 1 {name=p131487 lab=_79140_/X }
C {sky130_stdcells/xor2_4.sym} 132340 -19480 0 0 {name=X_79140_ }
C {devices/lab_pin.sym} 132260 -19370 0 0 {name=p131488 lab=_45524_/X }
C {devices/lab_pin.sym} 132260 -19330 0 0 {name=p131489 lab=_45528_/Y }
C {devices/lab_pin.sym} 132260 -19290 0 0 {name=p131490 lab=_45531_/Y }
C {devices/lab_pin.sym} 132420 -19330 0 1 {name=p131491 lab=_45532_/Y }
C {sky130_stdcells/a21oi_4.sym} 132340 -19330 0 0 {name=X_45532_ }
C {devices/lab_pin.sym} 132280 -19200 0 0 {name=p131492 lab=_57499_/A }
C {devices/lab_pin.sym} 132280 -19160 0 0 {name=p131493 lab=_73717_/A }
C {devices/lab_pin.sym} 132400 -19180 0 1 {name=p131494 lab=_57518_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -19180 0 0 {name=X_57518_ }
C {devices/lab_pin.sym} 132250 -19050 0 0 {name=p131495 lab=_88337_/CLK }
C {devices/lab_pin.sym} 132250 -19030 0 0 {name=p131496 lab=_40772_/X }
C {devices/lab_pin.sym} 132430 -19050 0 1 {name=p131497 lab=_88338_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -19040 0 0 {name=X_88338_ }
C {devices/lab_pin.sym} 132260 -18930 0 0 {name=p131498 lab=_76348_/X }
C {devices/lab_pin.sym} 132260 -18890 0 0 {name=p131499 lab=_76349_/Y }
C {devices/lab_pin.sym} 132260 -18850 0 0 {name=p131500 lab=_76353_/B }
C {devices/lab_pin.sym} 132420 -18890 0 1 {name=p131501 lab=_76352_/X }
C {sky130_stdcells/a21o_4.sym} 132340 -18890 0 0 {name=X_76352_ }
C {devices/lab_pin.sym} 132300 -18750 0 0 {name=p131502 lab=_51949_/A }
C {devices/lab_pin.sym} 132380 -18750 0 1 {name=p131503 lab=_42745_/A }
C {sky130_stdcells/buf_2.sym} 132340 -18750 0 0 {name=X_42744_ }
C {devices/lab_pin.sym} 132260 -18660 0 0 {name=p131504 lab=_73449_/X }
C {devices/lab_pin.sym} 132260 -18620 0 0 {name=p131505 lab=_85633_/Q }
C {devices/lab_pin.sym} 132260 -18580 0 0 {name=p131506 lab=_73450_/X }
C {devices/lab_pin.sym} 132260 -18540 0 0 {name=p131507 lab=_73563_/X }
C {devices/lab_pin.sym} 132420 -18600 0 1 {name=p131508 lab=_73564_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -18600 0 0 {name=X_73564_ }
C {devices/lab_pin.sym} 132260 -18470 0 0 {name=p131509 lab=_52850_/B }
C {devices/lab_pin.sym} 132260 -18430 0 0 {name=p131510 lab=_70761_/X }
C {devices/lab_pin.sym} 132260 -18390 0 0 {name=p131511 lab=_70775_/Y }
C {devices/lab_pin.sym} 132420 -18430 0 1 {name=p131512 lab=_70776_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -18430 0 0 {name=X_70776_ }
C {devices/lab_pin.sym} 132280 -18300 0 0 {name=p131513 lab=_58498_/A }
C {devices/lab_pin.sym} 132280 -18260 0 0 {name=p131514 lab=_58498_/B }
C {devices/lab_pin.sym} 132400 -18280 0 1 {name=p131515 lab=_58498_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -18280 0 0 {name=X_58498_ }
C {devices/lab_pin.sym} 132280 -18160 0 0 {name=p131516 lab=_75294_/Y }
C {devices/lab_pin.sym} 132280 -18120 0 0 {name=p131517 lab=_75303_/B }
C {devices/lab_pin.sym} 132400 -18140 0 1 {name=p131518 lab=_75304_/A }
C {sky130_stdcells/and2_4.sym} 132340 -18140 0 0 {name=X_75303_ }
C {devices/lab_pin.sym} 132300 -18010 0 0 {name=p131519 lab=_47975_/B }
C {devices/lab_pin.sym} 132380 -18010 0 1 {name=p131520 lab=_50300_/B }
C {sky130_stdcells/buf_2.sym} 132340 -18010 0 0 {name=X_48251_ }
C {devices/lab_pin.sym} 132280 -17920 0 0 {name=p131521 lab=_72563_/B }
C {devices/lab_pin.sym} 132280 -17880 0 0 {name=p131522 lab=_72508_/A }
C {devices/lab_pin.sym} 132280 -17840 0 0 {name=p131523 lab=_72607_/C }
C {devices/lab_pin.sym} 132280 -17800 0 0 {name=p131524 lab=_72515_/D }
C {devices/lab_pin.sym} 132400 -17860 0 1 {name=p131525 lab=_72517_/A }
C {sky130_stdcells/nand4_4.sym} 132340 -17860 0 0 {name=X_72515_ }
C {devices/lab_pin.sym} 132280 -17720 0 0 {name=p131526 lab=_79071_/A }
C {devices/lab_pin.sym} 132280 -17680 0 0 {name=p131527 lab=_79071_/B }
C {devices/lab_pin.sym} 132400 -17700 0 1 {name=p131528 lab=_79071_/X }
C {sky130_stdcells/xor2_4.sym} 132340 -17700 0 0 {name=X_79071_ }
C {devices/lab_pin.sym} 132280 -17580 0 0 {name=p131529 lab=_83005_/Q }
C {devices/lab_pin.sym} 132280 -17540 0 0 {name=p131530 lab=_44894_/B }
C {devices/lab_pin.sym} 132400 -17560 0 1 {name=p131531 lab=_45463_/Y }
C {sky130_stdcells/nor2_4.sym} 132340 -17560 0 0 {name=X_45463_ }
C {devices/lab_pin.sym} 132260 -17450 0 0 {name=p131532 lab=_57441_/X }
C {devices/lab_pin.sym} 132260 -17410 0 0 {name=p131533 lab=_56821_/X }
C {devices/lab_pin.sym} 132260 -17370 0 0 {name=p131534 lab=_57448_/X }
C {devices/lab_pin.sym} 132420 -17410 0 1 {name=p131535 lab=_57449_/X }
C {sky130_stdcells/o21a_4.sym} 132340 -17410 0 0 {name=X_57449_ }
C {devices/lab_pin.sym} 132300 -17270 0 0 {name=p131536 lab=_76283_/A }
C {devices/lab_pin.sym} 132380 -17270 0 1 {name=p131537 lab=_76283_/Y }
C {sky130_stdcells/inv_2.sym} 132340 -17270 0 0 {name=X_76283_ }
C {devices/lab_pin.sym} 132250 -17150 0 0 {name=p131538 lab=_88272_/CLK }
C {devices/lab_pin.sym} 132250 -17130 0 0 {name=p131539 lab=_88269_/D }
C {devices/lab_pin.sym} 132430 -17150 0 1 {name=p131540 lab=_88269_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -17140 0 0 {name=X_88269_ }
C {devices/lab_pin.sym} 132300 -17010 0 0 {name=p131541 lab=_42674_/Y }
C {devices/lab_pin.sym} 132380 -17010 0 1 {name=p131542 lab=_87776_/D }
C {sky130_stdcells/inv_2.sym} 132340 -17010 0 0 {name=X_42675_ }
C {devices/lab_pin.sym} 132280 -16900 0 0 {name=p131543 lab=_73495_/A }
C {devices/lab_pin.sym} 132280 -16860 0 0 {name=p131544 lab=_85860_/Q }
C {devices/lab_pin.sym} 132400 -16880 0 1 {name=p131545 lab=_73495_/X }
C {sky130_stdcells/and2_4.sym} 132340 -16880 0 0 {name=X_73495_ }
C {devices/lab_pin.sym} 132280 -16780 0 0 {name=p131546 lab=_47210_/A }
C {devices/lab_pin.sym} 132280 -16740 0 0 {name=p131547 lab=_47181_/B }
C {devices/lab_pin.sym} 132280 -16700 0 0 {name=p131548 lab=_47210_/C }
C {devices/lab_pin.sym} 132280 -16660 0 0 {name=p131549 lab=_51220_/D }
C {devices/lab_pin.sym} 132400 -16720 0 1 {name=p131550 lab=_47202_/X }
C {sky130_stdcells/and4_4.sym} 132340 -16720 0 0 {name=X_47202_ }
C {devices/lab_pin.sym} 132300 -16570 0 0 {name=p131551 lab=_78022_/A }
C {devices/lab_pin.sym} 132380 -16570 0 1 {name=p131552 lab=_78022_/Y }
C {sky130_stdcells/inv_2.sym} 132340 -16570 0 0 {name=X_78022_ }
C {devices/lab_pin.sym} 132260 -16480 0 0 {name=p131553 lab=_41529_/X }
C {devices/lab_pin.sym} 132260 -16440 0 0 {name=p131554 lab=_44412_/X }
C {devices/lab_pin.sym} 132260 -16400 0 0 {name=p131555 lab=_87121_/Q }
C {devices/lab_pin.sym} 132260 -16360 0 0 {name=p131556 lab=_44413_/X }
C {devices/lab_pin.sym} 132420 -16420 0 1 {name=p131557 lab=_44414_/X }
C {sky130_stdcells/a2bb2o_4.sym} 132340 -16420 0 0 {name=X_44414_ }
C {devices/lab_pin.sym} 132260 -16290 0 0 {name=p131558 lab=_75216_/Y }
C {devices/lab_pin.sym} 132260 -16250 0 0 {name=p131559 lab=_75219_/Y }
C {devices/lab_pin.sym} 132260 -16210 0 0 {name=p131560 lab=_75233_/X }
C {devices/lab_pin.sym} 132420 -16250 0 1 {name=p131561 lab=_75234_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -16250 0 0 {name=X_75234_ }
C {devices/lab_pin.sym} 132300 -16110 0 0 {name=p131562 lab=_41625_/Y }
C {devices/lab_pin.sym} 132380 -16110 0 1 {name=p131563 lab=_41626_/X }
C {sky130_stdcells/buf_2.sym} 132340 -16110 0 0 {name=X_41626_ }
C {devices/lab_pin.sym} 132300 -15990 0 0 {name=p131564 lab=_60460_/A }
C {devices/lab_pin.sym} 132380 -15990 0 1 {name=p131565 lab=_60571_/B }
C {sky130_stdcells/buf_2.sym} 132340 -15990 0 0 {name=X_60460_ }
C {devices/lab_pin.sym} 132280 -15880 0 0 {name=p131566 lab=_72414_/X }
C {devices/lab_pin.sym} 132280 -15840 0 0 {name=p131567 lab=_86277_/Q }
C {devices/lab_pin.sym} 132400 -15860 0 1 {name=p131568 lab=_72446_/Y }
C {sky130_stdcells/nor2_4.sym} 132340 -15860 0 0 {name=X_72446_ }
C {devices/lab_pin.sym} 132260 -15750 0 0 {name=p131569 lab=_65939_/B }
C {devices/lab_pin.sym} 132260 -15710 0 0 {name=p131570 lab=_48170_/X }
C {devices/lab_pin.sym} 132260 -15670 0 0 {name=p131571 lab=_48181_/Y }
C {devices/lab_pin.sym} 132420 -15710 0 1 {name=p131572 lab=_48182_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -15710 0 0 {name=X_48182_ }
C {devices/lab_pin.sym} 132300 -15570 0 0 {name=p131573 lab=_44891_/X }
C {devices/lab_pin.sym} 132380 -15570 0 1 {name=p131574 lab=_45394_/X }
C {sky130_stdcells/buf_2.sym} 132340 -15570 0 0 {name=X_45394_ }
C {devices/lab_pin.sym} 132280 -15480 0 0 {name=p131575 lab=_47113_/A }
C {devices/lab_pin.sym} 132280 -15440 0 0 {name=p131576 lab=_47133_/B }
C {devices/lab_pin.sym} 132280 -15400 0 0 {name=p131577 lab=_47091_/X }
C {devices/lab_pin.sym} 132280 -15360 0 0 {name=p131578 lab=_52872_/D }
C {devices/lab_pin.sym} 132400 -15420 0 1 {name=p131579 lab=_47133_/X }
C {sky130_stdcells/and4_4.sym} 132340 -15420 0 0 {name=X_47133_ }
C {devices/lab_pin.sym} 132300 -15270 0 0 {name=p131580 lab=_58923_/A }
C {devices/lab_pin.sym} 132380 -15270 0 1 {name=p131581 lab=_59119_/X }
C {sky130_stdcells/buf_2.sym} 132340 -15270 0 0 {name=X_59119_ }
C {devices/lab_pin.sym} 132300 -15150 0 0 {name=p131582 lab=_40409_/X }
C {devices/lab_pin.sym} 132380 -15150 0 1 {name=p131583 lab=_44345_/X }
C {sky130_stdcells/buf_2.sym} 132340 -15150 0 0 {name=X_44345_ }
C {devices/lab_pin.sym} 132260 -15050 0 0 {name=p131584 lab=_75131_/Y }
C {devices/lab_pin.sym} 132260 -15010 0 0 {name=p131585 lab=_75145_/Y }
C {devices/lab_pin.sym} 132260 -14970 0 0 {name=p131586 lab=_75144_/Y }
C {devices/lab_pin.sym} 132420 -15010 0 1 {name=p131587 lab=_75165_/X }
C {sky130_stdcells/a21o_4.sym} 132340 -15010 0 0 {name=X_75165_ }
C {devices/lab_pin.sym} 132260 -14900 0 0 {name=p131588 lab=_41556_/X }
C {devices/lab_pin.sym} 132260 -14860 0 0 {name=p131589 lab=_41530_/X }
C {devices/lab_pin.sym} 132260 -14820 0 0 {name=p131590 lab=_67011_/B }
C {devices/lab_pin.sym} 132260 -14780 0 0 {name=p131591 lab=_41531_/X }
C {devices/lab_pin.sym} 132420 -14840 0 1 {name=p131592 lab=_88193_/D }
C {sky130_stdcells/a2bb2o_4.sym} 132340 -14840 0 0 {name=X_41557_ }
C {devices/lab_pin.sym} 132280 -14700 0 0 {name=p131593 lab=_61183_/A }
C {devices/lab_pin.sym} 132280 -14660 0 0 {name=p131594 lab=_59905_/B }
C {devices/lab_pin.sym} 132400 -14680 0 1 {name=p131595 lab=_60512_/A }
C {sky130_stdcells/nor2_4.sym} 132340 -14680 0 0 {name=X_60391_ }
C {devices/lab_pin.sym} 132280 -14560 0 0 {name=p131596 lab=_72461_/A }
C {devices/lab_pin.sym} 132280 -14520 0 0 {name=p131597 lab=_72377_/B }
C {devices/lab_pin.sym} 132400 -14540 0 1 {name=p131598 lab=_72377_/Y }
C {sky130_stdcells/nor2_4.sym} 132340 -14540 0 0 {name=X_72377_ }
C {devices/lab_pin.sym} 132300 -14410 0 0 {name=p131599 lab=_83246_/CLK }
C {devices/lab_pin.sym} 132380 -14410 0 1 {name=p131600 lab=_84840_/CLK }
C {sky130_stdcells/clkbuf_16.sym} 132340 -14410 0 0 {name=Xclkbuf_opt_3_CLK }
C {devices/lab_pin.sym} 132280 -14320 0 0 {name=p131601 lab=_62129_/X }
C {devices/lab_pin.sym} 132280 -14280 0 0 {name=p131602 lab=_61748_/X }
C {devices/lab_pin.sym} 132280 -14240 0 0 {name=p131603 lab=_59608_/A }
C {devices/lab_pin.sym} 132280 -14200 0 0 {name=p131604 lab=_62130_/D }
C {devices/lab_pin.sym} 132400 -14260 0 1 {name=p131605 lab=_62131_/D }
C {sky130_stdcells/nand4_4.sym} 132340 -14260 0 0 {name=X_62130_ }
C {devices/lab_pin.sym} 132280 -14120 0 0 {name=p131606 lab=_74102_/Y }
C {devices/lab_pin.sym} 132280 -14080 0 0 {name=p131607 lab=_74116_/B }
C {devices/lab_pin.sym} 132400 -14100 0 1 {name=p131608 lab=_74116_/Y }
C {sky130_stdcells/xnor2_4.sym} 132340 -14100 0 0 {name=X_74116_ }
C {devices/lab_pin.sym} 132300 -13970 0 0 {name=p131609 lab=_40409_/X }
C {devices/lab_pin.sym} 132380 -13970 0 1 {name=p131610 lab=_40508_/X }
C {sky130_stdcells/buf_2.sym} 132340 -13970 0 0 {name=X_40508_ }
C {devices/lab_pin.sym} 132260 -13870 0 0 {name=p131611 lab=_59189_/A }
C {devices/lab_pin.sym} 132260 -13830 0 0 {name=p131612 lab=_47050_/X }
C {devices/lab_pin.sym} 132260 -13790 0 0 {name=p131613 lab=_47063_/Y }
C {devices/lab_pin.sym} 132420 -13830 0 1 {name=p131614 lab=_47064_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -13830 0 0 {name=X_47064_ }
C {devices/lab_pin.sym} 132260 -13710 0 0 {name=p131615 lab=_50365_/B }
C {devices/lab_pin.sym} 132260 -13670 0 0 {name=p131616 lab=_71320_/X }
C {devices/lab_pin.sym} 132260 -13630 0 0 {name=p131617 lab=_71327_/Y }
C {devices/lab_pin.sym} 132420 -13670 0 1 {name=p131618 lab=_83535_/D }
C {sky130_stdcells/o21ai_4.sym} 132340 -13670 0 0 {name=X_71328_ }
C {devices/lab_pin.sym} 132300 -13530 0 0 {name=p131619 lab=_57327_/B }
C {devices/lab_pin.sym} 132380 -13530 0 1 {name=p131620 lab=_57331_/B }
C {sky130_stdcells/buf_2.sym} 132340 -13530 0 0 {name=X_44276_ }
C {devices/lab_pin.sym} 132280 -13430 0 0 {name=p131621 lab=_79973_/A }
C {devices/lab_pin.sym} 132280 -13390 0 0 {name=p131622 lab=_79971_/X }
C {devices/lab_pin.sym} 132280 -13350 0 0 {name=p131623 lab=_79972_/Y }
C {devices/lab_pin.sym} 132400 -13390 0 1 {name=p131624 lab=_79973_/Y }
C {sky130_stdcells/nand3_4.sym} 132340 -13390 0 0 {name=X_79973_ }
C {devices/lab_pin.sym} 132300 -13250 0 0 {name=p131625 lab=_75096_/A }
C {devices/lab_pin.sym} 132380 -13250 0 1 {name=p131626 lab=_75098_/A }
C {sky130_stdcells/inv_2.sym} 132340 -13250 0 0 {name=X_75096_ }
C {devices/lab_pin.sym} 132260 -13160 0 0 {name=p131627 lab=_41485_/X }
C {devices/lab_pin.sym} 132260 -13120 0 0 {name=p131628 lab=_41486_/X }
C {devices/lab_pin.sym} 132260 -13080 0 0 {name=p131629 lab=_66694_/B }
C {devices/lab_pin.sym} 132260 -13040 0 0 {name=p131630 lab=_41487_/X }
C {devices/lab_pin.sym} 132420 -13100 0 1 {name=p131631 lab=_88206_/D }
C {sky130_stdcells/a2bb2o_4.sym} 132340 -13100 0 0 {name=X_41488_ }
C {devices/lab_pin.sym} 132260 -12990 0 0 {name=p131632 lab=_46013_/X }
C {devices/lab_pin.sym} 132260 -12950 0 0 {name=p131633 lab=_46001_/X }
C {devices/lab_pin.sym} 132260 -12910 0 0 {name=p131634 lab=_40514_/X }
C {devices/lab_pin.sym} 132260 -12870 0 0 {name=p131635 lab=_86814_/Q }
C {devices/lab_pin.sym} 132260 -12830 0 0 {name=p131636 lab=_46014_/X }
C {devices/lab_pin.sym} 132420 -12910 0 1 {name=p131637 lab=_46016_/A }
C {sky130_stdcells/o32ai_4.sym} 132340 -12910 0 0 {name=X_46015_ }
C {devices/lab_pin.sym} 132260 -12790 0 0 {name=p131638 lab=_43226_/X }
C {devices/lab_pin.sym} 132260 -12750 0 0 {name=p131639 lab=_43207_/X }
C {devices/lab_pin.sym} 132260 -12710 0 0 {name=p131640 lab=_40994_/X }
C {devices/lab_pin.sym} 132260 -12670 0 0 {name=p131641 lab=_87528_/Q }
C {devices/lab_pin.sym} 132260 -12630 0 0 {name=p131642 lab=_43212_/X }
C {devices/lab_pin.sym} 132420 -12710 0 1 {name=p131643 lab=_43227_/Y }
C {sky130_stdcells/o32ai_4.sym} 132340 -12710 0 0 {name=X_43227_ }
C {devices/lab_pin.sym} 132280 -12580 0 0 {name=p131644 lab=_84892_/Q }
C {devices/lab_pin.sym} 132280 -12540 0 0 {name=p131645 lab=_62128_/B }
C {devices/lab_pin.sym} 132280 -12500 0 0 {name=p131646 lab=_62010_/X }
C {devices/lab_pin.sym} 132280 -12460 0 0 {name=p131647 lab=_62060_/X }
C {devices/lab_pin.sym} 132400 -12520 0 1 {name=p131648 lab=_62061_/Y }
C {sky130_stdcells/nand4_4.sym} 132340 -12520 0 0 {name=X_62061_ }
C {devices/lab_pin.sym} 132280 -12380 0 0 {name=p131649 lab=_78912_/A }
C {devices/lab_pin.sym} 132280 -12340 0 0 {name=p131650 lab=_78912_/B }
C {devices/lab_pin.sym} 132400 -12360 0 1 {name=p131651 lab=_78924_/Y }
C {sky130_stdcells/nor2_4.sym} 132340 -12360 0 0 {name=X_78924_ }
C {devices/lab_pin.sym} 132260 -12250 0 0 {name=p131652 lab=_74048_/B }
C {devices/lab_pin.sym} 132260 -12210 0 0 {name=p131653 lab=_74048_/C }
C {devices/lab_pin.sym} 132260 -12170 0 0 {name=p131654 lab=_74046_/X }
C {devices/lab_pin.sym} 132420 -12210 0 1 {name=p131655 lab=_74047_/X }
C {sky130_stdcells/a21o_4.sym} 132340 -12210 0 0 {name=X_74047_ }
C {devices/lab_pin.sym} 132260 -12090 0 0 {name=p131656 lab=_40421_/X }
C {devices/lab_pin.sym} 132260 -12050 0 0 {name=p131657 lab=_81173_/Q }
C {devices/lab_pin.sym} 132260 -12010 0 0 {name=p131658 lab=_40438_/X }
C {devices/lab_pin.sym} 132420 -12050 0 1 {name=p131659 lab=_40439_/X }
C {sky130_stdcells/o21a_4.sym} 132340 -12050 0 0 {name=X_40439_ }
C {devices/lab_pin.sym} 132260 -11930 0 0 {name=p131660 lab=_50264_/B }
C {devices/lab_pin.sym} 132260 -11890 0 0 {name=p131661 lab=_71239_/A }
C {devices/lab_pin.sym} 132260 -11850 0 0 {name=p131662 lab=_71258_/Y }
C {devices/lab_pin.sym} 132420 -11890 0 1 {name=p131663 lab=_83555_/D }
C {sky130_stdcells/o21ai_4.sym} 132340 -11890 0 0 {name=X_71259_ }
C {devices/lab_pin.sym} 132280 -11770 0 0 {name=p131664 lab=_61012_/A }
C {devices/lab_pin.sym} 132280 -11730 0 0 {name=p131665 lab=_60918_/X }
C {devices/lab_pin.sym} 132280 -11690 0 0 {name=p131666 lab=_61012_/C }
C {devices/lab_pin.sym} 132400 -11730 0 1 {name=p131667 lab=_61012_/Y }
C {sky130_stdcells/nand3_4.sym} 132340 -11730 0 0 {name=X_61012_ }
C {devices/lab_pin.sym} 132300 -11590 0 0 {name=p131668 lab=_43158_/A }
C {devices/lab_pin.sym} 132380 -11590 0 1 {name=p131669 lab=_43158_/Y }
C {sky130_stdcells/inv_2.sym} 132340 -11590 0 0 {name=X_43158_ }
C {devices/lab_pin.sym} 132280 -11480 0 0 {name=p131670 lab=_78857_/B }
C {devices/lab_pin.sym} 132280 -11440 0 0 {name=p131671 lab=_78857_/A }
C {devices/lab_pin.sym} 132400 -11460 0 1 {name=p131672 lab=_78855_/X }
C {sky130_stdcells/or2_4.sym} 132340 -11460 0 0 {name=X_78855_ }
C {devices/lab_pin.sym} 132300 -11330 0 0 {name=p131673 lab=_42109_/A }
C {devices/lab_pin.sym} 132380 -11330 0 1 {name=p131674 lab=_42109_/Y }
C {sky130_stdcells/inv_2.sym} 132340 -11330 0 0 {name=X_42109_ }
C {devices/lab_pin.sym} 132260 -11240 0 0 {name=p131675 lab=_65685_/X }
C {devices/lab_pin.sym} 132260 -11200 0 0 {name=p131676 lab=_86183_/Q }
C {devices/lab_pin.sym} 132260 -11160 0 0 {name=p131677 lab=_65701_/X }
C {devices/lab_pin.sym} 132260 -11120 0 0 {name=p131678 lab=_65819_/X }
C {devices/lab_pin.sym} 132420 -11180 0 1 {name=p131679 lab=_65820_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -11180 0 0 {name=X_65820_ }
C {devices/lab_pin.sym} 132300 -11030 0 0 {name=p131680 lab=_82059_/Q }
C {devices/lab_pin.sym} 132380 -11030 0 1 {name=p131681 lab=_77806_/Y }
C {sky130_stdcells/inv_2.sym} 132340 -11030 0 0 {name=X_77806_ }
C {devices/lab_pin.sym} 132260 -10930 0 0 {name=p131682 lab=_47962_/Y }
C {devices/lab_pin.sym} 132260 -10890 0 0 {name=p131683 lab=_47954_/X }
C {devices/lab_pin.sym} 132260 -10850 0 0 {name=p131684 lab=_47965_/X }
C {devices/lab_pin.sym} 132420 -10890 0 1 {name=p131685 lab=_47966_/Y }
C {sky130_stdcells/a21oi_4.sym} 132340 -10890 0 0 {name=X_47966_ }
C {devices/lab_pin.sym} 132300 -10750 0 0 {name=p131686 lab=_87580_/Q }
C {devices/lab_pin.sym} 132380 -10750 0 1 {name=p131687 lab=_43089_/Y }
C {sky130_stdcells/inv_2.sym} 132340 -10750 0 0 {name=X_43089_ }
C {devices/lab_pin.sym} 132260 -10650 0 0 {name=p131688 lab=_78752_/A }
C {devices/lab_pin.sym} 132260 -10610 0 0 {name=p131689 lab=_78758_/A }
C {devices/lab_pin.sym} 132260 -10570 0 0 {name=p131690 lab=_78778_/B }
C {devices/lab_pin.sym} 132420 -10610 0 1 {name=p131691 lab=_78786_/X }
C {sky130_stdcells/a21o_4.sym} 132340 -10610 0 0 {name=X_78786_ }
C {devices/lab_pin.sym} 132280 -10480 0 0 {name=p131692 lab=_81333_/Q }
C {devices/lab_pin.sym} 132280 -10440 0 0 {name=p131693 lab=_81421_/Q }
C {devices/lab_pin.sym} 132400 -10460 0 1 {name=p131694 lab=_76005_/C }
C {sky130_stdcells/nand2_4.sym} 132340 -10460 0 0 {name=X_75998_ }
C {devices/lab_pin.sym} 132300 -10330 0 0 {name=p131695 lab=_49569_/A }
C {devices/lab_pin.sym} 132380 -10330 0 1 {name=p131696 lab=_49787_/A }
C {sky130_stdcells/buf_2.sym} 132340 -10330 0 0 {name=X_49705_ }
C {devices/lab_pin.sym} 132300 -10210 0 0 {name=p131697 lab=_46916_/Y }
C {devices/lab_pin.sym} 132380 -10210 0 1 {name=p131698 lab=_52746_/D }
C {sky130_stdcells/buf_2.sym} 132340 -10210 0 0 {name=X_46917_ }
C {devices/lab_pin.sym} 132260 -10120 0 0 {name=p131699 lab=_65733_/X }
C {devices/lab_pin.sym} 132260 -10080 0 0 {name=p131700 lab=_85580_/Q }
C {devices/lab_pin.sym} 132260 -10040 0 0 {name=p131701 lab=_65734_/X }
C {devices/lab_pin.sym} 132260 -10000 0 0 {name=p131702 lab=_65750_/X }
C {devices/lab_pin.sym} 132420 -10060 0 1 {name=p131703 lab=_65751_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -10060 0 0 {name=X_65751_ }
C {devices/lab_pin.sym} 132280 -9920 0 0 {name=p131704 lab=_77736_/Y }
C {devices/lab_pin.sym} 132280 -9880 0 0 {name=p131705 lab=_77737_/B }
C {devices/lab_pin.sym} 132400 -9900 0 1 {name=p131706 lab=_78045_/B }
C {sky130_stdcells/nand2_4.sym} 132340 -9900 0 0 {name=X_77737_ }
C {devices/lab_pin.sym} 132280 -9800 0 0 {name=p131707 lab=_62971_/A }
C {devices/lab_pin.sym} 132280 -9760 0 0 {name=p131708 lab=_64525_/C }
C {devices/lab_pin.sym} 132280 -9720 0 0 {name=p131709 lab=_60302_/X }
C {devices/lab_pin.sym} 132280 -9680 0 0 {name=p131710 lab=_62979_/D }
C {devices/lab_pin.sym} 132400 -9740 0 1 {name=p131711 lab=_62963_/X }
C {sky130_stdcells/and4_4.sym} 132340 -9740 0 0 {name=X_62963_ }
C {devices/lab_pin.sym} 132280 -9600 0 0 {name=p131712 lab=_80944_/Q }
C {devices/lab_pin.sym} 132280 -9560 0 0 {name=p131713 lab=_74949_/B }
C {devices/lab_pin.sym} 132400 -9580 0 1 {name=p131714 lab=_74949_/X }
C {sky130_stdcells/xor2_4.sym} 132340 -9580 0 0 {name=X_74949_ }
C {devices/lab_pin.sym} 132300 -9450 0 0 {name=p131715 lab=_47840_/A }
C {devices/lab_pin.sym} 132380 -9450 0 1 {name=p131716 lab=_47897_/X }
C {sky130_stdcells/buf_2.sym} 132340 -9450 0 0 {name=X_47897_ }
C {devices/lab_pin.sym} 132260 -9350 0 0 {name=p131717 lab=_64695_/X }
C {devices/lab_pin.sym} 132260 -9310 0 0 {name=p131718 lab=_64700_/X }
C {devices/lab_pin.sym} 132260 -9270 0 0 {name=p131719 lab=_64701_/X }
C {devices/lab_pin.sym} 132420 -9310 0 1 {name=p131720 lab=_64702_/X }
C {sky130_stdcells/a21o_4.sym} 132340 -9310 0 0 {name=X_64702_ }
C {devices/lab_pin.sym} 132280 -9200 0 0 {name=p131721 lab=_49625_/A }
C {devices/lab_pin.sym} 132280 -9160 0 0 {name=p131722 lab=_49614_/X }
C {devices/lab_pin.sym} 132280 -9120 0 0 {name=p131723 lab=_49629_/X }
C {devices/lab_pin.sym} 132280 -9080 0 0 {name=p131724 lab=_52853_/D }
C {devices/lab_pin.sym} 132400 -9140 0 1 {name=p131725 lab=_49636_/X }
C {sky130_stdcells/and4_4.sym} 132340 -9140 0 0 {name=X_49636_ }
C {devices/lab_pin.sym} 132260 -9010 0 0 {name=p131726 lab=_61912_/Y }
C {devices/lab_pin.sym} 132260 -8970 0 0 {name=p131727 lab=_61881_/X }
C {devices/lab_pin.sym} 132260 -8930 0 0 {name=p131728 lab=_61913_/Y }
C {devices/lab_pin.sym} 132420 -8970 0 1 {name=p131729 lab=_61914_/Y }
C {sky130_stdcells/a21oi_4.sym} 132340 -8970 0 0 {name=X_61914_ }
C {devices/lab_pin.sym} 132300 -8830 0 0 {name=p131730 lab=_69678_/A }
C {devices/lab_pin.sym} 132380 -8830 0 1 {name=p131731 lab=_68470_/X }
C {sky130_stdcells/buf_2.sym} 132340 -8830 0 0 {name=X_68470_ }
C {devices/lab_pin.sym} 132280 -8740 0 0 {name=p131732 lab=_46830_/A }
C {devices/lab_pin.sym} 132280 -8700 0 0 {name=p131733 lab=_46845_/X }
C {devices/lab_pin.sym} 132280 -8660 0 0 {name=p131734 lab=_46830_/C }
C {devices/lab_pin.sym} 132280 -8620 0 0 {name=p131735 lab=_52709_/D }
C {devices/lab_pin.sym} 132400 -8680 0 1 {name=p131736 lab=_46848_/X }
C {sky130_stdcells/and4_4.sym} 132340 -8680 0 0 {name=X_46848_ }
C {devices/lab_pin.sym} 132300 -8530 0 0 {name=p131737 lab=_65682_/A }
C {devices/lab_pin.sym} 132380 -8530 0 1 {name=p131738 lab=_65683_/C }
C {sky130_stdcells/inv_2.sym} 132340 -8530 0 0 {name=X_65682_ }
C {devices/lab_pin.sym} 132300 -8410 0 0 {name=p131739 lab=_77667_/X }
C {devices/lab_pin.sym} 132380 -8410 0 1 {name=p131740 lab=_77668_/Y }
C {sky130_stdcells/inv_2.sym} 132340 -8410 0 0 {name=X_77668_ }
C {devices/lab_pin.sym} 132280 -8310 0 0 {name=p131741 lab=_62894_/A }
C {devices/lab_pin.sym} 132280 -8270 0 0 {name=p131742 lab=_62852_/X }
C {devices/lab_pin.sym} 132280 -8230 0 0 {name=p131743 lab=_84373_/Q }
C {devices/lab_pin.sym} 132400 -8270 0 1 {name=p131744 lab=_62894_/Y }
C {sky130_stdcells/nor3_4.sym} 132340 -8270 0 0 {name=X_62894_ }
C {devices/lab_pin.sym} 132280 -8140 0 0 {name=p131745 lab=_67517_/A }
C {devices/lab_pin.sym} 132280 -8100 0 0 {name=p131746 lab=_67421_/B }
C {devices/lab_pin.sym} 132400 -8120 0 1 {name=p131747 lab=_67421_/X }
C {sky130_stdcells/and2_4.sym} 132340 -8120 0 0 {name=X_67421_ }
C {devices/lab_pin.sym} 132280 -8000 0 0 {name=p131748 lab=_79419_/A }
C {devices/lab_pin.sym} 132280 -7960 0 0 {name=p131749 lab=_79419_/B }
C {devices/lab_pin.sym} 132400 -7980 0 1 {name=p131750 lab=_79418_/A }
C {sky130_stdcells/xor2_4.sym} 132340 -7980 0 0 {name=X_79407_ }
C {devices/lab_pin.sym} 132280 -7870 0 0 {name=p131751 lab=_64630_/X }
C {devices/lab_pin.sym} 132280 -7830 0 0 {name=p131752 lab=_64633_/B }
C {devices/lab_pin.sym} 132280 -7790 0 0 {name=p131753 lab=_64632_/X }
C {devices/lab_pin.sym} 132400 -7830 0 1 {name=p131754 lab=_64633_/Y }
C {sky130_stdcells/nand3_4.sym} 132340 -7830 0 0 {name=X_64633_ }
C {devices/lab_pin.sym} 132300 -7690 0 0 {name=p131755 lab=_81664_/Q }
C {devices/lab_pin.sym} 132380 -7690 0 1 {name=p131756 lab=_76619_/Y }
C {sky130_stdcells/inv_2.sym} 132340 -7690 0 0 {name=X_76619_ }
C {devices/lab_pin.sym} 132300 -7570 0 0 {name=p131757 lab=_61856_/A }
C {devices/lab_pin.sym} 132380 -7570 0 1 {name=p131758 lab=_61846_/B }
C {sky130_stdcells/buf_2.sym} 132340 -7570 0 0 {name=X_61845_ }
C {devices/lab_pin.sym} 132280 -7460 0 0 {name=p131759 lab=_49558_/A }
C {devices/lab_pin.sym} 132280 -7420 0 0 {name=p131760 lab=_52781_/B }
C {devices/lab_pin.sym} 132400 -7440 0 1 {name=p131761 lab=_49567_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -7440 0 0 {name=X_49567_ }
C {devices/lab_pin.sym} 132300 -7310 0 0 {name=p131762 lab=_52667_/B }
C {devices/lab_pin.sym} 132380 -7310 0 1 {name=p131763 lab=_50976_/B }
C {sky130_stdcells/buf_2.sym} 132340 -7310 0 0 {name=X_46779_ }
C {devices/lab_pin.sym} 132300 -7190 0 0 {name=p131764 lab=_77599_/A }
C {devices/lab_pin.sym} 132380 -7190 0 1 {name=p131765 lab=_77603_/A }
C {sky130_stdcells/inv_2.sym} 132340 -7190 0 0 {name=X_77599_ }
C {devices/lab_pin.sym} 132300 -7070 0 0 {name=p131766 lab=_81779_/Q }
C {devices/lab_pin.sym} 132380 -7070 0 1 {name=p131767 lab=_48520_/A }
C {sky130_stdcells/inv_2.sym} 132340 -7070 0 0 {name=X_48518_ }
C {devices/lab_pin.sym} 132260 -6980 0 0 {name=p131768 lab=_67166_/X }
C {devices/lab_pin.sym} 132260 -6940 0 0 {name=p131769 lab=_67340_/Y }
C {devices/lab_pin.sym} 132260 -6900 0 0 {name=p131770 lab=_67269_/X }
C {devices/lab_pin.sym} 132260 -6860 0 0 {name=p131771 lab=_67351_/Y }
C {devices/lab_pin.sym} 132420 -6920 0 1 {name=p131772 lab=_67352_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -6920 0 0 {name=X_67352_ }
C {devices/lab_pin.sym} 132260 -6790 0 0 {name=p131773 lab=_79316_/Y }
C {devices/lab_pin.sym} 132260 -6750 0 0 {name=p131774 lab=_79334_/X }
C {devices/lab_pin.sym} 132260 -6710 0 0 {name=p131775 lab=_79337_/Y }
C {devices/lab_pin.sym} 132420 -6750 0 1 {name=p131776 lab=_79339_/B }
C {sky130_stdcells/a21oi_4.sym} 132340 -6750 0 0 {name=X_79338_ }
C {devices/lab_pin.sym} 132300 -6610 0 0 {name=p131777 lab=_64696_/A }
C {devices/lab_pin.sym} 132380 -6610 0 1 {name=p131778 lab=_64564_/X }
C {sky130_stdcells/buf_2.sym} 132340 -6610 0 0 {name=X_64564_ }
C {devices/lab_pin.sym} 132280 -6500 0 0 {name=p131779 lab=_49502_/A }
C {devices/lab_pin.sym} 132280 -6460 0 0 {name=p131780 lab=_51022_/B }
C {devices/lab_pin.sym} 132400 -6480 0 1 {name=p131781 lab=_49498_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -6480 0 0 {name=X_49498_ }
C {devices/lab_pin.sym} 132280 -6380 0 0 {name=p131782 lab=_61365_/X }
C {devices/lab_pin.sym} 132280 -6340 0 0 {name=p131783 lab=_61794_/B }
C {devices/lab_pin.sym} 132280 -6300 0 0 {name=p131784 lab=_59810_/A }
C {devices/lab_pin.sym} 132280 -6260 0 0 {name=p131785 lab=_61776_/D }
C {devices/lab_pin.sym} 132400 -6320 0 1 {name=p131786 lab=_61776_/Y }
C {sky130_stdcells/nand4_4.sym} 132340 -6320 0 0 {name=X_61776_ }
C {devices/lab_pin.sym} 132280 -6180 0 0 {name=p131787 lab=_66300_/X }
C {devices/lab_pin.sym} 132280 -6140 0 0 {name=p131788 lab=_66303_/B }
C {devices/lab_pin.sym} 132400 -6160 0 1 {name=p131789 lab=_66303_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -6160 0 0 {name=X_66303_ }
C {devices/lab_pin.sym} 132260 -6070 0 0 {name=p131790 lab=_63495_/X }
C {devices/lab_pin.sym} 132260 -6030 0 0 {name=p131791 lab=_63509_/X }
C {devices/lab_pin.sym} 132260 -5990 0 0 {name=p131792 lab=_63510_/X }
C {devices/lab_pin.sym} 132260 -5950 0 0 {name=p131793 lab=_63513_/X }
C {devices/lab_pin.sym} 132260 -5910 0 0 {name=p131794 lab=_63514_/Y }
C {devices/lab_pin.sym} 132420 -5990 0 1 {name=p131795 lab=_63515_/Y }
C {sky130_stdcells/o41ai_4.sym} 132340 -5990 0 0 {name=X_63515_ }
C {devices/lab_pin.sym} 132280 -5840 0 0 {name=p131796 lab=_48449_/A }
C {devices/lab_pin.sym} 132280 -5800 0 0 {name=p131797 lab=_48449_/B }
C {devices/lab_pin.sym} 132400 -5820 0 1 {name=p131798 lab=_48449_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -5820 0 0 {name=X_48449_ }
C {devices/lab_pin.sym} 132280 -5710 0 0 {name=p131799 lab=_60727_/A }
C {devices/lab_pin.sym} 132280 -5670 0 0 {name=p131800 lab=_60723_/X }
C {devices/lab_pin.sym} 132280 -5630 0 0 {name=p131801 lab=_60726_/Y }
C {devices/lab_pin.sym} 132400 -5670 0 1 {name=p131802 lab=_60727_/Y }
C {sky130_stdcells/nand3_4.sym} 132340 -5670 0 0 {name=X_60727_ }
C {devices/lab_pin.sym} 132260 -5550 0 0 {name=p131803 lab=_80900_/D }
C {devices/lab_pin.sym} 132260 -5510 0 0 {name=p131804 lab=_67211_/X }
C {devices/lab_pin.sym} 132260 -5470 0 0 {name=p131805 lab=_67282_/X }
C {devices/lab_pin.sym} 132420 -5510 0 1 {name=p131806 lab=_84076_/D }
C {sky130_stdcells/a21bo_4.sym} 132340 -5510 0 0 {name=X_67283_ }
C {devices/lab_pin.sym} 132280 -5380 0 0 {name=p131807 lab=_79282_/A }
C {devices/lab_pin.sym} 132280 -5340 0 0 {name=p131808 lab=_79268_/Y }
C {devices/lab_pin.sym} 132400 -5360 0 1 {name=p131809 lab=_79292_/B }
C {sky130_stdcells/xor2_4.sym} 132340 -5360 0 0 {name=X_79269_ }
C {devices/lab_pin.sym} 132280 -5250 0 0 {name=p131810 lab=_64474_/A }
C {devices/lab_pin.sym} 132280 -5210 0 0 {name=p131811 lab=_64421_/X }
C {devices/lab_pin.sym} 132280 -5170 0 0 {name=p131812 lab=_84888_/Q }
C {devices/lab_pin.sym} 132400 -5210 0 1 {name=p131813 lab=_64495_/X }
C {sky130_stdcells/and3_4.sym} 132340 -5210 0 0 {name=X_64495_ }
C {devices/lab_pin.sym} 132250 -5070 0 0 {name=p131814 lab=_81259_/CLK }
C {devices/lab_pin.sym} 132250 -5050 0 0 {name=p131815 lab=_76988_/X }
C {devices/lab_pin.sym} 132430 -5070 0 1 {name=p131816 lab=_81300_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -5060 0 0 {name=X_81300_ }
C {devices/lab_pin.sym} 132260 -4960 0 0 {name=p131817 lab=_43098_/A }
C {devices/lab_pin.sym} 132260 -4920 0 0 {name=p131818 lab=_68975_/X }
C {devices/lab_pin.sym} 132260 -4880 0 0 {name=p131819 lab=_66349_/X }
C {devices/lab_pin.sym} 132260 -4840 0 0 {name=p131820 lab=_69021_/X }
C {devices/lab_pin.sym} 132420 -4900 0 1 {name=p131821 lab=_69022_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -4900 0 0 {name=X_69022_ }
C {devices/lab_pin.sym} 132280 -4760 0 0 {name=p131822 lab=_66181_/A }
C {devices/lab_pin.sym} 132280 -4720 0 0 {name=p131823 lab=_74104_/B }
C {devices/lab_pin.sym} 132400 -4740 0 1 {name=p131824 lab=_66234_/X }
C {sky130_stdcells/and2_4.sym} 132340 -4740 0 0 {name=X_66234_ }
C {devices/lab_pin.sym} 132280 -4620 0 0 {name=p131825 lab=_51481_/A }
C {devices/lab_pin.sym} 132280 -4580 0 0 {name=p131826 lab=_52986_/B }
C {devices/lab_pin.sym} 132400 -4600 0 1 {name=p131827 lab=_51460_/Y }
C {sky130_stdcells/nand2_4.sym} 132340 -4600 0 0 {name=X_51460_ }
C {devices/lab_pin.sym} 132280 -4490 0 0 {name=p131828 lab=_63456_/A }
C {devices/lab_pin.sym} 132280 -4450 0 0 {name=p131829 lab=_63456_/B }
C {devices/lab_pin.sym} 132280 -4410 0 0 {name=p131830 lab=_80559_/B }
C {devices/lab_pin.sym} 132400 -4450 0 1 {name=p131831 lab=_63446_/Y }
C {sky130_stdcells/nor3_4.sym} 132340 -4450 0 0 {name=X_63446_ }
C {devices/lab_pin.sym} 132250 -4310 0 0 {name=p131832 lab=_82288_/CLK }
C {devices/lab_pin.sym} 132250 -4290 0 0 {name=p131833 lab=_82280_/D }
C {devices/lab_pin.sym} 132430 -4310 0 1 {name=p131834 lab=_82280_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -4300 0 0 {name=X_82280_ }
C {devices/lab_pin.sym} 132300 -4170 0 0 {name=p131835 lab=_63540_/A }
C {devices/lab_pin.sym} 132380 -4170 0 1 {name=p131836 lab=_60697_/B }
C {sky130_stdcells/buf_2.sym} 132340 -4170 0 0 {name=X_60658_ }
C {devices/lab_pin.sym} 132260 -4070 0 0 {name=p131837 lab=_86206_/Q }
C {devices/lab_pin.sym} 132260 -4030 0 0 {name=p131838 lab=_50403_/X }
C {devices/lab_pin.sym} 132260 -3990 0 0 {name=p131839 lab=_50410_/Y }
C {devices/lab_pin.sym} 132420 -4030 0 1 {name=p131840 lab=_50411_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -4030 0 0 {name=X_50411_ }
C {devices/lab_pin.sym} 132250 -3890 0 0 {name=p131841 lab=_81233_/CLK }
C {devices/lab_pin.sym} 132250 -3870 0 0 {name=p131842 lab=_81039_/Q }
C {devices/lab_pin.sym} 132430 -3890 0 1 {name=p131843 lab=_81231_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -3880 0 0 {name=X_81231_ }
C {devices/lab_pin.sym} 132260 -3770 0 0 {name=p131844 lab=_66162_/Y }
C {devices/lab_pin.sym} 132260 -3730 0 0 {name=p131845 lab=_66137_/X }
C {devices/lab_pin.sym} 132260 -3690 0 0 {name=p131846 lab=_66164_/Y }
C {devices/lab_pin.sym} 132420 -3730 0 1 {name=p131847 lab=_66165_/X }
C {sky130_stdcells/a21o_4.sym} 132340 -3730 0 0 {name=X_66165_ }
C {devices/lab_pin.sym} 132300 -3590 0 0 {name=p131848 lab=_51793_/A }
C {devices/lab_pin.sym} 132380 -3590 0 1 {name=p131849 lab=_51391_/X }
C {sky130_stdcells/buf_2.sym} 132340 -3590 0 0 {name=X_51391_ }
C {devices/lab_pin.sym} 132260 -3500 0 0 {name=p131850 lab=_61329_/B }
C {devices/lab_pin.sym} 132260 -3460 0 0 {name=p131851 lab=_60834_/X }
C {devices/lab_pin.sym} 132260 -3420 0 0 {name=p131852 lab=_63374_/X }
C {devices/lab_pin.sym} 132260 -3380 0 0 {name=p131853 lab=_63376_/X }
C {devices/lab_pin.sym} 132420 -3440 0 1 {name=p131854 lab=_63377_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -3440 0 0 {name=X_63377_ }
C {devices/lab_pin.sym} 132260 -3310 0 0 {name=p131855 lab=_60440_/X }
C {devices/lab_pin.sym} 132260 -3270 0 0 {name=p131856 lab=_60439_/X }
C {devices/lab_pin.sym} 132260 -3230 0 0 {name=p131857 lab=_60588_/X }
C {devices/lab_pin.sym} 132420 -3270 0 1 {name=p131858 lab=_63272_/A }
C {sky130_stdcells/a21oi_4.sym} 132340 -3270 0 0 {name=X_60589_ }
C {devices/lab_pin.sym} 132300 -3130 0 0 {name=p131859 lab=clkbuf_6_52_0_CLK/X }
C {devices/lab_pin.sym} 132380 -3130 0 1 {name=p131860 lab=clkbuf_8_209_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 132340 -3130 0 0 {name=Xclkbuf_7_104_0_CLK }
C {devices/lab_pin.sym} 132300 -3010 0 0 {name=p131861 lab=clkbuf_9_146_0_CLK/X }
C {devices/lab_pin.sym} 132380 -3010 0 1 {name=p131862 lab=_84732_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 132340 -3010 0 0 {name=Xclkbuf_10_292_0_CLK }
C {devices/lab_pin.sym} 132260 -2910 0 0 {name=p131863 lab=_53128_/Y }
C {devices/lab_pin.sym} 132260 -2870 0 0 {name=p131864 lab=_53111_/X }
C {devices/lab_pin.sym} 132260 -2830 0 0 {name=p131865 lab=_53129_/X }
C {devices/lab_pin.sym} 132420 -2870 0 1 {name=p131866 lab=_85692_/D }
C {sky130_stdcells/a21oi_4.sym} 132340 -2870 0 0 {name=X_53130_ }
C {devices/lab_pin.sym} 132260 -2760 0 0 {name=p131867 lab=_64944_/X }
C {devices/lab_pin.sym} 132260 -2720 0 0 {name=p131868 lab=_86125_/Q }
C {devices/lab_pin.sym} 132260 -2680 0 0 {name=p131869 lab=_65022_/X }
C {devices/lab_pin.sym} 132260 -2640 0 0 {name=p131870 lab=_65115_/X }
C {devices/lab_pin.sym} 132420 -2700 0 1 {name=p131871 lab=_65116_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -2700 0 0 {name=X_65116_ }
C {devices/lab_pin.sym} 132260 -2570 0 0 {name=p131872 lab=_86220_/Q }
C {devices/lab_pin.sym} 132260 -2530 0 0 {name=p131873 lab=_50316_/X }
C {devices/lab_pin.sym} 132260 -2490 0 0 {name=p131874 lab=_50341_/Y }
C {devices/lab_pin.sym} 132420 -2530 0 1 {name=p131875 lab=_50342_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -2530 0 0 {name=X_50342_ }
C {devices/lab_pin.sym} 132280 -2410 0 0 {name=p131876 lab=_62267_/A }
C {devices/lab_pin.sym} 132280 -2370 0 0 {name=p131877 lab=_62267_/B }
C {devices/lab_pin.sym} 132280 -2330 0 0 {name=p131878 lab=_62328_/C }
C {devices/lab_pin.sym} 132400 -2370 0 1 {name=p131879 lab=_62328_/Y }
C {sky130_stdcells/nor3_4.sym} 132340 -2370 0 0 {name=X_62328_ }
C {devices/lab_pin.sym} 132250 -2230 0 0 {name=p131880 lab=_80835_/CLK }
C {devices/lab_pin.sym} 132250 -2210 0 0 {name=p131881 lab=_74906_/B }
C {devices/lab_pin.sym} 132430 -2230 0 1 {name=p131882 lab=_81162_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -2220 0 0 {name=X_81162_ }
C {devices/lab_pin.sym} 132300 -2090 0 0 {name=p131883 lab=_65976_/A }
C {devices/lab_pin.sym} 132380 -2090 0 1 {name=p131884 lab=_66096_/X }
C {sky130_stdcells/buf_2.sym} 132340 -2090 0 0 {name=X_66096_ }
C {devices/lab_pin.sym} 132300 -1970 0 0 {name=p131885 lab=clkbuf_9_37_0_CLK/X }
C {devices/lab_pin.sym} 132380 -1970 0 1 {name=p131886 lab=_83012_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 132340 -1970 0 0 {name=Xclkbuf_10_74_0_CLK }
C {devices/lab_pin.sym} 132280 -1860 0 0 {name=p131887 lab=_80109_/X }
C {devices/lab_pin.sym} 132280 -1820 0 0 {name=p131888 lab=_80112_/Y }
C {devices/lab_pin.sym} 132400 -1840 0 1 {name=p131889 lab=_80114_/A }
C {sky130_stdcells/xor2_4.sym} 132340 -1840 0 0 {name=X_80113_ }
C {devices/lab_pin.sym} 132260 -1730 0 0 {name=p131890 lab=_85704_/Q }
C {devices/lab_pin.sym} 132260 -1690 0 0 {name=p131891 lab=_53038_/X }
C {devices/lab_pin.sym} 132260 -1650 0 0 {name=p131892 lab=_53060_/Y }
C {devices/lab_pin.sym} 132420 -1690 0 1 {name=p131893 lab=_53061_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -1690 0 0 {name=X_53061_ }
C {devices/lab_pin.sym} 132280 -1570 0 0 {name=p131894 lab=_65047_/A }
C {devices/lab_pin.sym} 132280 -1530 0 0 {name=p131895 lab=_65047_/B }
C {devices/lab_pin.sym} 132280 -1490 0 0 {name=p131896 lab=_65047_/C }
C {devices/lab_pin.sym} 132400 -1530 0 1 {name=p131897 lab=_65047_/Y }
C {sky130_stdcells/nor3_4.sym} 132340 -1530 0 0 {name=X_65047_ }
C {devices/lab_pin.sym} 132260 -1420 0 0 {name=p131898 lab=_87044_/Q }
C {devices/lab_pin.sym} 132260 -1380 0 0 {name=p131899 lab=_69690_/X }
C {devices/lab_pin.sym} 132260 -1340 0 0 {name=p131900 lab=_68473_/X }
C {devices/lab_pin.sym} 132260 -1300 0 0 {name=p131901 lab=_69923_/X }
C {devices/lab_pin.sym} 132420 -1360 0 1 {name=p131902 lab=_69924_/X }
C {sky130_stdcells/a211o_4.sym} 132340 -1360 0 0 {name=X_69924_ }
C {devices/lab_pin.sym} 132260 -1230 0 0 {name=p131903 lab=_86233_/Q }
C {devices/lab_pin.sym} 132260 -1190 0 0 {name=p131904 lab=_50250_/X }
C {devices/lab_pin.sym} 132260 -1150 0 0 {name=p131905 lab=_50272_/Y }
C {devices/lab_pin.sym} 132420 -1190 0 1 {name=p131906 lab=_50273_/Y }
C {sky130_stdcells/o21ai_4.sym} 132340 -1190 0 0 {name=X_50273_ }
C {devices/lab_pin.sym} 132300 -1050 0 0 {name=p131907 lab=_59976_/A }
C {devices/lab_pin.sym} 132380 -1050 0 1 {name=p131908 lab=_62259_/X }
C {sky130_stdcells/buf_2.sym} 132340 -1050 0 0 {name=X_62259_ }
C {devices/lab_pin.sym} 132250 -930 0 0 {name=p131909 lab=_85679_/CLK }
C {devices/lab_pin.sym} 132250 -910 0 0 {name=p131910 lab=_51659_/Y }
C {devices/lab_pin.sym} 132430 -930 0 1 {name=p131911 lab=_85970_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -920 0 0 {name=X_85970_ }
C {devices/lab_pin.sym} 132250 -790 0 0 {name=p131912 lab=_81928_/CLK }
C {devices/lab_pin.sym} 132250 -770 0 0 {name=p131913 lab=_81093_/D }
C {devices/lab_pin.sym} 132430 -790 0 1 {name=p131914 lab=_81093_/Q }
C {sky130_stdcells/dfxtp_4.sym} 132340 -780 0 0 {name=X_81093_ }
C {devices/lab_pin.sym} 133220 -42150 0 0 {name=p131915 lab=clkbuf_8_221_0_CLK/A }
C {devices/lab_pin.sym} 133300 -42150 0 1 {name=p131916 lab=clkbuf_9_441_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 133260 -42150 0 0 {name=Xclkbuf_8_220_0_CLK }
C {devices/lab_pin.sym} 133180 -42050 0 0 {name=p131917 lab=_52010_/Y }
C {devices/lab_pin.sym} 133180 -42010 0 0 {name=p131918 lab=_51987_/X }
C {devices/lab_pin.sym} 133180 -41970 0 0 {name=p131919 lab=_52011_/X }
C {devices/lab_pin.sym} 133340 -42010 0 1 {name=p131920 lab=_52012_/Y }
C {sky130_stdcells/a21oi_4.sym} 133260 -42010 0 0 {name=X_52012_ }
C {devices/lab_pin.sym} 133180 -41890 0 0 {name=p131921 lab=_80030_/Y }
C {devices/lab_pin.sym} 133180 -41850 0 0 {name=p131922 lab=_80035_/Y }
C {devices/lab_pin.sym} 133180 -41810 0 0 {name=p131923 lab=_80043_/X }
C {devices/lab_pin.sym} 133340 -41850 0 1 {name=p131924 lab=_80045_/B }
C {sky130_stdcells/o21ai_4.sym} 133260 -41850 0 0 {name=X_80044_ }
C {devices/lab_pin.sym} 133170 -41710 0 0 {name=p131925 lab=_84921_/CLK }
C {devices/lab_pin.sym} 133170 -41690 0 0 {name=p131926 lab=_58148_/Y }
C {devices/lab_pin.sym} 133350 -41710 0 1 {name=p131927 lab=_61323_/A }
C {sky130_stdcells/dfxtp_4.sym} 133260 -41700 0 0 {name=X_84921_ }
C {devices/lab_pin.sym} 133200 -41580 0 0 {name=p131928 lab=_69852_/X }
C {devices/lab_pin.sym} 133200 -41540 0 0 {name=p131929 lab=_69855_/B }
C {devices/lab_pin.sym} 133320 -41560 0 1 {name=p131930 lab=_69855_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -41560 0 0 {name=X_69855_ }
C {devices/lab_pin.sym} 133220 -41430 0 0 {name=p131931 lab=clkbuf_6_59_0_CLK/X }
C {devices/lab_pin.sym} 133300 -41430 0 1 {name=p131932 lab=clkbuf_8_239_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 133260 -41430 0 0 {name=Xclkbuf_7_119_0_CLK }
C {devices/lab_pin.sym} 133200 -41320 0 0 {name=p131933 lab=_56820_/A }
C {devices/lab_pin.sym} 133200 -41280 0 0 {name=p131934 lab=_56725_/B }
C {devices/lab_pin.sym} 133320 -41300 0 1 {name=p131935 lab=_56820_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -41300 0 0 {name=X_56820_ }
C {devices/lab_pin.sym} 133220 -41170 0 0 {name=p131936 lab=_69035_/A }
C {devices/lab_pin.sym} 133300 -41170 0 1 {name=p131937 lab=_68806_/X }
C {sky130_stdcells/buf_2.sym} 133260 -41170 0 0 {name=X_68806_ }
C {devices/lab_pin.sym} 133170 -41050 0 0 {name=p131938 lab=_86920_/CLK }
C {devices/lab_pin.sym} 133170 -41030 0 0 {name=p131939 lab=_42941_/Y }
C {devices/lab_pin.sym} 133350 -41050 0 1 {name=p131940 lab=_67985_/B }
C {sky130_stdcells/dfxtp_4.sym} 133260 -41040 0 0 {name=X_87640_ }
C {devices/lab_pin.sym} 133170 -40910 0 0 {name=p131941 lab=_84732_/CLK }
C {devices/lab_pin.sym} 133170 -40890 0 0 {name=p131942 lab=_84852_/D }
C {devices/lab_pin.sym} 133350 -40910 0 1 {name=p131943 lab=_84852_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -40900 0 0 {name=X_84852_ }
C {devices/lab_pin.sym} 133180 -40790 0 0 {name=p131944 lab=_69360_/X }
C {devices/lab_pin.sym} 133180 -40750 0 0 {name=p131945 lab=_69363_/X }
C {devices/lab_pin.sym} 133180 -40710 0 0 {name=p131946 lab=_69728_/X }
C {devices/lab_pin.sym} 133340 -40750 0 1 {name=p131947 lab=_69786_/Y }
C {sky130_stdcells/a21oi_4.sym} 133260 -40750 0 0 {name=X_69786_ }
C {devices/lab_pin.sym} 133220 -40610 0 0 {name=p131948 lab=_66879_/A }
C {devices/lab_pin.sym} 133300 -40610 0 1 {name=p131949 lab=_66998_/X }
C {sky130_stdcells/buf_2.sym} 133260 -40610 0 0 {name=X_66998_ }
C {devices/lab_pin.sym} 133220 -40490 0 0 {name=p131950 lab=clkbuf_9_44_0_CLK/X }
C {devices/lab_pin.sym} 133300 -40490 0 1 {name=p131951 lab=_84409_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 133260 -40490 0 0 {name=Xclkbuf_10_89_0_CLK }
C {devices/lab_pin.sym} 133170 -40370 0 0 {name=p131952 lab=_81807_/CLK }
C {devices/lab_pin.sym} 133170 -40350 0 0 {name=p131953 lab=_70307_/X }
C {devices/lab_pin.sym} 133350 -40370 0 1 {name=p131954 lab=_74748_/A }
C {sky130_stdcells/dfxtp_4.sym} 133260 -40360 0 0 {name=X_83803_ }
C {devices/lab_pin.sym} 133200 -40240 0 0 {name=p131955 lab=_57427_/A }
C {devices/lab_pin.sym} 133200 -40200 0 0 {name=p131956 lab=_56750_/Y }
C {devices/lab_pin.sym} 133320 -40220 0 1 {name=p131957 lab=_56752_/A }
C {sky130_stdcells/nand2_4.sym} 133260 -40220 0 0 {name=X_56751_ }
C {devices/lab_pin.sym} 133220 -40090 0 0 {name=p131958 lab=_68737_/A }
C {devices/lab_pin.sym} 133300 -40090 0 1 {name=p131959 lab=_68737_/X }
C {sky130_stdcells/buf_2.sym} 133260 -40090 0 0 {name=X_68737_ }
C {devices/lab_pin.sym} 133170 -39970 0 0 {name=p131960 lab=_83153_/CLK }
C {devices/lab_pin.sym} 133170 -39950 0 0 {name=p131961 lab=_43114_/Y }
C {devices/lab_pin.sym} 133350 -39970 0 1 {name=p131962 lab=_87571_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -39960 0 0 {name=X_87571_ }
C {devices/lab_pin.sym} 133220 -39830 0 0 {name=p131963 lab=_53874_/A }
C {devices/lab_pin.sym} 133300 -39830 0 1 {name=p131964 lab=_53964_/B }
C {sky130_stdcells/buf_2.sym} 133260 -39830 0 0 {name=X_53963_ }
C {devices/lab_pin.sym} 133180 -39730 0 0 {name=p131965 lab=_65946_/X }
C {devices/lab_pin.sym} 133180 -39690 0 0 {name=p131966 lab=_65948_/X }
C {devices/lab_pin.sym} 133180 -39650 0 0 {name=p131967 lab=_65937_/X }
C {devices/lab_pin.sym} 133340 -39690 0 1 {name=p131968 lab=_65949_/X }
C {sky130_stdcells/a21o_4.sym} 133260 -39690 0 0 {name=X_65949_ }
C {devices/lab_pin.sym} 133170 -39550 0 0 {name=p131969 lab=_84906_/CLK }
C {devices/lab_pin.sym} 133170 -39530 0 0 {name=p131970 lab=_58977_/X }
C {devices/lab_pin.sym} 133350 -39550 0 1 {name=p131971 lab=_62948_/C }
C {sky130_stdcells/dfxtp_4.sym} 133260 -39540 0 0 {name=X_84783_ }
C {devices/lab_pin.sym} 133220 -39410 0 0 {name=p131972 lab=clkbuf_8_235_0_CLK/A }
C {devices/lab_pin.sym} 133300 -39410 0 1 {name=p131973 lab=clkbuf_9_471_0_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 133260 -39410 0 0 {name=Xclkbuf_8_235_0_CLK }
C {devices/lab_pin.sym} 133170 -39290 0 0 {name=p131974 lab=_82131_/CLK }
C {devices/lab_pin.sym} 133170 -39270 0 0 {name=p131975 lab=_82027_/Q }
C {devices/lab_pin.sym} 133350 -39290 0 1 {name=p131976 lab=_77069_/A }
C {sky130_stdcells/dfxtp_4.sym} 133260 -39280 0 0 {name=X_81995_ }
C {devices/lab_pin.sym} 133220 -39150 0 0 {name=p131977 lab=clkbuf_9_115_0_CLK/X }
C {devices/lab_pin.sym} 133300 -39150 0 1 {name=p131978 lab=_82211_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 133260 -39150 0 0 {name=Xclkbuf_10_230_0_CLK }
C {devices/lab_pin.sym} 133200 -39040 0 0 {name=p131979 lab=_55711_/A }
C {devices/lab_pin.sym} 133200 -39000 0 0 {name=p131980 lab=_55702_/B }
C {devices/lab_pin.sym} 133320 -39020 0 1 {name=p131981 lab=_55702_/X }
C {sky130_stdcells/and2_4.sym} 133260 -39020 0 0 {name=X_55702_ }
C {devices/lab_pin.sym} 133170 -38890 0 0 {name=p131982 lab=_85593_/CLK }
C {devices/lab_pin.sym} 133170 -38870 0 0 {name=p131983 lab=_48443_/Y }
C {devices/lab_pin.sym} 133350 -38890 0 1 {name=p131984 lab=_86522_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -38880 0 0 {name=X_86522_ }
C {devices/lab_pin.sym} 133200 -38760 0 0 {name=p131985 lab=_52910_/A }
C {devices/lab_pin.sym} 133200 -38720 0 0 {name=p131986 lab=_51222_/B }
C {devices/lab_pin.sym} 133320 -38740 0 1 {name=p131987 lab=_52914_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -38740 0 0 {name=X_52914_ }
C {devices/lab_pin.sym} 133220 -38610 0 0 {name=p131988 lab=_84723_/Q }
C {devices/lab_pin.sym} 133300 -38610 0 1 {name=p131989 lab=_59471_/A }
C {sky130_stdcells/inv_2.sym} 133260 -38610 0 0 {name=X_59470_ }
C {devices/lab_pin.sym} 133170 -38490 0 0 {name=p131990 lab=_86317_/CLK }
C {devices/lab_pin.sym} 133170 -38470 0 0 {name=p131991 lab=_83734_/D }
C {devices/lab_pin.sym} 133350 -38490 0 1 {name=p131992 lab=_83734_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -38480 0 0 {name=X_83734_ }
C {devices/lab_pin.sym} 133220 -38350 0 0 {name=p131993 lab=_56682_/A }
C {devices/lab_pin.sym} 133300 -38350 0 1 {name=p131994 lab=_56682_/X }
C {sky130_stdcells/buf_2.sym} 133260 -38350 0 0 {name=X_56682_ }
C {devices/lab_pin.sym} 133170 -38230 0 0 {name=p131995 lab=_80813_/CLK }
C {devices/lab_pin.sym} 133170 -38210 0 0 {name=p131996 lab=_80990_/Q }
C {devices/lab_pin.sym} 133350 -38230 0 1 {name=p131997 lab=_80946_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -38220 0 0 {name=X_80946_ }
C {devices/lab_pin.sym} 133220 -38090 0 0 {name=p131998 lab=_68668_/A }
C {devices/lab_pin.sym} 133300 -38090 0 1 {name=p131999 lab=_68669_/B }
C {sky130_stdcells/inv_2.sym} 133260 -38090 0 0 {name=X_68668_ }
C {devices/lab_pin.sym} 133220 -37970 0 0 {name=p132000 lab=clkbuf_9_430_0_CLK/X }
C {devices/lab_pin.sym} 133300 -37970 0 1 {name=p132001 lab=_86127_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 133260 -37970 0 0 {name=Xclkbuf_10_860_0_CLK }
C {devices/lab_pin.sym} 133180 -37870 0 0 {name=p132002 lab=_53891_/Y }
C {devices/lab_pin.sym} 133180 -37830 0 0 {name=p132003 lab=_53892_/X }
C {devices/lab_pin.sym} 133180 -37790 0 0 {name=p132004 lab=_53893_/X }
C {devices/lab_pin.sym} 133340 -37830 0 1 {name=p132005 lab=_53894_/Y }
C {sky130_stdcells/a21oi_4.sym} 133260 -37830 0 0 {name=X_53894_ }
C {devices/lab_pin.sym} 133200 -37700 0 0 {name=p132006 lab=_58421_/A }
C {devices/lab_pin.sym} 133200 -37660 0 0 {name=p132007 lab=_58415_/B }
C {devices/lab_pin.sym} 133320 -37680 0 1 {name=p132008 lab=_58421_/Y }
C {sky130_stdcells/nand2_4.sym} 133260 -37680 0 0 {name=X_58421_ }
C {devices/lab_pin.sym} 133220 -37550 0 0 {name=p132009 lab=clkbuf_9_6_0_CLK/X }
C {devices/lab_pin.sym} 133300 -37550 0 1 {name=p132010 lab=_85248_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 133260 -37550 0 0 {name=Xclkbuf_10_12_0_CLK }
C {devices/lab_pin.sym} 133220 -37430 0 0 {name=p132011 lab=_68442_/A }
C {devices/lab_pin.sym} 133300 -37430 0 1 {name=p132012 lab=_67619_/X }
C {sky130_stdcells/buf_2.sym} 133260 -37430 0 0 {name=X_67619_ }
C {devices/lab_pin.sym} 133200 -37320 0 0 {name=p132013 lab=_55630_/X }
C {devices/lab_pin.sym} 133200 -37280 0 0 {name=p132014 lab=_55632_/X }
C {devices/lab_pin.sym} 133320 -37300 0 1 {name=p132015 lab=_55634_/A }
C {sky130_stdcells/and2_4.sym} 133260 -37300 0 0 {name=X_55633_ }
C {devices/lab_pin.sym} 133170 -37170 0 0 {name=p132016 lab=_86453_/CLK }
C {devices/lab_pin.sym} 133170 -37150 0 0 {name=p132017 lab=_86453_/D }
C {devices/lab_pin.sym} 133350 -37170 0 1 {name=p132018 lab=_86453_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -37160 0 0 {name=X_86453_ }
C {devices/lab_pin.sym} 133220 -37030 0 0 {name=p132019 lab=_52845_/A }
C {devices/lab_pin.sym} 133300 -37030 0 1 {name=p132020 lab=_52853_/C }
C {sky130_stdcells/buf_2.sym} 133260 -37030 0 0 {name=X_52845_ }
C {devices/lab_pin.sym} 133170 -36910 0 0 {name=p132021 lab=_83666_/CLK }
C {devices/lab_pin.sym} 133170 -36890 0 0 {name=p132022 lab=_70915_/Y }
C {devices/lab_pin.sym} 133350 -36910 0 1 {name=p132023 lab=_46840_/A }
C {sky130_stdcells/dfxtp_4.sym} 133260 -36900 0 0 {name=X_83665_ }
C {devices/lab_pin.sym} 133170 -36770 0 0 {name=p132024 lab=_80849_/CLK }
C {devices/lab_pin.sym} 133170 -36750 0 0 {name=p132025 lab=_75675_/B }
C {devices/lab_pin.sym} 133350 -36770 0 1 {name=p132026 lab=_80877_/Q }
C {sky130_stdcells/dfxtp_4.sym} 133260 -36760 0 0 {name=X_80877_ }
C {devices/lab_pin.sym} 133200 -36640 0 0 {name=p132027 lab=_68599_/A }
C {devices/lab_pin.sym} 133200 -36600 0 0 {name=p132028 lab=_87754_/Q }
C {devices/lab_pin.sym} 133320 -36620 0 1 {name=p132029 lab=_68599_/X }
C {sky130_stdcells/and2_4.sym} 133260 -36620 0 0 {name=X_68599_ }
